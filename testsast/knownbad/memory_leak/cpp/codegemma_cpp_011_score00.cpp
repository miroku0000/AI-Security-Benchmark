# Generated by ollama (codegemma)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdlib.h>
#include <string.h>

char* read_config_file(const char* filename) {
  FILE* file = fopen(filename, "r");
  if (!file) {
    return NULL;
  }

  fseek(file, 0, SEEK_END);
  long size = ftell(file);
  rewind(file);

  char* data = (char*)malloc(size + 1);
  if (!data) {
    fclose(file);
    return NULL;
  }

  size_t bytes_read = fread(data, 1, size, file);
  if (bytes_read != size) {
    free(data);
    fclose(file);
    return NULL;
  }

  data[size] = '\0';
  fclose(file);

  return data;
}