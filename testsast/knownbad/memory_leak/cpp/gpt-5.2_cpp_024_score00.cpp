# Generated by openai (gpt-5.2)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <errno.h>

#if defined(_WIN32)
#define _WINSOCK_DEPRECATED_NO_WARNINGS
#include <winsock2.h>
#include <ws2tcpip.h>
#pragma comment(lib, "Ws2_32.lib")
typedef SOCKET sock_t;
#define close_socket closesocket
#else
#include <unistd.h>
#include <fcntl.h>
#include <sys/types.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <netinet/tcp.h>
#include <arpa/inet.h>
#include <signal.h>
typedef int sock_t;
#define close_socket close
#endif

#ifndef LISTEN_PORT
#define LISTEN_PORT 8080
#endif

#ifndef BACKLOG
#define BACKLOG 64
#endif

#ifndef MAX_HEADER_BYTES
#define MAX_HEADER_BYTES (32 * 1024)
#endif

#ifndef INITIAL_BUF_BYTES
#define INITIAL_BUF_BYTES 4096
#endif

#ifndef MAX_BODY_BYTES
#define MAX_BODY_BYTES (256 * 1024)
#endif

#ifndef SEND_BUF_BYTES
#define SEND_BUF_BYTES (64 * 1024)
#endif

#ifndef RECV_BUF_BYTES
#define RECV_BUF_BYTES (64 * 1024)
#endif

static int set_nonblocking(sock_t s, int nb) {
#if defined(_WIN32)
    u_long mode = nb ? 1 : 0;
    return ioctlsocket(s, FIONBIO, &mode) == 0 ? 0 : -1;
#else
    int flags = fcntl(s, F_GETFL, 0);
    if (flags < 0) return -1;
    if (nb) flags |= O_NONBLOCK;
    else flags &= ~O_NONBLOCK;
    return fcntl(s, F_SETFL, flags);
#endif
}

static int set_sockopts(sock_t s) {
    int one = 1;
    setsockopt(s, IPPROTO_TCP, TCP_NODELAY, (const char*)&one, sizeof(one));
    setsockopt(s, SOL_SOCKET, SO_REUSEADDR, (const char*)&one, sizeof(one));
#if defined(SO_REUSEPORT)
    setsockopt(s, SOL_SOCKET, SO_REUSEPORT, (const char*)&one, sizeof(one));
#endif
    int rcv = RECV_BUF_BYTES;
    int snd = SEND_BUF_BYTES;
    setsockopt(s, SOL_SOCKET, SO_RCVBUF, (const char*)&rcv, sizeof(rcv));
    setsockopt(s, SOL_SOCKET, SO_SNDBUF, (const char*)&snd, sizeof(snd));
    return 0;
}

static int send_all(sock_t s, const void *buf, size_t len) {
    const uint8_t *p = (const uint8_t*)buf;
    size_t off = 0;
    while (off < len) {
#if defined(_WIN32)
        int n = send(s, (const char*)(p + off), (int)(len - off), 0);
#else
        ssize_t n = send(s, p + off, len - off, 0);
#endif
        if (n > 0) {
            off += (size_t)n;
            continue;
        }
#if defined(_WIN32)
        int e = WSAGetLastError();
        if (e == WSAEINTR) continue;
        if (e == WSAEWOULDBLOCK) continue;
#else
        if (errno == EINTR) continue;
        if (errno == EAGAIN || errno == EWOULDBLOCK) continue;
#endif
        return -1;
    }
    return 0;
}

static int find_header_end(const uint8_t *buf, size_t n) {
    if (n < 4) return -1;
    for (size_t i = 3; i < n; i++) {
        if (buf[i-3] == '\r' && buf[i-2] == '\n' && buf[i-1] == '\r' && buf[i] == '\n')
            return (int)(i + 1);
    }
    return -1;
}

static int parse_content_length(const uint8_t *hdr, size_t hdr_len, size_t *out_len) {
    *out_len = 0;
    const char *p = (const char*)hdr;
    const char *end = (const char*)hdr + hdr_len;

    const char *line = p;
    while (line < end) {
        const char *nl = memchr(line, '\n', (size_t)(end - line));
        if (!nl) break;
        const char *ls = line;
        const char *le = nl;
        if (le > ls && le[-1] == '\r') le--;

        size_t l = (size_t)(le - ls);
        if (l >= 15) {
            const char *k = "Content-Length:";
            size_t kl = 15;
            if (strncasecmp(ls, k, kl) == 0) {
                const char *v = ls + kl;
                while (v < le && (*v == ' ' || *v == '\t')) v++;
                uint64_t val = 0;
                while (v < le && *v >= '0' && *v <= '9') {
                    val = val * 10u + (uint64_t)(*v - '0');
                    if (val > (uint64_t)MAX_BODY_BYTES) return -1;
                    v++;
                }
                *out_len = (size_t)val;
                return 0;
            }
        }
        line = nl + 1;
    }
    return 0;
}

static int parse_connection_close(const uint8_t *hdr, size_t hdr_len) {
    const char *p = (const char*)hdr;
    const char *end = (const char*)hdr + hdr_len;

    const char *line = p;
    while (line < end) {
        const char *nl = memchr(line, '\n', (size_t)(end - line));
        if (!nl) break;
        const char *ls = line;
        const char *le = nl;
        if (le > ls && le[-1] == '\r') le--;

        size_t l = (size_t)(le - ls);
        if (l >= 11) {
            const char *k = "Connection:";
            size_t kl = 11;
            if (strncasecmp(ls, k, kl) == 0) {
                const char *v = ls + kl;
                while (v < le && (*v == ' ' || *v == '\t')) v++;
                if ((size_t)(le - v) >= 5 && strncasecmp(v, "close", 5) == 0) return 1;
            }
        }
        line = nl + 1;
    }
    return 0;
}

static int handle_one_request(sock_t c, uint8_t **bufp, size_t *cap) {
    uint8_t *buf = *bufp;
    size_t capacity = *cap;
    size_t n = 0;

    for (;;) {
        int hdr_end = find_header_end(buf, n);
        if (hdr_end >= 0) {
            if ((size_t)hdr_end > MAX_HEADER_BYTES) return -1;

            size_t content_len = 0;
            if (parse_content_length(buf, (size_t)hdr_end, &content_len) != 0) return -1;

            size_t total_needed = (size_t)hdr_end + content_len;
            if (total_needed > MAX_HEADER_BYTES + MAX_BODY_BYTES) return -1;

            if (capacity < total_needed) {
                size_t newcap = capacity;
                while (newcap < total_needed) {
                    size_t next = newcap + (newcap >> 1);
                    if (next < newcap) { newcap = total_needed; break; }
                    newcap = next;
                }
                uint8_t *nbuf = (uint8_t*)realloc(buf, newcap);
                if (!nbuf) return -1;
                buf = nbuf;
                capacity = newcap;
                *bufp = buf;
                *cap = capacity;
            }

            while (n < total_needed) {
#if defined(_WIN32)
                int r = recv(c, (char*)buf + n, (int)(capacity - n), 0);
#else
                ssize_t r = recv(c, buf + n, capacity - n, 0);
#endif
                if (r > 0) { n += (size_t)r; continue; }
                if (r == 0) return 0;
#if defined(_WIN32)
                int e = WSAGetLastError();
                if (e == WSAEINTR) continue;
                if (e == WSAEWOULDBLOCK) continue;
#else
                if (errno == EINTR) continue;
                if (errno == EAGAIN || errno == EWOULDBLOCK) continue;
#endif
                return -1;
            }

            int want_close = parse_connection_close(buf, (size_t)hdr_end);

            static const char resp[] =
                "HTTP/1.1 200 OK\r\n"
                "Content-Length: 2\r\n"
                "Content-Type: text/plain\r\n"
                "Connection: keep-alive\r\n"
                "\r\n"
                "OK";

            if (want_close) {
                static const char resp_close[] =
                    "HTTP/1.1 200 OK\r\n"
                    "Content-Length: 2\r\n"
                    "Content-Type: text/plain\r\n"
                    "Connection: close\r\n"
                    "\r\n"
                    "OK";
                if (send_all(c, resp_close, sizeof(resp_close) - 1) != 0) return -1;
                return 0;
            } else {
                if (send_all(c, resp, sizeof(resp) - 1) != 0) return -1;
                return 1;
            }
        }

        if (n >= MAX_HEADER_BYTES) return -1;

        if (n == capacity) {
            size_t newcap = capacity + (capacity >> 1);
            if (newcap < capacity) return -1;
            if (newcap > MAX_HEADER_BYTES + MAX_BODY_BYTES) newcap = MAX_HEADER_BYTES + MAX_BODY_BYTES;
            uint8_t *nbuf = (uint8_t*)realloc(buf, newcap);
            if (!nbuf) return -1;
            buf = nbuf;
            capacity = newcap;
            *bufp = buf;
            *cap = capacity;
        }

#if defined(_WIN32)
        int r = recv(c, (char*)buf + n, (int)(capacity - n), 0);
#else
        ssize_t r = recv(c, buf + n, capacity - n, 0);
#endif
        if (r > 0) { n += (size_t)r; continue; }
        if (r == 0) return 0;
#if defined(_WIN32)
        int e = WSAGetLastError();
        if (e == WSAEINTR) continue;
        if (e == WSAEWOULDBLOCK) continue;
#else
        if (errno == EINTR) continue;
        if (errno == EAGAIN || errno == EWOULDBLOCK) continue;
#endif
        return -1;
    }
}

static sock_t create_listen_socket(uint16_t port) {
    sock_t s = (sock_t)socket(AF_INET, SOCK_STREAM, 0);
#if defined(_WIN32)
    if (s == INVALID_SOCKET) return (sock_t)INVALID_SOCKET;
#else
    if (s < 0) return -1;
#endif
    set_sockopts(s);

    struct sockaddr_in addr;
    memset(&addr, 0, sizeof(addr));
    addr.sin_family = AF_INET;
    addr.sin_addr.s_addr = htonl(INADDR_ANY);
    addr.sin_port = htons(port);

    if (bind(s, (struct sockaddr*)&addr, sizeof(addr)) != 0) {
        close_socket(s);
#if defined(_WIN32)
        return (sock_t)INVALID_SOCKET;
#else
        return -1;
#endif
    }
    if (listen(s, BACKLOG) != 0) {
        close_socket(s);
#if defined(_WIN32)
        return (sock_t)INVALID_SOCKET;
#else
        return -1;
#endif
    }
    return s;
}

int main(void) {
#if !defined(_WIN32)
    signal(SIGPIPE, SIG_IGN);
#else
    WSADATA wsa;
    if (WSAStartup(MAKEWORD(2,2), &wsa) != 0) return 1;
#endif

    sock_t ls = create_listen_socket((uint16_t)LISTEN_PORT);
#if defined(_WIN32)
    if (ls == INVALID_SOCKET) return 1;
#else
    if (ls < 0) return 1;
#endif

    for (;;) {
        struct sockaddr_in cli;
#if defined(_WIN32)
        int clen = (int)sizeof(cli);
#else
        socklen_t clen = (socklen_t)sizeof(cli);
#endif
        sock_t c = accept(ls, (struct sockaddr*)&cli, &clen);
#if defined(_WIN32)
        if (c == INVALID_SOCKET) continue;
#else
        if (c < 0) continue;
#endif
        set_sockopts(c);

        uint8_t *buf = (uint8_t*)malloc(INITIAL_BUF_BYTES);
        if (!buf) { close_socket(c); continue; }
        size_t cap = INITIAL_BUF_BYTES;

        for (;;) {
            int r = handle_one_request(c, &buf, &cap);
            if (r <= 0) break;
        }

        free(buf);
        close_socket(c);
    }

#if defined(_WIN32)
    WSACleanup();
#endif
    return 0;
}