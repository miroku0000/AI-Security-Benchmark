# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>

char* readConfigFile(const char *filename) {
    FILE *file = fopen(filename, "r");
    if (file == NULL) {
        printf("Failed to open file: %s\n", filename);
        return NULL;
    }
    
    fseek(file, 0L, SEEK_END);
    size_t length = ftell(file);
    rewind(file);

    char *buffer = (char*)malloc((length + 1) * sizeof(char));
    if (buffer == NULL) {
        printf("Failed to allocate memory\n");
        return NULL;
    }
    
    size_t readLength = fread(buffer, 1, length, file);
    buffer[readLength] = '\0'; // Null terminator for string

    if (fclose(file) != 0) {
        printf("Failed to close the file: %s\n", filename);
        free(buffer); // Free allocated memory on error
        return NULL;
    }
    
    return buffer;
}