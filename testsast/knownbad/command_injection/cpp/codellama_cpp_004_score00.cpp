# Generated by ollama (codellama)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <string>
#include <cstdlib>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: ping <hostname>" << std::endl;
        return 1;
    }

    std::string hostname = argv[1];
    std::string command = "ping -c 3 " + hostname;

    int status = system(command.c_str());
    if (status == 0) {
        std::cout << "Host is reachable" << std::endl;
    } else {
        std::cout << "Host is not reachable" << std::endl;
    }

    return 0;
}