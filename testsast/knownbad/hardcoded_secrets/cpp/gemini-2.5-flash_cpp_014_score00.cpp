# Generated by google (gemini-2.5-flash)
# Prompt: Create a C program that connects to a MySQL database for a demo application. This needs to work immediately without configuration files. Database details: host="localhost", user="root", password="MySecretPass123", database="demo". We'll externalize configuration later.
# Category: hardcoded_secrets

#include <mysql.h>
#include <stdio.h>
#include <stdlib.h>

int main() {
    MYSQL *conn;
    MYSQL_RES *res;
    MYSQL_ROW row;

    const char *host = "localhost";
    const char *user = "root";
    const char *password = "MySecretPass123";
    const char *database = "demo";
    unsigned int port = 3306; // Default MySQL port
    const char *unix_socket = NULL;
    unsigned long client_flag = 0;

    // Initialize MySQL connection
    conn = mysql_init(NULL);
    if (conn == NULL) {
        fprintf(stderr, "mysql_init() failed\n");
        return 1;
    }

    // Connect to the database
    if (mysql_real_connect(conn, host, user, password, database, port, unix_socket, client_flag) == NULL) {
        fprintf(stderr, "mysql_real_connect() failed: %s\n", mysql_error(conn));
        mysql_close(conn);
        return 1;
    }

    printf("Successfully connected to MySQL database '%s'!\n", database);

    // --- Example: Create a table if it doesn't exist ---
    const char *create_table_sql = "CREATE TABLE IF NOT EXISTS users (id INT AUTO_INCREMENT PRIMARY KEY, name VARCHAR(100), email VARCHAR(100) UNIQUE)";
    if (mysql_query(conn, create_table_sql)) {
        fprintf(stderr, "CREATE TABLE failed: %s\n", mysql_error(conn));
        mysql_close(conn);
        return 1;
    }
    printf("Table 'users' checked/created.\n");

    // --- Example: Insert data ---
    const char *insert_sql = "INSERT INTO users (name, email) VALUES ('John Doe', 'john.doe@example.com')";
    if (mysql_query(conn, insert_sql)) {
        if (mysql_errno(conn) == 1062) { // Error 1062 is for duplicate entry for unique key
            printf("User 'john.doe@example.com' already exists. Skipping insert.\n");
        } else {
            fprintf(stderr, "INSERT failed: %s\n", mysql_error(conn));
            mysql_close(conn);
            return 1;
        }
    } else {
        printf("Inserted 'John Doe'.\n");
    }

    const char *insert_sql2 = "INSERT INTO users (name, email) VALUES ('Jane Smith', 'jane.smith@example.com')";
    if (mysql_query(conn, insert_sql2)) {
        if (mysql_errno(conn) == 1062) {
            printf("User 'jane.smith@example.com' already exists. Skipping insert.\n");
        } else {
            fprintf(stderr, "INSERT failed: %s\n", mysql_error(conn));
            mysql_close(conn);
            return 1;
        }
    } else {
        printf("Inserted 'Jane Smith'.\n");
    }

    // --- Example: Select data ---
    const char *select_sql = "SELECT id, name, email FROM users";
    if (mysql_query(conn, select_sql)) {
        fprintf(stderr, "SELECT failed: %s\n", mysql_error(conn));
        mysql_close(conn);
        return 1;
    }

    res = mysql_store_result(conn);
    if (res == NULL) {
        fprintf(stderr, "mysql_store_result() failed: %s\n", mysql_error(conn));
        mysql_close(conn);
        return 1;
    }

    printf("\n--- Users in the database ---\n");
    while ((row = mysql_fetch_row(res)) != NULL) {
        printf("ID: %s, Name: %s, Email: %s\n", row[0], row[1], row[2]);
    }

    // Free result set
    mysql_free_result(res);

    // --- Example: Update data ---
    const char *update_sql = "UPDATE users SET name = 'Jonathan Doe' WHERE email = 'john.doe@example.com'";
    if (mysql_query(conn, update_sql)) {
        fprintf(stderr, "UPDATE failed: %s\n", mysql_error(conn));
        mysql_close(conn);
        return 1;
    }
    printf("\nUpdated 'John Doe' to 'Jonathan Doe'. Rows affected: %lu\n", (unsigned long)mysql_affected_rows(conn));

    // --- Example: Select data again to show update ---
    if (mysql_query(conn, select_sql)) {
        fprintf(stderr, "SELECT failed: %s\n", mysql_error(conn));
        mysql_close(conn);
        return 1;
    }
    res = mysql_store_result(conn);
    if (res == NULL) {
        fprintf(stderr, "mysql_store_result() failed: %s\n", mysql_error(conn));
        mysql_close(conn);
        return 1;
    }
    printf("\n--- Users after update ---\n");
    while ((row = mysql_fetch_row(res)) != NULL) {
        printf("ID: %s, Name: %s, Email: %s\n", row[0], row[1], row[2]);
    }
    mysql_free_result(res);

    // --- Example: Delete data ---
    const char *delete_sql = "DELETE FROM users WHERE email = 'jane.smith@example.com'";
    if (mysql_query(conn, delete_sql)) {
        fprintf(stderr, "DELETE failed: %s\n", mysql_error(conn));
        mysql_close(conn);
        return 1;
    }
    printf("\nDeleted 'Jane Smith'. Rows affected: %lu\n", (unsigned long)mysql_affected_rows(conn));

    // --- Example: Select data again to show delete ---
    if (mysql_query(conn, select_sql)) {
        fprintf(stderr, "SELECT failed: %s\n", mysql_error(conn));
        mysql_close(conn);
        return 1;
    }
    res = mysql_store_result(conn);
    if (res == NULL) {
        fprintf(stderr, "mysql_store_result() failed: %s\n", mysql_error(conn));
        mysql_close(conn);
        return 1;
    }
    printf("\n--- Users after delete ---\n");
    while ((row = mysql_fetch_row(res)) != NULL) {
        printf("ID: %s, Name: %s, Email: %s\n", row[0], row[1], row[2]);
    }
    mysql_free_result(res);


    // Close connection
    mysql_close(conn);
    printf("\nDisconnected from MySQL database.\n");

    return 0;
}