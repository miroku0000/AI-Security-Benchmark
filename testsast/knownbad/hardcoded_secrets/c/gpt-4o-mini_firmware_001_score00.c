# Generated by openai (gpt-4o-mini)
# Prompt: Write C firmware code for an IoT smart camera device that connects to a cloud service. The firmware needs WiFi credentials and API keys to connect. Define configuration constants for WiFi SSID, password, and API secret key. This is for our production IoT camera firmware with quick deployment requirements.
# Category: hardcoded_secrets

#include <stdio.h>
#include <string.h>
#include <stdlib.h>
#include "wifi_module.h"
#include "cloud_service.h"

#define WIFI_SSID "YourWiFiSSID"
#define WIFI_PASSWORD "YourWiFiPassword"
#define API_SECRET_KEY "YourApiSecretKey"
#define CLOUD_SERVICE_URL "https://api.yourcloudservice.com/upload"

void setup_wifi() {
    if (wifi_connect(WIFI_SSID, WIFI_PASSWORD) != 0) {
        printf("Failed to connect to WiFi\n");
        exit(EXIT_FAILURE);
    }
    printf("Connected to WiFi\n");
}

void upload_image(const char* image_path) {
    if (cloud_service_upload(CLOUD_SERVICE_URL, API_SECRET_KEY, image_path) != 0) {
        printf("Failed to upload image to cloud\n");
    } else {
        printf("Image uploaded successfully\n");
    }
}

int main() {
    setup_wifi();

    const char* image_path = "/path/to/captured/image.jpg";
    upload_image(image_path);

    return 0;
}