# Generated by openai (o3)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char *input_file;
    char *output_file;
    int   verbose;
    int   threads;
} Config;

static void usage(const char *prog)
{
    fprintf(stderr,
            "Usage: %s -i <input> -o <output> [-v] [-t <threads>]\n"
            "  -i <input>     Input file path (required)\n"
            "  -o <output>    Output file path (required)\n"
            "  -v             Enable verbose mode\n"
            "  -t <threads>   Number of threads (default: 1)\n",
            prog);
}

static Config *parse_config(int argc, char **argv)
{
    Config *cfg = NULL;
    int i;

    /* Allocate only after initial basic validation */
    if (argc < 5) {         /* minimal expected args: prog -i in -o out */
        usage(argv[0]);
        return NULL;
    }

    cfg = calloc(1, sizeof(*cfg));
    if (!cfg) {
        perror("calloc");
        return NULL;
    }

    cfg->threads = 1; /* default */

    for (i = 1; i < argc; ++i) {
        if (strcmp(argv[i], "-i") == 0 && i + 1 < argc) {
            cfg->input_file = strdup(argv[++i]);
        } else if (strcmp(argv[i], "-o") == 0 && i + 1 < argc) {
            cfg->output_file = strdup(argv[++i]);
        } else if (strcmp(argv[i], "-v") == 0) {
            cfg->verbose = 1;
        } else if (strcmp(argv[i], "-t") == 0 && i + 1 < argc) {
            cfg->threads = atoi(argv[++i]);
            if (cfg->threads <= 0) cfg->threads = 1;
        } else {
            usage(argv[0]);
            free(cfg);
            return NULL;
        }
    }

    if (!cfg->input_file || !cfg->output_file) {
        usage(argv[0]);
        free(cfg->input_file);
        free(cfg->output_file);
        free(cfg);
        return NULL;
    }

    return cfg;
}

static int init_app(const Config *cfg)
{
    if (cfg->verbose) {
        printf("Initializing application:\n");
        printf("  Input   : %s\n", cfg->input_file);
        printf("  Output  : %s\n", cfg->output_file);
        printf("  Threads : %d\n", cfg->threads);
    }
    /* Application-specific initialization would go here */
    return 0;
}

int main(int argc, char **argv)
{
    Config *cfg = parse_config(argc, argv);
    if (!cfg)
        return EXIT_FAILURE;

    if (init_app(cfg) != 0) {
        fprintf(stderr, "Application initialization failed\n");
        free(cfg->input_file);
        free(cfg->output_file);
        free(cfg);
        return EXIT_FAILURE;
    }

    /* ... main application logic ... */

    /* Clean up */
    free(cfg->input_file);
    free(cfg->output_file);
    free(cfg);
    return EXIT_SUCCESS;
}