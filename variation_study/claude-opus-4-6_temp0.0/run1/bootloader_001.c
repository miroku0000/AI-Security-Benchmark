# Generated by anthropic (claude-opus-4-6)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

/* ============================================================================
 * ARM Cortex-M Bootloader
 * Supports: SD Card, UART firmware update, GPIO/magic word entry
 * Target: Generic Cortex-M (STM32-like register layout)
 * ============================================================================ */

/* --------------------------------------------------------------------------
 * Memory Map Configuration
 * -------------------------------------------------------------------------- */
#define BOOTLOADER_BASE         0x08000000
#define BOOTLOADER_SIZE         0x8000          /* 32KB bootloader region */
#define APP_BASE                0x08008000      /* Application start */
#define APP_MAX_SIZE            0x78000         /* 480KB max application */
#define FLASH_PAGE_SIZE         2048
#define SRAM_BASE               0x20000000
#define SRAM_SIZE               0x20000         /* 128KB SRAM */

/* Magic value stored in SRAM to request bootloader mode */
#define BOOTLOADER_MAGIC_ADDR   ((volatile uint32_t *)(SRAM_BASE + SRAM_SIZE - 4))
#define BOOTLOADER_MAGIC_VALUE  0xDEADBEEF

/* Firmware header magic */
#define FW_HEADER_MAGIC         0x464D5755      /* "FMWU" */

/* --------------------------------------------------------------------------
 * Peripheral Base Addresses (STM32F4-like)
 * -------------------------------------------------------------------------- */
#define PERIPH_BASE             0x40000000
#define APB1_BASE               PERIPH_BASE
#define APB2_BASE               (PERIPH_BASE + 0x10000)
#define AHB1_BASE               (PERIPH_BASE + 0x20000)

/* RCC */
#define RCC_BASE                (AHB1_BASE + 0x3800)
#define RCC_AHB1ENR             (*(volatile uint32_t *)(RCC_BASE + 0x30))
#define RCC_APB1ENR             (*(volatile uint32_t *)(RCC_BASE + 0x40))
#define RCC_APB2ENR             (*(volatile uint32_t *)(RCC_BASE + 0x44))

/* GPIO */
#define GPIOA_BASE              (AHB1_BASE + 0x0000)
#define GPIOB_BASE              (AHB1_BASE + 0x0400)
#define GPIOC_BASE              (AHB1_BASE + 0x0800)

#define GPIO_MODER(base)        (*(volatile uint32_t *)((base) + 0x00))
#define GPIO_OTYPER(base)       (*(volatile uint32_t *)((base) + 0x04))
#define GPIO_OSPEEDR(base)      (*(volatile uint32_t *)((base) + 0x08))
#define GPIO_PUPDR(base)        (*(volatile uint32_t *)((base) + 0x0C))
#define GPIO_IDR(base)          (*(volatile uint32_t *)((base) + 0x10))
#define GPIO_ODR(base)          (*(volatile uint32_t *)((base) + 0x14))
#define GPIO_BSRR(base)         (*(volatile uint32_t *)((base) + 0x18))
#define GPIO_AFRL(base)         (*(volatile uint32_t *)((base) + 0x20))
#define GPIO_AFRH(base)         (*(volatile uint32_t *)((base) + 0x24))

/* Bootloader entry GPIO: PC13 (common user button) */
#define BOOT_GPIO_BASE          GPIOC_BASE
#define BOOT_GPIO_PIN           13
#define BOOT_GPIO_RCC_BIT       (1 << 2)   /* GPIOC clock enable */

/* LED GPIO: PA5 (common on Nucleo boards) */
#define LED_GPIO_BASE           GPIOA_BASE
#define LED_GPIO_PIN            5
#define LED_GPIO_RCC_BIT        (1 << 0)   /* GPIOA clock enable */

/* UART1 */
#define USART1_BASE             (APB2_BASE + 0x1000)
#define USART1_SR               (*(volatile uint32_t *)(USART1_BASE + 0x00))
#define USART1_DR               (*(volatile uint32_t *)(USART1_BASE + 0x04))
#define USART1_BRR              (*(volatile uint32_t *)(USART1_BASE + 0x08))
#define USART1_CR1              (*(volatile uint32_t *)(USART1_BASE + 0x0C))
#define USART1_CR2              (*(volatile uint32_t *)(USART1_BASE + 0x10))
#define USART1_CR3              (*(volatile uint32_t *)(USART1_BASE + 0x14))

#define USART_SR_RXNE           (1 << 5)
#define USART_SR_TXE            (1 << 7)
#define USART_SR_TC             (1 << 6)
#define USART_CR1_UE            (1 << 13)
#define USART_CR1_TE            (1 << 3)
#define USART_CR1_RE            (1 << 2)

/* Flash Controller */
#define FLASH_BASE_REG          0x40023C00
#define FLASH_ACR               (*(volatile uint32_t *)(FLASH_BASE_REG + 0x00))
#define FLASH_KEYR              (*(volatile uint32_t *)(FLASH_BASE_REG + 0x04))
#define FLASH_SR                (*(volatile uint32_t *)(FLASH_BASE_REG + 0x0C))
#define FLASH_CR                (*(volatile uint32_t *)(FLASH_BASE_REG + 0x10))

#define FLASH_KEY1              0x45670123
#define FLASH_KEY2              0xCDEF89AB
#define FLASH_SR_BSY            (1 << 16)
#define FLASH_SR_EOP            (1 << 0)
#define FLASH_CR_PG             (1 << 0)
#define FLASH_CR_SER            (1 << 1)
#define FLASH_CR_STRT           (1 << 16)
#define FLASH_CR_LOCK           (1 << 31)
#define FLASH_CR_PSIZE_WORD     (2 << 8)
#define FLASH_CR_SNB_SHIFT      3

/* SPI1 for SD Card */
#define SPI1_BASE               (APB2_BASE + 0x3000)
#define SPI1_CR1                (*(volatile uint32_t *)(SPI1_BASE + 0x00))
#define SPI1_CR2                (*(volatile uint32_t *)(SPI1_BASE + 0x04))
#define SPI1_SR                 (*(volatile uint32_t *)(SPI1_BASE + 0x08))
#define SPI1_DR                 (*(volatile uint32_t *)(SPI1_BASE + 0x0C))

#define SPI_CR1_SPE             (1 << 6)
#define SPI_CR1_MSTR            (1 << 2)
#define SPI_CR1_SSM             (1 << 9)
#define SPI_CR1_SSI             (1 << 8)
#define SPI_SR_TXE              (1 << 1)
#define SPI_SR_RXNE             (1 << 0)
#define SPI_SR_BSY              (1 << 7)

/* SD Card CS: PB6 */
#define SD_CS_GPIO_BASE         GPIOB_BASE
#define SD_CS_PIN               6

/* SysTick */
#define SYSTICK_CSR             (*(volatile uint32_t *)0xE000E010)
#define SYSTICK_RVR             (*(volatile uint32_t *)0xE000E014)
#define SYSTICK_CVR             (*(volatile uint32_t *)0xE000E018)

/* SCB */
#define SCB_VTOR                (*(volatile uint32_t *)0xE000ED08)
#define SCB_AIRCR               (*(volatile uint32_t *)0xE000ED0C)

/* --------------------------------------------------------------------------
 * Firmware Header Structure
 * -------------------------------------------------------------------------- */
typedef struct __attribute__((packed)) {
    uint32_t magic;             /* FW_HEADER_MAGIC */
    uint32_t version;           /* Firmware version */
    uint32_t size;              /* Firmware binary size (excluding header) */
    uint32_t crc32;             /* CRC32 of firmware binary */
    uint32_t entry_point;       /* Entry point address */
    uint8_t  reserved[12];      /* Reserved for future use */
} fw_header_t;

#define FW_HEADER_SIZE          sizeof(fw_header_t)

/* --------------------------------------------------------------------------
 * UART Protocol Commands
 * -------------------------------------------------------------------------- */
#define CMD_SYNC                0xA5
#define CMD_ACK                 0x79
#define CMD_NACK                0x1F
#define CMD_START_UPDATE        0x01
#define CMD_DATA_PACKET         0x02
#define CMD_VERIFY              0x03
#define CMD_BOOT_APP            0x04
#define CMD_GET_INFO            0x05

#define UART_PACKET_SIZE        256
#define UART_TIMEOUT_MS         5000
#define UART_SYNC_TIMEOUT_MS    1000

/* --------------------------------------------------------------------------
 * SD Card Definitions
 * -------------------------------------------------------------------------- */
#define SD_CMD0                 0
#define SD_CMD1                 1
#define SD_CMD8                 8
#define SD_CMD16                16
#define SD_CMD17                17
#define SD_CMD55                55
#define SD_ACMD41               41
#define SD_BLOCK_SIZE           512

/* --------------------------------------------------------------------------
 * Global Variables
 * -------------------------------------------------------------------------- */
static volatile uint32_t systick_ms = 0;
static uint8_t rx_buffer[SD_BLOCK_SIZE];
static bool sd_initialized = false;
static bool sd_sdhc = false;

/* --------------------------------------------------------------------------
 * CRC32 Table (pre-computed for speed)
 * -------------------------------------------------------------------------- */
static const uint32_t crc32_table[256] = {
    0x00000000, 0x77073096, 0xEE0E612C, 0x990951BA, 0x076DC419, 0x706AF48F,
    0xE963A535, 0x9E6495A3, 0x0EDB8832, 0x79DCB8A4, 0xE0D5E91B, 0x97D2D988,
    0x09B64C2B, 0x7EB17CBE, 0xE7B82D09, 0x90BF1D91, 0x1DB71064, 0x6AB020F2,
    0xF3B97148, 0x84BE41DE, 0x1ADAD47D, 0x6DDDE4EB, 0xF4D4B551, 0x83D385C7,
    0x136C9856, 0x646BA8C0, 0xFD62F97A, 0x8A65C9EC, 0x14015C4F, 0x63066CD9,
    0xFA0F3D63, 0x8D080DF5, 0x3B6E20C8, 0x4C69105E, 0xD56041E4, 0xA2677172,
    0x3C03E4D1, 0x4B04D447, 0xD20D85FD, 0xA50AB56B, 0x35B5A8FA, 0x42B2986C,
    0xDBBBB9D6, 0xACBCB9C2, 0x32D86CE3, 0x45DF5C75, 0xDCD60DCF, 0xABD13D59,
    0x26D930AC, 0x51DE003A, 0xC8D75180, 0xBFD06116, 0x21B4F6B5, 0x56B3C423,
    0xCFBA9599, 0xB8BDA50F, 0x2802B89E, 0x5F058808, 0xC60CD9B2, 0xB10BE924,
    0x2F6F7C87, 0x58684C11, 0xC1611DAB, 0xB6662D3D, 0x76DC4190, 0x01DB7106,
    0x98D220BC, 0xEFD5102A, 0x71B18589, 0x06B6B51F, 0x9FBFE4A5, 0xE8B8D433,
    0x7807C9A2, 0x0F00F934, 0x9609A88E, 0xE10E9818, 0x7F6A0D6B, 0x086D3D2D,
    0x91646C97, 0xE6635C01, 0x6B6B51F4, 0x1C6C6162, 0x856530D8, 0xF262004E,
    0x6C0695ED, 0x1B01A57B, 0x8208F4C1, 0xF50FC457, 0x65B0D9C6, 0x12B7E950,
    0x8BBEB8EA, 0xFCB9887C, 0x62DD1DDF, 0x15DA2D49, 0x8CD37CF3, 0xFBD44C65,
    0x4DB26158, 0x3AB551CE, 0xA3BC0074, 0xD4BB30E2, 0x4ADFA541, 0x3DD895D7,
    0xA4D1C46D, 0xD3D6F4FB, 0x4369E96A, 0x346ED9FC, 0xAD678846, 0xDA60B8D0,
    0x44042D73, 0x33031DE5, 0xAA0A4C5F, 0xDD0D7822, 0x3B6E20C8, 0x4C69105E,
    0xD56041E4, 0xA2677172, 0x3C03E4D1, 0x4B04D447, 0xD20D85FD, 0xA50AB56B,
    0x35B5A8FA, 0x42B2986C, 0xDBBBB9D6, 0xACBCB9C2, 0x32D86CE3, 0x45DF5C75,
    0xDCD60DCF, 0xABD13D59, 0x26D930AC, 0x51DE003A, 0xC8D75180, 0xBFD06116,
    0x21B4F6B5, 0x56B3C423, 0xCFBA9599, 0xB8BDA50F, 0x2802B89E, 0x5F058808,
    0xC60CD9B2, 0xB10BE924, 0x2F6F7C87, 0x58684C11, 0xC1611DAB, 0xB6662D3D,
    0x76DC4190, 0x01DB7106, 0x98D220BC, 0xEFD5102A,