# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <time.h>

#define MAX_REQUEST_SIZE 4096
#define MAX_RESPONSE_SIZE 8192
#define MAX_PATH_SIZE 256
#define MAX_HEADERS 32
#define SIMULATED_REQUESTS 100

typedef enum {
    HTTP_GET,
    HTTP_POST,
    HTTP_PUT,
    HTTP_DELETE,
    HTTP_UNKNOWN
} http_method_t;

typedef struct {
    char name[128];
    char value[256];
} http_header_t;

typedef struct {
    http_method_t method;
    char path[MAX_PATH_SIZE];
    char version[16];
    http_header_t headers[MAX_HEADERS];
    int header_count;
    char *body;
    size_t body_length;
    char *raw_request;
    size_t raw_length;
} http_request_t;

typedef struct {
    int status_code;
    char status_text[64];
    http_header_t headers[MAX_HEADERS];
    int header_count;
    char *body;
    size_t body_length;
    char *raw_response;
    size_t raw_length;
} http_response_t;

typedef struct {
    unsigned long total_requests;
    unsigned long successful_requests;
    unsigned long failed_requests;
    unsigned long bytes_received;
    unsigned long bytes_sent;
    double total_processing_time_ms;
} server_stats_t;

static server_stats_t g_stats = {0};

static const char *simulated_requests[] = {
    "GET / HTTP/1.1\r\nHost: localhost\r\nConnection: keep-alive\r\n\r\n",
    "GET /index.html HTTP/1.1\r\nHost: localhost\r\nAccept: text/html\r\n\r\n",
    "POST /api/data HTTP/1.1\r\nHost: localhost\r\nContent-Type: application/json\r\nContent-Length: 27\r\n\r\n{\"key\":\"value\",\"num\":42}",
    "GET /api/status HTTP/1.1\r\nHost: localhost\r\nAccept: application/json\r\n\r\n",
    "GET /favicon.ico HTTP/1.1\r\nHost: localhost\r\n\r\n",
    "DELETE /api/data/1 HTTP/1.1\r\nHost: localhost\r\nAuthorization: Bearer token123\r\n\r\n",
    "PUT /api/data/2 HTTP/1.1\r\nHost: localhost\r\nContent-Type: application/json\r\nContent-Length: 20\r\n\r\n{\"updated\":\"true\"}",
    "GET /static/style.css HTTP/1.1\r\nHost: localhost\r\nAccept: text/css\r\n\r\n",
    "GET /nonexistent HTTP/1.1\r\nHost: localhost\r\n\r\n",
    "PATCH /bad HTTP/1.1\r\nHost: localhost\r\n\r\n",
};

static int simulated_request_count = sizeof(simulated_requests) / sizeof(simulated_requests[0]);

http_request_t *allocate_request(void) {
    http_request_t *req = (http_request_t *)calloc(1, sizeof(http_request_t));
    if (!req) {
        fprintf(stderr, "ERROR: Failed to allocate request structure\n");
        return NULL;
    }
    req->raw_request = (char *)malloc(MAX_REQUEST_SIZE);
    if (!req->raw_request) {
        fprintf(stderr, "ERROR: Failed to allocate request buffer\n");
        free(req);
        return NULL;
    }
    memset(req->raw_request, 0, MAX_REQUEST_SIZE);
    return req;
}

void free_request(http_request_t *req) {
    if (req) {
        if (req->raw_request) {
            free(req->raw_request);
            req->raw_request = NULL;
        }
        if (req->body) {
            free(req->body);
            req->body = NULL;
        }
        free(req);
    }
}

http_response_t *allocate_response(void) {
    http_response_t *resp = (http_response_t *)calloc(1, sizeof(http_response_t));
    if (!resp) {
        fprintf(stderr, "ERROR: Failed to allocate response structure\n");
        return NULL;
    }
    resp->raw_response = (char *)malloc(MAX_RESPONSE_SIZE);
    if (!resp->raw_response) {
        fprintf(stderr, "ERROR: Failed to allocate response buffer\n");
        free(resp);
        return NULL;
    }
    memset(resp->raw_response, 0, MAX_RESPONSE_SIZE);
    return resp;
}

void free_response(http_response_t *resp) {
    if (resp) {
        if (resp->raw_response) {
            free(resp->raw_response);
            resp->raw_response = NULL;
        }
        if (resp->body) {
            free(resp->body);
            resp->body = NULL;
        }
        free(resp);
    }
}

int simulate_receive_request(http_request_t *req, int request_index) {
    int idx = request_index % simulated_request_count;
    size_t len = strlen(simulated_requests[idx]);
    if (len >= MAX_REQUEST_SIZE) {
        len = MAX_REQUEST_SIZE - 1;
    }
    memcpy(req->raw_request, simulated_requests[idx], len);
    req->raw_request[len] = '\0';
    req->raw_length = len;
    g_stats.bytes_received += len;
    return 0;
}

http_method_t parse_method(const char *method_str) {
    if (strcmp(method_str, "GET") == 0) return HTTP_GET;
    if (strcmp(method_str, "POST") == 0) return HTTP_POST;
    if (strcmp(method_str, "PUT") == 0) return HTTP_PUT;
    if (strcmp(method_str, "DELETE") == 0) return HTTP_DELETE;
    return HTTP_UNKNOWN;
}

const char *method_to_string(http_method_t method) {
    switch (method) {
        case HTTP_GET: return "GET";
        case HTTP_POST: return "POST";
        case HTTP_PUT: return "PUT";
        case HTTP_DELETE: return "DELETE";
        default: return "UNKNOWN";
    }
}

int parse_request(http_request_t *req) {
    if (!req || !req->raw_request || req->raw_length == 0) {
        return -1;
    }

    char *work_buf = (char *)malloc(req->raw_length + 1);
    if (!work_buf) {
        return -1;
    }
    memcpy(work_buf, req->raw_request, req->raw_length);
    work_buf[req->raw_length] = '\0';

    /* Find end of request line */
    char *line_end = strstr(work_buf, "\r\n");
    if (!line_end) {
        free(work_buf);
        return -1;
    }
    *line_end = '\0';

    /* Parse request line: METHOD PATH VERSION */
    char method_str[16] = {0};
    char path_str[MAX_PATH_SIZE] = {0};
    char version_str[16] = {0};

    int parsed = sscanf(work_buf, "%15s %255s %15s", method_str, path_str, version_str);
    if (parsed < 2) {
        free(work_buf);
        return -1;
    }

    req->method = parse_method(method_str);
    strncpy(req->path, path_str, MAX_PATH_SIZE - 1);
    req->path[MAX_PATH_SIZE - 1] = '\0';
    if (parsed >= 3) {
        strncpy(req->version, version_str, sizeof(req->version) - 1);
    } else {
        strcpy(req->version, "HTTP/1.0");
    }

    /* Parse headers */
    char *header_start = line_end + 2;
    req->header_count = 0;

    while (req->header_count < MAX_HEADERS) {
        char *header_end = strstr(header_start, "\r\n");
        if (!header_end) break;
        if (header_end == header_start) {
            /* Empty line = end of headers */
            header_start = header_end + 2;
            break;
        }
        *header_end = '\0';

        char *colon = strchr(header_start, ':');
        if (colon) {
            *colon = '\0';
            char *value = colon + 1;
            while (*value == ' ') value++;

            strncpy(req->headers[req->header_count].name, header_start,
                    sizeof(req->headers[0].name) - 1);
            strncpy(req->headers[req->header_count].value, value,
                    sizeof(req->headers[0].value) - 1);
            req->header_count++;
        }
        header_start = header_end + 2;
    }

    /* Check for body */
    size_t header_offset = (size_t)(header_start - work_buf);
    if (header_offset < req->raw_length) {
        size_t body_len = req->raw_length - header_offset;
        if (body_len > 0) {
            req->body = (char *)malloc(body_len + 1);
            if (req->body) {
                memcpy(req->body, req->raw_request + header_offset, body_len);
                req->body[body_len] = '\0';
                req->body_length = body_len;
            }
        }
    }

    free(work_buf);
    return 0;
}

const char *find_header(http_request_t *req, const char *name) {
    for (int i = 0; i < req->header_count; i++) {
        if (strcasecmp(req->headers[i].name, name) == 0) {
            return req->headers[i].value;
        }
    }
    return NULL;
}

void set_response_status(http_response_t *resp, int code, const char *text) {
    resp->status_code = code;
    strncpy(resp->status_text, text, sizeof(resp->status_text) - 1);
}

void add_response_header(http_response_t *resp, const char *name, const char *value) {
    if (resp->header_count < MAX_HEADERS) {
        strncpy(resp->headers[resp->header_count].name, name,
                sizeof(resp->headers[0].name) - 1);
        strncpy(resp->headers[resp->header_count].value, value,
                sizeof(resp->headers[0].value) - 1);
        resp->header_count++;
    }
}

void set_response_body(http_response_t *resp, const char *body) {
    if (resp->body) {
        free(resp->body);
    }
    size_t len = strlen(body);
    resp->body = (char *)malloc(len + 1);
    if (resp->body) {
        memcpy(resp->body, body, len + 1);
        resp->body_length = len;
    }
}

int build_raw_response(http_response_t *resp) {
    int offset = snprintf(resp->raw_response, MAX_RESPONSE_SIZE,
                          "HTTP/1.1 %d %s\r\n", resp->status_code, resp->status_text);

    for (int i = 0; i < resp->header_count && offset < MAX_RESPONSE_SIZE; i++) {
        offset += snprintf(resp->raw_response + offset, MAX_RESPONSE_SIZE - offset,
                           "%s: %s\r\n", resp->headers[i].name, resp->headers[i].value);
    }

    if (resp->body && resp->body_length > 0) {
        char cl_buf[32];
        snprintf(cl_buf, sizeof(cl_buf), "%zu", resp->body_length);
        offset += snprintf(resp->raw_response + offset, MAX_RESPONSE_SIZE - offset,
                           "Content-Length: %s\r\n", cl_buf);
    }

    offset += snprintf(resp->raw_response + offset, MAX_RESPONSE_SIZE - offset, "\r\n");

    if (resp->body && resp->body_length > 0 && offset + (int)resp->body_length < MAX_RESPONSE_SIZE) {
        memcpy(resp->raw_response + offset, resp->body, resp->body_length);
        offset += (int)resp->body_length;
        resp->raw_response[offset] = '\0';
    }

    resp->raw_length = (size_t)offset;
    return 0;
}

void handle_get_root(http_request_t *req, http_response_t *resp) {
    (void)req;
    set_response_status(resp, 200, "OK");
    add_response_header(resp, "Content-Type", "text/html");
    add_response_header(resp, "Server", "EmbeddedHTTP/1.0");
    set_response_body(resp,
        "<html><head><title>Embedded Server</title></head>"
        "<body><h1>Welcome to Embedded Web Server</h1>"
        "<p>Server is running.</p></body></html>");
}

void handle_get_status(http_request_t *req, http_response_t *resp) {
    (void)req;
    char json_buf[512];
    snprintf(json_buf, sizeof(json_buf),
             "{\"status\":\"running\","
             "\"total_requests\":%lu,"
             "\"successful\":%lu,"
             "\"failed\":%lu,"
             "\"bytes_received\":%lu,"
             "\"bytes_sent\":%lu,"
             "\"avg_processing_ms\":%.3f}",
             g_stats.total_requests,
             g_stats.successful_requests,
             g_stats.failed_requests,
             g_stats.bytes_received,
             g_stats.bytes_sent,
             g_stats.total_requests > 0 ?
                 g_stats.total_processing_time_ms / g_stats.total_requests : 0.0);

    set_response_status(resp, 200, "OK");
    add_response_header(resp, "Content-Type", "application/json");
    add_response_header(resp, "Server", "EmbeddedHTTP/1.0");
    set_response_body(resp, json_buf);
}

void handle_post_data(http_request_t *req, http_response_t *resp) {
    set_response_status(resp, 201, "Created");
    add_response_header(resp, "Content-Type", "application/json");
    add_response_header(resp, "Server", "EmbeddedHTTP/1.0");

    char json_buf[512];
    snprintf(json_buf, sizeof(json_buf),
             "{\"status\":\"created\",\"received_bytes\":%zu,\"body\":\"%s\"}",
             req->body_length,
             req->body ? req->body : "");
    set_response_body(resp, json_buf);
}

void handle_put_data(http_request_t *req, http_response_t *resp) {
    set_response_status(resp, 200, "OK");
    add_response_header(resp, "Content-Type", "application/