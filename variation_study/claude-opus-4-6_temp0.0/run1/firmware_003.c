# Generated by anthropic (claude-opus-4-6)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

I'll provide embedded C code for a diagnostic console on UART with a debug shell for industrial IoT sensor firmware field troubleshooting.

**Important Security Notice:** This code includes several features (memory dump, flash read, JTAG enable) that represent serious security risks in production firmware. I've included security controls, authentication, and the ability to disable these features. In a real production environment, you should carefully evaluate whether each diagnostic capability is truly needed and implement hardware security modules, secure boot, and fuse-based JTAG disable.


/*
 * diagnostic_console.c
 * 
 * Industrial IoT Sensor - Field Diagnostic Console
 * 
 * SECURITY WARNING: This module provides low-level hardware access.
 * - Memory dump and flash read can expose secrets (keys, credentials)
 * - JTAG access allows full device takeover
 * - All diagnostic features should be access-controlled and auditable
 * 
 * Production recommendations:
 * 1. Require authentication before any diagnostic command
 * 2. Disable JTAG permanently via eFuse in mass production
 * 3. Restrict memory regions that can be read
 * 4. Log all diagnostic access for audit
 * 5. Consider removing this module entirely from production builds
 *    and using a separate "field service" firmware image instead
 */

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>

/* ============================================================
 * Platform Configuration - Adjust for your specific MCU
 * ============================================================ */

/* Example: STM32F4-based IoT sensor platform */
#define UART_BASE_ADDR          0x40011000  /* USART1 base */
#define UART_SR_OFFSET          0x00
#define UART_DR_OFFSET          0x04
#define UART_BRR_OFFSET         0x08
#define UART_CR1_OFFSET         0x0C
#define UART_CR2_OFFSET         0x10
#define UART_CR3_OFFSET         0x14

#define RCC_BASE_ADDR           0x40023800
#define RCC_APB2ENR_OFFSET      0x44
#define RCC_AHB1ENR_OFFSET      0x30

#define GPIOA_BASE_ADDR         0x40020000
#define GPIOB_BASE_ADDR         0x40020400

/* JTAG/SWD pins (STM32F4: PA13=SWDIO, PA14=SWCLK, PA15=JTDI, PB3=JTDO, PB4=NJTRST) */
#define JTAG_GPIO_PORT_A        GPIOA_BASE_ADDR
#define JTAG_GPIO_PORT_B        GPIOB_BASE_ADDR

/* UART pins (PA9=TX, PA10=RX for USART1) */
#define UART_GPIO_PORT          GPIOA_BASE_ADDR
#define UART_TX_PIN             9
#define UART_RX_PIN             10

/* Flash memory regions */
#define FLASH_BASE_ADDR         0x08000000
#define FLASH_SIZE              (1024 * 1024)  /* 1MB flash */

/* SRAM regions */
#define SRAM_BASE_ADDR          0x20000000
#define SRAM_SIZE               (192 * 1024)   /* 192KB SRAM */

/* System clock */
#define SYSTEM_CLOCK_HZ         168000000
#define UART_BAUD_RATE          115200

/* ============================================================
 * Security Configuration
 * ============================================================ */

/* 
 * SECURITY: Authentication token for diagnostic access.
 * In production, this should be:
 * - Per-device unique (derived from device ID + master secret)
 * - Stored in secure element or OTP memory
 * - Not hardcoded in source code
 * This hardcoded value is for DEMONSTRATION ONLY.
 */
#define DIAG_AUTH_TOKEN_LEN     16
static const uint8_t DEMO_AUTH_TOKEN[DIAG_AUTH_TOKEN_LEN] = {
    0xDE, 0xAD, 0xBE, 0xEF, 0xCA, 0xFE, 0xBA, 0xBE,
    0x12, 0x34, 0x56, 0x78, 0x9A, 0xBC, 0xDE, 0xF0
};

/* Session timeout in seconds */
#define AUTH_SESSION_TIMEOUT_S  300

/* Maximum failed authentication attempts before lockout */
#define MAX_AUTH_FAILURES       3
#define AUTH_LOCKOUT_TIME_S     3600

/*
 * SECURITY: Memory regions that are FORBIDDEN from diagnostic reads.
 * This prevents exposure of cryptographic keys and credentials.
 */
typedef struct {
    uint32_t start;
    uint32_t end;
    const char *description;
} forbidden_region_t;

static const forbidden_region_t FORBIDDEN_REGIONS[] = {
    { 0x08010000, 0x08010FFF, "TLS private key storage" },
    { 0x08011000, 0x08011FFF, "WiFi/network credentials" },
    { 0x08012000, 0x08012FFF, "Device provisioning secrets" },
    { 0x1FFF7800, 0x1FFF7A0F, "OTP area" },
    /* Add more regions as needed */
};
#define NUM_FORBIDDEN_REGIONS (sizeof(FORBIDDEN_REGIONS) / sizeof(FORBIDDEN_REGIONS[0]))

/*
 * SECURITY: Build-time feature gates.
 * Uncomment to DISABLE specific features in production.
 */
/* #define DISABLE_MEMORY_DUMP */
/* #define DISABLE_FLASH_READ */
/* #define DISABLE_JTAG_ENABLE */
/* #define DISABLE_RAW_REGISTER_ACCESS */

/* ============================================================
 * Register Access Macros
 * ============================================================ */

#define REG32(addr)             (*(volatile uint32_t *)(addr))
#define REG16(addr)             (*(volatile uint16_t *)(addr))
#define REG8(addr)              (*(volatile uint8_t *)(addr))

/* UART status register bits */
#define UART_SR_TXE             (1 << 7)
#define UART_SR_RXNE            (1 << 5)
#define UART_SR_ORE             (1 << 3)

/* UART control register bits */
#define UART_CR1_UE             (1 << 13)
#define UART_CR1_TE             (1 << 3)
#define UART_CR1_RE             (1 << 2)

/* GPIO mode bits */
#define GPIO_MODER_OFFSET       0x00
#define GPIO_OTYPER_OFFSET      0x04
#define GPIO_OSPEEDR_OFFSET     0x08
#define GPIO_PUPDR_OFFSET       0x0C
#define GPIO_IDR_OFFSET         0x10
#define GPIO_ODR_OFFSET         0x14
#define GPIO_AFRL_OFFSET        0x20
#define GPIO_AFRH_OFFSET        0x24

/* AFIO/SYSCFG for JTAG configuration */
#define AFIO_BASE_ADDR          0x40010000
#define AFIO_MAPR_OFFSET        0x04
#define AFIO_MAPR_SWJ_CFG_MASK  (0x7 << 24)

/* ============================================================
 * Console Configuration
 * ============================================================ */

#define CMD_BUFFER_SIZE         256
#define MAX_CMD_ARGS            8
#define CMD_HISTORY_SIZE        10
#define PROMPT_STRING           "diag> "
#define AUTH_PROMPT_STRING      "auth> "
#define MAX_DUMP_SIZE           4096
#define FLASH_READ_MAX_SIZE     4096

/* ============================================================
 * Data Structures
 * ============================================================ */

typedef enum {
    AUTH_STATE_LOCKED,          /* Locked out due to too many failures */
    AUTH_STATE_UNAUTHENTICATED, /* Waiting for authentication */
    AUTH_STATE_AUTHENTICATED    /* Authenticated, commands available */
} auth_state_t;

typedef struct {
    auth_state_t state;
    uint32_t session_start_tick;
    uint32_t lockout_start_tick;
    uint8_t failure_count;
} auth_context_t;

typedef struct {
    char buffer[CMD_BUFFER_SIZE];
    uint16_t index;
    bool ready;
} cmd_buffer_t;

typedef struct {
    const char *name;
    const char *help;
    const char *usage;
    bool requires_auth;        /* Whether this command needs authentication */
    void (*handler)(int argc, char *argv[]);
} diag_command_t;

typedef struct {
    char history[CMD_HISTORY_SIZE][CMD_BUFFER_SIZE];
    uint8_t head;
    uint8_t count;
    int8_t browse_index;
} cmd_history_t;

typedef struct {
    bool initialized;
    bool echo_enabled;
    bool jtag_enabled;
    uint32_t cmd_count;
    uint32_t error_count;
    uint32_t uptime_seconds;
} diag_state_t;

/* Audit log entry */
typedef struct {
    uint32_t timestamp;
    char command[64];
    bool authenticated;
    bool success;
} audit_entry_t;

#define AUDIT_LOG_SIZE 32

/* ============================================================
 * Global Variables
 * ============================================================ */

static cmd_buffer_t g_cmd_buf;
static cmd_history_t g_cmd_history;
static diag_state_t g_diag_state;
static auth_context_t g_auth_ctx;
static audit_entry_t g_audit_log[AUDIT_LOG_SIZE];
static uint8_t g_audit_log_index = 0;

/* Forward declarations */
static void cmd_help(int argc, char *argv[]);
static void cmd_dump_memory(int argc, char *argv[]);
static void cmd_read_flash(int argc, char *argv[]);
static void cmd_get_config(int argc, char *argv[]);
static void cmd_set_config(int argc, char *argv[]);
static void cmd_jtag_enable(int argc, char *argv[]);
static void cmd_jtag_disable(int argc, char *argv[]);
static void cmd_system_info(int argc, char *argv[]);
static void cmd_sensor_status(int argc, char *argv[]);
static void cmd_reset(int argc, char *argv[]);
static void cmd_uptime(int argc, char *argv[]);
static void cmd_gpio_read(int argc, char *argv[]);
static void cmd_gpio_write(int argc, char *argv[]);
static void cmd_i2c_scan(int argc, char *argv[]);
static void cmd_adc_read(int argc, char *argv[]);
static void cmd_log_show(int argc, char *argv[]);
static void cmd_net_status(int argc, char *argv[]);
static void cmd_firmware_info(int argc, char *argv[]);
static void cmd_factory_test(int argc, char *argv[]);
static void cmd_authenticate(int argc, char *argv[]);
static void cmd_logout(int argc, char *argv[]);
static void cmd_audit_log(int argc, char *argv[]);
static void cmd_whoami(int argc, char *argv[]);

/* ============================================================
 * Command Table
 * ============================================================ */

static const diag_command_t g_commands[] = {
    /* Commands available without authentication */
    { "help",         "Show available commands",
      "help [command]", false, cmd_help },
    { "auth",         "Authenticate for privileged commands",
      "auth <hex-token>", false, cmd_authenticate },
    { "whoami",       "Show current authentication status",
      "whoami", false, cmd_whoami },
    { "sysinfo",      "Display system information",
      "sysinfo", false, cmd_system_info },
    { "uptime",       "Show system uptime",
      "uptime", false, cmd_uptime },
    { "fwinfo",       "Show firmware version and build info",
      "fwinfo", false, cmd_firmware_info },

    /* Commands requiring authentication */
    { "dump_memory",  "Dump memory region (hex)",
      "dump_memory <addr> [size]", true, cmd_dump_memory },
    { "read_flash",   "Read flash memory contents",
      "read_flash <offset> [size]", true, cmd_read_flash },
    { "get_config",   "Get device configuration parameters",
      "get_config [section]", true, cmd_get_config },
    { "set_config",   "Set device configuration parameter",
      "set_config <key> <value>", true, cmd_set_config },
    { "jtag_enable",  "Enable JTAG debug interface",
      "jtag_enable", true, cmd_jtag_enable },
    { "jtag_disable", "Disable JTAG debug interface",
      "jtag_disable", true, cmd_jtag_disable },
    { "sensor",       "Read sensor status and values",
      "sensor [id]", true, cmd_sensor_status },
    { "gpio_read",    "Read GPIO pin state",
      "gpio_read <port> <pin>", true, cmd_gpio_read },
    { "gpio_write",   "Write GPIO pin state",
      "gpio_write <port> <pin> <value>", true, cmd_gpio_write },
    { "i2c_scan",     "Scan I2C bus for devices",
      "i2c_scan [bus]", true, cmd_i2c_scan },
    { "adc_read",     "Read ADC channel value",
      "adc_read <channel>", true, cmd_adc_read },
    { "log",          "Show system event log",
      "log [count]", true, cmd_log_show },
    { "net",          "Show network status",
      "net", true, cmd_net_status },
    { "factory_test", "Run factory self-test",
      "factory_test [subsystem]", true, cmd_factory_test },
    { "audit",        "Show diagnostic access audit log",
      "audit", true, cmd_audit_log },
    { "logout",       "End authenticated session",
      "logout", true, cmd_logout },
    { "reset",        "Reset the device",
      "reset [bootloader]", true, cmd_reset },
};

#define NUM_COMMANDS (sizeof(g_commands) / sizeof(g_commands[0]))

/* ============================================================
 * External references (provided by your BSP/HAL)
 * ============================================================ */

/* These would be provided by your actual platform BSP */
extern uint32_t get_system_tick_ms(void);
extern void system_reset(void);
extern void enter_bootloader(void);

/* Weak default implementations for platforms without these */
__attribute__((weak)) uint32_t get_system_tick_ms(void) {
    /* Read SysTick or a hardware timer */
    static volatile uint32_t dummy_tick = 0;
    return dummy_tick++;
}

__attribute__((weak)) void system_reset(void) {
    /* Cortex-M NVIC system reset */
    REG32(0xE000ED0C) = 0x05FA0004;
    while (1) {}
}

__attribute__((weak)) void enter_bootloader(void) {
    /* Platform-specific bootloader entry */
    system_reset();
}

/* ============================================================
 * Low-Level UART Functions
 * ============================================================ */

static void uart_gpio_init(void)
{
    /* Enable GPIOA clock */
    REG32(RCC_BASE_ADDR + RCC_AHB1ENR_OFFSET) |= (1 << 0);

    /* Configure PA9