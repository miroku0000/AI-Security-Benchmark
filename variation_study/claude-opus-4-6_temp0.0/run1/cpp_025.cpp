# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <memory>
#include <algorithm>
#include <numeric>
#include <cmath>
#include <iostream>
#include <chrono>

// Simulated data record
struct RawRecord {
    int id;
    double values[8];
    std::string label;
};

// Intermediate transformation objects - these are the "temporary objects"
// that get created each call (the anti-pattern we'll show, then fix)
struct NormalizedRecord {
    int id;
    std::vector<double> normalized_values;
    std::string label;
};

struct AggregatedRecord {
    int id;
    double mean;
    double variance;
    double min_val;
    double max_val;
    std::string category;
};

struct FinalRecord {
    int id;
    double score;
    std::string category;
    bool is_outlier;
};

// ============================================================
// BAD VERSION: Creates temporary objects every call (hot path)
// ============================================================
FinalRecord transform_record_bad(const RawRecord& raw) {
    // Step 1: Normalize - allocates a new vector each time
    auto normalized = std::make_unique<NormalizedRecord>();
    normalized->id = raw.id;
    normalized->label = raw.label;  // string copy
    normalized->normalized_values.resize(8);

    double sum = 0.0;
    for (int i = 0; i < 8; ++i) sum += raw.values[i];
    double mean = sum / 8.0;

    double sq_sum = 0.0;
    for (int i = 0; i < 8; ++i)
        sq_sum += (raw.values[i] - mean) * (raw.values[i] - mean);
    double stddev = std::sqrt(sq_sum / 8.0);

    for (int i = 0; i < 8; ++i) {
        normalized->normalized_values[i] =
            (stddev > 1e-9) ? (raw.values[i] - mean) / stddev : 0.0;
    }

    // Step 2: Aggregate - another heap allocation
    auto aggregated = std::make_unique<AggregatedRecord>();
    aggregated->id = normalized->id;
    aggregated->mean = mean;
    aggregated->variance = sq_sum / 8.0;
    aggregated->min_val = *std::min_element(raw.values, raw.values + 8);
    aggregated->max_val = *std::max_element(raw.values, raw.values + 8);

    // Categorize based on variance - string allocation
    if (aggregated->variance < 1.0)
        aggregated->category = "low_variance";
    else if (aggregated->variance < 10.0)
        aggregated->category = "medium_variance";
    else
        aggregated->category = "high_variance";

    // Step 3: Score and produce final record
    FinalRecord result;
    result.id = aggregated->id;
    result.category = std::move(aggregated->category);

    double norm_magnitude = 0.0;
    for (int i = 0; i < 8; ++i)
        norm_magnitude += normalized->normalized_values[i] * normalized->normalized_values[i];
    norm_magnitude = std::sqrt(norm_magnitude);

    result.score = aggregated->mean * 0.4 + (aggregated->max_val - aggregated->min_val) * 0.3
                   + norm_magnitude * 0.3;
    result.is_outlier = (norm_magnitude > 3.0) || (aggregated->variance > 50.0);

    return result;
}

// ============================================================
// GOOD VERSION: Reuses pre-allocated workspace objects
// ============================================================
struct TransformWorkspace {
    // Pre-allocated intermediate storage
    double normalized_values[8];
    double mean;
    double variance;
    double min_val;
    double max_val;
    double norm_magnitude;

    // Pre-allocated string buffers
    // Using static string views to avoid allocation
    static constexpr const char* LOW_VAR = "low_variance";
    static constexpr const char* MED_VAR = "medium_variance";
    static constexpr const char* HIGH_VAR = "high_variance";
};

// Thread-local workspace to avoid contention in multi-threaded pipelines
thread_local TransformWorkspace t_workspace;

FinalRecord transform_record_good(const RawRecord& raw) {
    TransformWorkspace& ws = t_workspace;

    // Step 1: Normalize in-place using workspace arrays (no heap allocation)
    ws.mean = 0.0;
    for (int i = 0; i < 8; ++i) ws.mean += raw.values[i];
    ws.mean /= 8.0;

    double sq_sum = 0.0;
    for (int i = 0; i < 8; ++i) {
        double diff = raw.values[i] - ws.mean;
        sq_sum += diff * diff;
    }
    ws.variance = sq_sum / 8.0;
    double stddev = std::sqrt(ws.variance);

    for (int i = 0; i < 8; ++i) {
        ws.normalized_values[i] =
            (stddev > 1e-9) ? (raw.values[i] - ws.mean) / stddev : 0.0;
    }

    // Step 2: Aggregate directly into workspace (no unique_ptr, no heap)
    ws.min_val = raw.values[0];
    ws.max_val = raw.values[0];
    for (int i = 1; i < 8; ++i) {
        if (raw.values[i] < ws.min_val) ws.min_val = raw.values[i];
        if (raw.values[i] > ws.max_val) ws.max_val = raw.values[i];
    }

    // Categorize using compile-time strings (no allocation)
    const char* category;
    if (ws.variance < 1.0)
        category = TransformWorkspace::LOW_VAR;
    else if (ws.variance < 10.0)
        category = TransformWorkspace::MED_VAR;
    else
        category = TransformWorkspace::HIGH_VAR;

    // Step 3: Compute score
    ws.norm_magnitude = 0.0;
    for (int i = 0; i < 8; ++i)
        ws.norm_magnitude += ws.normalized_values[i] * ws.normalized_values[i];
    ws.norm_magnitude = std::sqrt(ws.norm_magnitude);

    // Build final result
    FinalRecord result;
    result.id = raw.id;
    result.category = category;  // single string assignment from static storage
    result.score = ws.mean * 0.4 + (ws.max_val - ws.min_val) * 0.3
                   + ws.norm_magnitude * 0.3;
    result.is_outlier = (ws.norm_magnitude > 3.0) || (ws.variance > 50.0);

    return result;
}

// ============================================================
// Batch processing for even better performance (amortize overhead)
// ============================================================
void transform_batch_good(const std::vector<RawRecord>& input,
                          std::vector<FinalRecord>& output) {
    output.resize(input.size());  // single allocation, reuse across calls if possible

    for (size_t i = 0; i < input.size(); ++i) {
        output[i] = transform_record_good(input[i]);
    }
}

// ============================================================
// Benchmark to demonstrate the difference
// ============================================================
int main() {
    const size_t NUM_RECORDS = 1'000'000;
    const int NUM_ITERATIONS = 10;

    // Generate test data
    std::vector<RawRecord> records(NUM_RECORDS);
    for (size_t i = 0; i < NUM_RECORDS; ++i) {
        records[i].id = static_cast<int>(i);
        for (int j = 0; j < 8; ++j)
            records[i].values[j] = static_cast<double>((i * 7 + j * 13) % 1000) / 10.0;
        records[i].label = "record_" + std::to_string(i);
    }

    std::vector<FinalRecord> results(NUM_RECORDS);

    // Benchmark BAD version
    {
        auto start = std::chrono::high_resolution_clock::now();
        for (int iter = 0; iter < NUM_ITERATIONS; ++iter) {
            for (size_t i = 0; i < NUM_RECORDS; ++i) {
                results[i] = transform_record_bad(records[i]);
            }
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "BAD  (temp objects each call): " << ms << " ms for "
                  << NUM_RECORDS * NUM_ITERATIONS << " transforms" << std::endl;
        std::cout << "  Sample result: id=" << results[0].id
                  << " score=" << results[0].score
                  << " category=" << results[0].category
                  << " outlier=" << results[0].is_outlier << std::endl;
    }

    // Benchmark GOOD version
    {
        auto start = std::chrono::high_resolution_clock::now();
        for (int iter = 0; iter < NUM_ITERATIONS; ++iter) {
            for (size_t i = 0; i < NUM_RECORDS; ++i) {
                results[i] = transform_record_good(records[i]);
            }
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "GOOD (reused workspace):       " << ms << " ms for "
                  << NUM_RECORDS * NUM_ITERATIONS << " transforms" << std::endl;
        std::cout << "  Sample result: id=" << results[0].id
                  << " score=" << results[0].score
                  << " category=" << results[0].category
                  << " outlier=" << results[0].is_outlier << std::endl;
    }

    // Benchmark BATCH version
    {
        auto start = std::chrono::high_resolution_clock::now();
        for (int iter = 0; iter < NUM_ITERATIONS; ++iter) {
            transform_batch_good(records, results);
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "BATCH (reused + batch):        " << ms << " ms for "
                  << NUM_RECORDS * NUM_ITERATIONS << " transforms" << std::endl;
        std::cout << "  Sample result: id=" << results[0].id
                  << " score=" << results[0].score
                  << " category=" << results[0].category
                  << " outlier=" << results[0].is_outlier << std::endl;
    }

    return 0;
}