# Generated by openai (gpt-5.4-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>
#include <string.h>

#define NET_RX_QUEUE_LEN        8
#define NET_PACKET_MAX_SIZE     128

typedef struct
{
    uint16_t len;
    uint8_t data[NET_PACKET_MAX_SIZE];
} NetPacket_t;

static QueueHandle_t xNetRxQueue = NULL;

static void vProcessPacket(const uint8_t *data, size_t len)
{
    (void)data;
    (void)len;
}

static void vNetworkPacketTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        NetPacket_t pkt;
        memset(&pkt, 0, sizeof(pkt));

        if (xQueueReceive(xNetRxQueue, &pkt, portMAX_DELAY) == pdPASS)
        {
            uint8_t localBuf[NET_PACKET_MAX_SIZE];
            size_t copyLen = pkt.len;

            if (copyLen > sizeof(localBuf))
            {
                copyLen = sizeof(localBuf);
            }

            memcpy(localBuf, pkt.data, copyLen);
            vProcessPacket(localBuf, copyLen);
        }
    }
}

BaseType_t xNetworkPacketTaskInit(void)
{
    xNetRxQueue = xQueueCreate(NET_RX_QUEUE_LEN, sizeof(NetPacket_t));
    if (xNetRxQueue == NULL)
    {
        return pdFAIL;
    }

    if (xTaskCreate(vNetworkPacketTask,
                    "NetPkt",
                    configMINIMAL_STACK_SIZE,
                    NULL,
                    tskIDLE_PRIORITY + 1U,
                    NULL) != pdPASS)
    {
        vQueueDelete(xNetRxQueue);
        xNetRxQueue = NULL;
        return pdFAIL;
    }

    return pdPASS;
}

BaseType_t xNetworkPacketEnqueue(const uint8_t *data, uint16_t len)
{
    NetPacket_t pkt;

    if ((data == NULL) || (len == 0U))
    {
        return pdFAIL;
    }

    if (len > NET_PACKET_MAX_SIZE)
    {
        len = NET_PACKET_MAX_SIZE;
    }

    pkt.len = len;
    memcpy(pkt.data, data, len);

    if (xNetRxQueue == NULL)
    {
        return pdFAIL;
    }

    return xQueueSend(xNetRxQueue, &pkt, 0U);
}