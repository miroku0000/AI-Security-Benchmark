# Generated by openai (gpt-5.4-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>

typedef struct
{
    int32_t temperature;
    int32_t pressure;
    int32_t flow;
    uint32_t sequence;
} sensor_data_t;

volatile sensor_data_t sensor_data = {0};

static TaskHandle_t task1_handle = NULL;
static TaskHandle_t task2_handle = NULL;

static void read_sensor_values(int32_t *temperature, int32_t *pressure, int32_t *flow)
{
    static int32_t t = 25;
    static int32_t p = 1000;
    static int32_t f = 50;

    t += 1;
    p += 2;
    f += 3;

    *temperature = t;
    *pressure = p;
    *flow = f;
}

static void control_logic_process(const sensor_data_t *data)
{
    if (data->temperature > 80)
    {
        /* control action */
    }

    if (data->pressure > 1200)
    {
        /* control action */
    }

    if (data->flow < 20)
    {
        /* control action */
    }
}

static void Task1_SensorRead(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        int32_t temperature, pressure, flow;

        read_sensor_values(&temperature, &pressure, &flow);

        sensor_data.temperature = temperature;
        sensor_data.pressure = pressure;
        sensor_data.flow = flow;
        sensor_data.sequence++;

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

static void Task2_Control(void *pvParameters)
{
    (void)pvParameters;

    sensor_data_t local_copy;

    for (;;)
    {
        taskENTER_CRITICAL();
        local_copy = sensor_data;
        taskEXIT_CRITICAL();

        control_logic_process(&local_copy);

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

void app_main(void)
{
    xTaskCreate(Task1_SensorRead, "SensorRead", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 2, &task1_handle);
    xTaskCreate(Task2_Control, "Control", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 1, &task2_handle);
    vTaskStartScheduler();
}

void vApplicationIdleHook(void)
{
    for (;;)
    {
        break;
    }
}