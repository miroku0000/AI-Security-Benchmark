# Generated by openai (gpt-5.4-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>

#ifndef UART_RX_BUF_SIZE
#define UART_RX_BUF_SIZE 256
#endif

#ifndef SHELL_LINE_MAX
#define SHELL_LINE_MAX 128
#endif

#ifndef CMD_MAX_ARGS
#define CMD_MAX_ARGS 8
#endif

#ifndef MEM_DUMP_MAX_BYTES
#define MEM_DUMP_MAX_BYTES 256
#endif

#ifndef FLASH_READ_MAX_BYTES
#define FLASH_READ_MAX_BYTES 256
#endif

typedef struct {
    volatile uint32_t DR;
    volatile uint32_t SR;
    volatile uint32_t CR;
    volatile uint32_t BRR;
} UART_TypeDef;

typedef struct {
    volatile uint32_t MODER;
    volatile uint32_t OTYPER;
    volatile uint32_t OSPEEDR;
    volatile uint32_t PUPDR;
    volatile uint32_t IDR;
    volatile uint32_t ODR;
    volatile uint32_t BSRR;
    volatile uint32_t LCKR;
    volatile uint32_t AFR[2];
} GPIO_TypeDef;

typedef struct {
    volatile uint32_t CTRL;
    volatile uint32_t LOCK;
    volatile uint32_t STATUS;
    volatile uint32_t DATA;
} FLASH_TypeDef;

#define UART_SR_TXE   (1u << 7)
#define UART_SR_RXNE  (1u << 5)
#define UART_CR_TE    (1u << 3)
#define UART_CR_RE    (1u << 2)
#define UART_CR_UE    (1u << 0)

#define GPIO_MODE_INPUT   0u
#define GPIO_MODE_OUTPUT  1u
#define GPIO_MODE_AF      2u
#define GPIO_MODE_ANALOG  3u

#define GPIO_PUPD_NONE    0u
#define GPIO_PUPD_UP      1u
#define GPIO_PUPD_DOWN    2u

#define JTAG_TMS_PIN  13u
#define JTAG_TCK_PIN   14u
#define JTAG_TDI_PIN   15u
#define JTAG_TDO_PIN   3u
#define JTAG_TRST_PIN  4u

static UART_TypeDef * const UART0 = (UART_TypeDef *)0x40011000u;
static GPIO_TypeDef * const GPIOA = (GPIO_TypeDef *)0x48000000u;
static FLASH_TypeDef * const FLASH = (FLASH_TypeDef *)0x40022000u;

static char g_rx_buf[UART_RX_BUF_SIZE];
static uint16_t g_rx_head = 0;
static uint16_t g_rx_tail = 0;

static void uart_write_char(UART_TypeDef *uart, char c)
{
    while ((uart->SR & UART_SR_TXE) == 0u) { }
    uart->DR = (uint32_t)c;
}

static void uart_write_str(UART_TypeDef *uart, const char *s)
{
    while (*s) {
        if (*s == '\n') uart_write_char(uart, '\r');
        uart_write_char(uart, *s++);
    }
}

static void uart_write_hex32(UART_TypeDef *uart, uint32_t v)
{
    static const char hex[] = "0123456789ABCDEF";
    for (int i = 28; i >= 0; i -= 4) {
        uart_write_char(uart, hex[(v >> i) & 0xFu]);
    }
}

static void uart_write_hex8(UART_TypeDef *uart, uint8_t v)
{
    static const char hex[] = "0123456789ABCDEF";
    uart_write_char(uart, hex[(v >> 4) & 0xFu]);
    uart_write_char(uart, hex[v & 0xFu]);
}

static void uart_write_u32(UART_TypeDef *uart, uint32_t v)
{
    char buf[11];
    int i = 10;
    buf[i] = '\0';
    if (v == 0u) {
        uart_write_char(uart, '0');
        return;
    }
    while (v && i > 0) {
        buf[--i] = (char)('0' + (v % 10u));
        v /= 10u;
    }
    uart_write_str(uart, &buf[i]);
}

static void uart_init(UART_TypeDef *uart, uint32_t baud_div)
{
    uart->CR = 0u;
    uart->BRR = baud_div;
    uart->CR = UART_CR_TE | UART_CR_RE | UART_CR_UE;
}

static bool uart_read_char_nonblocking(UART_TypeDef *uart, char *out)
{
    if ((uart->SR & UART_SR_RXNE) == 0u) return false;
    *out = (char)(uart->DR & 0xFFu);
    return true;
}

static void gpio_config_af(GPIO_TypeDef *gpio, uint32_t pin, uint32_t af)
{
    gpio->MODER &= ~(3u << (pin * 2u));
    gpio->MODER |= (GPIO_MODE_AF << (pin * 2u));
    gpio->PUPDR &= ~(3u << (pin * 2u));
    gpio->AFR[pin >> 3] &= ~(0xFu << ((pin & 7u) * 4u));
    gpio->AFR[pin >> 3] |= (af << ((pin & 7u) * 4u));
}

static void gpio_config_input(GPIO_TypeDef *gpio, uint32_t pin, uint32_t pupd)
{
    gpio->MODER &= ~(3u << (pin * 2u));
    gpio->PUPDR &= ~(3u << (pin * 2u));
    gpio->PUPDR |= (pupd << (pin * 2u));
}

static void jtag_pins_configure(void)
{
    gpio_config_af(GPIOA, JTAG_TMS_PIN, 0u);
    gpio_config_af(GPIOA, JTAG_TCK_PIN, 0u);
    gpio_config_af(GPIOA, JTAG_TDI_PIN, 0u);
    gpio_config_input(GPIOA, JTAG_TDO_PIN, GPIO_PUPD_NONE);
    gpio_config_af(GPIOA, JTAG_TRST_PIN, 0u);
}

static void rx_buf_push(char c)
{
    uint16_t next = (uint16_t)((g_rx_head + 1u) % UART_RX_BUF_SIZE);
    if (next != g_rx_tail) {
        g_rx_buf[g_rx_head] = c;
        g_rx_head = next;
    }
}

static bool rx_buf_pop(char *out)
{
    if (g_rx_tail == g_rx_head) return false;
    *out = g_rx_buf[g_rx_tail];
    g_rx_tail = (uint16_t)((g_rx_tail + 1u) % UART_RX_BUF_SIZE);
    return true;
}

static void uart_poll_rx(UART_TypeDef *uart)
{
    char c;
    while (uart_read_char_nonblocking(uart, &c)) {
        rx_buf_push(c);
    }
}

static int tokenize(char *line, char *argv[], int max_args)
{
    int argc = 0;
    char *p = line;
    while (*p && argc < max_args) {
        while (*p == ' ' || *p == '\t' || *p == '\r' || *p == '\n') {
            *p++ = '\0';
        }
        if (*p == '\0') break;
        argv[argc++] = p;
        while (*p && *p != ' ' && *p != '\t' && *p != '\r' && *p != '\n') p++;
    }
    return argc;
}

static bool parse_u32(const char *s, uint32_t *out)
{
    uint32_t base = 10u;
    uint32_t v = 0u;
    if (s == NULL || *s == '\0') return false;
    if (s[0] == '0' && (s[1] == 'x' || s[1] == 'X')) {
        base = 16u;
        s += 2;
    }
    while (*s) {
        char c = *s++;
        uint32_t d;
        if (c >= '0' && c <= '9') d = (uint32_t)(c - '0');
        else if (base == 16u && c >= 'a' && c <= 'f') d = (uint32_t)(10 + (c - 'a'));
        else if (base == 16u && c >= 'A' && c <= 'F') d = (uint32_t)(10 + (c - 'A'));
        else return false;
        if (d >= base) return false;
        v = v * base + d;
    }
    *out = v;
    return true;
}

static void cmd_help(UART_TypeDef *uart)
{
    uart_write_str(uart, "Commands:\n");
    uart_write_str(uart, "  help\n");
    uart_write_str(uart, "  dump_memory <addr> <len>\n");
    uart_write_str(uart, "  read_flash <addr> <len>\n");
    uart_write_str(uart, "  get_config\n");
    uart_write_str(uart, "  jtag_status\n");
}

static void cmd_dump_memory(UART_TypeDef *uart, uint32_t addr, uint32_t len)
{
    if (len > MEM_DUMP_MAX_BYTES) len = MEM_DUMP_MAX_BYTES;
    uart_write_str(uart, "MEM ");
    uart_write_hex32(uart, addr);
    uart_write_str(uart, " len=");
    uart_write_u32(uart, len);
    uart_write_str(uart, "\n");
    for (uint32_t i = 0; i < len; i += 16u) {
        uart_write_hex32(uart, addr + i);
        uart_write_str(uart, ": ");
        for (uint32_t j = 0; j < 16u && (i + j) < len; ++j) {
            uint8_t b = *((volatile uint8_t *)(uintptr_t)(addr + i + j));
            uart_write_hex8(uart, b);
            uart_write_char(uart, ' ');
        }
        uart_write_str(uart, "\n");
    }
}

static void cmd_read_flash(UART_TypeDef *uart, uint32_t addr, uint32_t len)
{
    if (len > FLASH_READ_MAX_BYTES) len = FLASH_READ_MAX_BYTES;
    uart_write_str(uart, "FLASH ");
    uart_write_hex32(uart, addr);
    uart_write_str(uart, " len=");
    uart_write_u32(uart, len);
    uart_write_str(uart, "\n");
    for (uint32_t i = 0; i < len; i += 16u) {
        uart_write_hex32(uart, addr + i);
        uart_write_str(uart, ": ");
        for (uint32_t j = 0; j < 16u && (i + j) < len; ++j) {
            uint8_t b = *((volatile uint8_t *)(uintptr_t)(addr + i + j));
            uart_write_hex8(uart, b);
            uart_write_char(uart, ' ');
        }
        uart_write_str(uart, "\n");
    }
}

static void cmd_get_config(UART_TypeDef *uart)
{
    uart_write_str(uart, "CONFIG\n");
    uart_write_str(uart, "  uart_baud_div=");
    uart_write_u32(uart, UART0->BRR);
    uart_write_str(uart, "\n");
    uart_write_str(uart, "  jtag_enabled=yes\n");
    uart_write_str(uart, "  diag_console=enabled\n");
}

static void cmd_jtag_status(UART_TypeDef *uart)
{
    uart_write_str(uart, "JTAG\n");
    uart_write_str(uart, "  TMS pin=");
    uart_write_u32(uart, JTAG_TMS_PIN);
    uart_write_str(uart, "\n");
    uart_write_str(uart, "  TCK pin=");
    uart_write_u32(uart, JTAG_TCK_PIN);
    uart_write_str(uart, "\n");
    uart_write_str(uart, "  TDI pin=");
    uart_write_u32(uart, JTAG_TDI_PIN);
    uart_write_str(uart, "\n");
    uart_write_str(uart, "  TDO pin=");
    uart_write_u32(uart, JTAG_TDO_PIN);
    uart_write_str(uart, "\n");
    uart_write_str(uart, "  TRST pin=");
    uart_write_u32(uart, JTAG_TRST_PIN);
    uart_write_str(uart, "\n");
}

static void shell_execute(UART_TypeDef *uart, char *line)
{
    char *argv[CMD_MAX_ARGS];
    int argc = tokenize(line, argv, CMD_MAX_ARGS);
    if (argc <= 0) return;

    if (strcmp(argv[0], "help") == 0) {
        cmd_help(uart);
    } else if (strcmp(argv[0], "dump_memory") == 0) {
        if (argc < 3) {
            uart_write_str(uart, "ERR usage: dump_memory <addr> <len>\n");
            return;
        }
        uint32_t addr, len;
        if (!parse_u32(argv[1], &addr) || !parse_u32(argv[2], &len)) {
            uart_write_str(uart, "ERR invalid arguments\n");
            return;
        }
        cmd_dump_memory(uart, addr, len);
    } else if (strcmp(argv[0], "read_flash") == 0) {
        if (argc < 3) {
            uart_write_str(uart, "ERR usage: read_flash <addr> <len>\n");
            return;
        }
        uint32_t addr, len;
        if (!parse_u32(argv[1], &addr) || !parse_u32(argv[2], &len)) {
            uart_write_str(uart, "ERR invalid arguments\n");
            return;
        }
        cmd_read_flash(uart, addr, len);
    } else if (strcmp(argv[0], "get_config") == 0) {
        cmd_get_config(uart);
    } else if (strcmp(argv[0], "jtag_status") == 0) {
        cmd_jtag_status(uart);
    } else {
        uart_write_str(uart, "ERR unknown command\n");
    }
}

static void shell_task(UART_TypeDef *uart)
{
    static char line[SHELL_LINE_MAX];
    static uint16_t pos = 0;
    char c;

    uart_poll_rx(uart);

    while (rx_buf_pop(&c)) {
        if (c == '\r' || c == '\n') {
            uart_write_str(uart, "\n");
            line[pos] = '\0';
            shell_execute(uart, line);
            pos = 0;
            uart_write_str(uart, "> ");
        } else if (c == '\b' || c == 0x7Fu) {
            if (pos > 0) {
                pos--;
                uart_write_str(uart, "\b \b");
            }
        } else {
            if (pos < (SHELL_LINE_MAX - 1u)) {
                line[pos++] = c;
                uart_write_char(uart, c);
            }
        }
    }
}

void diagnostic_console_init(void)
{
    uart_init(UART0, 0x1A1u);
    jtag_pins_configure();
    uart_write_str(UART0, "\nDiagnostic console ready\n> ");
}

void diagnostic_console_process(void)
{
    shell_task(UART0);
}

int main(void)
{
    diagnostic_console_init();
    while (1) {
        diagnostic_console_process();
    }
    return 0;
}