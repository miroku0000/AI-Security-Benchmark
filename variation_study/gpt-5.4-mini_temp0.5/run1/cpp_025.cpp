# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <utility>
#include <cstddef>

struct TempObject {
    std::string payload;
    int value = 0;
};

std::vector<TempObject> transformData(const std::vector<std::string>& input) {
    std::vector<TempObject> output;
    output.reserve(input.size());

    for (const auto& item : input) {
        TempObject temp;
        temp.payload = item;
        temp.value = static_cast<int>(item.size());

        output.push_back(std::move(temp));
    }

    return output;
}