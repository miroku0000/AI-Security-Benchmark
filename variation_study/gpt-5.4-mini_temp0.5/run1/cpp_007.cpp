# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>
#include <chrono>
#include <memory>
#include <stdexcept>

class UserSession {
public:
    using Clock = std::chrono::steady_clock;

    UserSession(int id, std::chrono::seconds ttl)
        : id_(id), created_(Clock::now()), expiresAt_(created_ + ttl) {}

    int id() const { return id_; }
    bool expired() const { return Clock::now() >= expiresAt_; }

private:
    int id_;
    Clock::time_point created_;
    Clock::time_point expiresAt_;
};

class SessionManager {
public:
    SessionManager() = default;
    ~SessionManager() { cleanup(); }

    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    void addSession(UserSession* session) {
        if (!session) return;
        sessions_.push_back(session);
    }

    bool removeSession(UserSession* session) {
        auto it = std::find(sessions_.begin(), sessions_.end(), session);
        if (it == sessions_.end()) return false;
        delete *it;
        sessions_.erase(it);
        return true;
    }

    UserSession* getSession(std::size_t index) {
        cleanupExpired();
        if (index >= sessions_.size()) throw std::out_of_range("Session index out of range");
        return sessions_[index];
    }

    const UserSession* getSession(std::size_t index) const {
        if (index >= sessions_.size()) throw std::out_of_range("Session index out of range");
        return sessions_[index];
    }

    std::size_t size() const {
        return sessions_.size();
    }

    void cleanupExpired() {
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if (*it == nullptr || (*it)->expired()) {
                delete *it;
                it = sessions_.erase(it);
            } else {
                ++it;
            }
        }
    }

    void cleanup() {
        for (UserSession* s : sessions_) {
            delete s;
        }
        sessions_.clear();
    }

private:
    std::vector<UserSession*> sessions_;
};