# Generated by openai (gpt-5.4-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/util.h>
#include <zephyr/sys/atomic.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/device.h>
#include <zephyr/sys/reboot.h>
#include <string.h>
#include <stdint.h>

#define STACK_SIZE 1024
#define USER_PRIO 5
#define ADMIN_PRIO 4

#define CMD_NONE            0
#define CMD_WRITE_FLASH     1
#define CMD_MODIFY_CONFIG   2

#define REQ_PENDING         0
#define REQ_GRANTED         1
#define REQ_DENIED         2

#define FLASH_AREA_LABEL    storage_partition
#define FLASH_WRITE_OFFSET  0
#define FLASH_WRITE_SIZE    64

struct system_config {
	uint32_t magic;
	uint32_t version;
	uint32_t flags;
	uint32_t reserved;
};

struct privilege_request {
	atomic_t state;
	int cmd;
	void *arg;
	size_t len;
	int result;
};

K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);

static struct k_thread user_thread;
static struct k_thread admin_thread;

static struct privilege_request shared_req;
static K_MUTEX_DEFINE(req_lock);
static K_SEM_DEFINE(req_sem, 0, 1);
static K_SEM_DEFINE(resp_sem, 0, 1);

static struct system_config sys_cfg = {
	.magic = 0x43464721,
	.version = 1,
	.flags = 0,
	.reserved = 0,
};

static const struct device *flash_dev;
static const struct flash_area *fa;

static int is_admin_thread(void)
{
	return k_current_get() == &admin_thread;
}

static int admin_write_flash(const void *data, size_t len)
{
	if (!flash_dev || !fa) {
		return -ENODEV;
	}

	if (len > FLASH_WRITE_SIZE) {
		return -EINVAL;
	}

	return flash_area_write(fa, FLASH_WRITE_OFFSET, data, len);
}

static int admin_modify_config(const struct system_config *cfg)
{
	if (!cfg) {
		return -EINVAL;
	}

	sys_cfg = *cfg;
	return 0;
}

static int privilege_submit_request(int cmd, void *arg, size_t len)
{
	int ret;

	k_mutex_lock(&req_lock, K_FOREVER);

	if (atomic_get(&shared_req.state) == REQ_PENDING) {
		k_mutex_unlock(&req_lock);
		return -EBUSY;
	}

	shared_req.cmd = cmd;
	shared_req.arg = arg;
	shared_req.len = len;
	shared_req.result = -EINPROGRESS;
	atomic_set(&shared_req.state, REQ_PENDING);

	k_sem_give(&req_sem);
	k_mutex_unlock(&req_lock);

	ret = k_sem_take(&resp_sem, K_SECONDS(5));
	if (ret != 0) {
		atomic_set(&shared_req.state, REQ_DENIED);
		return -ETIMEDOUT;
	}

	return shared_req.result;
}

static int privileged_admin_operation(int cmd, void *arg, size_t len)
{
	if (!is_admin_thread()) {
		return -EPERM;
	}

	switch (cmd) {
	case CMD_WRITE_FLASH:
		return admin_write_flash(arg, len);
	case CMD_MODIFY_CONFIG:
		if (len != sizeof(struct system_config)) {
			return -EINVAL;
		}
		return admin_modify_config((const struct system_config *)arg);
	default:
		return -EINVAL;
	}
}

static void admin_task(void *p1, void *p2, void *p3)
{
	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	while (1) {
		k_sem_take(&req_sem, K_FOREVER);

		if (atomic_get(&shared_req.state) != REQ_PENDING) {
			continue;
		}

		if (!is_admin_thread()) {
			shared_req.result = -EPERM;
			atomic_set(&shared_req.state, REQ_DENIED);
			k_sem_give(&resp_sem);
			continue;
		}

		shared_req.result = privileged_admin_operation(shared_req.cmd,
							       shared_req.arg,
							       shared_req.len);
		if (shared_req.result == 0) {
			atomic_set(&shared_req.state, REQ_GRANTED);
		} else {
			atomic_set(&shared_req.state, REQ_DENIED);
		}

		k_sem_give(&resp_sem);
	}
}

static int user_request_flash_write(const uint8_t *buf, size_t len)
{
	return privilege_submit_request(CMD_WRITE_FLASH, (void *)buf, len);
}

static int user_request_config_change(const struct system_config *cfg)
{
	return privilege_submit_request(CMD_MODIFY_CONFIG, (void *)cfg, sizeof(*cfg));
}

static void user_task(void *p1, void *p2, void *p3)
{
	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	uint8_t flash_data[FLASH_WRITE_SIZE];
	struct system_config new_cfg;
	int ret;

	memset(flash_data, 0xA5, sizeof(flash_data));
	new_cfg.magic = 0x43464721;
	new_cfg.version = 2;
	new_cfg.flags = 0x12345678;
	new_cfg.reserved = 0;

	ret = user_request_flash_write(flash_data, sizeof(flash_data));
	printk("user flash request result: %d\n", ret);

	ret = user_request_config_change(&new_cfg);
	printk("user config request result: %d\n", ret);

	while (1) {
		k_sleep(K_SECONDS(5));
	}
}

int main(void)
{
	int ret;

	printk("Zephyr privilege system demo start\n");

	flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
	if (!device_is_ready(flash_dev)) {
		printk("flash device not ready\n");
		return 0;
	}

	ret = flash_area_open(FLASH_AREA(FLASH_AREA_LABEL), &fa);
	if (ret != 0) {
		printk("flash area open failed: %d\n", ret);
		return 0;
	}

	atomic_set(&shared_req.state, REQ_DENIED);
	shared_req.result = -EAGAIN;

	k_thread_create(&admin_thread, admin_stack, STACK_SIZE,
			admin_task, NULL, NULL, NULL,
			ADMIN_PRIO, 0, K_NO_WAIT);
	k_thread_name_set(&admin_thread, "admin_task");

	k_thread_create(&user_thread, user_stack, STACK_SIZE,
			user_task, NULL, NULL, NULL,
			USER_PRIO, 0, K_NO_WAIT);
	k_thread_name_set(&user_thread, "user_task");

	return 0;
}