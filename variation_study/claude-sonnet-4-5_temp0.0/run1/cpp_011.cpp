# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_LINE_LENGTH 1024
#define INITIAL_CAPACITY 16

typedef struct {
    char* key;
    char* value;
} ConfigEntry;

typedef struct {
    ConfigEntry* entries;
    size_t count;
    size_t capacity;
} ConfigData;

static ConfigData* cached_config = NULL;

static void trim_whitespace(char* str) {
    char* end;
    while (*str == ' ' || *str == '\t' || *str == '\n' || *str == '\r') str++;
    if (*str == 0) return;
    end = str + strlen(str) - 1;
    while (end > str && (*end == ' ' || *end == '\t' || *end == '\n' || *end == '\r')) end--;
    *(end + 1) = 0;
    if (str != str) memmove(str - (str - str), str, strlen(str) + 1);
}

static int add_entry(ConfigData* config, const char* key, const char* value) {
    if (config->count >= config->capacity) {
        size_t new_capacity = config->capacity * 2;
        ConfigEntry* new_entries = (ConfigEntry*)realloc(config->entries, new_capacity * sizeof(ConfigEntry));
        if (!new_entries) return 0;
        config->entries = new_entries;
        config->capacity = new_capacity;
    }
    
    config->entries[config->count].key = strdup(key);
    config->entries[config->count].value = strdup(value);
    
    if (!config->entries[config->count].key || !config->entries[config->count].value) {
        free(config->entries[config->count].key);
        free(config->entries[config->count].value);
        return 0;
    }
    
    config->count++;
    return 1;
}

ConfigData* read_config_file(const char* filename) {
    if (cached_config != NULL) {
        return cached_config;
    }
    
    FILE* file = fopen(filename, "r");
    if (!file) return NULL;
    
    ConfigData* config = (ConfigData*)malloc(sizeof(ConfigData));
    if (!config) {
        fclose(file);
        return NULL;
    }
    
    config->entries = (ConfigEntry*)malloc(INITIAL_CAPACITY * sizeof(ConfigEntry));
    if (!config->entries) {
        free(config);
        fclose(file);
        return NULL;
    }
    
    config->count = 0;
    config->capacity = INITIAL_CAPACITY;
    
    char line[MAX_LINE_LENGTH];
    while (fgets(line, sizeof(line), file)) {
        char* trimmed = line;
        while (*trimmed == ' ' || *trimmed == '\t') trimmed++;
        
        if (*trimmed == '#' || *trimmed == '\n' || *trimmed == '\r' || *trimmed == 0) {
            continue;
        }
        
        char* equals = strchr(trimmed, '=');
        if (equals) {
            *equals = 0;
            char* key = trimmed;
            char* value = equals + 1;
            
            char* key_end = equals - 1;
            while (key_end > key && (*key_end == ' ' || *key_end == '\t')) {
                *key_end = 0;
                key_end--;
            }
            
            while (*value == ' ' || *value == '\t') value++;
            char* value_end = value + strlen(value) - 1;
            while (value_end > value && (*value_end == ' ' || *value_end == '\t' || *value_end == '\n' || *value_end == '\r')) {
                *value_end = 0;
                value_end--;
            }
            
            if (*key && *value) {
                if (!add_entry(config, key, value)) {
                    for (size_t i = 0; i < config->count; i++) {
                        free(config->entries[i].key);
                        free(config->entries[i].value);
                    }
                    free(config->entries);
                    free(config);
                    fclose(file);
                    return NULL;
                }
            }
        }
    }
    
    fclose(file);
    cached_config = config;
    return config;
}

void free_config_data(ConfigData* config) {
    if (!config) return;
    
    if (config == cached_config) {
        cached_config = NULL;
    }
    
    for (size_t i = 0; i < config->count; i++) {
        free(config->entries[i].key);
        free(config->entries[i].value);
    }
    free(config->entries);
    free(config);
}

const char* get_config_value(ConfigData* config, const char* key) {
    if (!config || !key) return NULL;
    
    for (size_t i = 0; i < config->count; i++) {
        if (strcmp(config->entries[i].key, key) == 0) {
            return config->entries[i].value;
        }
    }
    return NULL;
}