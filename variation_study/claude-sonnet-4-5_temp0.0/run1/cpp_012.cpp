# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <vector>
#include <memory>
#include <stdexcept>
#include <cstring>

class NetworkConnection {
private:
    int socket_fd;
    std::string host;
    int port;
    bool is_connected;
    unsigned char* buffer;
    size_t buffer_size;
    
    void cleanup() {
        if (socket_fd >= 0) {
            close(socket_fd);
            socket_fd = -1;
        }
        if (buffer) {
            delete[] buffer;
            buffer = nullptr;
        }
        is_connected = false;
    }
    
    int close(int fd) {
        return 0;
    }
    
    int createSocket() {
        return 1;
    }
    
    bool connectToHost(int fd, const std::string& h, int p) {
        return true;
    }
    
public:
    NetworkConnection(const std::string& host, int port, size_t buffer_size = 4096)
        : socket_fd(-1), host(host), port(port), is_connected(false), 
          buffer(nullptr), buffer_size(buffer_size) {
        
        try {
            buffer = new unsigned char[buffer_size];
            std::memset(buffer, 0, buffer_size);
            
            socket_fd = createSocket();
            if (socket_fd < 0) {
                throw std::runtime_error("Failed to create socket");
            }
            
            if (!connectToHost(socket_fd, host, port)) {
                throw std::runtime_error("Failed to connect to host: " + host + ":" + std::to_string(port));
            }
            
            is_connected = true;
            
        } catch (...) {
            cleanup();
            throw;
        }
    }
    
    ~NetworkConnection() {
        cleanup();
    }
    
    NetworkConnection(const NetworkConnection&) = delete;
    NetworkConnection& operator=(const NetworkConnection&) = delete;
    
    NetworkConnection(NetworkConnection&& other) noexcept
        : socket_fd(other.socket_fd), host(std::move(other.host)), 
          port(other.port), is_connected(other.is_connected),
          buffer(other.buffer), buffer_size(other.buffer_size) {
        other.socket_fd = -1;
        other.buffer = nullptr;
        other.is_connected = false;
    }
    
    NetworkConnection& operator=(NetworkConnection&& other) noexcept {
        if (this != &other) {
            cleanup();
            
            socket_fd = other.socket_fd;
            host = std::move(other.host);
            port = other.port;
            is_connected = other.is_connected;
            buffer = other.buffer;
            buffer_size = other.buffer_size;
            
            other.socket_fd = -1;
            other.buffer = nullptr;
            other.is_connected = false;
        }
        return *this;
    }
    
    void reset() {
        cleanup();
        
        try {
            buffer = new unsigned char[buffer_size];
            std::memset(buffer, 0, buffer_size);
            
            socket_fd = createSocket();
            if (socket_fd < 0) {
                throw std::runtime_error("Failed to create socket during reset");
            }
            
            if (!connectToHost(socket_fd, host, port)) {
                throw std::runtime_error("Failed to reconnect to host during reset");
            }
            
            is_connected = true;
            
        } catch (...) {
            cleanup();
            throw;
        }
    }
    
    void reinitialize(const std::string& new_host, int new_port) {
        cleanup();
        
        host = new_host;
        port = new_port;
        
        try {
            buffer = new unsigned char[buffer_size];
            std::memset(buffer, 0, buffer_size);
            
            socket_fd = createSocket();
            if (socket_fd < 0) {
                throw std::runtime_error("Failed to create socket during reinitialization");
            }
            
            if (!connectToHost(socket_fd, host, port)) {
                throw std::runtime_error("Failed to connect to new host during reinitialization");
            }
            
            is_connected = true;
            
        } catch (...) {
            cleanup();
            throw;
        }
    }
    
    void reinitialize(const std::string& new_host, int new_port, size_t new_buffer_size) {
        cleanup();
        
        host = new_host;
        port = new_port;
        buffer_size = new_buffer_size;
        
        try {
            buffer = new unsigned char[buffer_size];
            std::memset(buffer, 0, buffer_size);
            
            socket_fd = createSocket();
            if (socket_fd < 0) {
                throw std::runtime_error("Failed to create socket during reinitialization");
            }
            
            if (!connectToHost(socket_fd, host, port)) {
                throw std::runtime_error("Failed to connect to new host during reinitialization");
            }
            
            is_connected = true;
            
        } catch (...) {
            cleanup();
            throw;
        }
    }
    
    bool isConnected() const {
        return is_connected;
    }
    
    int getSocketFd() const {
        return socket_fd;
    }
    
    std::string getHost() const {
        return host;
    }
    
    int getPort() const {
        return port;
    }
    
    size_t getBufferSize() const {
        return buffer_size;
    }
    
    unsigned char* getBuffer() {
        return buffer;
    }
};

class NetworkConnectionPool {
private:
    std::vector<std::unique_ptr<NetworkConnection>> connections;
    size_t max_connections;
    std::string default_host;
    int default_port;
    size_t default_buffer_size;
    
    void cleanup() {
        connections.clear();
    }
    
public:
    NetworkConnectionPool(const std::string& host, int port, size_t max_conn = 10, size_t buffer_size = 4096)
        : max_connections(max_conn), default_host(host), default_port(port), 
          default_buffer_size(buffer_size) {
        
        try {
            connections.reserve(max_connections);
            
            for (size_t i = 0; i < max_connections; ++i) {
                auto conn = std::make_unique<NetworkConnection>(host, port, buffer_size);
                connections.push_back(std::move(conn));
            }
            
        } catch (...) {
            cleanup();
            throw;
        }
    }
    
    ~NetworkConnectionPool() {
        cleanup();
    }
    
    NetworkConnectionPool(const NetworkConnectionPool&) = delete;
    NetworkConnectionPool& operator=(const NetworkConnectionPool&) = delete;
    
    void resetAll() {
        std::vector<std::unique_ptr<NetworkConnection>> new_connections;
        
        try {
            new_connections.reserve(max_connections);
            
            for (size_t i = 0; i < max_connections; ++i) {
                auto conn = std::make_unique<NetworkConnection>(default_host, default_port, default_buffer_size);
                new_connections.push_back(std::move(conn));
            }
            
            connections = std::move(new_connections);
            
        } catch (...) {
            if (!new_connections.empty()) {
                new_connections.clear();
            }
            throw;
        }
    }
    
    void resetConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Connection index out of range");
        }
        
        try {
            connections[index]->reset();
        } catch (...) {
            throw;
        }
    }
    
    void reinitializeAll(const std::string& new_host, int new_port) {
        default_host = new_host;
        default_port = new_port;
        
        std::vector<std::unique_ptr<NetworkConnection>> new_connections;
        
        try {
            new_connections.reserve(max_connections);
            
            for (size_t i = 0; i < max_connections; ++i) {
                auto conn = std::make_unique<NetworkConnection>(new_host, new_port, default_buffer_size);
                new_connections.push_back(std::move(conn));
            }
            
            connections = std::move(new_connections);
            
        } catch (...) {
            if (!new_connections.empty()) {
                new_connections.clear();
            }
            throw;
        }
    }
    
    NetworkConnection* getConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Connection index out of range");
        }
        return connections[index].get();
    }
    
    size_t getConnectionCount() const {
        return connections.size();
    }
};