# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <errno.h>
#include <fcntl.h>
#include <sys/select.h>

#define PORT 8080
#define MAX_CONNECTIONS 100
#define BUFFER_SIZE 8192
#define MAX_HEADER_SIZE 4096
#define BACKLOG 50

typedef struct {
    char *buffer;
    size_t size;
    size_t capacity;
} RequestBuffer;

typedef struct {
    int fd;
    RequestBuffer *req_buffer;
    int active;
} Connection;

RequestBuffer* create_request_buffer(size_t initial_capacity) {
    RequestBuffer *rb = (RequestBuffer*)malloc(sizeof(RequestBuffer));
    rb->buffer = (char*)malloc(initial_capacity);
    rb->size = 0;
    rb->capacity = initial_capacity;
    return rb;
}

void reset_request_buffer(RequestBuffer *rb) {
    rb->size = 0;
    memset(rb->buffer, 0, rb->capacity);
}

void free_request_buffer(RequestBuffer *rb) {
    free(rb->buffer);
    free(rb);
}

int set_nonblocking(int fd) {
    int flags = fcntl(fd, F_GETFL, 0);
    if (flags == -1) return -1;
    return fcntl(fd, F_SETFL, flags | O_NONBLOCK);
}

void parse_request_line(const char *buffer, char *method, char *path, char *version) {
    sscanf(buffer, "%s %s %s", method, path, version);
}

void process_request(Connection *conn) {
    char method[16] = {0};
    char path[256] = {0};
    char version[16] = {0};
    
    parse_request_line(conn->req_buffer->buffer, method, path, version);
    
    const char *response_200 = 
        "HTTP/1.1 200 OK\r\n"
        "Content-Type: text/html\r\n"
        "Content-Length: 13\r\n"
        "Connection: keep-alive\r\n"
        "\r\n"
        "Hello, World!";
    
    const char *response_404 = 
        "HTTP/1.1 404 Not Found\r\n"
        "Content-Type: text/html\r\n"
        "Content-Length: 9\r\n"
        "Connection: keep-alive\r\n"
        "\r\n"
        "Not Found";
    
    const char *response;
    if (strcmp(path, "/") == 0 || strcmp(path, "/index.html") == 0) {
        response = response_200;
    } else {
        response = response_404;
    }
    
    send(conn->fd, response, strlen(response), MSG_NOSIGNAL);
}

int is_request_complete(const char *buffer, size_t size) {
    if (size < 4) return 0;
    
    for (size_t i = 0; i <= size - 4; i++) {
        if (buffer[i] == '\r' && buffer[i+1] == '\n' && 
            buffer[i+2] == '\r' && buffer[i+3] == '\n') {
            return 1;
        }
    }
    return 0;
}

void handle_client_data(Connection *conn) {
    char temp_buffer[BUFFER_SIZE];
    ssize_t bytes_read;
    
    while ((bytes_read = recv(conn->fd, temp_buffer, sizeof(temp_buffer) - 1, 0)) > 0) {
        if (conn->req_buffer->size + bytes_read >= conn->req_buffer->capacity) {
            size_t new_capacity = conn->req_buffer->capacity * 2;
            char *new_buffer = (char*)realloc(conn->req_buffer->buffer, new_capacity);
            if (!new_buffer) {
                conn->active = 0;
                return;
            }
            conn->req_buffer->buffer = new_buffer;
            conn->req_buffer->capacity = new_capacity;
        }
        
        memcpy(conn->req_buffer->buffer + conn->req_buffer->size, temp_buffer, bytes_read);
        conn->req_buffer->size += bytes_read;
        conn->req_buffer->buffer[conn->req_buffer->size] = '\0';
        
        if (is_request_complete(conn->req_buffer->buffer, conn->req_buffer->size)) {
            process_request(conn);
            reset_request_buffer(conn->req_buffer);
        }
        
        if (conn->req_buffer->size > MAX_HEADER_SIZE) {
            const char *response_413 = 
                "HTTP/1.1 413 Payload Too Large\r\n"
                "Content-Length: 0\r\n"
                "Connection: close\r\n\r\n";
            send(conn->fd, response_413, strlen(response_413), MSG_NOSIGNAL);
            conn->active = 0;
            return;
        }
    }
    
    if (bytes_read == 0) {
        conn->active = 0;
    } else if (bytes_read < 0 && errno != EAGAIN && errno != EWOULDBLOCK) {
        conn->active = 0;
    }
}

int main() {
    int server_fd;
    struct sockaddr_in address;
    int opt = 1;
    Connection connections[MAX_CONNECTIONS] = {0};
    
    for (int i = 0; i < MAX_CONNECTIONS; i++) {
        connections[i].fd = -1;
        connections[i].req_buffer = NULL;
        connections[i].active = 0;
    }
    
    if ((server_fd = socket(AF_INET, SOCK_STREAM, 0)) == 0) {
        perror("socket failed");
        exit(EXIT_FAILURE);
    }
    
    if (setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR, &opt, sizeof(opt))) {
        perror("setsockopt");
        exit(EXIT_FAILURE);
    }
    
    address.sin_family = AF_INET;
    address.sin_addr.s_addr = INADDR_ANY;
    address.sin_port = htons(PORT);
    
    if (bind(server_fd, (struct sockaddr *)&address, sizeof(address)) < 0) {
        perror("bind failed");
        exit(EXIT_FAILURE);
    }
    
    if (listen(server_fd, BACKLOG) < 0) {
        perror("listen");
        exit(EXIT_FAILURE);
    }
    
    set_nonblocking(server_fd);
    
    printf("Server listening on port %d\n", PORT);
    
    while (1) {
        fd_set read_fds;
        int max_fd = server_fd;
        
        FD_ZERO(&read_fds);
        FD_SET(server_fd, &read_fds);
        
        for (int i = 0; i < MAX_CONNECTIONS; i++) {
            if (connections[i].active && connections[i].fd > 0) {
                FD_SET(connections[i].fd, &read_fds);
                if (connections[i].fd > max_fd) {
                    max_fd = connections[i].fd;
                }
            }
        }
        
        struct timeval timeout;
        timeout.tv_sec = 1;
        timeout.tv_usec = 0;
        
        int activity = select(max_fd + 1, &read_fds, NULL, NULL, &timeout);
        
        if (activity < 0 && errno != EINTR) {
            perror("select error");
            continue;
        }
        
        if (FD_ISSET(server_fd, &read_fds)) {
            struct sockaddr_in client_addr;
            socklen_t client_len = sizeof(client_addr);
            int new_socket = accept(server_fd, (struct sockaddr *)&client_addr, &client_len);
            
            if (new_socket >= 0) {
                set_nonblocking(new_socket);
                
                int slot = -1;
                for (int i = 0; i < MAX_CONNECTIONS; i++) {
                    if (!connections[i].active) {
                        slot = i;
                        break;
                    }
                }
                
                if (slot >= 0) {
                    connections[slot].fd = new_socket;
                    connections[slot].active = 1;
                    if (!connections[slot].req_buffer) {
                        connections[slot].req_buffer = create_request_buffer(BUFFER_SIZE);
                    } else {
                        reset_request_buffer(connections[slot].req_buffer);
                    }
                } else {
                    close(new_socket);
                }
            }
        }
        
        for (int i = 0; i < MAX_CONNECTIONS; i++) {
            if (connections[i].active && connections[i].fd > 0 && 
                FD_ISSET(connections[i].fd, &read_fds)) {
                handle_client_data(&connections[i]);
                
                if (!connections[i].active) {
                    close(connections[i].fd);
                    connections[i].fd = -1;
                    reset_request_buffer(connections[i].req_buffer);
                }
            }
        }
    }
    
    for (int i = 0; i < MAX_CONNECTIONS; i++) {
        if (connections[i].req_buffer) {
            free_request_buffer(connections[i].req_buffer);
        }
        if (connections[i].fd > 0) {
            close(connections[i].fd);
        }
    }
    
    close(server_fd);
    return 0;
}