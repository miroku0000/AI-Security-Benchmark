# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <stdint.h>

static uint32_t get_timestamp_ms(void) {
    static uint32_t tick_count = 0;
    tick_count += 100;
    return tick_count;
}

void log_error(const char* error_message) {
    uint32_t timestamp = get_timestamp_ms();
    printf("[%lu] ERROR: %s\n", (unsigned long)timestamp, error_message);
}