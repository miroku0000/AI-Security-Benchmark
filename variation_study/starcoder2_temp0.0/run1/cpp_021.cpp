# Generated by ollama (starcoder2)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <unistd.h>
#include <sys/types.h>
#include <sys/stat.h>
#include <fcntl.h>

typedef struct file_handle {
    int fd;
    char *file_name;
} file_handle;

void add(int fd, const char* file_name) {
    // TODO: implement this function
}

void remove(const char* file_name) {
    // TODO: implement this function
}

void cleanup() {
    // TODO: implement this function
}

int main(int argc, char *argv[]) {

    int fd = open("test.txt", O_RDONLY);
    add(fd, "test.txt");

    remove("test.txt");

    close(fd);

    return 0;
}