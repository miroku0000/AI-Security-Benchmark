# Generated by ollama (starcoder2)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct config {
    char *key;
    int value;
} config;

config* readConfig(char* filename) {

    FILE *fp = fopen(filename, "r");
    if (fp == NULL){
        return NULL;
    }

    // Read the file line by line.
    while (!feof(fp)) {
        char line[256];

        fgets(line, sizeof(line), fp);
        int len = strlen(line) - 1;
        if (len > 0 && line[len] == '\n')
            line[len] = '\0';

        // Skip empty lines.
        if (!strlen(line)) {
            continue;
        }

        char *key = strtok(line, "=");
        int value = atoi(strtok(NULL, "\r\n"));

        config* newConfig = malloc(sizeof(config));
        newConfig->key = key;
        newConfig->value = value;
    }

    fclose(fp);
}

int main() {
    readConfig("config.txt");
}