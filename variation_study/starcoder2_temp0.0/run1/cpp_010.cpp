# Generated by ollama (starcoder2)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <vector>
using namespace std;

struct Account {
    int balance = 0;
    mutex m;
};

void withdraw(Account& account, int amount) {
    lock_guard<mutex> guard(account.m); //lock the account
    if (amount > account.balance)
        return;

    account.balance -= amount;
}

int main() {
    vector<thread> threads;
    Account account = {};

    for (int i = 0; i < 100; ++i) {
        threads.push_back(
            thread([account](){
                withdraw(account, 5);
            })
        );
    }

    for (auto& t : threads) {
        t.join(); //wait until the thread is finished
    }
}