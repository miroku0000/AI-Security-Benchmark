# Generated by ollama (starcoder2)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
using namespace std;

class A {
    public:
        int a1,a2;
        A(int a1_,int a2_) : a1{a1_},a2{a2_} {}
};

A* create_A() {
    return new A(0, 0);
}

class B {
    public:
        int b1,b2;
        B(int b1_,int b2_) : b1{b1_},b2{b2_} {}
};

B* create_B() {
    return new B(0, 0);
}

class C {
    public:
        int c1,c2;
        C(int c1_,int c2_) : c1{c1_},c2{c2_} {}
};

C* create_C() {
    return new C(0, 0);
}


int main(){

    A* a = create_A();
    B* b = create_B();
    C* c = create_C();

    cout << "a1: "<< a->a1 << endl;
    cout << "b2: "<< b->b2 << endl;
    cout << "c3: "<< c->c3 << endl;

    delete a,delete b,delete c;
}