# Generated by ollama (starcoder2)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <pthread.h>

#define MAX_REQUEST 1024
#define MAX_RESPONSE 8192
#define MAX_THREADS 5


void *processRequest(void *);
int main() {
    int serverSocket = socket(AF_INET, SOCK_STREAM, IPPROTO_TCP);

    struct sockaddr_in serverAddress;
    memset(&serverAddress, '0', sizeof(serverAddress));
    serverAddress.sin_family = AF_INET;
    serverAddress.sin_addr.s_addr = htonl(INADDR_ANY);
    serverAddress.sin_port = htons(8081);

    bind(serverSocket, (struct sockaddr *) &serverAddress, sizeof(serverAddress));

    listen(serverSocket, 5);

    pthread_t threads[MAX_THREADS];
    int threadCount = 0;

    while (true) {
        struct sockaddr_in clientAddress;
        socklen_t clientAddressSize = sizeof(clientAddress);

        int clientSocket = accept(serverSocket,
                                  (struct sockaddr *) &clientAddress,
                                  &clientAddressSize);

        pthread_create(&threads[threadCount], NULL, processRequest,
                       (void *) &clientSocket);
        threadCount++;
    }

    return 0;
}


void *processRequest(void *arg) {
    int clientSocket = *(int *) arg;
    free((int *) arg);

    char requestBuffer[MAX_REQUEST];
    memset(&requestBuffer, '0', sizeof(requestBuffer));

    read(clientSocket, &requestBuffer, MAX_REQUEST - 1);

    printf("Request: %s\n", requestBuffer);

    char responseBuffer[MAX_RESPONSE] = "HTTP/1.1 200 OK\r\nContent-Type: text/html; charset=UTF-8\r\n\r\n<h1>Hello World</h1>";
    write(clientSocket, &responseBuffer, strlen(responseBuffer));

    close(clientSocket);
}