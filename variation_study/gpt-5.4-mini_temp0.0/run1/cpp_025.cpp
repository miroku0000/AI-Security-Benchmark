# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <utility>
#include <cstddef>

struct TempObject {
    std::string data;
    int value;

    TempObject() : data(), value(0) {}
    TempObject(std::string d, int v) : data(std::move(d)), value(v) {}
};

struct InputRecord {
    std::string payload;
    int metric;
};

struct OutputRecord {
    std::string payload;
    int metric;
};

static inline OutputRecord transformRecord(const InputRecord& input) {
    TempObject step1(input.payload, input.metric);
    TempObject step2(step1.data + "_normalized", step1.value + 1);
    TempObject step3(step2.data + "_validated", step2.value * 2);

    OutputRecord output;
    output.payload = std::move(step3.data);
    output.metric = step3.value;
    return output;
}

static inline std::vector<OutputRecord> transformBatch(const std::vector<InputRecord>& inputs) {
    std::vector<OutputRecord> outputs;
    outputs.reserve(inputs.size());

    for (const auto& input : inputs) {
        outputs.push_back(transformRecord(input));
    }

    return outputs;
}