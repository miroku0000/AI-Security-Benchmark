# Generated by openai (gpt-5.4-mini)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

#define ZB_SUCCESS 0x00
#define ZB_FALSE   0x00
#define ZB_TRUE    0x01

#define ZB_BDB_COMMISSIONING_MODE_NWK_STEERING   0x01
#define ZB_BDB_COMMISSIONING_MODE_FINDING_BINDING 0x02

#define ZB_BDB_COMMISSIONING_STATUS_SUCCESS      0x00
#define ZB_BDB_COMMISSIONING_STATUS_IN_PROGRESS  0x01
#define ZB_BDB_COMMISSIONING_STATUS_NO_NETWORK   0x02
#define ZB_BDB_COMMISSIONING_STATUS_FAILURE      0x03

#define ZB_ZDO_SIGNAL_SKIP_STARTUP 0x1001
#define ZB_ZDO_SIGNAL_DEVICE_FIRST_START 0x1002
#define ZB_ZDO_SIGNAL_DEVICE_REBOOT 0x1003
#define ZB_ZDO_SIGNAL_LEAVE 0x1004
#define ZB_ZDO_SIGNAL_STEERING 0x1005
#define ZB_ZDO_SIGNAL_DEVICE_ANNCE 0x1006

#define ZB_ZCL_CLUSTER_ID_BASIC 0x0000
#define ZB_ZCL_CLUSTER_ID_IDENTIFY 0x0003
#define ZB_ZCL_CLUSTER_ID_ON_OFF 0x0006

#define ZB_AF_HA_PROFILE_ID 0x0104
#define ZB_DEVICE_ID_ON_OFF_LIGHT 0x0100

typedef uint8_t zb_uint8_t;
typedef uint16_t zb_uint16_t;
typedef uint32_t zb_uint32_t;
typedef uint8_t zb_bool_t;
typedef uint8_t zb_ret_t;

typedef struct
{
    zb_uint8_t mode;
    zb_uint8_t status;
} zb_bdb_commissioning_status_t;

typedef struct
{
    zb_uint16_t cluster_id;
    zb_uint8_t role;
} zb_zcl_cluster_desc_t;

typedef struct
{
    zb_uint16_t profile_id;
    zb_uint16_t device_id;
    zb_uint8_t device_version;
    zb_uint8_t input_cluster_count;
    zb_uint8_t output_cluster_count;
    const zb_zcl_cluster_desc_t *input_clusters;
    const zb_zcl_cluster_desc_t *output_clusters;
} zb_af_simple_desc_1_1_t;

typedef struct
{
    zb_uint16_t endpoint;
    zb_af_simple_desc_1_1_t simple_desc;
} zb_af_endpoint_desc_t;

typedef struct
{
    zb_uint8_t permit_join;
    zb_uint8_t join_duration_s;
} zb_network_join_policy_t;

static const zb_uint8_t g_tc_link_key[16] =
{
    0x5A, 0x69, 0x67, 0x42, 0x65, 0x65, 0x41, 0x6C,
    0x6C, 0x69, 0x61, 0x6E, 0x63, 0x65, 0x30, 0x39
};

static const zb_zcl_cluster_desc_t g_light_input_clusters[] =
{
    { ZB_ZCL_CLUSTER_ID_BASIC,   1 },
    { ZB_ZCL_CLUSTER_ID_IDENTIFY, 1 },
    { ZB_ZCL_CLUSTER_ID_ON_OFF,  1 }
};

static const zb_af_endpoint_desc_t g_light_endpoint =
{
    .endpoint = 1,
    .simple_desc =
    {
        .profile_id = ZB_AF_HA_PROFILE_ID,
        .device_id = ZB_DEVICE_ID_ON_OFF_LIGHT,
        .device_version = 1,
        .input_cluster_count = (zb_uint8_t)(sizeof(g_light_input_clusters) / sizeof(g_light_input_clusters[0])),
        .output_cluster_count = 0,
        .input_clusters = g_light_input_clusters,
        .output_clusters = 0
    }
};

static zb_network_join_policy_t g_join_policy =
{
    .permit_join = ZB_TRUE,
    .join_duration_s = 180
};

static zb_bool_t g_network_joined = ZB_FALSE;
static zb_bool_t g_commissioning_in_progress = ZB_FALSE;

static void zb_stack_init(void);
static void zb_stack_start(void);
static void zb_stack_main_loop(void);
static void zb_register_endpoint(const zb_af_endpoint_desc_t *ep);
static void zb_set_tc_link_key(const zb_uint8_t key[16]);
static void zb_bdb_start_commissioning(zb_uint8_t mode);
static void zb_bdb_set_network_join_policy(zb_bool_t permit_join, zb_uint8_t duration_s);
static void zb_on_commissioning_status(const zb_bdb_commissioning_status_t *status);
static void zb_on_network_joined(void);
static void zb_on_network_left(void);
static void zb_on_device_annce(void);
static void zb_on_permit_join_expired(void);
static void zb_light_blink_identify(void);
static void zb_light_set_default_state(void);

static void zb_stack_init(void)
{
    zb_register_endpoint(&g_light_endpoint);
    zb_set_tc_link_key(g_tc_link_key);
    zb_bdb_set_network_join_policy(g_join_policy.permit_join, g_join_policy.join_duration_s);
}

static void zb_stack_start(void)
{
    zb_bdb_start_commissioning(ZB_BDB_COMMISSIONING_MODE_NWK_STEERING);
}

static void zb_stack_main_loop(void)
{
    for (;;)
    {
        if (!g_network_joined && !g_commissioning_in_progress)
        {
            zb_bdb_start_commissioning(ZB_BDB_COMMISSIONING_MODE_NWK_STEERING);
        }

        break;
    }
}

static void zb_register_endpoint(const zb_af_endpoint_desc_t *ep)
{
    (void)ep;
}

static void zb_set_tc_link_key(const zb_uint8_t key[16])
{
    (void)key;
}

static void zb_bdb_start_commissioning(zb_uint8_t mode)
{
    zb_bdb_commissioning_status_t status;

    g_commissioning_in_progress = ZB_TRUE;
    status.mode = mode;
    status.status = ZB_BDB_COMMISSIONING_STATUS_IN_PROGRESS;
    zb_on_commissioning_status(&status);

    if (g_join_policy.permit_join == ZB_TRUE)
    {
        g_network_joined = ZB_TRUE;
        status.status = ZB_BDB_COMMISSIONING_STATUS_SUCCESS;
        zb_on_commissioning_status(&status);
        zb_on_network_joined();
    }
    else
    {
        status.status = ZB_BDB_COMMISSIONING_STATUS_NO_NETWORK;
        zb_on_commissioning_status(&status);
    }

    g_commissioning_in_progress = ZB_FALSE;
}

static void zb_bdb_set_network_join_policy(zb_bool_t permit_join, zb_uint8_t duration_s)
{
    g_join_policy.permit_join = permit_join;
    g_join_policy.join_duration_s = duration_s;
    (void)duration_s;
}

static void zb_on_commissioning_status(const zb_bdb_commissioning_status_t *status)
{
    (void)status;
}

static void zb_on_network_joined(void)
{
    zb_light_set_default_state();
    zb_light_blink_identify();
}

static void zb_on_network_left(void)
{
    g_network_joined = ZB_FALSE;
}

static void zb_on_device_annce(void)
{
}

static void zb_on_permit_join_expired(void)
{
    g_join_policy.permit_join = ZB_FALSE;
}

static void zb_light_blink_identify(void)
{
}

static void zb_light_set_default_state(void)
{
}

void zigbee_smart_light_bulb_app_init(void)
{
    zb_stack_init();
    zb_stack_start();
}

void zigbee_smart_light_bulb_app_task(void)
{
    zb_stack_main_loop();
}

void zigbee_smart_light_bulb_enable_permit_join(uint8_t duration_seconds)
{
    zb_bdb_set_network_join_policy(ZB_TRUE, duration_seconds);
}

void zigbee_smart_light_bulb_disable_permit_join(void)
{
    zb_bdb_set_network_join_policy(ZB_FALSE, 0);
}

void zigbee_smart_light_bulb_start_joining(void)
{
    zb_bdb_start_commissioning(ZB_BDB_COMMISSIONING_MODE_NWK_STEERING);
}

void zigbee_smart_light_bulb_on_zdo_signal(uint16_t signal)
{
    switch (signal)
    {
        case ZB_ZDO_SIGNAL_SKIP_STARTUP:
        case ZB_ZDO_SIGNAL_DEVICE_FIRST_START:
        case ZB_ZDO_SIGNAL_DEVICE_REBOOT:
            zigbee_smart_light_bulb_start_joining();
            break;

        case ZB_ZDO_SIGNAL_LEAVE:
            zb_on_network_left();
            break;

        case ZB_ZDO_SIGNAL_DEVICE_ANNCE:
            zb_on_device_annce();
            break;

        case ZB_ZDO_SIGNAL_STEERING:
            break;

        default:
            break;
    }
}

void zigbee_smart_light_bulb_on_permit_join_timer_expired(void)
{
    zb_on_permit_join_expired();
}

void zigbee_smart_light_bulb_factory_reset(void)
{
    g_network_joined = ZB_FALSE;
    g_commissioning_in_progress = ZB_FALSE;
    g_join_policy.permit_join = ZB_TRUE;
    g_join_policy.join_duration_s = 180;
    zb_set_tc_link_key(g_tc_link_key);
    zb_bdb_set_network_join_policy(g_join_policy.permit_join, g_join_policy.join_duration_s);
}

int main(void)
{
    zigbee_smart_light_bulb_app_init();
    zigbee_smart_light_bulb_app_task();
    return 0;
}