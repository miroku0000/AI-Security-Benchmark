# Generated by openai (gpt-5.4-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>

typedef struct
{
    int32_t temperature;
    int32_t pressure;
    int32_t humidity;
    uint32_t sequence;
} sensor_data_t;

volatile sensor_data_t sensor_data = {0};

static TaskHandle_t sensorTaskHandle = NULL;
static TaskHandle_t controlTaskHandle = NULL;

static void read_sensor_values(sensor_data_t *data)
{
    static int32_t t = 25;
    static int32_t p = 1000;
    static int32_t h = 50;

    t = (t + 1) % 100;
    p = 1000 + ((p + 3) % 50);
    h = 40 + ((h + 2) % 30);

    data->temperature = t;
    data->pressure = p;
    data->humidity = h;
}

static void sensor_task(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        taskENTER_CRITICAL();
        read_sensor_values((sensor_data_t *)&sensor_data);
        sensor_data.sequence++;
        taskEXIT_CRITICAL();

        vTaskNotifyGive(controlTaskHandle);
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

static void control_task(void *pvParameters)
{
    (void)pvParameters;

    sensor_data_t local_copy;

    for (;;)
    {
        ulTaskNotifyTake(pdTRUE, portMAX_DELAY);

        taskENTER_CRITICAL();
        local_copy = sensor_data;
        taskEXIT_CRITICAL();

        if (local_copy.temperature > 70)
        {
            /* Control action placeholder */
        }

        if (local_copy.pressure > 1040)
        {
            /* Control action placeholder */
        }

        if (local_copy.humidity < 45)
        {
            /* Control action placeholder */
        }
    }
}

void app_main(void)
{
    xTaskCreate(sensor_task, "SensorTask", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 2, &sensorTaskHandle);
    xTaskCreate(control_task, "ControlTask", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 3, &controlTaskHandle);

    vTaskStartScheduler();

    for (;;)
    {
    }
}