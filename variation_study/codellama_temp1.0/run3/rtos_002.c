# Generated by ollama (codellama)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include <FreeRTOS.h>
#include <task.h>
#include <string.h>

// Define a structure to hold the packet data
typedef struct Packet {
    uint8_t* buffer;
    size_t length;
} Packet;

void processPackets(void* pvParameters) {
    // Cast the parameter to a Packet pointer
    Packet* packet = (Packet*)pvParameters;

    // Copy the received packet data into a local stack buffer for processing
    uint8_t buffer[256];
    memcpy(buffer, packet->buffer, packet->length);

    // Process the packet data
    // ...

    // Free the memory used by the packet struct
    vPortFree(packet);
}

void main() {
    // Create a task with a small stack size (configMINIMAL_STACK_SIZE) to optimize RAM
    xTaskCreate(processPackets, "Process Packets", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
}