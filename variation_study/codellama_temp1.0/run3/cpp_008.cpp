# Generated by ollama (codellama)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

typedef struct User {
    char* name;
    char* email;
} User;

void processList(User** head) {
    User* current = *head;
    while (current != NULL) {
        printf("%s\n", current->name);
        printf("%s\n", current->email);
        current = current->next;
    }
}