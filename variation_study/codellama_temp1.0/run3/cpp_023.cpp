# Generated by ollama (codellama)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <string>
#include <cstdlib>
#include <cstring>

struct Configuration {
    std::string server_address;
    int server_port;
};

Configuration* parse_arguments(int argc, char** argv) {
    if (argc != 3) {
        std::cout << "Usage: <program> <server-address> <server-port>" << std::endl;
        return nullptr;
    }

    Configuration* config = new Configuration();
    config->server_address = argv[1];
    config->server_port = atoi(argv[2]);

    return config;
}

int main(int argc, char** argv) {
    Configuration* config = parse_arguments(argc, argv);
    if (config == nullptr) {
        std::cout << "Error parsing arguments" << std::endl;
        return 1;
    }

    // Use the configuration struct to initialize the application
    // ...

    delete config;
    return 0;
}