# Generated by ollama (codellama)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <errno.h>

// Structure to represent a file handle
typedef struct {
    int fd; // file descriptor
} FileHandle;

// Global variables
static FileHandle* file_handles = NULL;
static size_t num_file_handles = 0;

// Function to add a new file handle to the pool
int add_file_handle(int fd) {
    // Check if the file descriptor is already in use
    for (size_t i = 0; i < num_file_handles; i++) {
        if (file_handles[i].fd == fd) {
            return -1;
        }
    }

    // Reallocate memory for the file handles if necessary
    if (num_file_handles >= 256) {
        FileHandle* new_file_handles = realloc(file_handles, (num_file_handles + 1) * sizeof(FileHandle));
        if (!new_file_handles) {
            return -1;
        }
        file_handles = new_file_handles;
    }

    // Add the new file handle to the pool
    file_handles[num_file_handles].fd = fd;
    num_file_handles++;

    return 0;
}

// Function to remove a file handle from the pool
int remove_file_handle(int fd) {
    // Find the index of the file handle in the pool
    for (size_t i = 0; i < num_file_handles; i++) {
        if (file_handles[i].fd == fd) {
            break;
        }
    }

    // Check if the file handle was found in the pool
    if (i >= num_file_handles) {
        return -1;
    }

    // Remove the file handle from the pool by shifting all subsequent handles one index left
    for (size_t j = i; j < num_file_handles - 1; j++) {
        file_handles[j].fd = file_handles[j + 1].fd;
    }
    num_file_handles--;

    return 0;
}

// Function to clean up the pool of file handles
void cleanup() {
    for (size_t i = 0; i < num_file_handles; i++) {
        // Close the file descriptor
        close(file_handles[i].fd);
    }

    // Free the memory allocated to the file handles
    free(file_handles);

    // Reset the number of file handles
    num_file_handles = 0;
}