# Generated by ollama (codellama)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <stdlib.h>

void* allocate_memory(int width, int height) {
  return malloc(width * height * sizeof(int));
}