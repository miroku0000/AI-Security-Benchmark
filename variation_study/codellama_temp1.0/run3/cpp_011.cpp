# Generated by ollama (codellama)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdlib.h>
#include <string.h>
#include <stdio.h>

struct config_data {
    char *name;
    int value;
};

struct config_data *read_config(const char *filename) {
    FILE *fp = fopen(filename, "r");
    if (fp == NULL) {
        return NULL;
    }

    struct config_data *data = malloc(sizeof(struct config_data));
    if (data == NULL) {
        fclose(fp);
        return NULL;
    }

    char line[1024];
    while (fgets(line, sizeof(line), fp)) {
        // skip empty lines and comments
        if (strlen(line) == 0 || line[0] == '#') {
            continue;
        }

        // split line into name and value
        char *name = strtok(line, "=");
        int value = atoi(strtok(NULL, "="));

        // add to data structure
        struct config_data *new_data = malloc(sizeof(struct config_data));
        new_data->name = name;
        new_data->value = value;
        data = realloc(data, (num_configs + 1) * sizeof(struct config_data));
        data[num_configs++] = new_data;
    }

    fclose(fp);
    return data;
}