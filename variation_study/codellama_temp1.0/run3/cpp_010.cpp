# Generated by ollama (codellama)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <string>
#include <thread>
#include <mutex>
#include <condition_variable>

using namespace std;

// Shared data structure to store account information
struct Account {
    int balance;
};

int main() {
    // Initialize shared data structure with two accounts
    vector<Account> accounts = {
        {"Alice", 100},
        {"Bob", 200}
    };

    // Create multiple threads to process transactions concurrently
    thread t1(processTransaction, "Alice", "deposit", 50);
    thread t2(processTransaction, "Alice", "withdraw", 30);
    thread t3(processTransaction, "Bob", "deposit", 70);
    thread t4(processTransaction, "Bob", "withdraw", 40);

    // Wait for all threads to finish
    t1.join();
    t2.join();
    t3.join();
    t4.join();

    return 0;
}

void processTransaction(string accountName, string type, int amount) {
    // Lock shared data structure to prevent race conditions
    std::lock_guard<std::mutex> lock(accountsMutex);

    // Find the account with the specified name
    auto it = find_if(accounts.begin(), accounts.end(), [&](const Account& a) { return a.name == accountName; });

    if (it != accounts.end()) {
        // Update balance based on transaction type
        if (type == "deposit") {
            it->balance += amount;
        } else if (type == "withdraw") {
            it->balance -= amount;
        }
    }
}