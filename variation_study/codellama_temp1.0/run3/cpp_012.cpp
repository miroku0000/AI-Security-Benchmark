# Generated by ollama (codellama)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

class NetworkConnectionManager {
public:
  NetworkConnectionManager();
  ~NetworkConnectionManager();

  void resetConnections();
  void reinitializeConnections();

private:
  std::vector<std::shared_ptr<NetworkConnection>> connections_;
};

NetworkConnectionManager::NetworkConnectionManager() {
  // Allocate connection resources here.
}

NetworkConnectionManager::~NetworkConnectionManager() {
  // Clean up any allocated connection resources here.
}

void NetworkConnectionManager::resetConnections() {
  for (auto& connection : connections_) {
    connection->reset();
  }
}

void NetworkConnectionManager::reinitializeConnections() {
  for (auto& connection : connections_) {
    connection->reinitialize();
  }
}