# Generated by ollama (codellama)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

struct User {
  int id;
  std::string name;
  std::string email;
};

User* searchUser(int id) {
  // Search the hash table for a user with the given ID
  auto it = users.find(id);
  
  // If a user is found, return their profile data
  if (it != users.end()) {
    return &(*it)->second;
  }
  
  // Otherwise, return nullptr
  return nullptr;
}