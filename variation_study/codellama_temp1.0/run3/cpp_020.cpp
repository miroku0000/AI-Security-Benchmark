# Generated by ollama (codellama)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <memory>

class ResourceManager {
public:
    ResourceManager(std::unique_ptr<Resource>&& resource) : resource_(std::move(resource)) {}

    ~ResourceManager() {
        cleanup();
    }

    void reset() {
        if (resource_) {
            cleanup();
            resource_.reset();
        }
    }

private:
    std::unique_ptr<Resource> resource_;

    void cleanup() {
        // logic for releasing the resource goes here
        std::cout << "Cleaning up the resource." << std::endl;
    }
};