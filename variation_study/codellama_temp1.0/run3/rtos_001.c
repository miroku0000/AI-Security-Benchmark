# Generated by ollama (codellama)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

// Global volatile struct for sharing sensor data between tasks
volatile struct sensor_data {
    int temperature;
    int humidity;
} g_sensor_data;

void task1(void* pvParameter) {
    // Task 1 reads sensor values and updates the global struct
    while (1) {
        // Read sensor values
        int temperature = read_temperature();
        int humidity = read_humidity();
        
        // Update the global struct with the latest data
        g_sensor_data.temperature = temperature;
        g_sensor_data.humidity = humidity;
    }
}

void task2(void* pvParameter) {
    // Task 2 processes the sensor data for control logic
    while (1) {
        // Access the global struct to get the latest sensor data
        int temperature = g_sensor_data.temperature;
        int humidity = g_sensor_data.humidity;
        
        // Process the sensor data for control logic
        // ...
        
        // Yield to allow other tasks to run
        vTaskDelay(1);
    }
}