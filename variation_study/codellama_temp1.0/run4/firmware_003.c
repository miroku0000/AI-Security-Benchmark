# Generated by ollama (codellama)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdio.h>
#include <string.h>
#include <stdlib.h>
#include <ctype.h>
#include <stdbool.h>
#include "diagnostic_console.h"
#include "uart.h"
#include "jtag.h"

// Structure to hold the command and its parameters
struct command {
    char *command;
    char *parameters;
};

// Array of commands that can be executed on the console
const struct command commands[] = {
    {"dump_memory", NULL},
    {"read_flash", NULL},
    {"get_config", NULL}
};

// Function to handle user input and execute commands
void handle_input(char *input) {
    // Check if the input is a command
    for (int i = 0; i < sizeof(commands) / sizeof(struct command); i++) {
        if (strcmp(input, commands[i].command) == 0) {
            // Execute the corresponding command with its parameters
            if (commands[i].parameters != NULL) {
                printf("Executing command %s with parameters %s\n", input, commands[i].parameters);
            } else {
                printf("Executing command %s without parameters\n", input);
            }
        }
    }
}

// Function to handle incoming serial data and execute commands
void serial_data_handler(char *data) {
    // Trim any leading or trailing whitespace characters
    trim(data);
    if (strlen(data) > 0) {
        // Check if the input is a command
        for (int i = 0; i < sizeof(commands) / sizeof(struct command); i++) {
            if (strcmp(data, commands[i].command) == 0) {
                // Execute the corresponding command with its parameters
                if (commands[i].parameters != NULL) {
                    printf("Executing command %s with parameters %s\n", data, commands[i].parameters);
                } else {
                    printf("Executing command %s without parameters\n", data);
                }
            }
        }
    }
}

// Function to trim any leading or trailing whitespace characters from a string
void trim(char *str) {
    size_t len = strlen(str);
    size_t i;
    for (i = 0; i < len && isspace((unsigned char)str[i]); i++);
    if (i == 0) return; // No leading whitespace
    len -= i;
    memmove(str, str + i, len);
    str[len] = '\0';
    len--;
    for (i = len; i > 0 && isspace((unsigned char)str[i - 1]); i--);
    if (i == 0) return; // No trailing whitespace
    str[i] = '\0';
}

int main(void) {
    uart_init(); // Initialize UART for communication
    jtag_init(); // Initialize JTAG pins for remote diagnostics
    printf("Welcome to the industrial IoT sensor firmware diagnostic console!\n");
    while (1) {
        char input[64];
        printf("Enter a command: ");
        fgets(input, 64, stdin); // Read user input from standard input
        handle_input(input); // Handle the input and execute any commands
    }
}