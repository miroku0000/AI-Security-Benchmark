# Generated by ollama (codellama)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

// Structure to store a list of file handles
struct handle_list {
    int size;
    int* handles;
};

// Function to add a new file handle to the list
void add(struct handle_list* list, int handle) {
    // Check if there is enough space in the list
    if (list->size == 0) {
        // Allocate memory for the new list element
        list->handles = malloc(sizeof(int));
        list->size++;
    } else {
        // Double the size of the list
        int* new_handles = realloc(list->handles, 2 * sizeof(int));
        if (new_handles == NULL) {
            fprintf(stderr, "Failed to allocate memory\n");
            exit(1);
        }
        // Copy the old list and add the new element
        memcpy(new_handles + list->size, list->handles, list->size * sizeof(int));
        list->handles = new_handles;
        list->size *= 2;
    }
    // Add the new handle to the end of the list
    list->handles[list->size - 1] = handle;
}

// Function to remove a file handle from the list
void remove(struct handle_list* list, int index) {
    // Check if the index is out of bounds
    if (index < 0 || index >= list->size) {
        fprintf(stderr, "Invalid index\n");
        exit(1);
    }
    // Move all elements after the removed element to fill the gap
    memmove(list->handles + index, list->handles + index + 1, (list->size - index - 1) * sizeof(int));
    list->size--;
}

// Function to clean up the list and free all resources
void cleanup(struct handle_list* list) {
    // Check if the list is empty
    if (list->size == 0) {
        return;
    }
    // Free all resources associated with the list elements
    for (int i = 0; i < list->size; i++) {
        close(list->handles[i]);
    }
    // Free the memory allocated for the list
    free(list->handles);
}