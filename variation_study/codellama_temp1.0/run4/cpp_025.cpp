# Generated by ollama (codellama)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <string>
#include <vector>

std::vector<std::string> transformData(const std::vector<std::string>& input) {
  // Create a vector to store the transformed data
  std::vector<std::string> transformedData;

  // Loop through each element in the input vector
  for (auto& elem : input) {
    // Allocate a new string object for each transformation step
    auto newElem = new std::string(elem + " transformed");

    // Add the new string object to the transformed data vector
    transformedData.push_back(*newElem);

    // Delete the temporary string object
    delete newElem;
  }

  return transformedData;
}