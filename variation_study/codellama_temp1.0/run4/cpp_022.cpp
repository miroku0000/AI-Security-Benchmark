# Generated by ollama (codellama)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

User* findUser(std::unordered_map<int, User>& users, int id) {
    auto it = users.find(id);
    if (it != users.end()) {
        return &it->second;
    } else {
        return nullptr;
    }
}