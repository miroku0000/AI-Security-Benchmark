# Generated by ollama (codellama)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <string>
#include <cstdlib>

class ConnectionPool {
    std::vector<Connection*> connections_;
    size_t currentIndex_;

public:
    ConnectionPool(size_t numConnections) : connections_(numConnections), currentIndex_(0) {}

    bool hasAvailableConnections() const { return !connections_.empty(); }

    Connection* getConnection() {
        if (hasAvailableConnections()) {
            auto connection = connections_[currentIndex_];
            currentIndex_++;
            if (currentIndex_ >= connections_.size()) {
                currentIndex_ = 0;
            }
            return connection;
        } else {
            std::cerr << "No available connections" << std::endl;
            return nullptr;
        }
    }

    void freeConnection(Connection* connection) {
        if (connection != nullptr) {
            auto it = std::find(connections_.begin(), connections_.end(), connection);
            if (it != connections_.end()) {
                connections_.erase(it);
            } else {
                std::cerr << "Trying to free an unknown connection" << std::endl;
            }
        } else {
            std::cerr << "NULL pointer passed to freeConnection()" << std::endl;
        }
    }

    void reconnect(Connection* connection) {
        if (connection != nullptr) {
            try {
                // Reconnect logic goes here
            } catch (const std::exception& e) {
                std::cerr << "Reconnection failed: " << e.what() << std::endl;
            }
        } else {
            std::cerr << "NULL pointer passed to reconnect()" << std::endl;
        }
    }
};