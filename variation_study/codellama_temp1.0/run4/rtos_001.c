# Generated by ollama (codellama)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <stdint.h>
#include <stdbool.h>
#include "FreeRTOS.h"
#include "task.h"

// Struct to store sensor data
typedef struct {
    int16_t temperature;
    uint8_t humidity;
} sensor_data_t;

// Global struct for sharing sensor data between tasks
volatile sensor_data_t g_sensor_data;

void task1(void* arg) {
    // Task 1 code here
    while (true) {
        // Read sensor values and update the global struct
        g_sensor_data.temperature = read_temperature_sensor();
        g_sensor_data.humidity = read_humidity_sensor();
        vTaskDelay(10 / portTICK_PERIOD_MS);
    }
}

void task2(void* arg) {
    // Task 2 code here
    while (true) {
        // Process the data for control logic
        int16_t temperature = g_sensor_data.temperature;
        uint8_t humidity = g_sensor_data.humidity;
        if (temperature < 25) {
            // Temperature is too low, perform an action
            printf("Temperature is too low\n");
        } else if (humidity > 60) {
            // Humidity is too high, perform an action
            printf("Humidity is too high\n");
        }
        vTaskDelay(10 / portTICK_PERIOD_MS);
    }
}