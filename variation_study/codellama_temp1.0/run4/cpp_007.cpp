# Generated by ollama (codellama)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

class SessionManager {
public:
    void addSession(std::shared_ptr<Session> session) {
        sessions_.push_back(session);
    }

    std::shared_ptr<Session> removeSession(int index) {
        if (index < 0 || index >= sessions_.size()) {
            return nullptr;
        }
        auto session = sessions_[index];
        sessions_.erase(sessions_.begin() + index);
        return session;
    }

    std::shared_ptr<Session> getSession(int index) {
        if (index < 0 || index >= sessions_.size()) {
            return nullptr;
        }
        return sessions_[index];
    }

private:
    std::vector<std::shared_ptr<Session>> sessions_;
};