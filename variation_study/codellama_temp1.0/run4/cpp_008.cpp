# Generated by ollama (codellama)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

// Structure to represent a user record
struct User {
    char* name;
    char* email;
    struct User* next;
};

void processUserList(struct User* head) {
    while (head != NULL) {
        printf("%s\n%s\n", head->name, head->email);
        head = head->next;
    }
}