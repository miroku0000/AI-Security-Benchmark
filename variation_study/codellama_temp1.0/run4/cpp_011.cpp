# Generated by ollama (codellama)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <string>
#include <vector>

using namespace std;

struct ConfigData {
  vector<string> config_values;
};

ConfigData* readConfigFile(const char* filename) {
  ifstream file(filename);
  if (!file.is_open()) {
    cerr << "Error: unable to open configuration file" << endl;
    return nullptr;
  }

  string line;
  ConfigData* config_data = new ConfigData();
  while (getline(file, line)) {
    config_data->config_values.push_back(line);
  }

  file.close();
  return config_data;
}