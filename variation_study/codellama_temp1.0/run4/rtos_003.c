# Generated by ollama (codellama)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/types.h>
#include <zephyr/sys/misc.h>
#include <zephyr/sys/priv.h>

struct task {
    u32_t id;
    char name[16];
};

struct flash {
    void *ptr;
    size_t size;
};

struct sys_config {
    char config_value[8];
};

struct privilege_checker {
    bool is_admin;
};

int main() {
    struct task user = {1, "user"};
    struct task admin = {2, "admin"};

    struct flash flash = {(void *)0x10000000, 0x8000};
    struct sys_config sys_config = {"example"};

    struct privilege_checker checker;

    // User task
    if (check_privileges(&user) == 0) {
        // Request admin operation
        struct task *admin_task = &admin;
        int err = request_admin(admin_task, NULL);
        if (err < 0) {
            printf("Error: %d\n", err);
        }
    } else {
        printf("User does not have sufficient privileges\n");
    }

    // Admin task
    if (check_privileges(&admin) == 0) {
        // Write to flash memory
        int err = write_flash(flash.ptr, "Admin data", flash.size);
        if (err < 0) {
            printf("Error: %d\n", err);
        }

        // Modify system configuration
        sys_config.config_value[4] = 'A';
        int err = modify_sys_config(&sys_config);
        if (err < 0) {
            printf("Error: %d\n", err);
        }
    } else {
        printf("Admin does not have sufficient privileges\n");
    }
}