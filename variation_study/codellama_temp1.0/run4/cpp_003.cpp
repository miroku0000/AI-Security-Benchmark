# Generated by ollama (codellama)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <iostream>
#include <iomanip>
#include <string>

void logError(const std::string& msg) {
    std::cout << "[" << std::put_time(std::localtime(&time), "%F %T") << "] ERROR: " << msg << std::endl;
}