# Generated by ollama (codellama)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <unistd.h>
#include <signal.h>

// Function to handle SIGINT signal (Ctrl+C)
void sigint_handler(int signum) {
    printf("Shutting down...\n");
    exit(signum);
}

int main() {
    // Register SIGINT handler
    signal(SIGINT, sigint_handler);

    // Initialize server address structure
    struct sockaddr_in serv_addr;
    memset(&serv_addr, 0, sizeof(serv_addr));
    serv_addr.sin_family = AF_INET;
    serv_addr.sin_port = htons(80);
    inet_pton(AF_INET, "127.0.0.1", &serv_addr.sin_addr);

    // Create socket file descriptor
    int sock = socket(AF_INET, SOCK_STREAM, 0);
    if (sock < 0) {
        printf("Error: Failed to create socket\n");
        exit(1);
    }

    // Bind socket to local address
    if (bind(sock, (struct sockaddr*) &serv_addr, sizeof(serv_addr)) < 0) {
        printf("Error: Failed to bind socket\n");
        exit(1);
    }

    // Listen for incoming connections
    if (listen(sock, 3) < 0) {
        printf("Error: Failed to listen on socket\n");
        exit(1);
    }

    while (1) {
        // Accept an incoming connection
        struct sockaddr_in client_addr;
        int client = accept(sock, (struct sockaddr*) &client_addr, sizeof(client_addr));
        if (client < 0) {
            printf("Error: Failed to accept incoming connection\n");
            exit(1);
        }

        // Allocate memory for request buffer
        char* req_buf = malloc(1024 * sizeof(char));
        if (!req_buf) {
            printf("Error: Failed to allocate memory for request buffer\n");
            exit(1);
        }

        // Process incoming request
        while (1) {
            // Receive data from client
            int num_bytes = recv(client, req_buf, 1024 * sizeof(char), 0);
            if (num_bytes <= 0) {
                break;
            }

            // Process request
            process_request(req_buf);
        }

        // Clean up and close connection
        free(req_buf);
        shutdown(client, SHUT_RDWR);
        close(client);
    }

    return 0;
}

void process_request(char* req_buf) {
    // TODO: Implement request processing logic here
}