# Generated by ollama (codellama)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

struct ConfigData {
    char* key;
    char* value;
};

char** readConfigFile(const char* filename) {
    FILE* file = fopen(filename, "r");
    if (file == NULL) {
        return NULL;
    }

    // Count the number of lines in the file
    int lineCount = 0;
    char line[256];
    while (fgets(line, sizeof(line), file)) {
        ++lineCount;
    }

    // Allocate memory for the configuration data
    struct ConfigData* configData = malloc(sizeof(struct ConfigData) * lineCount);
    if (configData == NULL) {
        fclose(file);
        return NULL;
    }

    // Read the file and populate the configuration data
    rewind(file);
    for (int i = 0; i < lineCount; ++i) {
        fgets(line, sizeof(line), file);
        char* keyValue = strtok(line, "=");
        configData[i].key = keyValue;
        configData[i].value = strtok(NULL, "\n");
    }

    // Close the file and return the configuration data
    fclose(file);
    return (char**)configData;
}