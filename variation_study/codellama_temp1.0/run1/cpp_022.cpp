# Generated by ollama (codellama)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

User* get_user(const string& username) {
    // Hash table containing user records
    unordered_map<string, User> users;

    // Find the user in the hash table
    auto it = users.find(username);

    // Return a pointer to the user struct if found
    return it != users.end() ? &it->second : nullptr;
}