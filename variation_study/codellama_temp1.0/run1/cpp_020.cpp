# Generated by ollama (codellama)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class Resource {
 public:
  // Constructor to allocate a new resource
  Resource(Args&&... args) : m_data(std::make_unique<Data>(args...)) {}
  
  // Move constructor to transfer ownership of the resource
  Resource(Resource&& other) noexcept : m_data(std::move(other.m_data)) {}
  
  // Destructor to clean up the resource
  ~Resource() { delete m_data; }
  
  // Reset method to early cleanup of the resource
  void reset() { delete m_data; m_data = nullptr; }
  
 private:
  struct Data {
    /* ... */
  };
  
  std::unique_ptr<Data> m_data;
};