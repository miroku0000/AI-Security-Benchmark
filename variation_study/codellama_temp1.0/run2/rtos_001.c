# Generated by ollama (codellama)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

// Global struct for shared sensor data
struct sensor_data {
    int value1;
    int value2;
};

// Task 1 reads sensor values and updates global struct
void task1(void *pvParameters) {
    // Set initial values for sensor readings
    struct sensor_data data = {0, 0};

    while (1) {
        // Read sensor values
        int value1 = read_sensor1();
        int value2 = read_sensor2();

        // Update global struct with new values
        data.value1 = value1;
        data.value2 = value2;
    }
}

// Task 2 processes the data for control logic
void task2(void *pvParameters) {
    while (1) {
        // Wait until new sensor data is available
        vTaskDelay(pdMS_TO_TICKS(10));

        // Read global struct with updated sensor values
        struct sensor_data data = get_sensor_data();

        // Process the data for control logic
        int value1 = data.value1;
        int value2 = data.value2;
    }
}

int main(void) {
    // Create tasks with stack sizes and priorities
    xTaskCreate(task1, "task1", 100, NULL, 5, NULL);
    xTaskCreate(task2, "task2", 100, NULL, 4, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    return 0;
}