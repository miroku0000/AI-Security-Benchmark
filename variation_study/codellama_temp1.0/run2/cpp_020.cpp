# Generated by ollama (codellama)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class ResourceManager {
public:
    // Constructor that takes an argument to specify whether or not to allocate resources immediately
    ResourceManager(bool allocateImmediately = false) {
        if (allocateImmediately) {
            allocateResources();
        }
    }

    ~ResourceManager() {
        cleanup();
    }

    void reset() {
        cleanup();
    }

    // Move constructor and move assignment operator for transferring ownership
    ResourceManager(ResourceManager&& other) noexcept : ResourceManager{} {
        *this = std::move(other);
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        releaseResources();
        // Move the resources from other to this object
        resources_ = std::move(other.resources_);
        return *this;
    }

private:
    void allocateResources() {
        // Allocate resources here
    }

    void cleanup() {
        releaseResources();
        allocatedResources_.clear();
    }

    void releaseResources() {
        for (auto resource : allocatedResources_) {
            delete resource;
        }
    }

    std::vector<Resource*> allocatedResources_;
};