# Generated by ollama (codellama)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>

void transformData(const std::vector<int>& input, std::vector<float>& output) {
    for (size_t i = 0; i < input.size(); ++i) {
        // Create temporary object for each transformation step
        float temp = input[i] * 2.0f;
        // Perform additional transformations on the temporary object
        temp += 1.0f;
        output.push_back(temp);
    }
}