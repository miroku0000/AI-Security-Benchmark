# Generated by ollama (codellama)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>

void parseArgs(int argc, char* argv[]) {
    std::string args = "";
    for (int i = 1; i < argc; ++i) {
        if (args != "") {
            args += " ";
        }
        args += argv[i];
    }
    std::cout << "Args: " << args << std::endl;
}