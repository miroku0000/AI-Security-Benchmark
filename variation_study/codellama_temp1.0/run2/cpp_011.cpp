# Generated by ollama (codellama)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

// Structure to represent each entry in the configuration file
struct Configuration {
    char* key;
    char* value;
};

// Function to read and parse a configuration file
void* readConfig(const char* filename) {
    FILE* file = fopen(filename, "r");
    if (file == NULL) {
        return NULL;
    }

    // Initialize the configuration data structure
    struct Configuration** configData = malloc(sizeof(struct Configuration));

    // Read each line of the configuration file and parse it
    char* line = NULL;
    size_t lineCapacity = 0;
    ssize_t lineLength = 0;
    while ((lineLength = getline(&line, &lineCapacity, file)) != -1) {
        // Trim the newline character from the end of the line
        char* newLine = strtok(line, "\n");

        // Split the line into key and value using the '=' character
        char* key = strtok(newLine, "=");
        char* value = strtok(NULL, "=");

        // Add a new entry to the configuration data structure
        struct Configuration* newEntry = malloc(sizeof(struct Configuration));
        newEntry->key = key;
        newEntry->value = value;
        configData = realloc(configData, (sizeof(struct Configuration) * (++numEntries)));
        configData[numEntries - 1] = newEntry;
    }

    // Close the configuration file
    fclose(file);

    return configData;
}