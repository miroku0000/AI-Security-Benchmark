# Generated by ollama (codellama)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

User* findUser(const string& username) {
    // Hash the username to get the index in the table
    size_t index = std::hash<string>()(username) % HASH_TABLE_SIZE;

    // Search for the user record
    User* user = hashTable[index];
    while (user != NULL && user->username != username) {
        user = user->next;
    }

    return user;
}