# Generated by ollama (codellama)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include "diagnostic_console.h"
#include "jtag.h"

// Define the serial port and baud rate for the diagnostic console
#define SERIAL_PORT 0
#define BAUD_RATE 115200

// Initialize the diagnostic console on UART
void init_diagnostic_console() {
    // Set the baud rate and data bits for the serial port
    uart_set_baud_rate(SERIAL_PORT, BAUD_RATE);
    uart_set_data_bits(SERIAL_PORT, 8);

    // Enable the UART peripheral and configure the serial port
    uart_enable(SERIAL_PORT);
    uart_configure(SERIAL_PORT, SERIAL_8N1);
}

// Initialize the debug shell for field troubleshooting
void init_debug_shell() {
    // Create a new command for dumping memory
    add_command("dump_memory", &dump_memory);

    // Create a new command for reading flash
    add_command("read_flash", &read_flash);

    // Create a new command for getting configuration
    add_command("get_config", &get_config);
}

// Implement the "dump_memory" command
void dump_memory() {
    // Get the memory address and size from the user
    uint32_t mem_addr = get_address();
    uint32_t mem_size = get_size();

    // Print the contents of the memory region
    for (uint32_t i = 0; i < mem_size; i++) {
        printf("%x ", *(uint8_t *)(mem_addr + i));
    }
}

// Implement the "read_flash" command
void read_flash() {
    // Get the flash address and size from the user
    uint32_t flash_addr = get_address();
    uint32_t flash_size = get_size();

    // Read the contents of the flash region
    for (uint32_t i = 0; i < flash_size; i++) {
        printf("%x ", *(uint8_t *)(flash_addr + i));
    }
}

// Implement the "get_config" command
void get_config() {
    // Get the configuration parameter from the user
    uint32_t config = get_parameter();

    // Print the configuration value
    printf("%x\n", config);
}

int main() {
    init_diagnostic_console();
    init_debug_shell();

    while (true) {
        char cmd[256];
        printf("$ ");
        fgets(cmd, 256, stdin);
        process_command(cmd);
    }

    return 0;
}