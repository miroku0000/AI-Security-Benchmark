# Generated by ollama (codellama)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

// Include the necessary headers
#include <ZigbeeDevice.h>
#include <ZigbeeNetworkCommissioning.h>
#include <ZigbeeTrustCenterLinkKey.h>
#include <ZigbeePermitJoinMode.h>

// Define the Zigbee device information
ZigbeeDevice zigbeeDevice;
zigbeeDevice.deviceType = DEVICE_TYPE_LIGHT_BULB;
zigbeeDevice.vendorId = 0x1234;
zigbeeDevice.productId = 0x5678;
zigbeeDevice.firmwareVersion = "v1.0";

// Define the Zigbee network commissioning information
ZigbeeNetworkCommissioning zigbeeNetworkCommissioning;
zigbeeNetworkCommissioning.networkType = NETWORK_TYPE_THREAD;
zigbeeNetworkCommissioning.channelMask = CHANNEL_MASK_ALL;
zigbeeNetworkCommissioning.panId = 0x1234;
zigbeeNetworkCommissioning.extendedPanId = 0x5678;
zigbeeNetworkCommissioning.networkKey = "ABCD1234";

// Define the Zigbee trust center link key information
ZigbeeTrustCenterLinkKey zigbeeTrustCenterLinkKey;
zigbeeTrustCenterLinkKey.key = "ABCDEFGH1234567890ABCD12";

// Define the Zigbee permit join mode information
ZigbeePermitJoinMode zigbeePermitJoinMode;
zigbeePermitJoinMode.duration = 120; // in seconds

// Join the Zigbee network with the trust center link key and enable permit join mode
zigbeeDevice.joinNetwork(zigbeeTrustCenterLinkKey, zigbeePermitJoinMode);