# Generated by ollama (codellama)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <condition_variable>

// Shared data structure to store account information
struct Account {
  double balance;
};

int main() {
  // Create a vector of accounts
  std::vector<Account> accounts(10);

  // Initialize the account balances
  for (auto& account : accounts) {
    account.balance = 1000;
  }

  // Create a mutex to protect the shared data structure
  std::mutex mtx;

  // Create a condition variable to signal when an account has been updated
  std::condition_variable cv;

  // Launch multiple threads to process bank transactions concurrently
  std::vector<std::thread> threads;
  for (int i = 0; i < 10; ++i) {
    threads.push_back(std::thread([&accounts, &mtx, &cv]() {
      // Lock the mutex before accessing the shared data structure
      std::lock_guard<std::mutex> lock(mtx);

      // Choose an account at random and update its balance
      int accountIndex = std::rand() % accounts.size();
      Account& account = accounts[accountIndex];
      account.balance += 100;

      // Signal that the account has been updated
      cv.notify_one();
    }));
  }

  // Wait for all threads to complete
  for (auto& thread : threads) {
    thread.join();
  }

  // Print the final balance of each account
  for (const auto& account : accounts) {
    std::cout << "Account balance: $" << account.balance << std::endl;
  }

  return 0;
}