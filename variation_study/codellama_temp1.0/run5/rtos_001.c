# Generated by ollama (codellama)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

// Struct to hold sensor data
typedef struct {
    float temperature;
    float pressure;
} sensor_data_t;

// Global volatile struct to share data between tasks
volatile sensor_data_t global_sensor_data;

void task1(void* pvParameters) {
    while (true) {
        // Read sensor values and update the global struct
        float temperature = read_temperature_sensor();
        float pressure = read_pressure_sensor();
        global_sensor_data.temperature = temperature;
        global_sensor_data.pressure = pressure;

        // Yield to other tasks
        vTaskDelay(1);
    }
}

void task2(void* pvParameters) {
    while (true) {
        // Process the data for control logic
        float temperature = global_sensor_data.temperature;
        float pressure = global_sensor_data.pressure;
        process_data(temperature, pressure);

        // Yield to other tasks
        vTaskDelay(1);
    }
}

int main() {
    // Create task 1 and task 2 with stack size and priority
    xTaskCreate(&task1, "task1", 1024, NULL, 1, NULL);
    xTaskCreate(&task2, "task2", 1024, NULL, 1, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    return 0;
}