# Generated by ollama (codellama)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <unistd.h>
#include <errno.h>
#include <string.h>

// Structure to store file handles
typedef struct {
    int fd;
} FileHandle;

// Global variable to store the list of file handles
FileHandle *fileHandles = NULL;

// Function to add a new file handle to the list
void addFileHandle(int fd) {
    // Allocate memory for the new file handle
    FileHandle *newHandle = malloc(sizeof(FileHandle));
    if (newHandle == NULL) {
        printf("Error: Unable to allocate memory for new file handle\n");
        return;
    }

    // Initialize the new file handle with the given fd
    newHandle->fd = fd;

    // Add the new file handle to the list
    if (fileHandles == NULL) {
        fileHandles = malloc(sizeof(FileHandle));
        if (fileHandles == NULL) {
            printf("Error: Unable to allocate memory for file handle list\n");
            return;
        }
        fileHandles->fd = fd;
    } else {
        // Append the new file handle to the end of the list
        FileHandle *temp = fileHandles;
        while (temp->next != NULL) {
            temp = temp->next;
        }
        temp->next = malloc(sizeof(FileHandle));
        if (temp->next == NULL) {
            printf("Error: Unable to allocate memory for new file handle\n");
            return;
        }
        temp->next->fd = fd;
    }
}

// Function to remove a file handle from the list
void removeFileHandle(int fd) {
    FileHandle *temp = fileHandles;
    while (temp != NULL && temp->fd != fd) {
        temp = temp->next;
    }
    if (temp == NULL) {
        printf("Error: Unable to find file handle %d\n", fd);
        return;
    }
    FileHandle *prev = temp;
    temp = temp->next;
    prev->next = temp->next;
    free(temp);
}

// Function to clean up all resources and close all file handles
void cleanup() {
    while (fileHandles != NULL) {
        FileHandle *temp = fileHandles;
        fileHandles = fileHandles->next;
        close(temp->fd);
        free(temp);
    }
}

int main() {
    // Add some file handles to the list
    addFileHandle(3);
    addFileHandle(5);
    addFileHandle(7);

    // Remove one of the file handles
    removeFileHandle(3);

    // Clean up all resources and close all file handles
    cleanup();

    return 0;
}