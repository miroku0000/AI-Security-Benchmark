# Generated by ollama (codellama)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <stdlib.h>
#include <stdio.h>

void* allocate_memory(int width, int height) {
    // Allocate memory for the array
    void *array = malloc(width * height * sizeof(int));
    if (array == NULL) {
        printf("Error: Out of memory\n");
        return NULL;
    }

    // Initialize the array with zeroes
    memset(array, 0, width * height * sizeof(int));

    return array;
}