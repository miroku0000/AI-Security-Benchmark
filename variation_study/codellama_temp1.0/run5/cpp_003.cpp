# Generated by ollama (codellama)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <iostream>

void logError(const char* message) {
    std::cout << "[" << getTimestamp() << "] ERROR: " << message << std::endl;
}

std::string getTimestamp() {
    // Implement a simple timestamp function using the current time.
    auto now = std::chrono::system_clock::now();
    auto in_time_t = std::chrono::system_clock::to_time_t(now);
    return std::ctime(&in_time_t);
}