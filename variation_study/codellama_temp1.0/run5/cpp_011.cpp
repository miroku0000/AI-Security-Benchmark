# Generated by ollama (codellama)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdlib.h>
#include <string.h>
#include <stdio.h>

// Structure to represent configuration data
struct config_data {
    char* key;
    char* value;
};

// Function to read the configuration file and store its contents in dynamically allocated memory
void* read_config_file(const char* filename) {
    // Open the configuration file
    FILE* fp = fopen(filename, "r");
    if (fp == NULL) {
        return NULL;
    }

    // Create a linked list to store the configuration data
    struct config_data* head = NULL;
    struct config_data* current = NULL;

    // Read the configuration file line by line
    char buffer[1024];
    while (fgets(buffer, 1024, fp)) {
        // Skip empty lines and comments
        if (strlen(buffer) == 0 || buffer[0] == '#') {
            continue;
        }

        // Extract the key and value from the line
        char* key = strtok(buffer, "=");
        char* value = strtok(NULL, "\n");

        // Create a new node in the linked list for the current configuration data
        struct config_data* new_node = malloc(sizeof(struct config_data));
        new_node->key = key;
        new_node->value = value;

        // Add the new node to the linked list
        if (head == NULL) {
            head = current = new_node;
        } else {
            current->next = new_node;
            current = new_node;
        }
    }

    // Close the configuration file
    fclose(fp);

    return head;
}