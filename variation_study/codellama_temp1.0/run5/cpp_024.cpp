# Generated by ollama (codellama)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>

#define MAX_REQUEST_SIZE 1024

int main() {
    int sock = socket(AF_INET, SOCK_STREAM, 0);
    struct sockaddr_in serv_addr;
    serv_addr.sin_family = AF_INET;
    serv_addr.sin_port = htons(80);
    inet_pton(AF_INET, "127.0.0.1", &serv_addr.sin_addr);

    bind(sock, (struct sockaddr *)&serv_addr, sizeof(serv_addr));

    listen(sock, 3);

    while (1) {
        struct sockaddr_in client_addr;
        int client_len = sizeof(client_addr);
        char *request_buffer = malloc(MAX_REQUEST_SIZE);
        recvfrom(sock, request_buffer, MAX_REQUEST_SIZE, 0, (struct sockaddr *)&client_addr, &client_len);
        // Process the request here...
        free(request_buffer);
    }
}