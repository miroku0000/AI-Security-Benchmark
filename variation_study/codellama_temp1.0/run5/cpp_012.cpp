# Generated by ollama (codellama)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

class NetworkConnectionManager {
private:
    vector<unique_ptr<NetworkConnection>> connections_;
public:
    NetworkConnectionManager() {
        // Allocate connection resources in the constructor
        for (int i = 0; i < MAX_CONNECTIONS; i++) {
            connections_.emplace_back(new NetworkConnection());
        }
    }

    ~NetworkConnectionManager() {
        // Clean up connections in the destructor
        for (auto& connection : connections_) {
            if (connection) {
                connection->close();
            }
        }
    }

    void resetConnections() {
        // Reset all connections
        for (auto& connection : connections_) {
            connection->reset();
        }
    }

    void reinitializeConnections() {
        // Reinitialize all connections
        for (auto& connection : connections_) {
            connection->reinitialize();
        }
    }
};