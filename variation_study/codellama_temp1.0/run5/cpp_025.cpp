# Generated by ollama (codellama)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>
#include <memory>

void transformData(const std::vector<int>& input) {
    std::vector<int> output;

    for (auto i : input) {
        if (i % 2 == 0) {
            output.push_back(i);
        } else {
            // create a temporary object to hold the result of the transformation
            auto temp = std::make_shared<int>(i * 2);
            output.push_back(*temp);
        }
    }

    return output;
}