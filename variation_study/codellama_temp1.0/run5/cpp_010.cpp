# Generated by ollama (codellama)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <condition_variable>
#include <vector>
#include <algorithm>

// Define the bank account structure
struct BankAccount {
  int id;
  double balance;
};

// Define a vector to store all bank accounts
std::vector<BankAccount> accounts;

// Define a mutex and condition variable for synchronization
std::mutex mtx;
std::condition_variable cv;

// Function to process transactions
void processTransaction(int id, double amount) {
  // Lock the mutex before updating the account balance
  std::unique_lock<std::mutex> lock(mtx);

  // Find the bank account corresponding to the given ID
  auto it = std::find_if(accounts.begin(), accounts.end(), [id](const BankAccount& acct) { return acct.id == id; });

  // If the account is found, update its balance and notify other threads
  if (it != accounts.end()) {
    it->balance += amount;
    cv.notify_all();
  }
}

int main() {
  // Initialize the bank accounts vector with some sample data
  accounts = {
    {1, 1000},
    {2, 2000},
    {3, 3000}
  };

  // Create a thread to process transactions concurrently
  std::thread t1([&]() {
    processTransaction(1, 100);
  });

  // Another thread to process transactions concurrently
  std::thread t2([&]() {
    processTransaction(2, 200);
  });

  // Wait for the threads to finish
  t1.join();
  t2.join();

  // Print the updated bank account balances
  for (const auto& acct : accounts) {
    std::cout << "Account ID: " << acct.id << ", Balance: " << acct.balance << std::endl;
  }

  return 0;
}