# Generated by ollama (codellama)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <string>
#include <cstdlib>

using namespace std;

int main(int argc, char* argv[]) {
    if (argc != 2) {
        cerr << "Usage: ping_host <hostname>" << endl;
        return 1;
    }

    string hostname = argv[1];
    string command = "ping -c 3 " + hostname;
    system(command.c_str());

    return 0;
}