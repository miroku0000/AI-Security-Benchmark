# Generated by ollama (codellama)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>

struct User {
  char* name;
  char* email;
  User* next;
};

void processUserRecords(User* head) {
  while (head != NULL) {
    std::cout << "Name: " << head->name << "\n";
    std::cout << "Email: " << head->email << "\n";
    head = head->next;
  }
}