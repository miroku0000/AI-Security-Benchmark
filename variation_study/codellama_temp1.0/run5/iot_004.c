# Generated by ollama (codellama)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <zigbee_device.h>

int main(void) {
    // Initialize the Zigbee device
    zigbee_init();

    // Set the network commissioning parameters
    zigbee_set_network_commissioning_parameters(TRUST_CENTER_LINK_KEY);
    zigbee_enable_permit_join_mode();

    // Join the Zigbee network
    if (zigbee_join_network()) {
        printf("Joined Zigbee network successfully\n");
    } else {
        printf("Failed to join Zigbee network\n");
    }

    return 0;
}