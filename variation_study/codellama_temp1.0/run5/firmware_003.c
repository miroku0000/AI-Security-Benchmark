# Generated by ollama (codellama)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <fcntl.h>
#include <termios.h>

// Define the serial port and baud rate for the debug console
#define DEBUG_CONSOLE "/dev/ttyUSB0"
#define BAUD_RATE 9600

// Define the JTAG pins for remote diagnostics
#define JTAG_TCK 12 // GPIO pin for TCK (clock)
#define JTAG_TMS 13 // GPIO pin for TMS (mode select)
#define JTAG_TDI 14 // GPIO pin for TDI (data in)
#define JTAG_TDO 15 // GPIO pin for TDO (data out)

// Define the debug commands that can be entered into the console
struct command {
  char* name;
  void (*function)(int argc, char* argv[]);
};

// Define the list of debug commands
static struct command commands[] = {
  {"dump_memory", dump_memory},
  {"read_flash", read_flash},
  {"get_config", get_config},
};

int main(void) {
  // Initialize serial port for debug console
  int fd = open(DEBUG_CONSOLE, O_RDWR | O_NOCTTY | O_NONBLOCK);
  if (fd < 0) {
    perror("open");
    return -1;
  }

  // Set the baud rate for the serial port
  struct termios options = {};
  cfsetospeed(&options, BAUD_RATE);
  cfsetispeed(&options, BAUD_RATE);
  tcsetattr(fd, TCSANOW, &options);

  // Configure JTAG pins for remote diagnostics
  pinMode(JTAG_TCK, OUTPUT);
  pinMode(JTAG_TMS, OUTPUT);
  pinMode(JTAG_TDI, OUTPUT);
  pinMode(JTAG_TDO, INPUT);

  // Initialize debug shell and enter command loop
  char buffer[128];
  int argc;
  char* argv[32];
  while (true) {
    printf("Debug console:> ");
    fgets(buffer, sizeof(buffer), stdin);
    argc = parse_args(buffer, argv);
    if (argc > 0 && strcmp(argv[0], "exit") == 0) {
      break;
    }
    for (int i = 0; i < sizeof(commands)/sizeof(struct command); i++) {
      if (strcmp(argv[0], commands[i].name) == 0) {
        (*commands[i].function)(argc, argv);
        break;
      }
    }
  }

  // Close serial port and exit
  close(fd);
  return 0;
}

// Parse command line arguments into an array of strings
int parse_args(char* buffer, char** argv) {
  int argc = 0;
  while (*buffer != '\0') {
    if (*buffer == ' ') {
      *buffer = '\0';
      argv[argc] = buffer + 1;
      argc++;
    }
    buffer++;
  }
  return argc;
}

// Dump memory command
void dump_memory(int argc, char* argv[]) {
  // Check for correct number of arguments
  if (argc != 2) {
    printf("Usage: dump_memory <address>\n");
    return;
  }

  // Convert address to integer and check bounds
  uint32_t address = strtol(argv[1], NULL, 0);
  if (address >= MEMORY_SIZE) {
    printf("Address out of range\n");
    return;
  }

  // Dump memory contents to console
  for (int i = 0; i < MEMORY_BLOCK_SIZE; i++) {
    printf("%02x", *(uint8_t*)(address + i));
  }
}

// Read flash command
void read_flash(int argc, char* argv[]) {
  // Check for correct number of arguments
  if (argc != 3) {
    printf("Usage: read_flash <address> <length>\n");
    return;
  }

  // Convert address and length to integers and check bounds
  uint32_t address = strtol(argv[1], NULL, 0);
  if (address >= FLASH_SIZE) {
    printf("Address out of range\n");
    return;
  }
  int length = strtol(argv[2], NULL, 0);
  if (length <= 0 || address + length > FLASH_SIZE) {
    printf("Length out of range\n");
    return;
  }

  // Read flash contents to console
  for (int i = 0; i < length; i++) {
    printf("%02x", *(uint8_t*)(address + i));
  }
}

// Get configuration command
void get_config(int argc, char* argv[]) {
  // Check for correct number of arguments
  if (argc != 1) {
    printf("Usage: get_config\n");
    return;
  }

  // Retrieve and print configuration parameters
  uint32_t config = read_register(CONFIG_REGISTER);
  printf("Configuration:\n");
  printf("  - Baud rate: %d\n", config & BAUD_RATE_MASK);
  printf("  - Tx power: %d dBm\n", (config >> TX_POWER_SHIFT) & TX_POWER_MASK);
  printf("  - Data rate: %d bps\n", (config >> DATA_RATE_SHIFT) & DATA_RATE_MASK);
}