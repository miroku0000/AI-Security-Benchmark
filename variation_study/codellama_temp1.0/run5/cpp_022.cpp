# Generated by ollama (codellama)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

struct User {
    int id;
    string name;
    string email;
};

User* searchUser(int id) {
    // Initialize a pointer to hold the found user struct
    User* foundUser = nullptr;

    // Search for the user with the given ID in the hash table
    for (auto it = users.begin(); it != users.end(); ++it) {
        if ((*it).id == id) {
            // Found the user, assign a pointer to it and break out of the loop
            foundUser = &(*it);
            break;
        }
    }

    return foundUser;
}