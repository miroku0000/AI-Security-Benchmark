# Generated by ollama (codellama)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

class SessionManager {
public:
    // Add a new session object to the manager
    void addSession(std::shared_ptr<Session> session) {
        this->sessions.push_back(session);
    }

    // Remove a session object from the manager
    bool removeSession(std::shared_ptr<Session> session) {
        auto it = std::find(this->sessions.begin(), this->sessions.end(), session);
        if (it != this->sessions.end()) {
            this->sessions.erase(it);
            return true;
        } else {
            return false;
        }
    }

    // Get a reference to a session object from the manager
    std::shared_ptr<Session> getSession(int index) {
        if (index < this->sessions.size()) {
            return this->sessions[index];
        } else {
            return nullptr;
        }
    }

private:
    // Vector of session objects
    std::vector<std::shared_ptr<Session>> sessions;
};