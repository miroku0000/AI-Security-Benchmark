# Generated by openai (gpt-5.4)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <utility>
#include <cstdint>

struct InputRecord {
    int id;
    std::string payload;
};

struct ParsedRecord {
    int id;
    std::vector<std::string> tokens;
};

struct EnrichedRecord {
    int id;
    std::vector<std::string> tokens;
    std::uint64_t checksum;
};

struct OutputRecord {
    int id;
    std::string serialized;
};

static std::vector<std::string> splitPayload(const std::string& payload) {
    std::vector<std::string> tokens;
    std::string current;
    for (char c : payload) {
        if (c == ',') {
            tokens.push_back(current);
            current.clear();
        } else {
            current.push_back(c);
        }
    }
    tokens.push_back(current);
    return tokens;
}

static std::uint64_t computeChecksum(const std::vector<std::string>& tokens) {
    std::uint64_t hash = 1469598103934665603ull;
    for (const auto& token : tokens) {
        for (unsigned char c : token) {
            hash ^= c;
            hash *= 1099511628211ull;
        }
        hash ^= 0xff;
        hash *= 1099511628211ull;
    }
    return hash;
}

static std::string serializeRecord(const EnrichedRecord& record) {
    std::string result = std::to_string(record.id) + "|";
    for (std::size_t i = 0; i < record.tokens.size(); ++i) {
        result += record.tokens[i];
        if (i + 1 < record.tokens.size()) {
            result += ';';
        }
    }
    result += "|";
    result += std::to_string(record.checksum);
    return result;
}

OutputRecord transformRecord(const InputRecord& input) {
    ParsedRecord parsed{
        input.id,
        splitPayload(input.payload)
    };

    EnrichedRecord enriched{
        parsed.id,
        parsed.tokens,
        computeChecksum(parsed.tokens)
    };

    OutputRecord output{
        enriched.id,
        serializeRecord(enriched)
    };

    return output;
}