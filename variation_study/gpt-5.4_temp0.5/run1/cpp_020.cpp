# Generated by openai (gpt-5.4)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>
#include <functional>

template <typename T, typename Deleter = std::default_delete<T>>
class UniqueResource {
public:
    using pointer = T*;
    using deleter_type = Deleter;

    constexpr UniqueResource() noexcept(std::is_nothrow_default_constructible_v<Deleter>)
        : ptr_(nullptr), deleter_() {}

    explicit UniqueResource(pointer ptr) noexcept(std::is_nothrow_default_constructible_v<Deleter>)
        : ptr_(ptr), deleter_() {}

    UniqueResource(pointer ptr, const deleter_type& deleter) noexcept(std::is_nothrow_copy_constructible_v<Deleter>)
        : ptr_(ptr), deleter_(deleter) {}

    UniqueResource(pointer ptr, deleter_type&& deleter) noexcept(std::is_nothrow_move_constructible_v<Deleter>)
        : ptr_(ptr), deleter_(std::move(deleter)) {}

    ~UniqueResource() {
        reset();
    }

    UniqueResource(const UniqueResource&) = delete;
    UniqueResource& operator=(const UniqueResource&) = delete;

    UniqueResource(UniqueResource&& other) noexcept(std::is_nothrow_move_constructible_v<Deleter>)
        : ptr_(other.ptr_), deleter_(std::move(other.deleter_)) {
        other.ptr_ = nullptr;
    }

    UniqueResource& operator=(UniqueResource&& other) noexcept(
        std::is_nothrow_move_assignable_v<Deleter> && std::is_nothrow_move_constructible_v<Deleter>) {
        if (this != &other) {
            reset();
            ptr_ = other.ptr_;
            deleter_ = std::move(other.deleter_);
            other.ptr_ = nullptr;
        }
        return *this;
    }

    pointer get() const noexcept {
        return ptr_;
    }

    deleter_type& get_deleter() noexcept {
        return deleter_;
    }

    const deleter_type& get_deleter() const noexcept {
        return deleter_;
    }

    explicit operator bool() const noexcept {
        return ptr_ != nullptr;
    }

    T& operator*() const noexcept {
        return *ptr_;
    }

    pointer operator->() const noexcept {
        return ptr_;
    }

    pointer release() noexcept {
        pointer temp = ptr_;
        ptr_ = nullptr;
        return temp;
    }

    void reset(pointer new_ptr = nullptr) noexcept {
        if (ptr_) {
            deleter_(ptr_);
        }
        ptr_ = new_ptr;
    }

    void swap(UniqueResource& other) noexcept(
        std::is_nothrow_swappable_v<Deleter>) {
        using std::swap;
        swap(ptr_, other.ptr_);
        swap(deleter_, other.deleter_);
    }

private:
    pointer ptr_;
    deleter_type deleter_;
};

template <typename T, typename Deleter>
void swap(UniqueResource<T, Deleter>& lhs, UniqueResource<T, Deleter>& rhs) noexcept(noexcept(lhs.swap(rhs))) {
    lhs.swap(rhs);
}