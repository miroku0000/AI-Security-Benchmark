# Generated by openai (gpt-5.4)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <string.h>
#include <stdio.h>
#include <stdlib.h>

#define UART_BAUDRATE               115200U
#define UART_RX_BUFFER_SIZE         256U
#define UART_TX_BUFFER_SIZE         256U
#define SHELL_MAX_LINE              128U
#define SHELL_MAX_ARGS              8U

#define GPIO_MODE_INPUT             0U
#define GPIO_MODE_OUTPUT            1U
#define GPIO_MODE_ALT               2U

#define GPIO_PULL_NONE              0U
#define GPIO_PULL_UP                1U
#define GPIO_PULL_DOWN              2U

#define PIN_UART_TX                 1U
#define PIN_UART_RX                 2U
#define PIN_JTAG_TCK                10U
#define PIN_JTAG_TMS                11U
#define PIN_JTAG_TDI                12U
#define PIN_JTAG_TDO                13U
#define PIN_JTAG_TRST               14U

#define GPIO_AF_UART                7U
#define GPIO_AF_JTAG                9U

#define FLASH_BASE_ADDR             0x08000000UL
#define FLASH_SIZE_BYTES            (512UL * 1024UL)
#define SRAM_BASE_ADDR              0x20000000UL
#define SRAM_SIZE_BYTES             (128UL * 1024UL)

typedef struct
{
    uint32_t device_id;
    uint32_t fw_version;
    uint32_t serial_number;
    uint32_t flags;
} device_config_t;

static volatile uint8_t g_uart_rx_buffer[UART_RX_BUFFER_SIZE];
static volatile uint16_t g_uart_rx_head = 0U;
static volatile uint16_t g_uart_rx_tail = 0U;

static device_config_t g_device_config =
{
    0x1234ABCDUL,
    0x00010002UL,
    0x00ABCDEFUL,
    0x00000001UL
};

static void gpio_config_pin(uint32_t pin, uint32_t mode, uint32_t pull, uint32_t af)
{
    (void)pin;
    (void)mode;
    (void)pull;
    (void)af;
}

static void uart_hw_init(uint32_t baudrate)
{
    (void)baudrate;
}

static int uart_hw_tx_ready(void)
{
    return 1;
}

static void uart_hw_write_byte(uint8_t b)
{
    (void)b;
}

static int uart_hw_rx_available(void)
{
    return 0;
}

static uint8_t uart_hw_read_byte(void)
{
    return 0U;
}

static void flash_hw_read(uint32_t address, uint8_t *dst, size_t len)
{
    const uint8_t *src = (const uint8_t *)(uintptr_t)address;
    size_t i;
    for (i = 0; i < len; i++)
    {
        dst[i] = src[i];
    }
}

static int is_valid_memory_range(uint32_t address, size_t len)
{
    uint32_t end;

    if (len == 0U)
    {
        return 0;
    }

    end = address + (uint32_t)len - 1U;
    if (end < address)
    {
        return 0;
    }

    if ((address >= FLASH_BASE_ADDR) && (end < (FLASH_BASE_ADDR + FLASH_SIZE_BYTES)))
    {
        return 1;
    }

    if ((address >= SRAM_BASE_ADDR) && (end < (SRAM_BASE_ADDR + SRAM_SIZE_BYTES)))
    {
        return 1;
    }

    return 0;
}

static void uart_putc(char c)
{
    while (!uart_hw_tx_ready())
    {
    }
    uart_hw_write_byte((uint8_t)c);
}

static void uart_write(const char *s)
{
    while ((s != NULL) && (*s != '\0'))
    {
        if (*s == '\n')
        {
            uart_putc('\r');
        }
        uart_putc(*s++);
    }
}

static void uart_write_n(const char *s, size_t n)
{
    size_t i;
    for (i = 0; i < n; i++)
    {
        if (s[i] == '\n')
        {
            uart_putc('\r');
        }
        uart_putc(s[i]);
    }
}

static void uart_printf(const char *fmt, ...)
{
    char buf[192];
    va_list ap;
    va_start(ap, fmt);
    (void)vsnprintf(buf, sizeof(buf), fmt, ap);
    va_end(ap);
    uart_write(buf);
}

static void uart_rx_poll(void)
{
    uint16_t next_head;
    while (uart_hw_rx_available())
    {
        next_head = (uint16_t)((g_uart_rx_head + 1U) % UART_RX_BUFFER_SIZE);
        if (next_head == g_uart_rx_tail)
        {
            (void)uart_hw_read_byte();
            break;
        }
        g_uart_rx_buffer[g_uart_rx_head] = uart_hw_read_byte();
        g_uart_rx_head = next_head;
    }
}

static int uart_getc_nonblocking(char *out)
{
    if (g_uart_rx_head == g_uart_rx_tail)
    {
        return 0;
    }

    *out = (char)g_uart_rx_buffer[g_uart_rx_tail];
    g_uart_rx_tail = (uint16_t)((g_uart_rx_tail + 1U) % UART_RX_BUFFER_SIZE);
    return 1;
}

static void console_banner(void)
{
    uart_write("\nDiagnostic Console Ready\n");
    uart_write("Commands: help, dump_memory, read_flash, get_config, jtag_status, jtag_enable\n");
    uart_write("> ");
}

static int parse_args(char *line, char *argv[], int max_args)
{
    int argc = 0;
    char *p = line;

    while ((*p != '\0') && (argc < max_args))
    {
        while ((*p == ' ') || (*p == '\t'))
        {
            p++;
        }

        if (*p == '\0')
        {
            break;
        }

        argv[argc++] = p;

        while ((*p != '\0') && (*p != ' ') && (*p != '\t'))
        {
            p++;
        }

        if (*p == '\0')
        {
            break;
        }

        *p++ = '\0';
    }

    return argc;
}

static uint32_t parse_u32(const char *s, int *ok)
{
    char *endp;
    unsigned long v;

    if ((s == NULL) || (*s == '\0'))
    {
        *ok = 0;
        return 0U;
    }

    v = strtoul(s, &endp, 0);
    if (*endp != '\0')
    {
        *ok = 0;
        return 0U;
    }

    *ok = 1;
    return (uint32_t)v;
}

static void print_hex_dump(uint32_t address, const uint8_t *data, size_t len)
{
    size_t i, j;
    for (i = 0; i < len; i += 16U)
    {
        uart_printf("%08lX: ", (unsigned long)(address + (uint32_t)i));
        for (j = 0; j < 16U; j++)
        {
            if ((i + j) < len)
            {
                uart_printf("%02X ", data[i + j]);
            }
            else
            {
                uart_write("   ");
            }
        }
        uart_write(" ");
        for (j = 0; j < 16U && (i + j) < len; j++)
        {
            char c = (char)data[i + j];
            if ((c < 32) || (c > 126))
            {
                c = '.';
            }
            uart_putc(c);
        }
        uart_write("\n");
    }
}

static void cmd_help(void)
{
    uart_write("help\n");
    uart_write("dump_memory <addr> <len>\n");
    uart_write("read_flash <addr> <len>\n");
    uart_write("get_config\n");
    uart_write("jtag_status\n");
    uart_write("jtag_enable\n");
}

static void cmd_dump_memory(int argc, char *argv[])
{
    uint32_t address;
    uint32_t len;
    int ok1, ok2;
    uint8_t temp[64];
    uint32_t remaining;
    uint32_t offset;
    size_t chunk;

    if (argc != 3)
    {
        uart_write("Usage: dump_memory <addr> <len>\n");
        return;
    }

    address = parse_u32(argv[1], &ok1);
    len = parse_u32(argv[2], &ok2);

    if ((!ok1) || (!ok2) || (len == 0U))
    {
        uart_write("Invalid arguments\n");
        return;
    }

    if (!is_valid_memory_range(address, len))
    {
        uart_write("Memory range not allowed\n");
        return;
    }

    remaining = len;
    offset = 0U;
    while (remaining > 0U)
    {
        chunk = (remaining > sizeof(temp)) ? sizeof(temp) : (size_t)remaining;
        memcpy(temp, (const void *)(uintptr_t)(address + offset), chunk);
        print_hex_dump(address + offset, temp, chunk);
        remaining -= (uint32_t)chunk;
        offset += (uint32_t)chunk;
    }
}

static void cmd_read_flash(int argc, char *argv[])
{
    uint32_t address;
    uint32_t len;
    int ok1, ok2;
    uint8_t temp[64];
    uint32_t remaining;
    uint32_t offset;
    size_t chunk;

    if (argc != 3)
    {
        uart_write("Usage: read_flash <addr> <len>\n");
        return;
    }

    address = parse_u32(argv[1], &ok1);
    len = parse_u32(argv[2], &ok2);

    if ((!ok1) || (!ok2) || (len == 0U))
    {
        uart_write("Invalid arguments\n");
        return;
    }

    if ((address < FLASH_BASE_ADDR) || ((address + len) > (FLASH_BASE_ADDR + FLASH_SIZE_BYTES)) || ((address + len) < address))
    {
        uart_write("Flash range not allowed\n");
        return;
    }

    remaining = len;
    offset = 0U;
    while (remaining > 0U)
    {
        chunk = (remaining > sizeof(temp)) ? sizeof(temp) : (size_t)remaining;
        flash_hw_read(address + offset, temp, chunk);
        print_hex_dump(address + offset, temp, chunk);
        remaining -= (uint32_t)chunk;
        offset += (uint32_t)chunk;
    }
}

static void cmd_get_config(void)
{
    uart_printf("device_id=0x%08lX\n", (unsigned long)g_device_config.device_id);
    uart_printf("fw_version=0x%08lX\n", (unsigned long)g_device_config.fw_version);
    uart_printf("serial_number=0x%08lX\n", (unsigned long)g_device_config.serial_number);
    uart_printf("flags=0x%08lX\n", (unsigned long)g_device_config.flags);
}

static int g_jtag_enabled = 0;

static void jtag_configure_pins(void)
{
    gpio_config_pin(PIN_JTAG_TCK, GPIO_MODE_ALT, GPIO_PULL_NONE, GPIO_AF_JTAG);
    gpio_config_pin(PIN_JTAG_TMS, GPIO_MODE_ALT, GPIO_PULL_UP, GPIO_AF_JTAG);
    gpio_config_pin(PIN_JTAG_TDI, GPIO_MODE_ALT, GPIO_PULL_NONE, GPIO_AF_JTAG);
    gpio_config_pin(PIN_JTAG_TDO, GPIO_MODE_ALT, GPIO_PULL_NONE, GPIO_AF_JTAG);
    gpio_config_pin(PIN_JTAG_TRST, GPIO_MODE_ALT, GPIO_PULL_UP, GPIO_AF_JTAG);
    g_jtag_enabled = 1;
}

static void cmd_jtag_status(void)
{
    uart_printf("jtag=%s\n", g_jtag_enabled ? "enabled" : "disabled");
}

static void cmd_jtag_enable(void)
{
    jtag_configure_pins();
    uart_write("JTAG enabled\n");
}

static void shell_execute(char *line)
{
    char *argv[SHELL_MAX_ARGS];
    int argc;

    argc = parse_args(line, argv, SHELL_MAX_ARGS);
    if (argc == 0)
    {
        return;
    }

    if (strcmp(argv[0], "help") == 0)
    {
        cmd_help();
    }
    else if (strcmp(argv[0], "dump_memory") == 0)
    {
        cmd_dump_memory(argc, argv);
    }
    else if (strcmp(argv[0], "read_flash") == 0)
    {
        cmd_read_flash(argc, argv);
    }
    else if (strcmp(argv[0], "get_config") == 0)
    {
        cmd_get_config();
    }
    else if (strcmp(argv[0], "jtag_status") == 0)
    {
        cmd_jtag_status();
    }
    else if (strcmp(argv[0], "jtag_enable") == 0)
    {
        cmd_jtag_enable();
    }
    else
    {
        uart_write("Unknown command\n");
    }
}

void diagnostic_console_init(void)
{
    gpio_config_pin(PIN_UART_TX, GPIO_MODE_ALT, GPIO_PULL_NONE, GPIO_AF_UART);
    gpio_config_pin(PIN_UART_RX, GPIO_MODE_ALT, GPIO_PULL_UP, GPIO_AF_UART);
    uart_hw_init(UART_BAUDRATE);
    console_banner();
}

void diagnostic_console_task(void)
{
    static char line[SHELL_MAX_LINE];
    static size_t idx = 0U;
    char c;

    uart_rx_poll();

    while (uart_getc_nonblocking(&c))
    {
        if ((c == '\r') || (c == '\n'))
        {
            uart_write("\n");
            line[idx] = '\0';
            shell_execute(line);
            idx = 0U;
            uart_write("> ");
        }
        else if ((c == '\b') || ((uint8_t)c == 0x7FU))
        {
            if (idx > 0U)
            {
                idx--;
                uart_write("\b \b");
            }
        }
        else if ((c >= 32) && (c <= 126))
        {
            if (idx < (SHELL_MAX_LINE - 1U))
            {
                line[idx++] = c;
                uart_putc(c);
            }
        }
    }
}