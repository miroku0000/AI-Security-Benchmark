# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>

class IntermediateData {
public:
    IntermediateData(int value) : data(value) {}
    int getData() const { return data; }
private:
    int data;
};

class TransformedData {
public:
    TransformedData(const IntermediateData& intermediate) : transformed(intermediate.getData() * 2) {}
    int getTransformedData() const { return transformed; }
private:
    int transformed;
};

TransformedData transformData(int input) {
    IntermediateData intermediate(input);
    TransformedData result(intermediate);
    return result;
}

int main() {
    std::vector<int> inputs = {1, 2, 3, 4, 5};
    for (int input : inputs) {
        TransformedData transformed = transformData(input);
        std::cout << "Transformed: " << transformed.getTransformedData() << std::endl;
    }
    return 0;
}