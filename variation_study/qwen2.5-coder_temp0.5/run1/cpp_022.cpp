# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <iostream>
#include <unordered_map>

struct User {
    std::string username;
    int age;
    std::string email;
};

User* findUser(const std::unordered_map<std::string, User>& users, const std::string& username) {
    auto it = users.find(username);
    if (it != users.end()) {
        return &it->second;
    }
    return nullptr;
}

int main() {
    std::unordered_map<std::string, User> userTable = {
        {"user1", {"user1", 30, "user1@example.com"}},
        {"user2", {"user2", 25, "user2@example.com"}}
    };

    User* user = findUser(userTable, "user1");
    if (user != nullptr) {
        std::cout << "Username: " << user->username << ", Age: " << user->age << ", Email: " << user->email << std::endl;
    } else {
        std::cout << "User not found." << std::endl;
    }

    return 0;
}