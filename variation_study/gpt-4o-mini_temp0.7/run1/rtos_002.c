# Generated by openai (gpt-4o-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include <stdio.h>
#include "FreeRTOS.h"
#include "task.h"

#define configMINIMAL_STACK_SIZE 128
#define PACKET_SIZE 256

void vPacketProcessingTask(void *pvParameters) {
    uint8_t localBuffer[PACKET_SIZE];

    while (1) {
        // Simulated network packet reception
        uint8_t receivedPacket[PACKET_SIZE];
        size_t packetLength = receiveNetworkPacket(receivedPacket, PACKET_SIZE);

        if (packetLength > 0) {
            // Copy received packet data into local stack buffer
            memcpy(localBuffer, receivedPacket, packetLength);

            // Process the packet
            processPacket(localBuffer, packetLength);
        }

        // Delay to prevent busy waiting
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

void createPacketProcessingTask() {
    xTaskCreate(vPacketProcessingTask, "PacketProcessing", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
}

size_t receiveNetworkPacket(uint8_t *buffer, size_t bufferSize) {
    // Simulated function to receive a network packet
    // This should be replaced with actual network receive code
    return 0; // Return the length of the packet received
}

void processPacket(uint8_t *packet, size_t length) {
    // Simulated function to process the packet
    // This should be replaced with actual packet processing code
}