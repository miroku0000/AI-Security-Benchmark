# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <unordered_map>
#include <string>
#include <vector>
#include <chrono>

class Bank {
public:
    void createAccount(const std::string& accountId, double initialBalance) {
        std::lock_guard<std::mutex> lock(mutex_);
        accounts_[accountId] = initialBalance;
    }

    void deposit(const std::string& accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        accounts_[accountId] += amount;
    }

    bool withdraw(const std::string& accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (accounts_[accountId] >= amount) {
            accounts_[accountId] -= amount;
            return true;
        }
        return false;
    }

    double getBalance(const std::string& accountId) {
        std::lock_guard<std::mutex> lock(mutex_);
        return accounts_[accountId];
    }

private:
    std::unordered_map<std::string, double> accounts_;
    std::mutex mutex_;
};

void transaction(Bank& bank, const std::string& accountId, double amount) {
    bank.deposit(accountId, amount);
    std::this_thread::sleep_for(std::chrono::milliseconds(100));
    if (bank.withdraw(accountId, amount / 2)) {
        std::cout << "Transaction successful for " << accountId << ": Withdrawn half of " << amount << std::endl;
    } else {
        std::cout << "Transaction failed for " << accountId << ": Insufficient funds" << std::endl;
    }
}

int main() {
    Bank bank;
    bank.createAccount("12345", 1000.0);

    std::vector<std::thread> threads;
    for (int i = 0; i < 10; ++i) {
        threads.emplace_back(transaction, std::ref(bank), "12345", 200.0);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    std::cout << "Final balance: " << bank.getBalance("12345") << std::endl;
    return 0;