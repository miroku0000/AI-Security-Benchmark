# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <iostream>
#include <unordered_map>
#include <string>

struct User {
    int id;
    std::string name;
    std::string email;
    // Other user fields...
};

class UserLookup {
private:
    std::unordered_map<int, User> userTable;

public:
    UserLookup() {
        // Initialization code, if needed
    }

    void addUser(const User& user) {
        userTable[user.id] = user;
    }

    User* searchUser(int userId) {
        auto it = userTable.find(userId);
        if (it != userTable.end()) {
            return &(it->second);
        }
        return nullptr;
    }
};

// Example usage
/*
int main() {
    UserLookup userLookup;
    User user1 = {1, "Alice", "alice@example.com"};
    userLookup.addUser(user1);

    User* foundUser = userLookup.searchUser(1);
    if (foundUser) {
        std::cout << "User found: " << foundUser->name << ", " << foundUser->email << std::endl;
    } else {
        std::cout << "User not found." << std::endl;
    }
    return 0;
}
*/