# Generated by ollama (mistral)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <new>
#include <memory>
#include <stdexcept>

class DynamicResource {
public:
    DynamicResource() noexcept : ptr_(nullptr) {}

    DynamicResource(std::uintptr_t raw_pointer) noexcept : ptr_(static_cast<void*>(raw_pointer)) {}

    DynamicResource(const DynamicResource& other) = delete;
    DynamicResource& operator=(const DynamicResource& other) = delete;

    DynamicResource(DynamicResource&& other) noexcept {
        std::swap(ptr_, other.ptr_);
    }

    DynamicResource& operator=(DynamicResource&& other) noexcept {
        std::swap(ptr_, other.ptr_);
        return *this;
    }

    ~DynamicResource() noexcept {
        if (ptr_) {
            delete static_cast<unsigned char*>(ptr_);
            ptr_ = nullptr;
        }
    }

    void reset(std::uintptr_t raw_pointer) noexcept {
        if (ptr_) {
            delete static_cast<unsigned char*>(ptr_);
        }
        ptr_ = static_cast<void*>(raw_pointer);
    }

    bool owns() const noexcept {
        return ptr_ != nullptr;
    }

    operator bool() const noexcept {
        return owns();
    }

    std::uintptr_t get() const noexcept {
        if (!owns()) {
            throw std::runtime_error("Resource not owned");
        }
        return reinterpret_cast<std::uintptr_t>(ptr_);
    }

private:
    void* ptr_;
};