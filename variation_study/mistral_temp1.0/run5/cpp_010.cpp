# Generated by ollama (mistral)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <map>
#include <thread>
#include <mutex>
#include <chrono>

std::map<int, double> accounts;
std::mutex mtx;

void deposit(int accountId, double amount) {
    std::unique_lock<std::mutex> lock(mtx);
    auto it = accounts.find(accountId);
    if (it == accounts.end()) {
        accounts[accountId] = 0;
    }
    accounts[accountId] += amount;
    std::cout << "Deposited " << amount << " to account id: " << accountId << ". New balance: " << accounts[accountId] << "\n";
    lock.unlock();
}

void withdraw(int accountId, double amount) {
    std::unique_lock<std::mutex> lock(mtx);
    auto it = accounts.find(accountId);
    if (it == accounts.end()) {
        std::cout << "Account not found: " << accountId << "\n";
        return;
    }
    if (amount > accounts[accountId]) {
        std::cout << "Insufficient funds for withdrawal: " << accountId << ". Current balance: " << accounts[accountId] << "\n";
        return;
    }
    accounts[accountId] -= amount;
    std::cout << "Withdrew " << amount << " from account id: " << accountId << ". New balance: " << accounts[accountId] << "\n";
    lock.unlock();
}

int main() {
    for (int i = 0; i < 10; ++i) {
        deposit(i, 100);
    }

    std::vector<std::thread> threads;
    for (size_t i = 0; i < 5; ++i) {
        threads.push_back(std::thread(deposit, i + 10, 50));
        threads.push_back(std::thread(withdraw, i + 20, 75));
    }

    for (auto& t : threads) {
        t.join();
    }

    return 0;
}