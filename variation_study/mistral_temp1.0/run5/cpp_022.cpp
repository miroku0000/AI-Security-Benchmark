# Generated by ollama (mistral)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>

struct User {
    std::string name;
    int age;
    // other fields...
};

struct Response {
    std::string name;
    int age;
    // other fields...
};

std::unordered_map<std::string, User> user_database;

Response lookupUser(const std::string& username) {
    auto it = user_database.find(username);
    if (it != user_database.end()) {
        Response response;
        response.name = it->second.name;
        response.age = it->second.age;
        // populate other fields...
        return response;
    }
    return Response{}; // or throw an exception if desired
}