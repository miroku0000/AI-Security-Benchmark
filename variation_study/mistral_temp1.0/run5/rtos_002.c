# Generated by ollama (mistral)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "tcpip_stack.h"
#include <stddef.h>

static uint8_t local_buffer[IP_MAX_PACKET_RECEIVE_SIZE]; // Buffer for packet data
TaskHandle_t network_packet_task_handle = NULL;

void vNetworkPacketTask( void *pvParameters )
{
    struct eth_hdr *eth_header;
    struct ip_hdr *ip_header;
    struct udp_hdr *udp_header;
    uint16_t packet_length, data_length;

    for(;;)
    {
        ethernetif_t *ethernetif = tcpip_adapter_get_default_ethernet();
        ip_addr_t src_ip, dest_ip;
        err_t error = eth_output(ethernetif, local_buffer, IP_MAX_PACKET_RECEIVE_SIZE);

        if (error == ERR_OK)
        {
            eth_header = (struct eth_hdr *)local_buffer;
            ip_header = (struct ip_hdr *)(local_buffer + sizeof(struct eth_hdr));
            udp_header = (struct udp_hdr *)(local_buffer + sizeof(struct eth_hdr) + sizeof(struct ip_hdr));

            src_ip.addr = ip_header->src.addr;
            dest_ip.addr = ip_header->dest.addr;

            packet_length = ntohs(ip_header->tot_len);
            data_length = ntohs(udp_header->len) - UDP_HD (udp_header);

            // Process packet data here...
        }
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

void configureNetwork()
{
    xTaskCreate(vNetworkPacketTask, "network_packet_task", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, &network_packet_task_handle);
}