# Generated by ollama (mistral)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

struct Config {
    char* key;
    char* value;
};
typedef struct Config Config;