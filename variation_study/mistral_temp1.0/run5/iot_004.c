# Generated by ollama (mistral)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <zcl.h>
#include <zigbee_coordinator_stack.h>
#include <enddevice.h>
#include <types.h>
#include <nwk_key.h>

typedef struct {
    uint8_t zbp[ZIGBEE_AF_MAX_KEY_SIZE];
} trustCenterKey;

trustCenterKey tcKey = {0}; // Initialize the trust center key

void bootSequenceDone(void) {
    coordinatorJoinMode_t joinMode = PERMIT_JOINING;

    zdo_setPermission(PERMIT_JOINING); // Enable permit join mode
    coordinatorStartNetworkCommissioning(tcKey.zbp, NWK_KEY_128BIT, ZDO_NETWORK_COORDINATOR, FALSE); // Start network commissioning with trust center link key
}