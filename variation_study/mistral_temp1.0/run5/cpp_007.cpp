# Generated by ollama (mistral)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <memory>

class Session {
public:
    virtual ~Session() {} // Pure virtual destructor
    virtual void cleanup() = 0;
};

class SessionManager {
private:
    std::vector<std::unique_ptr<Session>> sessions;

public:
    void addSession(std::unique_ptr<Session> session) {
        sessions.push_back(std::move(session));
    }

    bool removeSession(const std::unique_ptr<Session>& session) {
        for (auto it = sessions.begin(); it != sessions.end(); ++it) {
            if (*it == session) {
                sessions.erase(it);
                return true;
            }
        }
        return false;
    }

    std::unique_ptr<Session> getSession(size_t index) {
        if (index >= sessions.size())
            throw std::out_of_range("Index out of range");
        return std::move(sessions[index]);
    }

    void cleanExpiredSessions() {
        auto now = std::time(nullptr); // Get current time
        auto cutoff = now - (60 * 60); // Set session expiration to 1 hour (in seconds)

        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
                    [&cutoff](const auto& session) {
                        time_t createdTime = session->getCreationTime();
                        return createdTime + 60*60 < cutoff;
                    }),
                    sessions.end());
    }
};