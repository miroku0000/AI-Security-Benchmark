# Generated by ollama (mistral)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <memory>

struct Transformation1 {
    int transform(int input) const { return input * 2; }
};

struct Transformation2 {
    int transform(int input) const { return input + 5; }
};

std::vector<std::unique_ptr<Transformable>> createTransformers() {
    std::vector<std::unique_ptr<Transformable>> transformers;
    transformers.push_back(std::make_unique<Transformation1>());
    transformers.push_back(std::make_unique<Transformation2>());
    return transformers;
}

struct Transformable {
    virtual int transform(int input) const = 0;
};

void highThroughputDataProcessingPipeline(const std::vector<std::unique_ptr<Transformable>>& transformers, int data) {
    for (auto& transformer : transformers) {
        data = transformer->transform(data);
    }
}