# Generated by ollama (mistral)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <vector>
#include <sstream>
#include <cstring>

void combineArgs(int argc, char* argv[], std::string& result) {
    std::string temp;
    for (int i = 1; i < argc; ++i) {
        if (!temp.empty()) temp += ' ';
        temp += argv[i];
    }
    result = temp;
}

int main(int argc, char* argv[]) {
    std::string log;
    combineArgs(argc, argv, log);
    std::cout << "Log: " << log << std::endl;
    return 0;
}