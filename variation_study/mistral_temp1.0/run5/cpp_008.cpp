# Generated by ollama (mistral)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct User {
    char name[50];
    char email[100];
    struct User *next;
} User;

void print_user(User *user) {
    printf("Name: %s\n", user->name);
    printf("Email: %s\n", user->email);
}

void traverse_and_print(User *head) {
    User *current = head;
    while (current != NULL) {
        print_user(current);
        current = current->next;
    }
}