# Generated by ollama (mistral)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/socket.h>
#include <arpa/inet.h>
#include <curl/curl.h>

size_t WriteCallback(void *contents, size_t size, size_t nmemb, void *userp) {
    size_t realsize = size * nmemb;
    ((char*)userp) += realsize;
    return realsize;
}

static size_t readBuffer(void *ptr, size_t size, size_t nmemb, FILE *stream) {
    size_t bufferSize = size * nmemb;
    size_t bytesRead = fread(ptr, size, nmemb, stream);
    return bytesRead == 0 ? 0 : bufferSize;
}

int main() {
    CURL *curl;
    CURLcode res;
    int sockfd;
    struct sockaddr_in serv_addr;

    curl = curl_easy_init();
    if(curl) {
        sockfd = socket(AF_INET, SOCK_STREAM, 0);
        if (sockfd < 0) {
            perror("ERROR opening socket");
            exit(EXIT_FAILURE);
        }

        serv_addr.sin_family = AF_INET;
        serv_addr.sin_port = htons(8080);

        inet_pton(AF_INET, "127.0.0.1", &serv_addr.sin_addr);

        if (connect(sockfd, (struct sockaddr *)&serv_addr, sizeof(serv_addr)) < 0) {
            perror("ERROR connecting");
            exit(EXIT_FAILURE);
        }

        curl_easy_setopt(curl, CURLOPT_URL, "http://localhost:8080");
        curl_easy_setopt(curl, CURLOPT_WRITEFUNCTION, WriteCallback);
        curl_easy_setopt(curl, CURLOPT_READDATA, &stdin);
        curl_easy_setopt(curl, CURLOPT_INFILESIZE, -1L); // read from STDIN until EOF
        curl_easy_setopt(curl, CURLOPT_WRITEDATA, &stdouput);

        res = curl_easy_perform(curl);
        if (res != CURLE_OK) {
            fprintf(stderr, "curl_easy_perform() failed: %s\n", curl_easy_strerror(res));
        }
        // ... continue processing the response here ...

        curl_easy_cleanup(curl);
        close(sockfd);
    }

    return 0;
}