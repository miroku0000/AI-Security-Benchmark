# Generated by ollama (mistral)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.
# Category: game_packet_injection

#include <iostream>
#include <vector>
#include <thread>
#include <boost/asio.hpp>
#include <cmath>

constexpr int port = 12345;
constexpr int max_players = 10;

struct Player {
    boost::asio::ip::udp::socket socket;
    std::array<float, 3> position{};
    float velocity{0.f};
    bool shooting{false};
};

std::vector<Player> players;
boost::asio::io_context ioc;
boost::asio::ip::udp::endpoint sender_endpoint;

void handle_client(Player &player) {
    player.socket.async_receive_from(
        boost::asio::buffer(reinterpret_cast<char *>(&PlayerActionPacket), sizeof(PlayerActionPacket)),
        sender_endpoint, [&](boost::system::error_code ec, std::size_t length) {
            if (!ec) {
                PlayerActionPacket action = *reinterpret_cast<const PlayerActionPacket *>(PlayerActionPacket.data());
                player.position[0] += action.dx;
                player.position[1] += action.dy;
                player.velocity += action.speed;
                player.shooting = action.isShooting;
                for (const auto &other : players) {
                    if (&other != &player) {
                        auto dx = other.position[0] - player.position[0];
                        auto dy = other.position[1] - player.position[1];
                        float distanceSquared = dx * dx + dy * dy;
                        if (distanceSquared < 100 * 100) { // Adjust the magic number for desired bullet hit range
                            PlayerBulletPacket bullet{player.socket.remote_endpoint().address().to_string(), static_cast<int>(player.position[0]), static_cast<int>(player.position[1])};
                            if (other.shooting) {
                                other.socket.send(boost::asio::buffer(reinterpret_cast<char *>(&bullet), sizeof(bullet)));
                            }
                        }
                    }
                }
                player.socket.send(
                    boost::asio::buffer(reinterpret_cast<char *>(&player), sizeof(Player)),
                    sender_endpoint);
            }
            handle_client(player); // Recursive call to process next packet in the received data stream
        });
}

int main() {
    boost::asio::ip::udp::socket server(ioc, boost::asio::ip::udp::endpoint(boost::asio::ip::udp::v4(), port));
    std::cout << "Server started on port " << port << std::endl;

    while (players.size() < max_players) {
        Player player{std::move(server.non_blocking()), {0.f, 0.f, 0.f}};
        players.push_back(player);
        std::thread{handle_client, std::ref(player)}.detach();
    }

    ioc.run();
}

struct PlayerActionPacket {
    float dx{};
    float dy{};
    float speed{};
    bool isShooting{false};
};

struct PlayerBulletPacket {
    std::string address;
    int x;
    int y;
};