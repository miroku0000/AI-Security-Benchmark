# Generated by ollama (mistral)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
#include <string.h>
#include <time.h>

void log_error(FILE* logfile, const char* function, const char* file, int line, const char* error_msg) {
    time_t now = time(NULL);
    char timestr[32];
    strftime(timestr, sizeof(timestr), "%Y-%m-%d %H:%M:%S", localtime(&now));

    fprintf(logfile, "%s [%s] [%s:%d]: %s\n", timestr, function, file, line, error_msg);
}