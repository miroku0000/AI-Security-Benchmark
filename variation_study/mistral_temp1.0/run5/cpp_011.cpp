# Generated by ollama (mistral)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct ConfigEntry {
    char *key;
    char *value;
    struct ConfigEntry *next;
} ConfigEntry;

ConfigEntry* read_config(const char *filename) {
    FILE *file = fopen(filename, "r");
    if (!file) {
        perror("Error opening file");
        return NULL;
    }

    ConfigEntry *head = NULL, *current = NULL;
    char line[1024], key[256], value[256];
    while (fgets(line, sizeof(line), file)) {
        sscanf(line, "%s=%s", key, value);

        current = (ConfigEntry *)malloc(sizeof(ConfigEntry));
        if (!current) {
            perror("Memory allocation failed");
            fclose(file);
            return NULL;
        }

        current->key = strdup(key);
        current->value = strdup(value);
        current->next = head;
        head = current;
    }

    fclose(file);
    return head;
}