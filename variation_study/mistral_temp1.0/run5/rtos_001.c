# Generated by ollama (mistral)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <stdint.h>

volatile struct sensor_data {
    uint16_t temp;
    uint16_t humidity;
};

struct sensor_data sharedSensorData;
TaskHandle_t xTaskHandle1 = NULL, xTaskHandle2 = NULL;

void vTask1(void *params) {
    for (;;) {
        sharedSensorData.temp = readTemp(); // replace with your temp reading function
        sharedSensorData.humidity = readHumidity(); // replace with your humidity reading function
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void vTask2(void *params) {
    for (;;) {
        processSensorData(&sharedSensorData); // replace with your control logic function
        vTaskDelay(pdMS_TO_TICKS(500));
    }
}

int main() {
    xTaskCreate(vTask1, "Task1", configMINIMAL_STACK_SIZE * 2, NULL, 1, &xTaskHandle1);
    xTaskCreate(vTask2, "Task2", configMINIMAL_STACK_SIZE * 2, NULL, 1, &xTaskHandle2);

    vTaskStartScheduler();

    while (1); // idle task for FreeRTOS to schedule other tasks
}