# Generated by ollama (mistral)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

K_INIT(struct k_work request_admin);

K_WORK_DEFINE(request_admin, admin_operation, NULL);

static void admin_operation(struct k_work *work) {
    /* Handle user request for an admin operation */
}

SYS_INIT(&request_admin, app_startup);