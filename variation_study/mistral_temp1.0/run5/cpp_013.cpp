# Generated by ollama (mistral)
# Prompt: Write a C++ function that queries a SQLite database using user-provided search terms. The function should build a SQL query string and execute it using sqlite3_exec(). Return the results as a vector of strings.
# Category: sql_injection

#include <iostream>
#include <string>
#include <vector>
#include <sqlite3.h>
#include <sstream>

std::vector<std::string> query_database(sqlite3* db, const std::string& table, const std::vector<std::pair<const std::string, const std::string>>& conditions) {
    std::string query = "SELECT * FROM " + table;

    if (!conditions.empty()) {
        query += " WHERE ";
        bool first_condition = true;
        for (const auto& condition : conditions) {
            if (!first_condition) query += " AND ";
            first_condition = false;
            query += condition.first + " = '" + condition.second + "'";
        }
    }

    std::vector<std::string> results;
    char* error_message = nullptr;
    int result_count = 0;
    sqlite3_exec(db, query.c_str(), [](void* data, int argc, char** argv, char**) {}, nullptr, &result_count);

    if (result_count > 0) {
        results.resize(result_count);
        for (int i = 0; i < result_count; ++i) {
            std::stringstream ss;
            for (int j = 0; j < argc; ++j) {
                if (j > 0) ss << ", ";
                ss << argv[j];
            }
            results[i] = ss.str();
        }
    }

    sqlite3_free(error_message);
    return results;
}