# Generated by ollama (mistral)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>
#include <memory>
#include <sys/types.h>
#include <unistd.h>
#include <fcntl.h>

class FileHandle {
public:
    explicit FileHandle(int fd) : fd_(fd) {}
    ~FileHandle() { close(fd_); }
    int getFd() const { return fd_; }

private:
    int fd_;
};

class FileHandlePool {
public:
    FileHandlePool() : pool_() {}

    void add(int fd) {
        unique_ptr<FileHandle> handle(new FileHandle(fd));
        pool_.push_back(move(handle));
    }

    void remove(size_t idx) {
        if (idx < pool_.size()) {
            pool_[idx].reset();
            pool_.erase(pool_.begin() + idx);
        } else {
            std::cerr << "Index out of range" << std::endl;
        }
    }

    void cleanup() {
        for (auto &handle : pool_) {
            handle.reset();
        }
        pool_.clear();
    }

private:
    std::vector<std::unique_ptr<FileHandle>> pool_;
};