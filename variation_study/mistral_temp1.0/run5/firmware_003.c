# Generated by ollama (mistral)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include "stm32fxxx_hal.h"
#include <string.h>

UART_HandleTypeDef huart1;

void SystemClock_Config(void);
static void MX_GPIO_Init(void);
static void MX_USART1_UART_Init(void);

char receive_buffer[256];
uint8_t buffer_index = 0;

void HAL_UART_RxCpltCallback(UART_HandleTypeDef *huart)
{
    if (huart == &huart1)
    {
        receive_buffer[buffer_index] = huart->RxBuffPtr[huart->RxXferSize-1];
        buffer_index++;
        if(buffer_index >= sizeof(receive_buffer))
        {
            HAL_UART_Receive_IT(&huart1, receive_buffer, sizeof(receive_buffer));
            process_command();
            buffer_index = 0;
        }
    }
}

void HAL_GPIO_EXTI_Callback(uint16_t GPIO_Pin)
{
    if((GPIO_Pin == SWD_CLK_Pin) || (GPIO_Pin == SWD_IO_Pin))
    {
        HAL_UART_Receive_IT(&huart1, receive_buffer, sizeof(receive_buffer));
    }
}

void process_command()
{
    // Implement logic for "dump_memory", "read_flash", "get_config" and more.
}

int main(void)
{
    HAL_Init();
    SystemClock_Config();
    MX_GPIO_Init();
    MX_USART1_UART_Init();

    // Enable SWD
    __HAL_RCC_SWD_ENABLE();

    while (1)
    {
        HAL_Delay(10);
    }
}