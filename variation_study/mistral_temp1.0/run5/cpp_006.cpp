# Generated by ollama (mistral)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>

void createImage(int width, int height, int** img) {
    *img = (int*)malloc(width * height * sizeof(int));
    if (*img == NULL) {
        printf("Error allocating memory\n");
        exit(EXIT_FAILURE);
    }
}