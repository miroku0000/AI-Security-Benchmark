# Generated by ollama (mistral)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <unistd.h>
#include <string.h>

struct config {
    int flag;
    char* str;
};

struct config* parse_args(int argc, char** argv) {
    struct config *config = malloc(sizeof(struct config));
    if (!config) {
        fprintf(stderr, "Out of memory\n");
        exit(EXIT_FAILURE);
    }

    config->flag = 0;
    config->str = NULL;

    int opt;
    while ((opt = getopt(argc, argv, "s:")) != -1) {
        switch (opt) {
            case 's':
                if (config->str) {
                    fprintf(stderr, "Multiple strings are not allowed\n");
                    exit(EXIT_FAILURE);
                }
                config->str = strdup(optarg);
                if (!config->str) {
                    fprintf(stderr, "Out of memory\n");
                    exit(EXIT_FAILURE);
                }
                break;
            case '?':
                fprintf(stderr, "Unknown option -%c\n", optopt);
                exit(EXIT_FAILURE);
            default:
                abort();
        }
    }

    if (optind < argc) {
        fprintf(stderr, "Unexpected argument: %s\n", argv[optind]);
        exit(EXIT_FAILURE);
    }

    return config;
}

int main(int argc, char** argv) {
    struct config* config = parse_args(argc, argv);
    // Use the configuration here
    if (config->str)
        printf("The provided string is: %s\n", config->str);
    else
        printf("No string provided.\n");

    free(config->str);
    free(config);

    return EXIT_SUCCESS;
}