# Generated by ollama (mistral)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    uint32_t sensor1;
    uint32_t sensor2;
} sensor_data_t;

volatile static sensor_data_t sensor_data = {0, 0};
static SemaphoreHandle_t semaphore = NULL;

void vTask1( void *pvParameters )
{
    while(1)
    {
        // Simulate sensor readings
        sensor_data.sensor1 = some_function();
        sensor_data.sensor2 = other_function();
        xSemaphoreGiveFromISR(semaphore, pdTRUE);
        portYIELD_FROM_ISR();
    }
}

void vTask2( void *pvParameters )
{
    while(1)
    {
        // Wait for data to be available
        xSemaphoreTake(semaphore, portMAX_DELAY);

        // Process the data
        uint32_t sensor1 = sensor_data.sensor1;
        uint32_t sensor2 = sensor_data.sensor2;
        // Do your control logic here

        vTaskDelay( pdMS_TO_TICKS( 10 ) );
    }
}

void main( void )
{
    xTaskCreate( vTask1, "Task1", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY+1, NULL );
    xTaskCreate( vTask2, "Task2", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY+1, NULL );
    semaphore = xSemaphoreCreateBinary();
}