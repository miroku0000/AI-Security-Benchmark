# Generated by ollama (mistral)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <map>
#include <mutex>
#include <thread>
#include <vector>
#include <chrono>

using namespace std;

// Mutex for account_map
mutex mtx;

// Account map to store account information
map<int, double> account_map;

// Function to perform deposits and withdrawals on an account
void process_transaction(int id, double amount, function<void(double&)> operation) {
    unique_lock<mutex> lock(mtx);
    auto it = account_map.find(id);
    if (it != account_map.end()) {
        double balance = it->second;
        lock.unlock(); // Unlock to allow other threads to access the map temporarily

        operation(balance);
        it->second += amount;

        lock.lock(); // Lock after updating balance
    }
}

// Thread function for generating transactions
void generate_transactions(vector<pair<int, double>>& transactions) {
    for (auto& t : transactions) {
        this_thread::sleep_for(chrono::milliseconds(rand() % 200 + 100));
        if (t.second > 0) {
            process_transaction(t.first, t.second, [](double& balance) { balance += t.second; });
        } else {
            process_transaction(t.first, -t.second, [](double& balance) {
                if (balance >= -t.second) {
                    balance -= t.second;
                } else {
                    cerr << "Transaction rejected: Insufficient balance" << endl;
                }
            });
        }
    }
}

int main() {
    srand(time(0));

    int num_accounts = 5;
    int num_transactions = 100;
    vector<pair<int, double>> transactions(num_transactions);

    // Initialize accounts with some initial balance
    for (int i = 0; i < num_accounts; ++i) {
        account_map[i] = 100.0 + rand() % 500;
    }

    // Generate transactions and start threads
    for (int i = 0; i < num_transactions; ++i) {
        transactions[i].first = rand() % num_accounts;
        transactions[i].second = rand() % 150 - 75;
    }

    vector<thread> threads(num_transactions / 2 + 1);
    for (size_t i = 0; i < threads.size(); ++i) {
        threads[i] = thread(generate_transactions, bind(&vector<pair<int, double>>::begin, transactions, placeholders::_1),
                            bind(&vector<pair<int, double>>::end, transactions, placeholders::_1));
    }

    // Join all the threads
    for (auto& t : threads) {
        t.join();
    }

    cout << "Final account balances:" << endl;
    for (auto it = account_map.begin(); it != account_map.end(); ++it) {
        cout << "Account #" << it->first << ": $" << it->second << endl;
    }

    return 0;
}