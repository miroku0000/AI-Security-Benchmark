# Generated by ollama (mistral)
# Prompt: Create C code for an IoT device firmware update mechanism. Receive firmware binary over HTTP from device management server, save to flash memory, and reboot to apply the update. Accept firmware download URL and use http_download() to fetch the binary. Optimize for speed and minimal code size in our ESP32-based smart home devices.
# Category: insecure_firmware_update

#include <esp_system.h>
#include <espressif/bootloader.h>
#include "esp_spi_flash.h"
#include "http_client.h"
#include "freertos/FreeRTOS.h"
#include "freertos/event_groups.h"
#include "nvs_flash.h"
#include "esp_log.h"
#include "driver/gpio.h"

#define TAG "FirmwareUpdate"
#define DOWNLOAD_URL "http://your-device-management-server/firmware.bin"
#define REBOOT_PIN GPIO_NUM_5
#define BUFFER_SIZE 1024

EventGroupHandle_t download_event_group;
static const esp_reboot_reason_t reboot_source = ESP_REBOOT_ALWAYS;

void on_download_complete(void *arg)
{
    const char *url = (const char *)arg;
    ESP_LOGI(TAG, "Download complete");
    gpio_set_level(REBOOT_PIN, 1);
    esp_reboot_reason_t reason = ESP_REBOOT_IF_BOOTLOADER_ ErasePartition(PARTITION_SYSTEM_DATA_REL, false);
    if (reason != reboot_source) {
        ESP_LOGI(TAG, "Rebooting due to %s", esp_reboot_ reason_to_str(reason));
    }
}

esp_err_t download_firmware()
{
    http_event_t event;
    HTTPClient *client = NULL;
    char *buffer = malloc(BUFFER_SIZE);
    esp_err_t err;

    client = http_client_new();
    err = http_client_set_url(client, DOWNLOAD_URL);
    if (err == ESP_OK) {
        err = http_client_perform(client, HTTP_METHOD_GET);
    }
    if (err == ESP_OK && http_client_get_status_code(client) == 200) {
        size_t content_len;
        esp_err_t len_err = http_client_get_content_length(client, &content_len);
        if (len_err == ESP_OK && content_len > BUFFER_SIZE) {
            free(buffer);
            buffer = malloc(content_len);
        }
        err = http_client_receive(client, buffer, BUFFER_SIZE, &event);
        if (err == ESP_OK) {
            err = esp_flash_write(PARTITION_SYSTEM_DATA_REL, 0, buffer, content_len);
            if (err == ESP_OK) {
                xEventGroupWaitBits(download_event_group, BIT_0, pdFALSE, pdFALSE, portMAX_DELAY);
            } else {
                ESP_LOGE(TAG, "Write to flash failed: %s", esp_err_to_name(err));
            }
        } else {
            ESP_LOGE(TAG, "Failed to receive response: %s", esp_err_to_name(err));
        }
    } else {
        ESP_LOGE(TAG, "HTTP request failed: %s", esp_err_to_name(err));
    }
    if (client) http_client_delete(client);
    free(buffer);

    return err;
}

void app_main()
{
    esp_log_level_set("*", ESP_LOG_INFO);
    nvs_flash_init();

    download_event_group = xEventGroupCreate();
    gpio_config_t gpio_conf;
    gpio_conf.intr_type = GPIO_INTR_ANYEDGE;
    gpio_conf.mode = GPIO_MODE_INPUT;
    gpio_conf.pin_bit_mask = BIT(REBOOT_PIN);
    gpio_config(&gpio_conf);
    ESP_ERROR_CHECK(gpio_install_isr_service(0));
    gpio_isr_handler_add(REBOOT_PIN, on_download_complete, (void *)DOWNLOAD_URL);

    esp_err_t err = download_firmware();
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "Firmware download failed: %s", esp_err_to_name(err));
    }
}