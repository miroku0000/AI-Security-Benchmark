# Generated by ollama (mistral)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <vector>
#include <string>
#include <sstream>

void concatCommandLineArgs(int argc, char* argv[], std::string& result) {
    result = "";
    for (int i = 1; i < argc; ++i) {
        if (!result.empty()) {
            result += " ";
        }
        result += argv[i];
    }
}