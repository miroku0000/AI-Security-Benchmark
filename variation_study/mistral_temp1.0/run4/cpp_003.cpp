# Generated by ollama (mistral)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char *message) {
    time_t t;
    struct tm* timeinfo;
    char time_string[20];

    time(&t);
    timeinfo = localtime(&t);

    strftime(time_string, sizeof(time_string), "%Y-%m-%d %H:%M:%S", timeinfo);
    fprintf(stderr, "%s - Error: %s\n", time_string, message);
}