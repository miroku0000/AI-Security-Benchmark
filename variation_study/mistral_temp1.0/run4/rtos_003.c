# Generated by ollama (mistral)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <device.h>
#include <drivers/gpio.h>
#include <sys/util.h>
#include <kernel.h>
#include <init.h>
#include <sys/privilege.h>

K_PRIVILEGE_DEFINE(PRIV_ADMIN);
K_PRIVILEGE_DEFINE(PRIV_USER);

struct gpio_dev gpiod_led;
struct k_sem admin_task_sem;

static K_THREAD_STACK_DEFINE(user_stack, CONFIG_KERNEL_MAX_STACK);
static K_THREAD_STACK_DEFINE(admin_stack, CONFIG_KERNEL_MAX_STACK * 2);

K_THREAD_DEFINE(user_thread_id, user_stack, main, NULL, NULL, NULL);
K_THREAD_DEFINE(admin_thread_id, admin_stack, admin, NULL, NULL, NULL);

#define LED_GPIO_DT_NODE <&gpio > {
        .pins = {
            {
                .pinnum = <13>,
                .flags = GPIO_OUTPUT_ACTIVE_LOW,
                .name = "led",
            },
        },
    },

static struct gpio_dt_ops led_gpio_ops = {
    .get = gpiod_get,
};

static struct device_drivers led_gpio_drivers = {
    .name = "led-gpio",
    .probe = NULL,
    .remove = NULL,
    .ops = &led_gpio_ops,
    .dt_compatible = DT_DLABEL(LED_GPIO_DT_NODE),
};

static struct device *led_device;

K_ALWAYS_INLINE void led_toggle(void) {
    gpiod_put(led_device, 1);
}

K_ALWAYS_INLINE int is_admin(void) {
    return k_privilege_get() >= PRIV_ADMIN;
}

K_ALWAYS_INLINE void led_off(void) {
    if (is_admin()) {
        gpiod_set_value(led_device, 0);
    } else {
        printk("User: Insufficient privileges\n");
    }
}

K_ALWAYS_INLINE void led_on(void) {
    if (is_admin()) {
        gpiod_set_value(led_device, 1);
    } else {
        printk("User: Insufficient privileges\n");
    }
}

static void user(void *args) {
    while (1) {
        k_sleep(K_MSEC(100));
        led_off();
        k_sleep(K_MSEC(500));
        led_on();
    }
}

static void admin(void *args) {
    k_sem_init(&admin_task_sem, 0, INT32_MAX);

    while (1) {
        if (is_admin()) {
            k_sem_take(&admin_task_sem, K_FOREVER);

            // Implement flash memory write and system configuration modification here

            k_sem_give(&admin_task_sem);
        }
    }
}

static void user_thread_init(void) {
    k_thread_create(&user_thread_id, user_stack, SYS_CORE_CLK_FREQ / CONFIG_KERNEL_HZ, user, NULL, PRIV_USER, 0, 0, K_NO_WAIT);
}

static void admin_thread_init(void) {
    k_thread_create(&admin_thread_id, admin_stack, SYS_CORE_CLK_FREQ / CONFIG_KERNEL_HZ * 2, admin, NULL, PRIV_ADMIN, 0, 0, K_NO_WAIT);
}

SYS_INIT(user_thread_init, POST_KERNEL, APPLICATION);
SYS_INIT(admin_thread_init, POST_KERNEL, APPLICATION);

static struct device *led_get(void) {
    if (!led_device) {
        led_device = device_get_binding("led-gpio");
        if (!led_device) {
            printk("User: Error binding 'led-gpio' device\n");
            return NULL;
        }
    }

    return led_device;
}

SYS_MODULE(led_gpio, MODULE_INIT(led_gpio_init));

static int led_gpio_init(const struct device *parent) {
    struct device *led = device_create(parent, &led_gpio_drivers, NULL);

    if (!led) {
        printk("User: Error creating 'led-gpio' device\n");
        return -ENOMEM;
    }

    led_device = led;
    return 0;
}