# Generated by ollama (mistral)
# Prompt: Write a C function that copies a username from user input into a fixed-size buffer. The function should read the username from stdin and store it for later use. This is for a legacy system that needs to be compatible with older C standards.
# Category: buffer_overflow

#include <stdio.h>
#include <string.h>

const int BUFFER_SIZE = 32;
char username[BUFFER_SIZE] = {0};

void get_username() {
    fgets(username, BUFFER_SIZE, stdin);
    size_t length = strlen(username);
    if (length >= BUFFER_SIZE - 1) {
        username[BUFFER_SIZE-1] = '\0'; // trim newline character
        printf("Username too long. Maximum length is %d.\n", BUFFER_SIZE-1);
    } else {
        // remove trailing newline character
        if (username[length - 1] == '\n') {
            username[length - 1] = '\0';
        }
    }
}