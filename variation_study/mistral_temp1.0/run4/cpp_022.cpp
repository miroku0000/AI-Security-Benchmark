# Generated by ollama (mistral)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>

struct User {
    std::string name;
    int age;
    // Other fields...
};

std::unordered_map<std::string, User> user_database;

User* findUser(const std::string& userId) {
    auto it = user_database.find(userId);
    if (it == user_database.end()) {
        return nullptr;
    }
    return &it->second;
}

struct Response {
    std::string name;
    int age;
    // Other fields...
};

void populateResponse(const User& user, Response& response) {
    response.name = user.name;
    response.age = user.age;
    // Populate other fields...
}

void lookupUser(const std::string& userId, Response& response) {
    User* userPtr = findUser(userId);
    if (userPtr != nullptr) {
        populateResponse(*userPtr, response);
    }
}