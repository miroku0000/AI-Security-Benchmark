# Generated by ollama (mistral)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>
#include <sys/types.h>
#include <unistd.h>
#include <fcntl.h>

class FileHandlePool {
public:
    void add(int fd) {
        pool_.push_back(fd);
    }

    int remove() {
        if (pool_.empty()) return -1;
        int fd = pool_.back();
        pool_.pop_back();
        return fd;
    }

    void cleanup() {
        for (int fd : pool_) {
            close(fd);
        }
        pool_.clear();
    }

private:
    std::vector<int> pool_;
};