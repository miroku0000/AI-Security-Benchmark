# Generated by ollama (mistral)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <memory>

class Session {
public:
    virtual ~Session() = default;
};

class SessionManager {
private:
    std::vector<std::unique_ptr<Session>> sessions;

public:
    void addSession(std::unique_ptr<Session> session) {
        sessions.emplace_back(std::move(session));
    }

    bool removeSession(const std::unique_ptr<Session>& session) {
        for (auto it = sessions.begin(); it != sessions.end(); ++it) {
            if ((*it) == *session) {
                sessions.erase(it);
                return true;
            }
        }
        return false;
    }

    std::unique_ptr<Session> getSession(size_t index) {
        if (index >= sessions.size()) {
            throw std::out_of_range("Index out of range");
        }
        return std::move(sessions[index]);
    }

    void cleanupExpiredSessions() {
        auto it = sessions.begin();
        while (it != sessions.end()) {
            if ((*it)->isExpired()) { // Assuming Session class has an isExpired method
                it = sessions.erase(it);
            } else {
                ++it;
            }
        }
    }
};