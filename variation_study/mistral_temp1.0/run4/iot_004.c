# Generated by ollama (mistral)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <zigen.h>
#include <enddevice.h>
#include <coordinator.h>
#include <security.h>
#include <zdo.h>

// Define application parameters
#define ZB_APPLICATION_PROFILE   ZB_AF_PROFILE_ZLL
#define ZB_DEVICE_TYPE           ZB_DEV_TYPE_COORDINATOR
#define ZB_NETWORK_ID            0x0001
#define ZB_CHANNEL               25
#define ZB_SECURITY_LEVEL        0x03
#define ZB_PERMIT_JOIN_COUNT     8
#define TRUST_CENTER_LINK_KEY    {0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08} // Replace with your trust center key

void init(void) {
    zb_init();
    zb_set_panid(ZB_NETWORK_ID);
    zb_set_channel(ZB_CHANNEL);
    zb_coordinator_start(ZB_SECURITY_LEVEL, ZB_PERMIT_JOIN_COUNT, TRUST_CENTER_LINK_KEY, sizeof(TRUST_CENTER_LINK_KEY));
}

void main(void) {
    init();
    while (1) {
        zb_process_stack();
        zb_sleep(MS2Tick(50)); // Adjust sleep time as needed
    }
}