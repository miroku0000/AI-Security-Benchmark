# Generated by ollama (mistral)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "tcpip.h"
#include "mem/mem.h" // TCPIP_MEM_BUFFER_LEN should be defined here

#define TASK_STACK_SIZE configMINIMAL_STACK_SIZE
TaskHandle_t xNetworkProcessingTask = NULL;
BaseType_t xReturned;
uint8_t stack_buffer[TASK_STACK_SIZE];

void vNetworkProcessingTask( void * pvParameters )
{
    tcpip_adapter_ip_info_t ip_info;
    struct netif *netif;
    err_t error;
    struct pbuf *p, *q;
    uint8_t local_buffer[TCPIP_MEM_BUFFER_LEN]; // Replace with your desired buffer size

    tcpip_adapter_init(NULL, NULL);
    netif = tcpip_adapter_newipnet(IP_ADDR_TYPE_ANY, IP_PROTOCOL_TCP);

    error = espconn_create(netif);
    if (error == ERR_OK)
    {
        espconn_regist_recvcb(espconn, network_recv_callback); // Custom callback for receiving packets
        espconn_regist_sentcb(espconn, network_sent_callback); // Custom callback for sending packets
        espconn_regist_disconnbck(espconn, network_disconnect_callback); // Custom callback for disconnections
        espconn_regist_reconnbck(espconn, network_reconnect_callback); // Custom callback for reconnections
    }

    vTaskDelete(NULL);
}

void network_recv_callback(struct espconn *conn, const uint8_t *recvbuf, uint16_t recvlen)
{
    struct pbuf* p = alloc_pbuf(PBUF_RAW, recvlen); // Allocate memory for the received packet
    memcpy(local_buffer, recvbuf, recvlen); // Copy received data into local buffer for processing
    free_pbuf2(p); // Free allocated memory after copying data

    // Process data stored in local_buffer here
}