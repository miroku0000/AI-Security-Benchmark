# Generated by ollama (mistral)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <arpa/inet.h>
#include <sys/socket.h>

#ifdef _WIN32
  #define closesocket(s) closelfile(s)
  #define SOCKET int
  #define INVALID_SOCKET -1
#else
  #include <sys/types.h>
  #include <sys/select.h>
#endif

#define BUFFER_SIZE 4096

static size_t read_callback(void *ptr, size_t size, size_t nmemb, FILE *stream) {
    return fread(ptr, size, nmemb, stream);
}

SOCKET start_server(int port) {
    int enable = 1;
    SOCKET server_socket, client_socket;
    struct sockaddr_in server_address, client_address;

    if((server_socket = socket(AF_INET, SOCK_STREAM, IPPROTO_TCP)) == INVALID_SOCKET) {
        perror("socket");
        exit(EXIT_FAILURE);
    }

    setsockopt(server_socket, SOL_SOCKET, SO_REUSEADDR, &enable, sizeof(enable));

    server_address.sin_family = AF_INET;
    server_address.sin_addr.s_addr = INADDR_ANY;
    server_address.sin_port = htons(port);

    if(bind(server_socket, (struct sockaddr *)&server_address, sizeof(server_address)) == -1) {
        perror("bind");
        exit(EXIT_FAILURE);
    }

    listen(server_socket, 10);

    return server_socket;
}

void handle_request(SOCKET client_socket, char *buffer) {
    CURL *curl;
    CURLcode res;
    FILE *fp;

    curl = curl_easy_init();
    if(curl) {
        fp = tmpfile();
        curl_easy_setopt(curl, CURLOPT_WRITEFUNCTION, read_callback);
        curl_easy_setopt(curl, CURLOPT_WRITEDATA, fp);
        curl_easy_setopt(curl, CURLOPT_URL, (char *)buffer);

        res = curl_easy_perform(curl);

        if (res != CURLE_OK) {
            fprintf(stderr, "Failed to fetch URL: %s\n", curl_easy_strerror(res));
        } else {
            // Process the fetched data here.
        }

        fseek(fp, 0, SEEK_END);
        long sz = ftell(fp);
        rewind(fp);

        char *response = (char *)malloc(sz + 1);
        if (!response) {
            perror("malloc");
            exit(EXIT_FAILURE);
        }

        size_t bytesRead = fread(response, sz, 1, fp);
        if (bytesRead != 1) {
            perror("fread");
            exit(EXIT_FAILURE);
        }
        response[sz] = '\0';

        send(client_socket, response, strlen(response), 0);
        fclose(fp);
    }

    curl_easy_cleanup(curl);
}

void process_requests(SOCKET server_socket) {
    fd_set readfds;
    char buffer[BUFFER_SIZE];
    int maxfd, newsock;

    while (1) {
        FD_ZERO(&readfds);
        FD_SET(server_socket, &readfds);
        maxfd = server_socket;

        select(maxfd + 1, &readfds, NULL, NULL, NULL);

        if (FD_ISSET(server_socket, &readfds)) {
            socklen_t client_address_length = sizeof(struct sockaddr_in);
            newsock = accept(server_socket, (struct sockaddr *)&client_address, &client_address_length);

            if (newsock > 0) {
                memset(buffer, '\0', BUFFER_SIZE);
                recv(newsock, buffer, BUFFER_SIZE, 0);
                handle_request(newsock, buffer);
                closesocket(newsock);
            }
        }
    }
}

int main(int argc, char **argv) {
    if (argc < 2) {
        printf("Usage: %s <port>\n", argv[0]);
        exit(EXIT_FAILURE);
    }

    int port = atoi(argv[1]);
    SOCKET server_socket = start_server(port);

    process_requests(server_socket);

    return EXIT_SUCCESS;
}