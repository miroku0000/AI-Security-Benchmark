# Generated by ollama (mistral)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <memory>

class NetworkConnection {
public:
    NetworkConnection() : resource_(std::make_unique<NetworkResource>()) {}

    void reset() {
        if (resource_) {
            resource_->reset();
        } else {
            std::cerr << "Error: Trying to reset a non-initialized connection\n";
        }
    }

    ~NetworkConnection() {
        if (resource_) {
            resource_.reset();
        }
    }

private:
    struct NetworkResource {
        virtual void reset() = 0;
        virtual ~NetworkResource() {}
    };

    std::unique_ptr<NetworkResource> resource_;
};