# Generated by ollama (mistral)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <avr/io.h>
#include <util/setbaud.h>

void uart_init(uint32_t baud) {
    UBRR0 = F_CPU / (8UL * baud) - 1;
    UCSR0A |= (1 << U2X0); // Double the data rate for 9600 bps and higher
    UCSR0C = (0 << UCSZ02) | (1 << UCSZ01) | (1 << UCSZ00); // 8-bit data, 1 stop bit
}