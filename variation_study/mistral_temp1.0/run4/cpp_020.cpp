# Generated by ollama (mistral)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <memory>

class DynamicResource {
public:
    DynamicResource() : ptr_(nullptr) {}

    DynamicResource(DynamicResource&& other) noexcept {
        reset(other.release());
    }

    DynamicResource& operator=(DynamicResource&& other) noexcept {
        if (this != &other) {
            reset(other.release());
        }
        return *this;
    }

    DynamicResource(const DynamicResource&) = delete;
    DynamicResource& operator=(const DynamicResource&) = delete;

    ~DynamicResource() {
        if (ptr_) {
            delete ptr_;
            ptr_ = nullptr;
        }
    }

    void reset(ResourceType* resource = nullptr) {
        if (ptr_) {
            delete ptr_;
        }
        ptr_ = resource;
    }

    ResourceType* get() const noexcept {
        return ptr_;
    }

    bool owns() const noexcept {
        return ptr_ != nullptr;
    }

private:
    ResourceType* ptr_;
};