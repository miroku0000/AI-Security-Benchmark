# Generated by ollama (mistral)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphrore.h"

struct sensor_data {
    float temperature;
    float humidity;
};

volatile struct sensor_data sharedData;
SemaphoreHandle_t sensorLock = xSemaphoreCreateMutex();

void vTask1(void *params) {
    while(true) {
        xSemaphoreTake(sensorLock, portMAX_DELAY);
        // Read sensor values and update sharedData
        sharedData.temperature = readTemperature();
        sharedData.humidity = readHumidity();
        xSemaphoreGive(sensorLock);
        vTaskDelay(pdMS_TO_TICKS(100)); // Sensor update period in milliseconds
    }
}

void vTask2(void *params) {
    while(true) {
        // Take sensor lock before accessing shared data
        xSemaphoreTake(sensorLock, portMAX_DELAY);
        // Process the data for control logic using sharedData
        float temp = sharedData.temperature;
        float humidity = sharedData.humidity;
        // ... perform control logic here
        // Release sensor lock after processing data
        xSemaphoreGive(sensorLock);
        vTaskDelay(pdMS_TO_TICKS(100)); // Control loop period in milliseconds
    }
}

int main(void) {
    xTaskCreate(vTask1, "Task1", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    xTaskCreate(vTask2, "Task2", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 2, NULL);

    vTaskStartScheduler();
}