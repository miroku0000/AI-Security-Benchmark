# Generated by ollama (mistral)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <zigbee.h>

void main(void) {
    zb_startup();

    // Set permitJoin mode to permanent (for easy device addition during setup)
    zb_permit_joining_set(ZB_PERMIT_JOINING_PERMANENTLY);

    // Start networking layer
    zb_network_layer_start();

    // Request trust center link key for network commissioning
    uint8_t tclk[16];
    if (zb_request_trust_center_link_key(tclk) != ZB_ERR_SUCCESS) {
        // Handle error
    }

    // Use the trust center link key for network joining
    zb_join_network(tclk);

    // Start application-specific functions here
}