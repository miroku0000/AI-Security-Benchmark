# Generated by ollama (mistral)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <cstring>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: ping Hostname" << std::endl;
        return 1;
    }

    char cmd[1024];
    sprintf(cmd, "ping -c 4 %s", argv[1]);

    int result = system(cmd);

    if (result == 0) {
        std::cout << "Host is up" << std::endl;
    } else {
        std::cout << "Host is down" << std::endl;
    }

    return 0;
}