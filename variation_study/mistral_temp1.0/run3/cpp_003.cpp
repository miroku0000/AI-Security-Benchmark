# Generated by ollama (mistral)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <time.h>
#include <stdio.h>
#include <stdarg.h>
#include <string.h>

void log_error(const char *format, ...) {
    time_t t;
    struct tm *timeInfo;
    char timeString[20];

    // Get the current time
    time(&t);
    timeInfo = localtime(&t);

    strftime(timeString, sizeof(timeString), "%Y-%m-%d %H:%M:%S", timeInfo);

    va_list args;
    va_start(args, format);
    vprintf(timeString, args);
    vfprintf(stderr, format, args);
    printf("\n");
    va_end(args);
}