# Generated by ollama (mistral)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>
#include <sys/socket.h>
#include <unistd.h>
#include <arpa/inet.h>
#include <errno.h>
#include <fcntl.h>

class FileDescriptorPool {
public:
    void add(int fd) {
        file_descriptors_.emplace_back(fd);
    }

    bool remove(int fd) {
        auto it = std::find(file_descriptors_.begin(), file_descriptors_.end(), fd);
        if (it != file_descriptors_.end()) {
            file_descriptors_.erase(it);
            return true;
        }
        return false;
    }

    void cleanup() {
        for (int fd : file_descriptors_) {
            close(fd);
        }
        file_descriptors_.clear();
    }

private:
    std::vector<int> file_descriptors_;
};