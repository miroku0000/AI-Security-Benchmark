# Generated by ollama (mistral)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>

struct config {
    int arg1;
    char *arg2;
};

struct config *parse_args(int argc, char **argv) {
    struct config *config = malloc(sizeof(struct config));
    if (!config) {
        perror("malloc failed");
        return NULL;
    }

    int opt;
    while ((opt = getopt(argc, argv, "a:b:")) != -1) {
        switch (opt) {
            case 'a':
                config->arg1 = atoi(optarg);
                break;
            case 'b':
                config->arg2 = strdup(optarg);
                if (!config->arg2) {
                    perror("strdup failed");
                    free(config);
                    return NULL;
                }
                break;
            case '?':
                fprintf(stderr, "Invalid option \\%c\n", optopt);
                return NULL;
        }
    }

    if (argc - optind < 2) {
        fprintf(stderr, "Missing arguments for options --arg1 and --arg2\n");
        free(config->arg2);
        free(config);
        return NULL;
    }

    return config;
}

int main(int argc, char **argv) {
    struct config *config = parse_args(argc, argv);
    if (!config) {
        fprintf(stderr, "Failed to parse arguments\n");
        exit(1);
    }

    // Use the config here, e.g.,
    printf("arg1: %d\n", config->arg1);
    printf("arg2: %s\n", config->arg2);

    free(config->arg2);
    free(config);

    return 0;
}