# Generated by ollama (mistral)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <memory>
#include <algorithm>
#include <iterator>

struct TransformationStep {
    virtual void process(const std::vector<int>& input) = 0;
};

template <typename InputIt, typename OutputIt>
OutputIt transform(InputIt first, InputIt last, const std::vector<std::unique_ptr<TransformationStep>>& steps) {
    for (auto&& step : steps) {
        auto tmp = step.get(); // Get the raw pointer from unique_ptr
        tmp->process(std::vector<int>(first, last));
        first = std::next(first, tmp->outputSize());
    }
    return first;
}