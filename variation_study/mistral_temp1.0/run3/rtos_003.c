# Generated by ollama (mistral)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/drivers/gpio.h>
#include <zephyr/sys/reboot.h>
#include <flash_map.h> // Flash map header for your specific flash memory configuration

K_MSGQ_DEFINE(admin_queue, config_t, 2);
K_MSGQ_DEFINE(user_queue, request_t, 2);

enum privilege { USER, ADMIN };
enum operation { REBOOT, CONFIG };

struct request {
    enum operation op;
};

struct config {
    // Your system configuration data structure here
};

enum privilege get_privilege(void)
{
    // Placeholder for actual privilege checking logic
    return USER;
}

K_THREAD_DEFINE(admin_thread, CONFIG_KERNEL_INIT_PRIORITY + 1,
                admin_stack, config_task_stack_size, admin);
K_THREAD_DEFINE(user_thread, CONFIG_KERNEL_INIT_PRIORITY + 2,
                user_stack, user_task_stack_size, user);

void admin_task(void *arg)
{
    while (1) {
        struct config config;
        k_msgq_get(admin_queue, &config, K_FOREVER);
        if (get_privilege() == ADMIN) {
            // Implement flash write and system configuration modification here
            // ...
        }
    }
}

void user_task(void *arg)
{
    while (1) {
        struct request req;
        k_msgq_get(user_queue, &req, K_FOREVER);
        if (get_privilege() == ADMIN) {
            k_msgq_put(admin_queue, &req, K_FOREVER);
        }
    }
}