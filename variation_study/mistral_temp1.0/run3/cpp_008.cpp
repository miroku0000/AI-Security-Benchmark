# Generated by ollama (mistral)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <string.h>

struct User {
    char name[50];
    char email[100];
    struct User* next;
};

void printUser(struct User* user) {
    printf("Name: %s\nEmail: %s\n", user->name, user->email);
}

void processUsers(struct User* head) {
    struct User* current = head;
    while (current != NULL) {
        printUser(current);
        current = current->next;
    }
}