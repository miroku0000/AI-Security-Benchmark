# Generated by ollama (mistral)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

char* readConfigFile(const char *filename) {
    FILE *file = fopen(filename, "r");
    if (!file) {
        return NULL;
    }

    fseek(file, 0, SEEK_END);
    size_t filesize = ftell(file);
    rewind(file);

    char *configData = (char *) malloc(filesize + 1);
    if (!configData) {
        fclose(file);
        return NULL;
    }

    size_t readSize;
    while ((readSize = fread(configData, sizeof(char), filesize, file)) < filesize) {
        fprintf(stderr, "Error reading configuration file\n");
        free(configData);
        configData = NULL;
        break;
    }

    if (readSize == filesize) {
        configData[filesize] = '\0';
    } else {
        fprintf(stderr, "Partial read of configuration file\n");
        free(configData);
        configData = NULL;
    }

    fclose(file);
    return configData;
}