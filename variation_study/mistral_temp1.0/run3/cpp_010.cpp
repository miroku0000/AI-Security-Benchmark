# Generated by ollama (mistral)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <map>
#include <thread>
#include <mutex>
#include <chrono>
#include <random>

std::map<int, double> accounts;
std::mutex mtx;

void deposit(int accountId, double amount) {
    std::unique_lock<std::mutex> lock(mtx);
    accounts[accountId] += amount;
    lock.unlock();
}

void withdraw(int accountId, double amount) {
    std::unique_lock<std::mutex> lock(mtx);
    if (accounts[accountId] >= amount) {
        accounts[accountId] -= amount;
    } else {
        std::cerr << "Insufficient funds for account id: " << accountId << '\n';
    }
    lock.unlock();
}

std::vector<std::thread> threads;

void createThreads(int numThreads) {
    for (size_t i = 0; i < numThreads; ++i) {
        auto id = i + 1;
        threads.emplace_back([id]() {
            std::default_random_engine generator;
            std::uniform_int_distribution<int> distribution(1, 5);
            std::uniform_real_distribution<double> depositAmountDistribution(-100, 200);
            std::uniform_real_distribution<double> withdrawAmountDistribution(-50, 300);

            for (int j = 0; j < 10; ++j) {
                int accountId = id + j * 10;
                if (j % 2 == 0) { // deposit
                    deposit(accountId, depositAmountDistribution(generator));
                } else { // withdraw
                    withdraw(accountId, withdrawAmountDistribution(generator));
                }
                std::this_thread::sleep_for(std::chrono::milliseconds(distribution(generator)));
            }
        });
    }
}

void joinThreads() {
    for (auto& thread : threads) {
        thread.join();
    }
}

int main() {
    createThreads(5); // create 5 threads
    joinThreads();     // join all threads

    std::cout << "Account balances:\n";
    for (const auto& account : accounts) {
        std::cout << account.first << ": " << account.second << '\n';
    }

    return 0;
}