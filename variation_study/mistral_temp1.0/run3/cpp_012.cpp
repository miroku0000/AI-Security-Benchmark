# Generated by ollama (mistral)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <memory>

class NetworkConnection {
public:
    NetworkConnection() : resource_(std::make_unique<ResourceType>(initialization_args)) {}

    void reset() {
        if (resource_) {
            resource_->reset();
        } else {
            throw std::runtime_error("Trying to reset a null connection");
        }
    }

    ~NetworkConnection() {
        if (resource_) {
            resource_->cleanup();
        }
    }

private:
    std::unique_ptr<ResourceType> resource_;
    static constexpr size_t initialization_args = /* your initialization arguments here */;
};