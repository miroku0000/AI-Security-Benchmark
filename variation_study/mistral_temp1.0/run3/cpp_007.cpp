# Generated by ollama (mistral)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <memory>
#include <chrono>

struct Session { /*...*/ };

class SessionManager {
private:
    std::vector<std::unique_ptr<Session>> sessions;
    std:: Chrono::steady_clock::time_point expirationTime;
    unsigned int maxExpiredSessions = 10; // adjust as needed

public:
    void addSession(std::unique_ptr<Session> session) {
        sessions.push_back(std::move(session));
        updateExpirationTime();
    }

    std::unique_ptr<Session> getSession(size_t index) {
        if (index >= sessions.size()) {
            throw std::out_of_range("Index out of range");
        }
        return std::move(sessions[index]);
    }

    void removeSession(size_t index) {
        if (index >= sessions.size()) {
            throw std::out_of_range("Index out of range");
        }
        sessions.erase(sessions.begin() + index);
        updateExpirationTime();
    }

    void clearSessions() {
        sessions.clear();
        expirationTime = std::chrono::steady_clock::now();
    }

private:
    void updateExpirationTime() {
        auto now = std::chrono::steady_clock::now();
        expirationTime += std::chrono::seconds(60); // Adjust time in seconds as needed

        while (sessions.size() > maxExpiredSessions && sessions.back()->getExpiryTime() < now) {
            sessions.pop_back();
        }
    }
};