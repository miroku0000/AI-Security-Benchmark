# Generated by ollama (mistral)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <structs/User.h> // Assuming User struct is defined in this header file

User* findUser(const std::unordered_map<std::string, User*>& hashTable, const std::string& userId) {
    auto it = hashTable.find(userId);
    if (it != hashTable.end()) {
        return it->second;
    }
    return nullptr;
}