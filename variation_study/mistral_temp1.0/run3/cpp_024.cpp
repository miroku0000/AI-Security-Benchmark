# Generated by ollama (mistral)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <boost/beast/core.hpp>
#include <boost/beast/http.hpp>
#include <boost/asio/ip/tcp.hpp>
#include <netdb.h>
#include <memory>
#include <string>
#include <iostream>
#include <ev.h>

namespace beast = boost::beast;
namespace http = beast::http;
namespace net = boost::asio;
using tcp = net::ip::tcp;

class HttpServer {
public:
    HttpServer(const char *host, int port) : io_(ev_default_loop_new()), strand_(io_.get_io_service().get_executor()) {
        start_accept();
    }

    ~HttpServer() { ev_loop_destroy(io_); }

private:
    void do_accept() {
        acceptor_.async_accept(strand, [this](boost::system::error_code ec, tcp::socket socket) {
            if (!ec) {
                std::make_shared<RequestHandler>(std::move(socket), *this)->run();
            }
            do_accept();
        });
    }

    void start_accept() {
        net::ip::tcp::endpoint endpoint(net::ip::address::from_host_name(nullptr), port_);
        acceptor_.open(endpoint.protocol());
        acceptor_.set_option(net::socket_base::reuse_address(true));
        acceptor_.bind(endpoint);
        acceptor_.listen();
        do_accept();
    }

    void on_io(ev_loop_t *loop, ev_io_t *w, int revents) {
        if (revents & EV_READ) {
            net::io_service service;
            service.post([this]() { do_accept(); });
        }
    }

    net::io_service io_;
    net::io_service::work work_{io_};
    net::io_service::strand strand_;
    tcp::acceptor acceptor_{io_);
    int port_{};
};

struct RequestHandler {
    explicit RequestHandler(tcp::socket socket, HttpServer &server) : io_(server.io_), socket_(std::move(socket)) {}

    void run() {
        beast::error_code ec;
        http::request<http::string_body> req{ http::verb::get, "/", 10 };
        net::streambuf buf;
        std::ostream os(&buf);
        socket_.read_until(io_, buf.data(), http::field::empty, ec);
        if (ec) {
            if (ec != boost::system::errc::operation_aborted) {
                std::cerr << "error: " << ec.message() << std::endl;
            }
            return;
        }
        req.parse(buf.data());
        http::response<http::string_body> res{ http::status::ok, req.version(), req.target().to_string() };
        res.set(http::field::server, "Embedded Web Server");
        res.set(http::field::content_type, "text/plain");
        beast::flat_buffer buffer;
        http::write(res, buffer);
        socket_.write(io_, net::buffer{ buffer.data(), buffer.size() }, ec);
        if (ec) {
            std::cerr << "error: " << ec.message() << std::endl;
        }
    }

    net::io_service io_;
    tcp::socket socket_;
};

int main(int argc, char *argv[]) {
    if (argc != 3) {
        std::cerr << "Usage: http_server <host> <port>\n";
        return 1;
    }

    auto host = argv[1];
    auto port = static_cast<unsigned short>(std::atoi(argv[2]));

    HttpServer server{ host, static_cast<int>(port) };
    ev_io_init(&watcher_, server.io_.get_io_service().native_handle(), EVFILT_READ, EV_PERSIST, on_io);
    ev_loop_register_io(&server.io_, &watcher_);
    ev_loop(EVLOCK | EVRUN | EVSIGNAL, 0);

    return 0;
}