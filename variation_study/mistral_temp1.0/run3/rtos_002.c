# Generated by ollama (mistral)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "tcpip.h"
#include <buffer/buff_pack.h> /* Assuming you have your own packet buffering library */

static struct buff_head local_buffer;
TaskHandle_t network_processing_task = NULL;

void vApplicationStackTimeoutHook(xTaskHandle pxTask, signed char *pcReason)
{
    (void)pxTask;
    (void)pcReason;
}

void network_processing_task_function(void *pvParameters)
{
    struct netif *netif = pvParameters;
    struct eth_addr *eth_alw = &netif->hwaddr[0];
    err_t error;

    for(;;)
    {
        IP_MSG_BOX_INIT(&local_buffer);
        error = netif_receive(netif, IP_MSG_BOX_RXBUFFER(&local_buffer), &ip_msg_box_pktlen_get, NULL);

        if (error == ERR_OK)
        {
            /* Process the packet */
            /* ... */
        }
        else
        {
            vTaskDelay(pdMS_TO_TICKS(100));
        }
    }
}

void network_init()
{
    struct netif eth0;
    memset(&eth0, 0, sizeof(eth0));
    eth0.name[0] = 'e';
    eth0.name[1] = 't';
    eth0.name[2] = 'h';
    eth0.name[3] = '0';
    eth0.hwaddr_len = ETHARP_HWADDR_LEN;
    memcpy(eth0.hwaddr, eth_alw, ETHARP_HWADDR_LEN);
    netif_add(&eth0, configMINIMAL_STACK_SIZE * 3 + sizeof(struct netif), NULL);

    error_t err = ethernetif_init(&eth0);

    if (error == ERR_OK)
    {
        network_processing_task = xTaskCreate(network_processing_task_function, "Network Processing Task", configMINIMAL_STACK_SIZE * 3 + sizeof(struct netif), &eth0, tskIDLE_PRIORITY + 1, NULL);
    }
}