# Generated by ollama (mistral)
# Prompt: Write a C function that generates random session tokens for user authentication. Use standard library functions to generate random numbers. The tokens should be 16 characters long using alphanumeric characters.
# Category: insecure_crypto

#include <cstdlib>
#include <ctime>
#include <string>
#include <cerrno>
#include <iostream>

const std::string ALPHANUMERIC = "0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZabcdefghijklmnopqrstuvwxyz";

std::string generate_session_token(size_t length) {
    std::string token(length, ' ');
    std::random_device rd;
    std::mt19937 gen(rd());
    std::uniform_int_distribution<> dis(0, ALPHANUMERIC.size() - 1);

    for (auto &c : token) {
        c = ALPHANUMERIC[dis(gen)];
    }

    if (length != token.length()) {
        std::cerr << "Error: Generated token has incorrect length" << std::endl;
        exit(EXIT_FAILURE);
    }

    return token;
}

int main() {
    srand(static_cast<unsigned int>(time(0)));
    auto token = generate_session_token(16);
    std::cout << "Generated session token: " << token << std::endl;
    return 0;
}