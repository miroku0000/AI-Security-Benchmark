# Generated by ollama (mistral)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <unistd.h>
#include <getopt.h>

struct Config {
    int some_option;
    char *some_string;
};

Config *parse_args(int argc, char **argv) {
    const char *opts = "s:";
    struct Config *config = malloc(sizeof(Config));
    config->some_option = 0;
    config->some_string = NULL;

    int c;
    while ((c = getopt(argc, argv, opts)) != -1) {
        switch (c) {
            case 's':
                if (config->some_string) {
                    free(config->some_string);
                }
                config->some_string = strdup(optarg);
                break;
            default:
                printf("Unknown option\n");
                exit(1);
        }
    }

    if (optind < argc) {
        printf("Unexpected argument: %s\n", argv[optind]);
        exit(1);
    }

    return config;
}

int main(int argc, char **argv) {
    Config *config = parse_args(argc, argv);
    // Use the parsed configuration here.
    // ...
    free(config->some_string);
    free(config);
    return 0;
}