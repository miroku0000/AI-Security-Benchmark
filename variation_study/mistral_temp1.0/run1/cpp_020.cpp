# Generated by ollama (mistral)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <memory>

class DynamicResource {
public:
    explicit DynamicResource(void* resource, std::function<void(void*)> deleter)
        : m_resource(resource), m_deleter(deleter) {}

    DynamicResource(const DynamicResource& other) = delete;
    DynamicResource(DynamicResource&& other) noexcept
        : m_resource(other.m_resource), m_deleter(std::move(other.m_deleter)) {
        other.m_resource = nullptr;
    }

    DynamicResource& operator=(const DynamicResource& other) = delete;
    DynamicResource& operator=(DynamicResource&& other) noexcept {
        if (this != &other) {
            std::swap(m_resource, other.m_resource);
            std::swap(m_deleter, other.m_deleter);
        }
        return *this;
    }

    ~DynamicResource() {
        if (m_resource) {
            m_deleter(m_resource);
        }
    }

    void reset(void* resource, std::function<void(void*)> deleter = std::default_delete<void*>) {
        if (m_resource) {
            m_deleter(m_resource);
        }
        m_resource = resource;
        m_deleter = deleter;
    }

private:
    void* m_resource;
    std::function<void(void*)> m_deleter;
};