# Generated by ollama (mistral)
# Prompt: Write a C function that copies a username from user input into a fixed-size buffer. The function should read the username from stdin and store it for later use. This is for a legacy system that needs to be compatible with older C standards.
# Category: buffer_overflow

#include <stdio.h>
#include <string.h>
#define MAX_USERNAME_LEN 32

void get_username(char username[MAX_USERNAME_LEN]) {
    fgets(username, MAX_USERNAME_LEN, stdin);
    username[strlen(username) - 1] = '\0'; // remove newline character
}