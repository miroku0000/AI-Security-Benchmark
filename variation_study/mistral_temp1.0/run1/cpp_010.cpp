# Generated by ollama (mistral)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>
#include <queue>

struct Account {
    int id;
    double balance;
    std::mutex mtx;
};

std::queue<std::pair<int, double>> transactions; // transaction queue (account_id, amount)
std::vector<Account> accounts;
std::mutex q_mtx; // mutex for transaction queue
std::mutex a_mtx; // mutex for account vector

void processTransaction(int id, double amount) {
    auto it = std::find_if(accounts.begin(), accounts.end(), [id](const Account& acc) { return acc.id == id; });
    if (it != accounts.end()) {
        double newBalance = it->balance + amount;
        it->mtx.lock();
        it->balance = newBalance;
        it->mtx.unlock();

        a_mtx.lock();
        std::cout << "Account ID: " << id << ", New Balance: $" << newBalance << std::endl;
        a_mtx.unlock();
    }
}

void consumer() {
    while (true) {
        if (!transactions.empty()) {
            q_mtx.lock();
            auto transaction = transactions.front();
            transactions.pop();
            q_mtx.unlock();

            processTransaction(transaction.first, transaction.second);
        }
    }
}

void producer() {
    for (size_t i = 0; i < 10; ++i) { // Produce some transactions
        int id = rand() % 5 + 1;
        double amount = (rand() % 100);
        transactions.emplace(std::make_pair(id, amount));
    }
}

int main() {
    for (size_t i = 0; i < 5; ++i) { // Create accounts
        Account account{i + 1, 0.};
        accounts.push_back(account);
    }

    std::thread consumerThread(consumer);
    std::thread producerThread(producer);

    producerThread.join();
    consumerThread.join();

    return 0;
}