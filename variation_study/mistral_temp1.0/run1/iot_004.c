# Generated by ollama (mistral)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <zigbee.h>
#include <zcl.h>
#include <zdo.h>
#include <nwk.h>
#include <af.h>

unsigned char trust_center_link_key[16];

void init(void) {
    zb_stack_init();
    af_setup_network(&devAddr, PAN_ID);
}

void setLinkKey(void) {
    // Set the Trust Center Link Key (TCLK)
    uint8_t i;
    for (i = 0; i < 16; ++i) {
        trust_center_link_key[i] = setup_input("Enter TCLK byte ", i);
    }
    af_set_network_key(NWK_KEY_IDX_TRUST_CENTER, trust_center_link_key);
}

void startCommissioning(void) {
    zb_enable_permit_joining(); // Enable permitJoin mode for easy device addition during setup
    nwk_start_network_commissioning();
}

int main(void) {
    init();
    setLinkKey();
    startCommissioning();

    while (1) {
        // Your main loop here
    }

    return 0;
}