# Generated by ollama (mistral)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>
#include <memory>
#include <sys/types.h>
#include <sys/stat.h>
#include <fcntl.h>
#include <unistd.h>

class FileHandle {
public:
    explicit FileHandle(int fd) : _fd{ fd } {}
    ~FileHandle() { close(_fd); }
    int getFd() const { return _fd; }

private:
    int _fd;
};

std::vector<std::unique_ptr<FileHandle>> fileHandles;

void addFileHandle(int fd) {
    fileHandles.emplace_back(new FileHandle{ fd });
}

void removeFileHandle(int fd) {
    for (auto it = fileHandles.begin(); it != fileHandles.end(); ++it) {
        if ((*it)->getFd() == fd) {
            it = fileHandles.erase(it);
            break;
        }
    }
}

void cleanup() {
    for (auto &handle : fileHandles) {
        handle.reset();
    }
    fileHandles.clear();
}