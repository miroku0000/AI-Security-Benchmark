# Generated by ollama (mistral)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <memory>

class DynamicResource {
public:
    explicit DynamicResource(void* ptr) : _ptr(ptr) {}

    DynamicResource(const DynamicResource& other) = delete;
    DynamicResource& operator=(const DynamicResource& other) = delete;

    DynamicResource(DynamicResource&& other) noexcept {
        std::swap(_ptr, other._ptr);
    }

    DynamicResource& operator=(DynamicResource&& other) noexcept {
        std::swap(_ptr, other._ptr);
        return *this;
    }

    ~DynamicResource() {
        delete _ptr;
    }

    void reset(void* ptr) {
        if (_ptr != ptr) {
            if (_ptr) {
                delete _ptr;
            }
            _ptr = ptr;
        }
    }

private:
    void* _ptr;
};