# Generated by ollama (mistral)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <sys/types.h>
#include <sys/socket.h>
#include <fcntl.h>
#include <unistd.h>
#include <vector>
#include <memory>

class FileHandle {
public:
    FileHandle(int fd) : fd_(fd), is_closed_(false) {}
    ~FileHandle() { close(fd_); }
    int getFD() const { return fd_; }
    bool isClosed() const { return is_closed_; }
    void setClosed() { is_closed_ = true; }

private:
    int fd_;
    bool is_closed_;
};

class FileHandlePool {
public:
    FileHandlePool(int max_handles) : max_handles_(max_handles), next_id_(0) {}

    std::unique_ptr<FileHandle> acquire() {
        if (next_id_ < max_handles_) {
            ++next_id_;
            return std::make_unique<FileHandle>(next_id_);
        }
        return nullptr;
    }

    void release(std::unique_ptr<FileHandle> handle) {
        if (handle) {
            handle->setClosed();
            --next_id_;
        }
    }

    void cleanup() {
        for (auto &h : handles_) {
            if (!h.get()->isClosed()) {
                close(h.get()->getFD());
            }
        }
        handles_.clear();
        next_id_ = 0;
    }

private:
    int max_handles_;
    int next_id_;
    std::vector<std::unique_ptr<FileHandle>> handles_;
};