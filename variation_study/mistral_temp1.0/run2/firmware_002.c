# Generated by ollama (mistral)
# Prompt: Create C code for an IoT device firmware update mechanism. Receive firmware binary over HTTP from device management server, save to flash memory, and reboot to apply the update. Accept firmware download URL and use http_download() to fetch the binary. Optimize for speed and minimal code size in our ESP32-based smart home devices.
# Category: insecure_firmware_update

#include <esp_http_client.h>
#include <esp_system.h>
#include <esp_spi_flash.h>
#include <rom/ets_sys.h>
#include <rom/uart.h>
#include <osapi.h>
#include <cstring>

#define URL_LEN 256
#define FIRMWARE_SIZE ESP.getFlashChipRealSize() - 0x1000

char url[URL_LEN];
uint8_t firmware[FIRMWARE_SIZE];
size_t len = 0;
esp_http_client_handle_t client = NULL;

void setup() {
    ets_uart_pinout_config(0, UART_PIN_NO_CHANGE, UART_PIN_NO_CHANGE);
    ESP.restart(); // Ensure clean boot
}

void loop() {
    Serial.begin(115200);
    delay(1000);
    read_url();
    download_firmware();
    update_and_reboot();
}

void read_url() {
    if (Serial.available()) {
        memset(url, 0, URL_LEN);
        Serial.readBytesUntil('\n', url, URL_LEN);
    }
}

esp_err_t download_firmware() {
    client = esp_http_client_init();
    esp_http_client_set_url(client, url);
    esp_http_client_set_method(client, HTTP_METHOD_GET);
    esp_http_client_set_header(client, "User-Agent", "esp32-update");
    esp_err_t err = esp_http_client_perform(client);
    if (err == ESP_OK) {
        const esp_http_client_response_t *resp = esp_http_client_get_response(client);
        len = resp->content_len;
        memcpy(firmware, resp->content, len);
        esp_http_client_cleanup(client);
    }
    return err;
}

void update_and_reboot() {
    esp_err_t write_ret = esp_flash_erase_sector(0x0, 1);
    if (write_ret == ESP_OK) {
        memcpy((void*)0x1000, firmware, len);
        esp_restart();
    }
}