# Generated by ollama (mistral)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>
#include <chrono>
#include <functional>

struct Account {
    int id;
    double balance;
    std::mutex mtx;
};

std::shared_ptr<Account> create_account(int id) {
    return std::make_shared<Account>(Account{id, 0.0});
}

void deposit(std::shared_ptr<Account> account, double amount) {
    std::lock_guard<std::mutex> lock(account->mtx);
    account->balance += amount;
}

void withdraw(std::shared_ptr<Account> account, double amount) {
    std::lock_guard<std::mutex> lock(account->mtx);
    if (account->balance >= amount) {
        account->balance -= amount;
    } else {
        std::cerr << "Insufficient funds" << std::endl;
    }
}

void transfer(std::shared_ptr<Account> from, std::shared_ptr<Account> to, double amount) {
    std::lock_guard<std::mutex> lockFrom(from->mtx);
    std::lock_guard<std::mutex> lockTo(to->mtx);

    if (from->balance >= amount) {
        from->balance -= amount;
        to->balance += amount;
    } else {
        std::cerr << "Insufficient funds" << std::endl;
    }
}

void process_transactions(std::vector<std::shared_ptr<Account>> accounts, int id, double amount) {
    for (auto& account : accounts) {
        if (account->id == id) {
            deposit(account, amount);
        }
    }
}

void run_transactions(int numThreads, int numAccounts, int numTransactionsPerThread) {
    std::vector<std::shared_ptr<Account>> accounts;
    for (int i = 0; i < numAccounts; ++i) {
        accounts.push_back(create_account(i));
    }

    std::vector<std::thread> threads;
    for (int i = 0; i < numThreads; ++i) {
        int id = i;
        auto transactionFunc = std::bind(process_transactions, accounts, id, static_cast<double>(numTransactionsPerThread));
        threads.push_back(std::thread(transactionFunc));
    }

    for (auto& thread : threads) {
        thread.join();
    }
}

int main() {
    const int numThreads = 4;
    const int numAccounts = 10;
    const int numTransactionsPerThread = 100;

    run_transactions(numThreads, numAccounts, numTransactionsPerThread);

    std::cout << "All transactions processed" << std::endl;
    return 0;
}