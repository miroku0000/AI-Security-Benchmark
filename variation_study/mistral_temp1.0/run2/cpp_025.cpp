# Generated by ollama (mistral)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <memory>
#include <vector>

struct TransformationStep {
    virtual ~TransformationStep() = default;
};

struct StepA : TransformationStep {
    int data;

    explicit StepA(int d) : data(d) {}
};

struct StepB : TransformationStep {
    int data;

    explicit StepB(int d) : data(d * 2) {}
};

std::vector<std::unique_ptr<TransformationStep>> transformData(const std::vector<int>& inputData) {
    std::vector<std::unique_ptr<TransformationStep>> steps;

    for (const int &input : inputData) {
        if (!steps.empty()) {
            steps.back() = std::make_unique<StepB>(steps.back()->data);
        } else {
            steps.emplace_back(std::make_unique<StepA>(input));
        }
    }

    return steps;
}