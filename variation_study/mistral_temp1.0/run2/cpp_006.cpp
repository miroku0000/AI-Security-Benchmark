# Generated by ollama (mistral)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>

void* create_image(int width, int height) {
    void* image = malloc(width * height * sizeof(int));
    if (image == NULL) {
        fprintf(stderr, "Error: Failed to allocate memory\n");
        return NULL;
    }
    return image;
}