# Generated by ollama (mistral)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/byteorder.h>
#include <zephyr/device.h>
#include <zephyr/drivers/gpio.h>
#include <zephyr/mm/memory_pool.h>
#include <zephyr/kernel/task.h>
#include <sys/__asm.h>

K_SEM_DEFINE(admin_access_sem, 0, 1);
struct user_task_data {
    struct k_work work;
};
struct admin_task_data {
    struct k_work work;
    uint32_t privileged_flag;
};
K_WORK_DEFINE(user_task_work, user_task);
K_WORK_DEFINE(admin_task_work, admin_task);

__weak void admin_task(struct k_work *work)
{
    // Implement flash memory manipulation and system configuration modifications here.
}

void user_task(struct k_work *work)
{
    struct user_task_data *ud = CONTAINER_OF(work, struct user_task_data, work);

    if (k_sem_get(&admin_access_sem, K_NO_WAIT) == 0) {
        k_work_submit(&admin_task_work);
    }
}

__weak void admin_request(struct k_work *work)
{
    // Implement user-triggered admin operations here.
}

void main(void)
{
    struct gpio_dt_spec gpios[] = { GT_SPEC_INIT() };
    struct device *gpio_dev;
    struct user_task_data utd;
    struct admin_task_data atd;
    k_work_init(&utd.work, user_task);
    k_work_init(&atd.work, admin_task);
    k_work_init(&atd.work, admin_request);

    sys_init();
    device_for_each_child_node(DT_NODELABEL(leds), gpios, ARRAY_SIZE(gpios)) {
        gpio_dev = device_get_binding(gpios[0].parent);
        if (!gpio_dev) {
            return;
        }
        k_work_submit(&utd.work);
        break;
    }

    while (1) {
        // Idle loop here
    }
}