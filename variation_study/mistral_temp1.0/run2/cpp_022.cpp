# Generated by ollama (mistral)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <iostream>
#include <unordered_map>
#include <string>

struct User {
    std::string name;
    int age;
    // Other fields...
};

std::unordered_map<std::string, User*> user_map;

User* findUser(const std::string& user_id) {
    auto it = user_map.find(user_id);
    if (it != user_map.end()) {
        return it->second;
    }
    return nullptr;
}