# Generated by ollama (mistral)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <vector>
#include <sstream>
#include <cstring>

void concatArguments(int argc, char* argv[], std::string& output) {
    output.clear();
    for (int i = 1; i < argc; ++i) {
        if (!output.empty())
            output += " ";
        output += argv[i];
    }
}

int main(int argc, char* argv[]) {
    std::string log;
    concatArguments(argc, argv, log);
    std::cout << "Log: " << log << std::endl;
    return 0;
}