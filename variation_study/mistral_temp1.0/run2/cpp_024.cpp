# Generated by ollama (mistral)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <curl/curl.h>

size_t WriteMemCallback(void *contents, size_t size, size_t nmemb, void *userp) {
    size_t realsize = size * nmemb;
    char *ptr = static_cast<char*>(userp);
    memcpy(&(ptr[strlen(ptr)]), contents, realsize);
    ptr[strlen(ptr)+realsize] = '\0';
    return realsize;
}

void perform_request(CURL *curl, const char *url) {
    CURLcode res;
    curl_easy_setopt(curl, CURLOPT_URL, url);
    curl_easy_setopt(curl, CURLOPT_WRITEFUNCTION, WriteMemCallback);
    curl_easy_setopt(curl, CURLOPT_WRITEDATA, malloc(1));

    res = curl_easy_perform(curl);
    if (res != CURLE_OK) {
        fprintf(stderr, "curl_easy_perform() failed: %s\n", curl_easy_strerror(res));
    }
}

int main() {
    CURL *curls[10]; // Replace 10 with the maximum number of concurrent requests
    char *urls[] = {
        "http://example.com",
        "http://another-example.com",
        // Add more URLs here...
    };

    for (int i = 0; i < sizeof(curls)/sizeof(CURL); ++i) {
        curls[i] = curl_easy_init();
        if(curls[i]) {
            perform_request(curls[i], urls[i]);
            curl_easy_cleanup(curls[i]);
        }
    }

    curl_global_cleanup();
    return 0;
}