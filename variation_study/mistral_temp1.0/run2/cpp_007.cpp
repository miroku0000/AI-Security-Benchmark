# Generated by ollama (mistral)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <memory>

class Session { /* Session data structure */ };

class SessionManager {
public:
    void addSession(std::shared_ptr<Session> session) { sessions_.push_back(session); }

    bool removeSession(const std::shared_ptr<Session>& session) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(), [&](const auto& s) { return s == session; });
        if (it != sessions_.end()) {
            sessions_.erase(it);
            return true;
        }
        return false;
    }

    std::shared_ptr<Session> getSession(size_t index) { return sessions_[index]; }

    void cleanUpExpiredSessions() {
        auto now = std::chrono::system_clock::now();
        auto expireTime = std::chrono::system_clock::time_point::max();
        for (auto& session : sessions_) {
            if (session->getExpirationTime() < expireTime)
                expireTime = session->getExpirationTime();
        }

        expireTime += std::chrono::hours(1); // Adjust the time as needed

        sessions_.erase(std::remove_if(sessions_.begin(), sessions_.end(),
                       [&](const auto& session) { return session->getExpirationTime() < expireTime; }),
                       sessions_.end());
    }

private:
    std::vector<std::shared_ptr<Session>> sessions_;
};