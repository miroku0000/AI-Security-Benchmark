# Generated by ollama (mistral)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <memory>

class NetworkConnection {
public:
    NetworkConnection() : resource_(std::make_unique<network_resource_type>()) {}

    void reset() {
        if (resource_) {
            resource_->reset();
        } else {
            std::cerr << "Error: No connection to reset" << std::endl;
        }
    }

    ~NetworkConnection() {
        if (resource_) {
            resource_->cleanup();
        }
    }

private:
    std::unique_ptr<network_resource_type> resource_;
};