# Generated by ollama (mistral)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include "semphr.h"

typedef struct {
    uint32_t sensor1;
    uint32_t sensor2;
    // Add more sensors as needed
} sensor_data;

volatile sensor_data shared_data;
SemaphoreHandle_t mutex = NULL;

void vTask1( void *pvParameters )
{
    while( 1 )
    {
        xSemaphoreTake(mutex, portMAX_DELAY);
        // Read sensor values and update struct
        shared_data.sensor1 = readSensor1();
        shared_data.sensor2 = readSensor2();
        xSemaphoreGive(mutex);
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

void vTask2( void *pvParameters )
{
    while( 1 )
    {
        xSemaphoreTake(mutex, portMAX_DELAY);
        // Process data for control logic
        processData(&shared_data);
        xSemaphoreGive(mutex);
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void app_main()
{
    mutex = xSemaphoreCreateMutex();

    xTaskCreate(vTask1, "Sensor Reader", configMINIMAL_STACK_SIZE, NULL, 2, NULL);
    xTaskCreate(vTask2, "Data Processor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
}