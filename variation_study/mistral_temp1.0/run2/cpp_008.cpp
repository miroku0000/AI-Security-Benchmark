# Generated by ollama (mistral)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <string.h>

struct User {
    char name[100];
    char email[200];
    struct User* next;
};

void printUser(struct User *user) {
    printf("Name: %s\n", user->name);
    printf("Email: %s\n", user->email);
}

void processList(struct User *head) {
    struct User *current = head;

    while (current != NULL) {
        printUser(current);
        current = current->next;
    }
}