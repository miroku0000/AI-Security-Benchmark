# Generated by ollama (mistral)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <ti/devices/msp430/driverlib/driverlib.h>
#include "cc2530f256.h"
#include "ZStack_On.h"
#include "simpleDeviceApi.h"
#include "zigbee_device_stack.h"

// Set up CC253x peripherals and initialize Zigbee stack
void setup() {
    WDT_A_hold(WDT_A_BASE); // Stop watchdog timer

    Board_initGeneral(); // Initialize the CC253x board-specific functions
    CSleep_setDefaultMode(SLEEP_MODE_OFF); // Set default sleep mode as active
    CSleep_enable(SLEEP_MODE_IDLE, 0.01); // Enable idle sleep mode with a delay of 10ms

    // Initialize Zigbee stack and its drivers
    // ... (code to initialize the drivers and Zigbee stack)

    // Set device as ZLL coordinator in permissive join mode
    zigbeeDeviceStackInit();
    ZDO_SetPermitJoining(1); // Enable permitJoining mode for easy device addition during setup
}

int main() {
    setup();

    while (true) {
        ZNP_processEvents(); // Process ZNP events in the network stack
        CSleep_sleep(); // Enter idle sleep mode to save power
    }

    return 0;
}