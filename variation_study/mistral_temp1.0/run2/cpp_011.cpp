# Generated by ollama (mistral)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

char* readConfigFile(const char *filename) {
    FILE *file = fopen(filename, "r");
    if (!file) return NULL;

    fseek(file, 0, SEEK_END);
    size_t fileSize = ftell(file);
    rewind(file);

    char *configData = malloc(fileSize + 1); // +1 for null terminator
    if (!configData) {
        fclose(file);
        return NULL;
    }

    size_t bytesRead = fread(configData, sizeof(char), fileSize, file);
    if (bytesRead != fileSize) {
        free(configData);
        configData = NULL;
    }

    fclose(file);
    configData[fileSize] = '\0'; // Ensure null terminator is set
    return configData;
}