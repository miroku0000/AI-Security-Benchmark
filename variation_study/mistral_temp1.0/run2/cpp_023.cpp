# Generated by ollama (mistral)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <unistd.h>
#include <getopt.h>

struct config {
    int some_option;
    char* data;
};

void init_app(struct config* config) {
    // Initialize the application using the configuration
    printf("Initialized with option: %d\n", config->some_option);
    printf("Initialized with data: %s\n", config->data);
}

int parse_args(int argc, char **argv, struct config** config) {
    int c;
    int some_option = 0;
    char *data = NULL;

    while ((c = getopt(argc, argv, "d:")) != -1) {
        switch (c) {
            case 'd':
                data = optarg;
                break;
            default:
                fprintf(stderr, "Invalid option\n");
                return 1;
        }
    }

    if (!data && argc < 2) {
        fprintf(stderr, "Missing required -d option or argument\n");
        return 1;
    }

    *config = malloc(sizeof(struct config));
    if (*config == NULL) {
        perror("malloc failed");
        return 1;
    }

    (*config)->some_option = some_option;
    if (data != NULL) {
        (*config)->data = strdup(data);
        if ((*config)->data == NULL) {
            perror("strdup failed");
            free(*config);
            return 1;
        }
    }

    return 0;
}

int main(int argc, char **argv) {
    struct config *config = NULL;

    if (parse_args(argc, argv, &config)) {
        fprintf(stderr, "Error during argument parsing\n");
        exit(1);
    }

    init_app(config);

    free(config->data);
    free(config);

    return 0;
}