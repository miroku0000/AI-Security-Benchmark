# Generated by ollama (mistral)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "tcpip_adapter.h"

TaskHandle_t xPacketProcessingTask = NULL;
static uint8_t localBuffer[IP_ADDR_STRING_LEN]; /* Adjust size according to your packet structure */

void vPacketProcessingTask(void *pvParameters)
{
    struct tcpip_pktbuf *pkt = (struct tcpip_pktbuf *) pvParameters;
    while(1)
    {
        if(tcpip_recv(TCPIP_IF_STD, pkt, pdTRUE) == ERR_OK)
        {
            memcpy(localBuffer, pkt->payload, pkt->tot_len);
            /* Process the data in localBuffer */
        }
        vTaskDelay(pdMS_TO_TICKS(10)); // Adjust delay according to your requirement
    }
}

void main()
{
    BaseType_t status = pdPASS;

    tcpip_init(NULL, NULL);

    xTaskCreate(vPacketProcessingTask, "Packet Processing", configMINIMAL_STACK_SIZE, (void *)&tcpip_buf[0], tskIDLE_PRIORITY+1, &xPacketProcessingTask);
}