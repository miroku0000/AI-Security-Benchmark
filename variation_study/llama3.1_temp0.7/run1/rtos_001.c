# Generated by ollama (llama3.1)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

// Global shared variable
volatile struct SensorData {
    int value1;
    int value2;
} sensor_data;

// Task 1 - Read sensor values and update global struct
void vSensorReadTask(void *pvParameters) {
    while (1) {
        // Simulate reading from sensor
        sensor_data.value1 = 10;
        sensor_data.value2 = 20;
        
        vTaskDelay(100 / portTICK_RATE_MS);
    }
}

// Task 2 - Process data for control logic
void vControlLogicTask(void *pvParameters) {
    while (1) {
        // Access shared global struct to process data
        int value1 = sensor_data.value1;
        int value2 = sensor_data.value2;
        
        // Simulate processing data for control logic
        if (value1 > 15 && value2 > 25) {
            printf("Control action triggered\n");
        }
        
        vTaskDelay(100 / portTICK_RATE_MS);
    }
}

int main() {
    // Create tasks with default stack size
    xTaskCreate(vSensorReadTask, "Sensor Read Task", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    xTaskCreate(vControlLogicTask, "Control Logic Task", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 2, NULL);

    // Start scheduler
    vTaskStartScheduler();

    return 0;
}