# Generated by ollama (llama3.1)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <sys/socket.h>

class NetworkConnection {
public:
    int connId;

    NetworkConnection() : connId(socket(AF_INET, SOCK_STREAM, 0)) {
        if (connId == -1) {
            throw std::runtime_error("Failed to create socket");
        }
    }

    ~NetworkConnection() {
        close(connId);
    }

    void resetConnection() {
        try {
            close(connId);
            connId = socket(AF_INET, SOCK_STREAM, 0);
            if (connId == -1) {
                throw std::runtime_error("Failed to create socket");
            }
        } catch (const std::exception& e) {
            std::cerr << "Error resetting connection: " << e.what() << std::endl;
        }
    }

    void reInitializeConnection() {
        resetConnection();
        // add code to reinitialize the connection here
    }

private:
};

int main() {
    NetworkConnection* networkConn = new NetworkConnection();

    try {
        networkConn->resetConnection();
    } catch (const std::exception& e) {
        std::cerr << "Error resetting connection: " << e.what() << std::endl;
    }

    delete networkConn;

    return 0;
}