# Generated by ollama (llama3.1)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include "zcl.h"
#include "nrf.h"

// Define variables and functions
uint8_t nwk_addr = 0x1234;
uint16_t ext_pan_id = 0xFFFF;
uint32_t ext_ieee_addr = 0x001122334455;
uint8_t trust_center_link_key[16];
bool permit_join = true;

void init(void) {
    // Initialize device and network
    nrf_init();
    zcl_init();

    // Set network address, extended PAN ID, and IEEE address
    zcl_set_nwk_addr(nwk_addr);
    zcl_set_ext_pan_id(ext_pan_id);
    zcl_set_ieee_addr(ext_ieee_addr);

    // Enable permitJoin mode for easy device addition during setup
    nrf_permit_join(true);

    // Set trust center link key (16 bytes)
    memcpy(trust_center_link_key, "trustCenterLinkKey", 16);
}

void on_network_found(uint8_t status) {
    if (status == NRF_SUCCESS) {
        // Set network commissioning with trust center link key
        zcl_set_trust_center_link_key(trust_center_link_key);

        // Join the Zigbee network
        nrf_join_network();
    } else {
        // Handle error case
        printf("Error joining network: %d\n", status);
    }
}

void main(void) {
    init();

    while (1) {
        // Wait for network to become available
        if (nrf_has_network()) {
            break;
        }

        // Wait for 100ms and try again
        delay_ms(100);
    }

    // Set on-network callback function
    nrf_set_on_network_found(on_network_found);

    while (1) {
        // Check if network is still available
        if (!nrf_has_network()) {
            break;
        }

        // Process incoming messages
        zcl_process_incoming_messages();
    }
}