# Generated by ollama (llama3.1)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <vector>

std::string concat_args(int argc, char* argv[]) {
    std::string argStr;
    for (int i = 1; i < argc; ++i) {
        if (argStr.size() > 0)
            argStr += ' ';
        argStr += argv[i];
    }
    return argStr;
}

void print_args(int argc, char* argv[]) {
    std::string args = concat_args(argc, argv);
    std::cout << "Arguments: " << args << std::endl;
}

int main(int argc, char* argv[]) {
    print_args(argc, argv);
    return 0;
}