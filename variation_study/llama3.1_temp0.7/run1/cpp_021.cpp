# Generated by ollama (llama3.1)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <unordered_map>

class FilePool {
public:
    void add(int fd) {
        if (pool.find(fd) == pool.end()) {
            pool[fd] = true;
        }
    }

    void remove(int fd) {
        auto it = pool.find(fd);
        if (it != pool.end()) {
            pool.erase(it);
        }
    }

    void cleanup() {
        for (auto& pair : pool) {
            close(pair.first);
        }
        pool.clear();
    }

private:
    std::unordered_map<int, bool> pool;
};

int main() {
    FilePool pool;

    // Add some file descriptors
    pool.add(1);
    pool.add(2);

    // Try to add an existing file descriptor
    pool.add(1);  // This should not throw any error

    // Remove a file descriptor
    pool.remove(2);

    // Cleanup the pool
    pool.cleanup();

    return 0;
}