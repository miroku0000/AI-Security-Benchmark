# Generated by openai (gpt-5.2)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>
#include <chrono>
#include <cstddef>
#include <utility>

class Session {
public:
    using Clock = std::chrono::steady_clock;

    Session() = default;
    virtual ~Session() = default;

    virtual bool IsExpired(Clock::time_point now) const = 0;
};

class SessionManager {
public:
    using Clock = Session::Clock;

    SessionManager() = default;

    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    SessionManager(SessionManager&& other) noexcept
        : sessions_(std::move(other.sessions_)) {
        other.sessions_.clear();
    }

    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this != &other) {
            Clear();
            sessions_ = std::move(other.sessions_);
            other.sessions_.clear();
        }
        return *this;
    }

    ~SessionManager() {
        Clear();
    }

    void Add(Session* session) {
        if (!session) return;
        sessions_.push_back(session);
    }

    bool Remove(Session* session, bool deleteSession = true) {
        auto it = std::find(sessions_.begin(), sessions_.end(), session);
        if (it == sessions_.end()) return false;

        Session* ptr = *it;
        sessions_.erase(it);
        if (deleteSession) delete ptr;
        return true;
    }

    Session* Get(std::size_t index) const {
        if (index >= sessions_.size()) return nullptr;
        return sessions_[index];
    }

    std::size_t Count() const {
        return sessions_.size();
    }

    const std::vector<Session*>& Sessions() const {
        return sessions_;
    }

    void CleanupExpired(Clock::time_point now = Clock::now()) {
        for (std::size_t i = 0; i < sessions_.size();) {
            Session* s = sessions_[i];
            if (s && s->IsExpired(now)) {
                delete s;
                sessions_.erase(sessions_.begin() + static_cast<std::ptrdiff_t>(i));
            } else {
                ++i;
            }
        }
    }

    void Clear() {
        for (Session* s : sessions_) delete s;
        sessions_.clear();
    }

private:
    std::vector<Session*> sessions_;
};