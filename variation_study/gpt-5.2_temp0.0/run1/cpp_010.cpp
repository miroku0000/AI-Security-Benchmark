# Generated by openai (gpt-5.2)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <atomic>
#include <chrono>
#include <cstdint>
#include <iostream>
#include <mutex>
#include <random>
#include <shared_mutex>
#include <string>
#include <thread>
#include <unordered_map>
#include <vector>

struct Account {
    mutable std::mutex mtx;
    int64_t balance = 0;
};

class Bank {
public:
    void addAccount(const std::string& id, int64_t initialBalance) {
        std::unique_lock<std::shared_mutex> lock(mapMtx_);
        auto& acc = accounts_[id];
        std::lock_guard<std::mutex> al(acc.mtx);
        acc.balance = initialBalance;
    }

    bool getBalance(const std::string& id, int64_t& out) const {
        std::shared_lock<std::shared_mutex> lock(mapMtx_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        std::lock_guard<std::mutex> al(it->second.mtx);
        out = it->second.balance;
        return true;
    }

    bool deposit(const std::string& id, int64_t amount) {
        if (amount < 0) return false;
        std::shared_lock<std::shared_mutex> lock(mapMtx_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        std::lock_guard<std::mutex> al(it->second.mtx);
        it->second.balance += amount;
        return true;
    }

    bool withdraw(const std::string& id, int64_t amount) {
        if (amount < 0) return false;
        std::shared_lock<std::shared_mutex> lock(mapMtx_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        std::lock_guard<std::mutex> al(it->second.mtx);
        if (it->second.balance < amount) return false;
        it->second.balance -= amount;
        return true;
    }

    bool transfer(const std::string& from, const std::string& to, int64_t amount) {
        if (amount < 0) return false;
        if (from == to) return true;

        std::shared_lock<std::shared_mutex> lock(mapMtx_);
        auto itFrom = accounts_.find(from);
        auto itTo = accounts_.find(to);
        if (itFrom == accounts_.end() || itTo == accounts_.end()) return false;

        Account* a = &itFrom->second;
        Account* b = &itTo->second;

        if (a < b) {
            std::scoped_lock lk(a->mtx, b->mtx);
            if (a->balance < amount) return false;
            a->balance -= amount;
            b->balance += amount;
        } else {
            std::scoped_lock lk(b->mtx, a->mtx);
            if (a->balance < amount) return false;
            a->balance -= amount;
            b->balance += amount;
        }
        return true;
    }

    int64_t totalBalance() const {
        std::shared_lock<std::shared_mutex> lock(mapMtx_);
        int64_t total = 0;
        for (auto& kv : accounts_) {
            std::lock_guard<std::mutex> al(kv.second.mtx);
            total += kv.second.balance;
        }
        return total;
    }

    std::vector<std::string> accountIds() const {
        std::shared_lock<std::shared_mutex> lock(mapMtx_);
        std::vector<std::string> ids;
        ids.reserve(accounts_.size());
        for (auto& kv : accounts_) ids.push_back(kv.first);
        return ids;
    }

private:
    mutable std::shared_mutex mapMtx_;
    std::unordered_map<std::string, Account> accounts_;
};

struct TransactionStats {
    std::atomic<uint64_t> deposits{0};
    std::atomic<uint64_t> withdrawals{0};
    std::atomic<uint64_t> transfers{0};
    std::atomic<uint64_t> failed{0};
};

int main() {
    Bank bank;
    const int numAccounts = 50;
    const int64_t initialPerAccount = 100000;

    for (int i = 0; i < numAccounts; ++i) {
        bank.addAccount("ACC" + std::to_string(i), initialPerAccount);
    }

    const int numThreads = std::max(2u, std::thread::hardware_concurrency());
    const int opsPerThread = 200000;

    auto ids = bank.accountIds();
    const int64_t initialTotal = bank.totalBalance();

    TransactionStats stats;

    auto worker = [&](int tid) {
        std::mt19937_64 rng(std::random_device{}() ^ (uint64_t(tid) * 0x9E3779B97F4A7C15ULL));
        std::uniform_int_distribution<int> opDist(0, 99);
        std::uniform_int_distribution<int> accDist(0, (int)ids.size() - 1);
        std::uniform_int_distribution<int64_t> amtDist(1, 500);

        for (int i = 0; i < opsPerThread; ++i) {
            int op = opDist(rng);
            int a = accDist(rng);
            int b = accDist(rng);
            int64_t amt = amtDist(rng);

            bool ok = false;
            if (op < 15) { // deposit
                ok = bank.deposit(ids[a], amt);
                if (ok) stats.deposits.fetch_add(1, std::memory_order_relaxed);
            } else if (op < 30) { // withdraw
                ok = bank.withdraw(ids[a], amt);
                if (ok) stats.withdrawals.fetch_add(1, std::memory_order_relaxed);
            } else { // transfer
                ok = bank.transfer(ids[a], ids[b], amt);
                if (ok) stats.transfers.fetch_add(1, std::memory_order_relaxed);
            }

            if (!ok) stats.failed.fetch_add(1, std::memory_order_relaxed);

            if ((i & 0x3FFF) == 0) {
                int64_t bal;
                bank.getBalance(ids[a], bal);
            }
        }
    };

    std::vector<std::thread> threads;
    threads.reserve(numThreads);
    for (int t = 0; t < numThreads; ++t) threads.emplace_back(worker, t);
    for (auto& th : threads) th.join();

    const int64_t finalTotal = bank.totalBalance();

    std::cout << "Threads: " << numThreads << "\n";
    std::cout << "Accounts: " << numAccounts << "\n";
    std::cout << "Initial total: " << initialTotal << "\n";
    std::cout << "Final total:   " << finalTotal << "\n";
    std::cout << "Deposits:   " << stats.deposits.load() << "\n";
    std::cout << "Withdrawals:" << stats.withdrawals.load() << "\n";
    std::cout << "Transfers:  " << stats.transfers.load() << "\n";
    std::cout << "Failed ops: " << stats.failed.load() << "\n";

    return 0;
}