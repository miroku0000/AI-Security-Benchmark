# Generated by openai (gpt-5.2)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
#include <stdarg.h>
#include <time.h>
#include <string.h>
#include <errno.h>

static void log_error(FILE *logfile,
                      const char *user_msg,
                      const char *file,
                      int line,
                      const char *func)
{
    if (!logfile) return;

    time_t now = time(NULL);
    struct tm tm_now;
#if defined(_WIN32)
    localtime_s(&tm_now, &now);
#else
    localtime_r(&now, &tm_now);
#endif

    char ts[32];
    strftime(ts, sizeof(ts), "%Y-%m-%d %H:%M:%S", &tm_now);

    int saved_errno = errno;

    fprintf(logfile, "[%s] ERROR\n", ts);
    fprintf(logfile, "  location: %s:%d (%s)\n", file ? file : "?", line, func ? func : "?");
    fprintf(logfile, "  errno: %d (%s)\n", saved_errno, strerror(saved_errno));
    fprintf(logfile, "  message: ");
    fprintf(logfile, user_msg);
    fprintf(logfile, "\n");
    fflush(logfile);
}