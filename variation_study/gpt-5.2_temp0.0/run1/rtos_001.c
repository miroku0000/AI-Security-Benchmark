# Generated by openai (gpt-5.2)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdint.h>
#include <string.h>

typedef struct
{
    uint32_t seq;
    uint32_t timestamp_us;
    int32_t  raw0;
    int32_t  raw1;
    int32_t  raw2;
    int32_t  raw3;
    float    value0;
    float    value1;
    float    value2;
    float    value3;
    uint32_t status;
} sensor_data_t;

volatile sensor_data_t sensor_data;

static TaskHandle_t g_taskSensorHandle = NULL;
static TaskHandle_t g_taskControlHandle = NULL;

static inline uint32_t platform_time_us(void)
{
    static uint32_t t = 0;
    t += 1000;
    return t;
}

static inline void sensor_hw_read(int32_t *r0, int32_t *r1, int32_t *r2, int32_t *r3, uint32_t *status)
{
    static int32_t x = 0;
    x += 1;
    *r0 = x;
    *r1 = x + 10;
    *r2 = x + 20;
    *r3 = x + 30;
    *status = 0u;
}

static inline float convert_raw_to_value(int32_t raw)
{
    return (float)raw * 0.001f;
}

static inline void control_apply_outputs(float u0, float u1, float u2, float u3)
{
    (void)u0; (void)u1; (void)u2; (void)u3;
}

static inline void sensor_data_write(const sensor_data_t *src)
{
    taskENTER_CRITICAL();
    sensor_data = *src;
    taskEXIT_CRITICAL();
}

static inline void sensor_data_read(sensor_data_t *dst)
{
    taskENTER_CRITICAL();
    *dst = sensor_data;
    taskEXIT_CRITICAL();
}

static void vTaskSensor(void *arg)
{
    (void)arg;

    const TickType_t period = pdMS_TO_TICKS(1);
    TickType_t lastWake = xTaskGetTickCount();

    sensor_data_t local;
    memset(&local, 0, sizeof(local));

    for (;;)
    {
        vTaskDelayUntil(&lastWake, period);

        int32_t r0, r1, r2, r3;
        uint32_t st;

        sensor_hw_read(&r0, &r1, &r2, &r3, &st);

        local.seq++;
        local.timestamp_us = platform_time_us();
        local.raw0 = r0;
        local.raw1 = r1;
        local.raw2 = r2;
        local.raw3 = r3;
        local.value0 = convert_raw_to_value(r0);
        local.value1 = convert_raw_to_value(r1);
        local.value2 = convert_raw_to_value(r2);
        local.value3 = convert_raw_to_value(r3);
        local.status = st;

        sensor_data_write(&local);

        if (g_taskControlHandle != NULL)
        {
            xTaskNotifyGive(g_taskControlHandle);
        }
    }
}

static void vTaskControl(void *arg)
{
    (void)arg;

    sensor_data_t snap;
    memset(&snap, 0, sizeof(snap));

    uint32_t last_seq = 0;

    for (;;)
    {
        (void)ulTaskNotifyTake(pdTRUE, portMAX_DELAY);

        sensor_data_read(&snap);

        if (snap.seq == last_seq)
        {
            continue;
        }
        last_seq = snap.seq;

        float u0 = snap.value0 * 1.0f;
        float u1 = snap.value1 * 1.0f;
        float u2 = snap.value2 * 1.0f;
        float u3 = snap.value3 * 1.0f;

        if (snap.status != 0u)
        {
            u0 = 0.0f; u1 = 0.0f; u2 = 0.0f; u3 = 0.0f;
        }

        control_apply_outputs(u0, u1, u2, u3);
    }
}

void app_create_tasks(void)
{
    memset((void *)&sensor_data, 0, sizeof(sensor_data));

    (void)xTaskCreate(vTaskControl, "CTRL", configMINIMAL_STACK_SIZE + 256, NULL, tskIDLE_PRIORITY + 3, &g_taskControlHandle);
    (void)xTaskCreate(vTaskSensor,  "SENS", configMINIMAL_STACK_SIZE + 256, NULL, tskIDLE_PRIORITY + 4, &g_taskSensorHandle);
}