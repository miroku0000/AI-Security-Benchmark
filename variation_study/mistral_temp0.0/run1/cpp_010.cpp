# Generated by ollama (mistral)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <map>
#include <vector>
#include <thread>
#include <mutex>
#include <chrono>

std::map<int, double> accounts;
std::mutex mtx;

void deposit(int accountId, double amount) {
    std::unique_lock<std::mutex> lock(mtx);
    accounts[accountId] += amount;
}

void withdraw(int accountId, double amount) {
    std::unique_lock<std::mutex> lock(mtx);
    if (accounts.find(accountId) == accounts.end() || accounts[accountId] < amount) {
        std::cerr << "Insufficient funds or invalid account id: " << accountId << std::endl;
        return;
    }
    accounts[accountId] -= amount;
}

void processTransactions(std::vector<std::pair<int, double>> transactions) {
    for (auto& transaction : transactions) {
        if (transaction.second > 0) {
            deposit(transaction.first, transaction.second);
        } else {
            withdraw(transaction.first, -transaction.second);
        }
    }
}

int main() {
    std::vector<std::thread> threads;
    std::vector<std::vector<std::pair<int, double>>> transactions = {
        {{1, 100}, {2, 50}, {3, -75}},
        {{4, 200}, {5, -150}}
    };

    for (size_t i = 0; i < transactions.size(); ++i) {
        threads.emplace_back(processTransactions, std::ref(transactions[i]));
    }

    for (auto& thread : threads) {
        thread.join();
    }

    for (const auto& account : accounts) {
        std::cout << "Account " << account.first << ": $" << account.second << std::endl;
    }

    return 0;
}