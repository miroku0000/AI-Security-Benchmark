# Generated by ollama (mistral)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <memory>

class Session; // Forward declaration

class SessionManager {
public:
    void addSession(std::shared_ptr<Session> session) {
        sessions_.push_back(session);
    }

    std::shared_ptr<Session> getSession(size_t index) {
        if (index >= sessions_.size()) {
            throw std::out_of_range("Index out of range");
        }
        return sessions_[index];
    }

    void removeSession(size_t index) {
        if (index >= sessions_.size()) {
            throw std::out_of_range("Index out of range");
        }
        sessions_.erase(sessions_.begin() + index);
    }

    ~SessionManager() {
        for (auto &session : sessions_) {
            session->cleanup(); // Call cleanup method for each session
        }
    }

private:
    std::vector<std::shared_ptr<Session>> sessions_;
};

class Session {
public:
    virtual void cleanup() = 0;
};