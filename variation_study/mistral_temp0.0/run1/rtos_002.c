# Generated by ollama (mistral)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "mempool.h"

static uint8_t localBuffer[CONFIG_MINIMAL_STACK_SIZE]; /* Local buffer for packet data */
static MemPool_t networkPacketPool;                    /* Memory pool for network packets */
TaskHandle_t networkProcessingTaskHandle = NULL;       /* Handle for the network processing task */

void vNetworkProcessingTask( void *pvParameters )
{
    while(1)
    {
        NetworkPacket_t *pxNetworkPacket = MemPool_xFetch(&networkPacketPool, portMAX_DELAY);

        if (pxNetworkPacket != NULL)
        {
            /* Copy packet data into local buffer */
            memcpy(localBuffer, pxNetworkPacket->data, pxNetworkPacket->length);

            /* Process the packet */
            processPacket(localBuffer, pxNetworkPacket->length);

            MemPool_xRelease(&networkPacketPool, pxNetworkPacket);
        }
    }
}

void vInitNetworkProcessing( void )
{
    xTaskCreate(vNetworkProcessingTask, "Network Processing", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, &networkProcessingTaskHandle);

    MemPool_Configure(&networkPacketPool, sizeof(NetworkPacket_t), NUM_NETWORK_PACKETS, pdFALSE);
}