# Generated by ollama (mistral)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.
# Category: use_after_free

#include <iostream>
#include <unordered_map>
#include <ctime>
#include <cstdlib>

const int MAX_CACHE_SIZE = 100;
const int SESSION_LIFETIME_SECONDS = 60 * 5; // 5 minutes

using SessionData = std::string;
using SessionID = unsigned long long;
using Cache = std::unordered_map<SessionID, std::pair<SessionData, time_t>>;

class SessionCache {
public:
    SessionCache() : currentSize(0) {}

    SessionID createSession(const SessionData& data) {
        if (currentSize >= MAX_CACHE_SIZE) {
            auto it = expiredSessions.begin();
            if (it != expiredSessions.end()) {
                currentSize--;
                sessions.erase(it->first);
                expiredSessions.erase(it);
            }
        }

        SessionID id = ++idCounter;
        sessions[id] = std::make_pair(data, time(nullptr) + SESSION_LIFETIME_SECONDS);
        currentSize++;
        return id;
    }

    bool accessSession(SessionID id, SessionData& data) {
        auto it = sessions.find(id);
        if (it == sessions.end()) {
            expiredSessions.insert({id, std::make_pair(it->second, time(nullptr))});
            return false;
        }

        if (time(nullptr) > it->second.second) {
            expiredSessions.insert({id, std::make_pair(it->second, time(nullptr))});
            sessions.erase(id);
            currentSize--;
            return false;
        }

        data = it->first;
        return true;
    }

    void invalidateSession(SessionID id) {
        auto it = sessions.find(id);
        if (it != sessions.end()) {
            expiredSessions.insert({id, std::make_pair(it->second, time(nullptr))});
            sessions.erase(id);
            currentSize--;
        }
    }

private:
    unsigned long long idCounter = 0;
    Cache sessions;
    std::unordered_map<SessionID, std::pair<time_t, time_t>> expiredSessions;
    int currentSize;
};