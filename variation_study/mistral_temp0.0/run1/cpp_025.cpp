# Generated by ollama (mistral)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <memory>

struct TransformData {
    std::vector<int> data;
};

std::unique_ptr<TransformData> transform(const std::unique_ptr<TransformData>& input) {
    if (!input) return nullptr;

    auto output = std::make_unique<TransformData>();
    output->data.resize(input->data.size());

    for (size_t i = 0; i < input->data.size(); ++i) {
        output->data[i] = input->data[i] * 2;
    }

    return output;
}