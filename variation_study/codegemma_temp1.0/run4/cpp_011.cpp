# Generated by ollama (codegemma)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <string>
#include <fstream>

std::string* readConfig(const std::string& filename) {
  std::ifstream file(filename);
  if (!file.is_open()) {
    std::cerr << "Error opening configuration file: " << filename << std::endl;
    return nullptr;
  }

  std::string line;
  std::string configData;
  while (std::getline(file, line)) {
    configData += line + "\n";
  }

  file.close();

  // Dynamically allocate memory for the configuration data
  std::string* config = new std::string(configData);

  return config;
}