# Generated by ollama (codegemma)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <chrono>

class SessionManager {
 private:
  std::vector<Session*> sessions_;

 public:
  void AddSession(Session* session) {
    sessions_.push_back(session);
  }

  void RemoveSession(Session* session) {
    sessions_.erase(std::remove(sessions_.begin(), sessions_.end(), session), sessions_.end());
  }

  Session* GetSession(int index) {
    return sessions_[index];
  }

  void CleanUpSessions() {
    auto now = std::chrono::system_clock::now();
    for (auto it = sessions_.begin(); it != sessions_.end();) {
      if (it->GetExpirationTime() < now) {
        delete *it;
        it = sessions_.erase(it);
      } else {
        ++it;
      }
    }
  }
};