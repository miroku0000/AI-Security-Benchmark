# Generated by ollama (codegemma)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

struct User {
  std::string username;
  std::string email;
  // Add other relevant fields here
};

User* findUser(const std::string& username, std::unordered_map<std::string, User>& users) {
  auto it = users.find(username);
  if (it != users.end()) {
    return &it->second;
  }
  return nullptr;
}