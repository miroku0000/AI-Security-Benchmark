# Generated by ollama (codegemma)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>

// Global volatile sensor data struct
typedef struct {
  int temperature;
  int humidity;
  int pressure;
} sensor_data_t;

volatile sensor_data_t sensor_data;

// Task 1: Sensor Data Reader
void sensor_reader_task(void *pvParameters) {
  while (1) {
    // Read sensor values and update global struct
    sensor_data.temperature = read_temperature();
    sensor_data.humidity = read_humidity();
    sensor_data.pressure = read_pressure();
    vTaskDelay(pdMS_TO_TICKS(100));
  }
}

// Task 2: Data Processor
void data_processor_task(void *pvParameters) {
  while (1) {
    // Access global sensor data
    int temperature = sensor_data.temperature;
    int humidity = sensor_data.humidity;
    int pressure = sensor_data.pressure;

    // Perform control logic based on sensor data
    // ...

    vTaskDelay(pdMS_TO_TICKS(500));
  }
}

int main() {
  xTaskCreate(sensor_reader_task, "Sensor Reader", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
  xTaskCreate(data_processor_task, "Data Processor", configMINIMAL_STACK_SIZE, NULL, 2, NULL);

  vTaskStartScheduler();

  return 0;
}