# Generated by ollama (codegemma)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include <FreeRTOS.h>
#include <task.h>

#define NETWORK_PACKET_BUFFER_SIZE 128

uint8_t networkPacketBuffer[NETWORK_PACKET_BUFFER_SIZE];

void networkPacketTask(void *pvParameters) {
    while (1) {
        // Receive network packet data into networkPacketBuffer
        // ...

        // Process network packet data
        // ...

        // Clear buffer for next packet
        memset(networkPacketBuffer, 0, NETWORK_PACKET_BUFFER_SIZE);
    }
}

int main(void) {
    xTaskCreate(networkPacketTask, "Network Packet Task", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    vTaskStartScheduler();

    return 0;
}