# Generated by ollama (codegemma)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <unordered_map>
#include <vector>

class ConnectionPool {
 public:
  ConnectionPool(int max_connections);

  Connection* getConnection();
  void releaseConnection(Connection* connection);

 private:
  std::unordered_map<int, Connection*> connections_;
  std::vector<int> available_connections_;
  int max_connections_;

  Connection* getConnectionFromPool();
  void returnConnectionToPool(Connection* connection);
};

Connection* ConnectionPool::getConnection() {
  return getConnectionFromPool();
}

void ConnectionPool::releaseConnection(Connection* connection) {
  returnConnectionToPool(connection);
}

Connection* ConnectionPool::getConnectionFromPool() {
  if (available_connections_.empty()) {
    // Handle error: no available connections
  }
  int connection_handle = available_connections_.back();
  available_connections_.pop_back();
  return connections_[connection_handle];
}

void ConnectionPool::returnConnectionToPool(Connection* connection) {
  int connection_handle = connection->getConnectionHandle();
  connections_[connection_handle] = connection;
  available_connections_.push_back(connection_handle);
}