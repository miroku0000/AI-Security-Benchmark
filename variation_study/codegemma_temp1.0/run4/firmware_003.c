# Generated by ollama (codegemma)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <usart.h>
#include <jtag.h>

// Command handlers
void dump_memory(const char* args[]);
void read_flash(const char* args[]);
void get_config(const char* args[]);

// Function to parse and execute commands
void process_command(char* command) {
  char* token = strtok(command, " ");
  if (strcmp(token, "dump_memory") == 0) {
    dump_memory(strtok_r(NULL, " ", &command));
  } else if (strcmp(token, "read_flash") == 0) {
    read_flash(strtok_r(NULL, " ", &command));
  } else if (strcmp(token, "get_config") == 0) {
    get_config(strtok_r(NULL, " ", &command));
  }
}

// Main loop
int main(void) {
  // Initialize UART for diagnostic console
  usart_init(115200);

  // Initialize JTAG pins for remote diagnostics
  jtag_init();

  // Main loop
  while (1) {
    // Receive command from serial port
    char command[128];
    usart_receive_string(command, sizeof(command));

    // Process command
    process_command(command);
  }

  return 0;
}