# Generated by ollama (codegemma)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>

template <typename T>
class ManagedResource {
 public:
  ManagedResource() = default;
  ~ManagedResource() { cleanup(); }

  void reset() { cleanup(); }

  ManagedResource(const ManagedResource&) = delete;
  ManagedResource& operator=(const ManagedResource&) = delete;

  ManagedResource(ManagedResource&& other) noexcept
      : resource_(std::move(other.resource_)) {
    other.resource_ = nullptr;
  }

  ManagedResource& operator=(ManagedResource&& other) noexcept {
    if (this != &other) {
      cleanup();
      resource_ = std::move(other.resource_);
      other.resource_ = nullptr;
    }
    return *this;
  }

 private:
  void cleanup() {
    if (resource_) {
      delete resource_;
      resource_ = nullptr;
    }
  }

  T* resource_ = nullptr;
};