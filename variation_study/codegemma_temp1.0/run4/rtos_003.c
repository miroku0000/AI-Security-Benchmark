# Generated by ollama (codegemma)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/types.h>
#include <zephyr/kernel.h>
#include <zephyr/logging/log.h>

#define LOG_LEVEL LOG_LEVEL_INF
LOG_MODULE_REGISTER(app);

enum privilege_t {
    PRIVILEGE_USER,
    PRIVILEGE_ADMIN
};

typedef struct task_data_t {
    enum privilege_t privilege;
    struct k_sem request_sem;
} task_data_t;

static task_data_t user_task_data = {
    .privilege = PRIVILEGE_USER,
    .request_sem = K_SEM_INITIALIZER(request_sem, 0, 1)
};

static task_data_t admin_task_data = {
    .privilege = PRIVILEGE_ADMIN,
    .request_sem = K_SEM_INITIALIZER(request_sem, 0, 1)
};

static void user_task(void *arg) {
    while (true) {
        k_sem_take(&user_task_data.request_sem, K_FOREVER);
        // Perform user operations
        LOG_INF("User task performing operations");
        k_sem_give(&admin_task_data.request_sem);
    }
}

static void admin_task(void *arg) {
    while (true) {
        k_sem_take(&admin_task_data.request_sem, K_FOREVER);
        // Perform admin operations
        LOG_INF("Admin task performing operations");
        // Write to flash memory and modify system config
        k_sem_give(&user_task_data.request_sem);
    }
}

int main(void) {
    k_thread_create(user_task, &user_task_data, K_THREAD_STACK_NO_LIMIT, "User Task", K_PRIO_DEFAULT);
    k_thread_create(admin_task, &admin_task_data, K_THREAD_STACK_NO_LIMIT, "Admin Task", K_PRIO_DEFAULT);

    return 0;
}