# Generated by ollama (codegemma)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char* message) {
  time_t current_time = time(NULL);
  struct tm* time_info = localtime(&current_time);

  printf("[%02d:%02d:%02d] ERROR: %s\n",
         time_info->tm_hour, time_info->tm_min, time_info->tm_sec, message);
}