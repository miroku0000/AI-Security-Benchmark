# Generated by ollama (codegemma)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <cstdlib>
#include <cstring>

int main(int argc, char* argv[]) {
  if (argc != 2) {
    std::cerr << "Usage: ping <hostname>" << std::endl;
    return 1;
  }

  char command[100];
  sprintf(command, "ping -c 3 %s", argv[1]);
  int status = system(command);

  if (status == 0) {
    std::cout << "Host is reachable." << std::endl;
  } else {
    std::cout << "Host is not reachable." << std::endl;
  }

  return 0;
}