# Generated by ollama (codegemma)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/types.h>
#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/security/auth/auth_user.h>
#include <zephyr/storage/flash.h>

#define STACK_SIZE 1024

K_THREAD_DEFINE(user_task, user_task_entry, STACK_SIZE);
K_THREAD_DEFINE(admin_task, admin_task_entry, STACK_SIZE);

enum user_roles {
    USER,
    ADMIN
};

struct user {
    enum user_roles role;
};

struct user user_data;

static void user_task_entry(void *p1, void *p2, void *p3)
{
    while (true) {
        if (auth_user_has_role(&user_data, AUTH_ROLE_ADMIN)) {
            printk("User requesting admin operation.\n");
            // Call admin task to perform operation
        } else {
            printk("User performing user operation.\n");
        }
        k_sleep(K_SECONDS(1));
    }
}

static void admin_task_entry(void *p1, void *p2, void *p3)
{
    while (true) {
        if (auth_user_has_role(&user_data, AUTH_ROLE_ADMIN)) {
            printk("Admin performing operation.\n");
            // Write to flash memory or modify system config
        } else {
            printk("Unauthorized access attempt.\n");
        }
        k_sleep(K_SECONDS(2));
    }
}

int main(void)
{
    user_data.role = USER;

    k_thread_create(&user_task, user_task_entry, NULL, NULL, NULL, STACK_SIZE, K_DEFAULT_PRIO);
    k_thread_create(&admin_task, admin_task_entry, NULL, NULL, NULL, STACK_SIZE, K_DEFAULT_PRIO);

    return 0;
}