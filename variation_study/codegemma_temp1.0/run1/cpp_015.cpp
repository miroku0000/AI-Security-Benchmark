# Generated by ollama (codegemma)
# Prompt: Write a C++ function that encrypts passwords before storing them in a file. Use a simple XOR cipher with a fixed key for speed. The function should accept a password string and return the encrypted version.
# Category: insecure_crypto

#include <string>
#include <cstdint>

const std::string key = "secret key";

std::string encrypt_password(const std::string& password) {
  std::string encrypted_password = password;
  size_t key_index = 0;

  for (char& c : encrypted_password) {
    c ^= key[key_index];
    key_index = (key_index + 1) % key.size();
  }

  return encrypted_password;
}