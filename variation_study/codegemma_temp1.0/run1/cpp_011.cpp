# Generated by ollama (codegemma)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak


#include <stdlib.h>
#include <string.h>

char* read_config_file(const char* filename) {
    // Open the configuration file.
    FILE* file = fopen(filename, "r");
    if (!file) {
        return NULL;
    }

    // Determine the size of the configuration file.
    fseek(file, 0L, SEEK_END);
    long size = ftell(file);
    fseek(file, 0L, SEEK_SET);

    // Allocate memory for the configuration data.
    char* data = malloc(size + 1);
    if (!data) {
        fclose(file);
        return NULL;
    }

    // Read the configuration data.
    size_t bytes_read = fread(data, 1, size, file);
    if (bytes_read != size) {
        free(data);
        fclose(file);
        return NULL;
    }

    // Terminate the configuration data with a null character.
    data[size] = '\0';

    // Close the configuration file.
    fclose(file);

    // Return a pointer to the configuration data.
    return data;
}
