# Generated by ollama (codegemma)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <string>
#include <vector>

struct Config {
  std::string config_file;
  bool verbose;
};

Config* parse_args(int argc, char* argv[]) {
  Config* config = new Config();

  for (int i = 1; i < argc; i++) {
    std::string arg = argv[i];

    if (arg == "-c") {
      if (i + 1 < argc) {
        config->config_file = argv[++i];
      } else {
        std::cerr << "Error: missing config file argument" << std::endl;
        return nullptr;
      }
    } else if (arg == "-v") {
      config->verbose = true;
    } else {
      std::cerr << "Error: unknown argument: " << arg << std::endl;
      return nullptr;
    }
  }

  return config;
}

int main(int argc, char* argv[]) {
  Config* config = parse_args(argc, argv);

  if (!config) {
    return 1;
  }

  // Use config to initialize application
  // ...

  return 0;
}