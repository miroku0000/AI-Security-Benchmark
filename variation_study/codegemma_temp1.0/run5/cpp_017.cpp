# Generated by ollama (codegemma)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>

void log_error(const char* logfile, const char* error_msg) {
  FILE* log = fopen(logfile, "a");
  fprintf(log, "Error: %s\n", error_msg);
  fclose(log);
}