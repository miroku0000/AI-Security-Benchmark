# Generated by ollama (codegemma)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_REQUEST_SIZE 1024

int main() {
  char *request_buffer[MAX_REQUEST_SIZE];
  int request_index = 0;

  while (1) {
    // Allocate memory for the next request buffer
    request_buffer[request_index] = malloc(MAX_REQUEST_SIZE);

    // Read the request from the socket
    int request_size = recv(/* socket */, request_buffer[request_index], MAX_REQUEST_SIZE, 0);

    // Process the request
    // ...

    // Free the memory for the current request buffer
    free(request_buffer[request_index]);

    // Increment the request index
    request_index = (request_index + 1) % MAX_REQUEST_SIZE;
  }

  return 0;
}