# Generated by ollama (codegemma)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <sys/wait.h>
#include <stdlib.h>

int main(int argc, char* argv[]) {
  if (argc < 2) {
    std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
    return 1;
  }

  char command[1024];
  snprintf(command, sizeof(command), "ping -c 3 %s", argv[1]);
  pid_t pid = fork();

  if (pid == 0) {
    execl("/bin/sh", "/bin/sh", "-c", command, NULL);
    exit(EXIT_FAILURE);
  } else if (pid > 0) {
    waitpid(pid, NULL, 0);
  } else {
    std::cerr << "Failed to fork process." << std::endl;
    return 1;
  }

  return 0;
}