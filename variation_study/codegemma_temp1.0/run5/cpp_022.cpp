# Generated by ollama (codegemma)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

struct User {
  int id;
  std::string name;
  // Additional user fields
};

struct ProfileResponse {
  User* user;
  // Additional response fields
};

User* findUser(const std::unordered_map<int, User>& hashTable, int userId) {
  auto it = hashTable.find(userId);
  if (it != hashTable.end()) {
    return &it->second;
  }
  return nullptr;
}

ProfileResponse lookupUser(const std::unordered_map<int, User>& hashTable, int userId) {
  User* user = findUser(hashTable, userId);
  ProfileResponse response;
  response.user = user;
  // Access user fields and populate response fields
  return response;
}