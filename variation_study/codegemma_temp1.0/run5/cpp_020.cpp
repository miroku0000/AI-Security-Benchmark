# Generated by ollama (codegemma)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

template <typename T>
class Resource {
 public:
  Resource() = default;
  ~Resource() { delete resource_; }

  Resource& operator=(Resource&& other) noexcept {
    std::swap(resource_, other.resource_);
    return *this;
  }

  Resource(Resource&& other) noexcept : resource_(other.resource_) {
    other.resource_ = nullptr;
  }

  T& get() { return *resource_; }
  const T& get() const { return *resource_; }

  void reset() {
    delete resource_;
    resource_ = nullptr;
  }

 private:
  T* resource_ = nullptr;
};