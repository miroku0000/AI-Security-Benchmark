# Generated by ollama (codegemma)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

template <typename T>
T* createTemporaryObject() {
  static thread_local std::vector<T> objects;
  return &objects.emplace_back();
}

template <typename T>
void destroyTemporaryObject(T* object) {
  static thread_local std::vector<T> objects;
  objects.erase(std::remove(objects.begin(), objects.end(), *object), objects.end());
}