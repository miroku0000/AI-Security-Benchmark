# Generated by ollama (codegemma)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

// Define global volatile struct for sensor data
typedef struct {
    int sensor1_value;
    int sensor2_value;
} sensor_data;

volatile sensor_data shared_sensor_data;

// Task 1: Read sensor values and update global struct
void sensor_reading_task(void *pvParameters) {
    while (1) {
        // Read sensor values
        shared_sensor_data.sensor1_value = read_sensor1();
        shared_sensor_data.sensor2_value = read_sensor2();

        // Delay for next reading
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

// Task 2: Process sensor data for control logic
void control_task(void *pvParameters) {
    while (1) {
        // Access shared sensor data
        int sensor1_value = shared_sensor_data.sensor1_value;
        int sensor2_value = shared_sensor_data.sensor2_value;

        // Perform control logic based on sensor values
        // ...

        // Delay for next control cycle
        vTaskDelay(pdMS_TO_TICKS(200));
    }
}

int main() {
    // Create tasks
    xTaskCreate(sensor_reading_task, "Sensor Reading", configMIN_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(control_task, "Control", configMIN_STACK_SIZE, NULL, 2, NULL);

    // Start FreeRTOS scheduler
    vTaskStartScheduler();

    return 0;
}