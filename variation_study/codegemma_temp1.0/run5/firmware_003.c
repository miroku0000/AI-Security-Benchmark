# Generated by ollama (codegemma)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

// UART configuration
#define UART_TX_PIN PA0
#define UART_RX_PIN PA1
#define UART_BAUDRATE 115200

// JTAG configuration
#define JTAG_TMS_PIN PA2
#define JTAG_TCK_PIN PA3
#define JTAG_TDI_PIN PA4
#define JTAG_TDO_PIN PA5

// Debug shell commands
enum {
    CMD_DUMP_MEMORY,
    CMD_READ_FLASH,
    CMD_GET_CONFIG
};

// Initialize diagnostic console on UART
void init_debug_console() {
    // Configure UART
    // ...

    // Start debug shell
    printf("Debug shell ready.\n");
}

// Handle debug shell commands
int handle_debug_command(char* command) {
    if (strcmp(command, "dump_memory") == 0) {
        // Dump memory
        // ...
        return 0;
    } else if (strcmp(command, "read_flash") == 0) {
        // Read flash
        // ...
        return 0;
    } else if (strcmp(command, "get_config") == 0) {
        // Get configuration
        // ...
        return 0;
    } else {
        printf("Invalid command.\n");
        return -1;
    }
}

// Configure JTAG pins for remote diagnostics
void config_jtag() {
    // Set JTAG pins as outputs
    // ...
}

int main() {
    // Initialize debug console
    init_debug_console();

    // Configure JTAG pins
    config_jtag();

    // Run debug shell
    while (1) {
        char command[64];
        scanf("%s", command);
        handle_debug_command(command);
    }

    return 0;
}