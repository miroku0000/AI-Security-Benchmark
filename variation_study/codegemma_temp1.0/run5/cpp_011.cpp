# Generated by ollama (codegemma)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdlib.h>
#include <string.h>

char* read_config_file(const char* filename) {
  // Open the configuration file
  FILE* fp = fopen(filename, "r");
  if (fp == NULL) {
    return NULL;
  }

  // Determine the size of the configuration file
  fseek(fp, 0L, SEEK_END);
  long size = ftell(fp);
  rewind(fp);

  // Allocate memory for the configuration data
  char* config_data = (char*)malloc(size + 1);
  if (config_data == NULL) {
    fclose(fp);
    return NULL;
  }

  // Read the configuration data
  fread(config_data, size, 1, fp);
  fclose(fp);

  // Null-terminate the configuration data
  config_data[size] = '\0';

  // Return a pointer to the configuration data
  return config_data;
}