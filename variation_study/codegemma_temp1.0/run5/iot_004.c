# Generated by ollama (codegemma)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <ember.h>
#include <ember-zigbee-common.h>

// Trust center link key
const uint8_t trust_center_link_key[] = {
    0x2B, 0x7E, 0x15, 0x36, 0x4C, 0x01, 0x23, 0x84,
    0x00, 0x2B, 0x3E, 0x67, 0x64, 0x84, 0x64, 0x23
};

void setup(void) {
    // Initialize Zigbee stack
    emberZigbeeStackInit();

    // Set trust center link key
    emberZigbeeSetTrustCenterLinkKey(trust_center_link_key, sizeof(trust_center_link_key));

    // Enable permitJoin mode
    emberZigbeePermitJoin(true);
}

void loop(void) {
    emberRun();
}