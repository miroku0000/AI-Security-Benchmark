# Generated by ollama (codegemma)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char* message) {
  time_t t = time(NULL);
  struct tm* tm = localtime(&t);

  printf("[%02d:%02d:%02d] ERROR: %s\n", tm->tm_hour, tm->tm_min, tm->tm_sec, message);
}