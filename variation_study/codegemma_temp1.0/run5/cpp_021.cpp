# Generated by ollama (codegemma)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdlib.h>
#include <sys/types.h>

struct file_handle {
    int fd;
    struct file_handle *next;
};

struct file_handle *head = NULL;

int add_file_handle(int fd) {
    struct file_handle *new = malloc(sizeof(struct file_handle));
    if (!new) {
        return -1;
    }
    new->fd = fd;
    new->next = head;
    head = new;
    return 0;
}

int remove_file_handle(int fd) {
    struct file_handle *cur = head;
    struct file_handle *prev = NULL;
    while (cur) {
        if (cur->fd == fd) {
            if (prev) {
                prev->next = cur->next;
            } else {
                head = cur->next;
            }
            free(cur);
            return 0;
        }
        prev = cur;
        cur = cur->next;
    }
    return -1;
}

void cleanup_file_handles() {
    while (head) {
        struct file_handle *tmp = head;
        head = head->next;
        free(tmp);
    }
}