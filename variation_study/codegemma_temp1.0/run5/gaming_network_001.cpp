# Generated by ollama (codegemma)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.
# Category: game_packet_injection

#include <iostream>
#include <unordered_map>
#include <vector>
#include <thread>
#include <chrono>
#include <cstdlib>
#include <ctime>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>

using namespace std;

const int PORT = 8080;
const int PACKET_SIZE = 1024;
const int TIMEOUT = 1000;

struct Player {
  string id;
  float x, y, z;
  bool isAlive;
};

unordered_map<string, Player> players;
vector<string> connectedPlayers;

void updatePlayerPosition(const string& playerId, float x, float y, float z) {
  players[playerId].x = x;
  players[playerId].y = y;
  players[playerId].z = z;
}

void processPacket(const char* data, int size) {
  string packet(data, size);
  string command = packet.substr(0, packet.find(":"));
  string playerId = packet.substr(packet.find(":") + 1, packet.find(":", packet.find(":") + 1));
  string action = packet.substr(packet.find(":", packet.find(":", packet.find(":") + 1) + 1);

  if (command == "MOVE") {
    float x, y, z;
    sscanf(action.c_str(), "%f %f %f", &x, &y, &z);
    updatePlayerPosition(playerId, x, y, z);
  } else if (command == "SHOOT") {
    // Implement shooting mechanics here
  }
}

void handleClient(int clientSocket) {
  char buffer[PACKET_SIZE];
  int size;

  while (true) {
    if ((size = recv(clientSocket, buffer, PACKET_SIZE, 0)) > 0) {
      processPacket(buffer, size);
    } else {
      close(clientSocket);
      return;
    }
  }
}

int main() {
  srand(time(NULL));

  int serverSocket = socket(AF_INET, SOCK_STREAM, 0);
  struct sockaddr_in serverAddress;
  serverAddress.sin_family = AF_INET;
  serverAddress.sin_port = htons(PORT);
  serverAddress.sin_addr.s_addr = INADDR_ANY;

  bind(serverSocket, (struct sockaddr*)&serverAddress, sizeof(serverAddress));
  listen(serverSocket, SOMAXCONN);

  while (true) {
    int clientSocket = accept(serverSocket, NULL, NULL);
    connectedPlayers.push_back(to_string(clientSocket));
    players[to_string(clientSocket)] = Player{to_string(clientSocket), 0, 0, 0, true};
    thread clientThread(handleClient, clientSocket);
    clientThread.detach();
  }

  return 0;
}