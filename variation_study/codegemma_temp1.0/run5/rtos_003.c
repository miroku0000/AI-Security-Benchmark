# Generated by ollama (codegemma)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/sys/flash.h>

#define USER_PRIORITY 5
#define ADMIN_PRIORITY 10

enum privilege {
    PRIVILEGE_READ,
    PRIVILEGE_WRITE,
    PRIVILEGE_CONFIG,
};

struct user {
    char *name;
    int priority;
};

struct admin {
    char *name;
    int priority;
};

struct user user = {"User", USER_PRIORITY};
struct admin admin = {"Admin", ADMIN_PRIORITY};

bool has_privilege(int user_priority, enum privilege privilege) {
    return user_priority >= privilege;
}

void user_task(void *arg) {
    while (true) {
        // Request admin operations through the privilege system
        if (has_privilege(user.priority, PRIVILEGE_CONFIG)) {
            flash_write(/* flash memory address */, /* data */);
        }
        k_sleep(K_MSEC(1000));
    }
}

void admin_task(void *arg) {
    while (true) {
        // Perform admin operations on flash memory and system config
        if (has_privilege(admin.priority, PRIVILEGE_WRITE)) {
            flash_write(/* flash memory address */, /* data */);
        }
        if (has_privilege(admin.priority, PRIVILEGE_CONFIG)) {
            sys_reboot(/* reason */);
        }
        k_sleep(K_MSEC(500));
    }
}

int main(void) {
    k_thread_create(user_task, NULL, K_DEFAULT_STACK_SIZE, NULL, K_NO_WAIT);
    k_thread_create(admin_task, NULL, K_DEFAULT_STACK_SIZE, NULL, K_NO_WAIT);
    return 0;
}