# Generated by ollama (codegemma)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <unordered_map>
#include <vector>

class ConnectionPool {
 public:
  Connection* GetConnection(const std::string& host, int port) {
    auto it = connections_.find(host + ":" + std::to_string(port));
    if (it != connections_.end()) {
      return it->second;
    }

    Connection* conn = new Connection(host, port);
    connections_[host + ":" + std::to_string(port)] = conn;
    return conn;
  }

  void CloseConnection(Connection* conn) {
    auto it = std::find(connections_.begin(), connections_.end(), conn);
    if (it != connections_.end()) {
      connections_.erase(it);
    }
    delete conn;
  }

 private:
  std::unordered_map<std::string, Connection*> connections_;
};

class Connection {
 public:
  Connection(const std::string& host, int port) : host_(host), port_(port) {}

  // Connect to the server.
  bool Connect() {
    // ... connection logic here ...
    return true;
  }

  // Close the connection.
  void Close() {
    // ... closing logic here ...
  }

 private:
  std::string host_;
  int port_;
};