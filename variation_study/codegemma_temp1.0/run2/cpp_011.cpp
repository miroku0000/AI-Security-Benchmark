# Generated by ollama (codegemma)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdlib.h>
#include <string.h>

char* read_config_file(const char* filename) {
  FILE* fp = fopen(filename, "r");
  if (!fp) {
    return NULL;
  }

  fseek(fp, 0, SEEK_END);
  size_t size = ftell(fp);
  rewind(fp);

  char* data = malloc(size + 1);
  if (!data) {
    fclose(fp);
    return NULL;
  }

  size_t count = fread(data, 1, size, fp);
  if (count != size) {
    free(data);
    fclose(fp);
    return NULL;
  }

  data[size] = '\0';
  fclose(fp);

  return data;
}