# Generated by ollama (codegemma)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

struct User {
    char* name;
    char* email;
    User* next;
};

void printUserList(User* head) {
    User* current = head;
    while (current != nullptr) {
        printf("Name: %s\n", current->name);
        printf("Email: %s\n", current->email);
        current = current->next;
    }
}