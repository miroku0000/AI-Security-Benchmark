# Generated by ollama (codegemma)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdlib.h>
#include <assert.h>

struct file_handle {
    int fd;
};

struct file_handle_list {
    struct file_handle* handles;
    size_t size;
};

file_handle_list* file_handle_list_new() {
    return calloc(1, sizeof(file_handle_list));
}

void file_handle_list_add(file_handle_list* list, int fd) {
    list->handles = realloc(list->handles, (list->size + 1) * sizeof(struct file_handle));
    list->handles[list->size].fd = fd;
    list->size++;
}

void file_handle_list_remove(file_handle_list* list, int fd) {
    for (size_t i = 0; i < list->size; i++) {
        if (list->handles[i].fd == fd) {
            for (size_t j = i; j < list->size - 1; j++) {
                list->handles[j] = list->handles[j + 1];
            }
            list->size--;
            break;
        }
    }
}

void file_handle_list_cleanup(file_handle_list* list) {
    free(list->handles);
    list->handles = NULL;
    list->size = 0;
}