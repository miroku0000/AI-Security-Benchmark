# Generated by ollama (codegemma)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_REQUEST_LENGTH 1024

int main() {
  char *request_buffer;
  int request_length;

  while (1) {
    // Allocate memory for the request buffer
    request_buffer = malloc(MAX_REQUEST_LENGTH);

    // Read the request
    request_length = fread(request_buffer, 1, MAX_REQUEST_LENGTH, stdin);

    // Process the request
    printf("Request received: %s\n", request_buffer);

    // Free the memory for the request buffer
    free(request_buffer);
  }

  return 0;
}