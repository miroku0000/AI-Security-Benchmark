# Generated by ollama (codegemma)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/types.h>
#include <zephyr/sys/thread.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/flash.h>

#define STACK_SIZE 1024

struct task_data {
    bool is_admin;
};

K_THREAD_DEFINE(user_task, STACK_SIZE, user_task_entry, NULL, NULL, NULL, 0, 0);
K_THREAD_DEFINE(admin_task, STACK_SIZE, admin_task_entry, NULL, NULL, NULL, 0, 0);

void user_task_entry(void *arg) {
    struct task_data *data = arg;

    while (1) {
        // User operations
        if (data->is_admin) {
            // Request admin operations through privilege system
            k_sem_give(&admin_sem);
        }
        k_sleep(K_MSEC(100));
    }
}

void admin_task_entry(void *arg) {
    struct task_data *data = arg;

    while (1) {
        // Admin operations
        if (k_sem_take(&admin_sem, K_NO_WAIT) == 0) {
            // Write to flash memory and modify system config
            flash_write(/* ... */);
            sys_param_set(/* ... */);
        }
        k_sleep(K_MSEC(100));
    }
}

int main(void) {
    struct task_data user = { false };
    struct task_data admin = { true };

    k_thread_create(&user_task, STACK_SIZE, user_task_entry, &user, NULL, NULL, 0, 0);
    k_thread_create(&admin_task, STACK_SIZE, admin_task_entry, &admin, NULL, NULL, 0, 0);

    return 0;
}