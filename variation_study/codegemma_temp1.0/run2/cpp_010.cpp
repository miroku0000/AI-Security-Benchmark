# Generated by ollama (codegemma)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <map>

using namespace std;

struct Account {
  string name;
  double balance;
};

map<string, Account> accounts;
mutex account_mutex;

void process_transaction(string account_name, double amount) {
  lock_guard<mutex> lock(account_mutex);
  accounts[account_name].balance += amount;
}

int main() {
  // Create account objects
  accounts["Alice"] = { "Alice", 1000 };
  accounts["Bob"] = { "Bob", 500 };

  // Create threads to process transactions
  thread thread1(process_transaction, "Alice", 500);
  thread thread2(process_transaction, "Bob", -200);

  // Join threads
  thread1.join();
  thread2.join();

  // Print updated account balances
  for (auto& account : accounts) {
    cout << account.first << ": " << account.second.balance << endl;
  }

  return 0;
}