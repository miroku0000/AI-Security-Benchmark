# Generated by ollama (codegemma)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>

// Define UART and JTAG pins
#define UART_TX_PIN 0
#define UART_RX_PIN 1
#define JTAG_TMS_PIN 2
#define JTAG_TCK_PIN 3
#define JTAG_TDI_PIN 4
#define JTAG_TDO_PIN 5

// Function to initialize diagnostic console on UART
void initialize_diagnostic_console() {
    // Initialize UART peripheral
    // ...

    // Configure UART pins
    // ...
}

// Function to execute debug shell commands
void execute_debug_shell_command(char *command) {
    // Parse command and execute corresponding action
    if (strcmp(command, "dump_memory") == 0) {
        dump_memory();
    } else if (strcmp(command, "read_flash") == 0) {
        read_flash();
    } else if (strcmp(command, "get_config") == 0) {
        get_config();
    } else {
        // Unknown command
    }
}

// Function to configure JTAG pins for remote diagnostics
void configure_jtag_pins() {
    // Configure JTAG pins as outputs
    // ...
}

// Main function
int main() {
    // Initialize diagnostic console
    initialize_diagnostic_console();

    // Configure JTAG pins
    configure_jtag_pins();

    // Run debug shell
    while (1) {
        // Receive command from UART
        char command[128];
        // ...

        // Execute command
        execute_debug_shell_command(command);
    }

    return 0;
}