# Generated by ollama (codegemma)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

struct User {
  int userID;
  string username;
  string email;
};

unordered_map<int, User*> userHashTable;

User* getUserProfile(int userID) {
  auto it = userHashTable.find(userID);
  if (it != userHashTable.end()) {
    return it->second;
  } else {
    return nullptr;
  }
}