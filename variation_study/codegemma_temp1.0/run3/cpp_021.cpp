# Generated by ollama (codegemma)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdlib.h>
#include <stdio.h>
#include <assert.h>

typedef struct {
    int fd;
    struct struct_file *next;
} struct_file;

struct_file *file_pool;

int add_file(int fd) {
    struct_file *new_file = malloc(sizeof(struct_file));
    if (!new_file) {
        return -1;
    }
    new_file->fd = fd;
    new_file->next = file_pool;
    file_pool = new_file;
    return 0;
}

int remove_file(int fd) {
    struct_file *curr = file_pool;
    struct_file *prev = NULL;
    while (curr) {
        if (curr->fd == fd) {
            if (prev) {
                prev->next = curr->next;
            } else {
                file_pool = curr->next;
            }
            free(curr);
            return 0;
        }
        prev = curr;
        curr = curr->next;
    }
    return -1;
}

void cleanup_files() {
    while (file_pool) {
        struct_file *tmp = file_pool;
        file_pool = file_pool->next;
        free(tmp);
    }
}