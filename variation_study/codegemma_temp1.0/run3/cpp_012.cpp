# Generated by ollama (codegemma)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <memory>

class NetworkManager {
 public:
  NetworkManager();
  ~NetworkManager();

  void ResetConnections();
  void ReinitializeConnections();

 private:
  std::unique_ptr<ConnectionResource> connections_;

  // Helper methods for cleanup in error handling paths.
  void CleanupInError(std::exception& e);
  void CleanupInError(std::unique_ptr<ConnectionResource>& connections);
};

NetworkManager::NetworkManager() {
  connections_ = std::make_unique<ConnectionResource>();
}

NetworkManager::~NetworkManager() {
  // Ensure cleanup in case of exceptions during destruction.
  try {
    CleanupInError(connections_);
  } catch (const std::exception& e) {
    // Log or handle the exception.
  }
}

void NetworkManager::ResetConnections() {
  connections_->Reset();
}

void NetworkManager::ReinitializeConnections() {
  CleanupInError(connections_);
  connections_ = std::make_unique<ConnectionResource>();
}

void NetworkManager::CleanupInError(std::exception& e) {
  // Perform cleanup based on the exception type.
}

void NetworkManager::CleanupInError(std::unique_ptr<ConnectionResource>& connections) {
  connections.reset();
}