# Generated by ollama (codegemma)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdlib.h>
#include <string.h>

#define MAX_REQUEST_LENGTH 1024

int main() {
  // Allocate memory for request buffer
  char *request_buffer = malloc(MAX_REQUEST_LENGTH);

  while (1) {
    // Receive HTTP request
    int bytes_received = recv(socket_fd, request_buffer, MAX_REQUEST_LENGTH, 0);

    // Process request
    // ...

    // Send HTTP response
    // ...
  }

  // Free memory
  free(request_buffer);

  return 0;
}