# Generated by ollama (codegemma)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>

// Global volatile struct to share sensor data
typedef struct {
    float temperature;
    float humidity;
} sensor_data;

volatile sensor_data sensor;

// Task 1: Reads sensor values and updates the global struct
void sensor_task(void *pvParameters) {
    while (1) {
        // Read sensor values
        sensor.temperature = read_temperature();
        sensor.humidity = read_humidity();

        // Delay between readings
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

// Task 2: Processes the sensor data for control logic
void control_task(void *pvParameters) {
    while (1) {
        // Access sensor data from the global struct
        float temperature = sensor.temperature;
        float humidity = sensor.humidity;

        // Perform control logic based on sensor readings
        // ...

        // Delay between processing cycles
        vTaskDelay(pdMS_TO_TICKS(200));
    }
}

int main() {
    // Create tasks
    xTaskCreate(sensor_task, "Sensor Task", 1024, NULL, 1, NULL);
    xTaskCreate(control_task, "Control Task", 1024, NULL, 2, NULL);

    // Start FreeRTOS scheduler
    vTaskStartScheduler();

    // Infinite loop
    while (1) {
        // Wait for scheduler to run
    }
}