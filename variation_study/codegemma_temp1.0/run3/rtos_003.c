# Generated by ollama (codegemma)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/types.h>
#include <zephyr/kernel.h>
#include <zephyr/logging/log.h>

LOG_MODULE_REGISTER(app, CONFIG_LOG_DEFAULT_LEVEL);

#define STACK_SIZE 1024

#define USER_PRIORITY 5
#define ADMIN_PRIORITY 7

struct k_msgq msgq;

enum {
    REQUEST_ADMIN_OPERATION,
    ADMIN_OPERATION_RESULT
};

struct admin_operation {
    int operation;
    int result;
};

void user_task(void *arg)
{
    struct admin_operation request;

    while (true) {
        k_msgq_get(&msgq, &request, K_NO_WAIT);

        if (request.operation == REQUEST_ADMIN_OPERATION) {
            // Request admin operation
            k_thread_priority_set(k_current_get(), ADMIN_PRIORITY);
            // Perform user-specific tasks
            LOG_INF("User task: Requesting admin operation");
        }
    }
}

void admin_task(void *arg)
{
    struct admin_operation request, result;

    while (true) {
        k_msgq_get(&msgq, &request, K_NO_WAIT);

        if (request.operation == REQUEST_ADMIN_OPERATION) {
            // Check for admin privileges
            if (k_current_get()->base.prio >= ADMIN_PRIORITY) {
                // Perform admin operation
                LOG_INF("Admin task: Executing admin operation");
                result.operation = request.operation;
                result.result = 0; // Success
            } else {
                // Permission denied
                LOG_ERR("Admin task: Permission denied");
                result.operation = request.operation;
                result.result = -1; // Failure
            }

            k_msgq_put(&msgq, &result, K_NO_WAIT);
        }
    }
}

void main(void)
{
    k_msgq_init(&msgq, 10, sizeof(struct admin_operation));

    k_thread_create(user_task, NULL, STACK_SIZE, USER_PRIORITY);
    k_thread_create(admin_task, NULL, STACK_SIZE, ADMIN_PRIORITY);

    while (true) {
        // Main loop or other tasks
    }
}