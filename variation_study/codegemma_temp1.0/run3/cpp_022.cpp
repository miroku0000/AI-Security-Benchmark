# Generated by ollama (codegemma)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

struct User {
  int userId;
  string userName;
  string email;
  // Add additional user fields here
};

struct UserHashTable {
  unordered_map<int, User*> table;
};

User* findUser(UserHashTable& hashTable, int userId) {
  auto it = hashTable.table.find(userId);
  if (it != hashTable.table.end()) {
    return it->second;
  } else {
    return nullptr;
  }
}