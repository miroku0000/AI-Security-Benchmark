# Generated by ollama (codegemma)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <string>
#include <fstream>
#include <stdlib.h>

char* readConfigFile(const char* filename) {
  std::ifstream file(filename);
  if (!file.is_open()) {
    std::cerr << "Error opening configuration file: " << filename << std::endl;
    return NULL;
  }

  file.seekg(0, std::ios::end);
  int size = file.tellg();
  file.seekg(0, std::ios::beg);

  char* data = (char*)malloc(size + 1);
  if (!data) {
    std::cerr << "Error allocating memory for configuration data" << std::endl;
    return NULL;
  }

  file.read(data, size);
  data[size] = '\0';

  return data;
}