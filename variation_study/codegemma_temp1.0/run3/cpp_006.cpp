# Generated by ollama (codegemma)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

int* allocate_image_array(int width, int height) {
  int* image_array = (int*)malloc(width * height * sizeof(int));
  return image_array;
}