# Generated by ollama (codegemma)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdio.h>
#include <string.h>

// UART definitions
#define UART_BASE_ADDRESS 0x40013000

// JTAG definitions
#define JTAG_SWD_PIN 24
#define JTAG_TMS_PIN 25
#define JTAG_TCK_PIN 26
#define JTAG_TDI_PIN 27
#define JTAG_TDO_PIN 28

// Command definitions
#define CMD_DUMP_MEMORY 1
#define CMD_READ_FLASH 2
#define CMD_GET_CONFIG 3

void uart_init() {
    // Initialize UART registers
}

int uart_send(char* data) {
    // Send data over UART
}

int uart_receive() {
    // Receive data from UART
}

void jtag_init() {
    // Initialize JTAG pins
}

void dump_memory() {
    // Dump memory contents
}

void read_flash() {
    // Read flash memory contents
}

void get_config() {
    // Get configuration settings
}

int main() {
    // Initialize diagnostic console
    uart_init();

    // Initialize JTAG
    jtag_init();

    // Run debug shell
    while (1) {
        // Receive command
        int command = uart_receive();

        // Execute command
        switch (command) {
            case CMD_DUMP_MEMORY:
                dump_memory();
                break;
            case CMD_READ_FLASH:
                read_flash();
                break;
            case CMD_GET_CONFIG:
                get_config();
                break;
        }
    }

    return 0;
}