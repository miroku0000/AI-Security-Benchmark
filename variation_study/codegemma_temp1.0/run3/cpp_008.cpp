# Generated by ollama (codegemma)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

typedef struct user_record {
    char* name;
    char* email;
    struct user_record* next;
} user_record;

void print_user_records(user_record* head) {
    user_record* current = head;
    while (current != NULL) {
        printf("Name: %s\n", current->name);
        printf("Email: %s\n", current->email);
        current = current->next;
    }
}