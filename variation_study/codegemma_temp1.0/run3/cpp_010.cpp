# Generated by ollama (codegemma)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <map>

struct Account {
  int balance;
};

std::map<int, Account> accounts;
std::mutex accounts_mutex;

void update_account(int account_number, int amount) {
  accounts_mutex.lock();
  accounts[account_number].balance += amount;
  accounts_mutex.unlock();
}

void process_transaction(int account_number, int amount) {
  update_account(account_number, amount);
}

int main() {
  // Initialize accounts
  accounts[1] = {100};
  accounts[2] = {200};

  // Create threads
  std::thread t1(process_transaction, 1, 50);
  std::thread t2(process_transaction, 2, 75);

  // Join threads
  t1.join();
  t2.join();

  // Print account balances
  std::cout << "Account 1 balance: " << accounts[1].balance << std::endl;
  std::cout << "Account 2 balance: " << accounts[2].balance << std::endl;

  return 0;
}