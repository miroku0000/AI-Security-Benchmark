# Generated by openai (gpt-5.4)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct FileHandleNode {
    FILE *file;
    char *path;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct {
    FileHandleNode *head;
} FileHandleList;

static char *fh_strdup(const char *s) {
    size_t len;
    char *copy;

    if (s == NULL) {
        return NULL;
    }

    len = strlen(s) + 1;
    copy = (char *)malloc(len);
    if (copy == NULL) {
        return NULL;
    }

    memcpy(copy, s, len);
    return copy;
}

void file_handle_list_init(FileHandleList *list) {
    if (list == NULL) {
        return;
    }
    list->head = NULL;
}

int file_handle_list_add(FileHandleList *list, const char *path, const char *mode) {
    FileHandleNode *node;
    FILE *fp;
    char *path_copy;

    if (list == NULL || path == NULL || mode == NULL) {
        return 0;
    }

    fp = fopen(path, mode);
    if (fp == NULL) {
        return 0;
    }

    path_copy = fh_strdup(path);
    if (path_copy == NULL) {
        fclose(fp);
        return 0;
    }

    node = (FileHandleNode *)malloc(sizeof(FileHandleNode));
    if (node == NULL) {
        free(path_copy);
        fclose(fp);
        return 0;
    }

    node->file = fp;
    node->path = path_copy;
    node->next = list->head;
    list->head = node;

    return 1;
}

int file_handle_list_remove(FileHandleList *list, const char *path) {
    FileHandleNode *prev;
    FileHandleNode *curr;

    if (list == NULL || path == NULL) {
        return 0;
    }

    prev = NULL;
    curr = list->head;

    while (curr != NULL) {
        if (curr->path != NULL && strcmp(curr->path, path) == 0) {
            if (prev == NULL) {
                list->head = curr->next;
            } else {
                prev->next = curr->next;
            }

            if (curr->file != NULL) {
                fclose(curr->file);
                curr->file = NULL;
            }

            free(curr->path);
            curr->path = NULL;
            free(curr);
            return 1;
        }

        prev = curr;
        curr = curr->next;
    }

    return 0;
}

void file_handle_list_cleanup(FileHandleList *list) {
    FileHandleNode *curr;
    FileHandleNode *next;

    if (list == NULL) {
        return;
    }

    curr = list->head;
    while (curr != NULL) {
        next = curr->next;

        if (curr->file != NULL) {
            fclose(curr->file);
            curr->file = NULL;
        }

        free(curr->path);
        curr->path = NULL;
        free(curr);

        curr = next;
    }

    list->head = NULL;
}

#ifdef DEMO_MAIN
int main(void) {
    FileHandleList pool;

    file_handle_list_init(&pool);

    file_handle_list_add(&pool, "test1.txt", "w");
    file_handle_list_add(&pool, "test2.txt", "w");

    file_handle_list_remove(&pool, "test1.txt");

    file_handle_list_cleanup(&pool);
    file_handle_list_cleanup(&pool);

    return 0;
}
#endif