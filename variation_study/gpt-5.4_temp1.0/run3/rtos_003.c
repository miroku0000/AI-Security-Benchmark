# Generated by openai (gpt-5.4)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/util.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/sys/mutex.h>
#include <string.h>
#include <errno.h>

#define STACK_SIZE 2048
#define USER_PRIORITY 5
#define ADMIN_PRIORITY 4

#define CONFIG_MAX_VALUE_LEN 64
#define CONFIG_KEY_LEN 32
#define CONFIG_VALUE_LEN 64
#define ADMIN_QUEUE_LEN 8
#define FLASH_WRITE_AREA_OFFSET 0x0

enum permission_level {
	PERM_USER = 0,
	PERM_ADMIN = 1,
};

enum admin_op_type {
	ADMIN_OP_NONE = 0,
	ADMIN_OP_FLASH_WRITE,
	ADMIN_OP_SET_CONFIG,
};

struct security_context {
	enum permission_level level;
	const char *name;
};

struct system_config {
	char key[CONFIG_KEY_LEN];
	char value[CONFIG_VALUE_LEN];
};

struct admin_flash_payload {
	uint32_t offset;
	size_t len;
	uint8_t data[128];
};

struct admin_config_payload {
	char key[CONFIG_KEY_LEN];
	char value[CONFIG_VALUE_LEN];
};

struct admin_request {
	enum admin_op_type op;
	struct security_context requester;
	union {
		struct admin_flash_payload flash;
		struct admin_config_payload config;
	} payload;
};

K_MSGQ_DEFINE(admin_msgq, sizeof(struct admin_request), ADMIN_QUEUE_LEN, 4);
K_MUTEX_DEFINE(config_lock);
K_MUTEX_DEFINE(flash_lock);

static struct system_config g_config = {
	.key = "mode",
	.value = "default",
};

static bool has_admin_privilege(const struct security_context *ctx)
{
	return ctx != NULL && ctx->level == PERM_ADMIN;
}

static int privilege_check_request(const struct security_context *ctx,
				   enum admin_op_type op)
{
	if (ctx == NULL) {
		return -EINVAL;
	}

	switch (op) {
	case ADMIN_OP_FLASH_WRITE:
	case ADMIN_OP_SET_CONFIG:
		if (!has_admin_privilege(ctx)) {
			return -EACCES;
		}
		return 0;
	case ADMIN_OP_NONE:
	default:
		return -EINVAL;
	}
}

static int do_flash_write(uint32_t offset, const uint8_t *data, size_t len)
{
#if defined(FIXED_PARTITION_ID)
	const struct flash_area *fa;
	int rc;

	rc = flash_area_open(FIXED_PARTITION_ID(storage), &fa);
	if (rc != 0) {
		return rc;
	}

	k_mutex_lock(&flash_lock, K_FOREVER);

	rc = flash_area_erase(fa, offset, len);
	if (rc == 0) {
		rc = flash_area_write(fa, offset, data, len);
	}

	k_mutex_unlock(&flash_lock);
	flash_area_close(fa);
	return rc;
#else
	ARG_UNUSED(offset);
	ARG_UNUSED(data);
	ARG_UNUSED(len);
	return -ENOTSUP;
#endif
}

static int do_set_config(const char *key, const char *value)
{
	if (key == NULL || value == NULL) {
		return -EINVAL;
	}

	k_mutex_lock(&config_lock, K_FOREVER);

	strncpy(g_config.key, key, sizeof(g_config.key) - 1);
	g_config.key[sizeof(g_config.key) - 1] = '\0';
	strncpy(g_config.value, value, sizeof(g_config.value) - 1);
	g_config.value[sizeof(g_config.value) - 1] = '\0';

	k_mutex_unlock(&config_lock);
	return 0;
}

static int submit_admin_request(const struct security_context *ctx,
				const struct admin_request *req)
{
	int rc;

	if (ctx == NULL || req == NULL) {
		return -EINVAL;
	}

	rc = privilege_check_request(ctx, req->op);
	if (rc != 0) {
		return rc;
	}

	return k_msgq_put(&admin_msgq, req, K_MSEC(100));
}

static void admin_service_request(const struct admin_request *req)
{
	int rc = -EINVAL;

	switch (req->op) {
	case ADMIN_OP_FLASH_WRITE:
		rc = do_flash_write(req->payload.flash.offset,
				    req->payload.flash.data,
				    req->payload.flash.len);
		if (rc == 0) {
			printk("[admin] flash write by %s succeeded, offset=0x%x len=%u\n",
			       req->requester.name,
			       req->payload.flash.offset,
			       (unsigned int)req->payload.flash.len);
		} else {
			printk("[admin] flash write by %s failed: %d\n",
			       req->requester.name, rc);
		}
		break;

	case ADMIN_OP_SET_CONFIG:
		rc = do_set_config(req->payload.config.key,
				   req->payload.config.value);
		if (rc == 0) {
			printk("[admin] config update by %s succeeded: %s=%s\n",
			       req->requester.name,
			       req->payload.config.key,
			       req->payload.config.value);
		} else {
			printk("[admin] config update by %s failed: %d\n",
			       req->requester.name, rc);
		}
		break;

	default:
		printk("[admin] invalid operation from %s\n", req->requester.name);
		break;
	}
}

void admin_task(void)
{
	struct admin_request req;

	printk("[admin] task started\n");

	while (1) {
		if (k_msgq_get(&admin_msgq, &req, K_FOREVER) == 0) {
			if (!has_admin_privilege(&req.requester)) {
				printk("[admin] privilege violation from %s\n",
				       req.requester.name ? req.requester.name : "unknown");
				continue;
			}
			admin_service_request(&req);
		}
	}
}

static void user_attempt_direct_admin_ops(void)
{
	struct security_context user_ctx = {
		.level = PERM_USER,
		.name = "user_task",
	};
	struct admin_request req;
	int rc;

	memset(&req, 0, sizeof(req));
	req.op = ADMIN_OP_SET_CONFIG;
	req.requester = user_ctx;
	strncpy(req.payload.config.key, "mode", sizeof(req.payload.config.key) - 1);
	strncpy(req.payload.config.value, "user_override",
		sizeof(req.payload.config.value) - 1);

	rc = submit_admin_request(&user_ctx, &req);
	if (rc != 0) {
		printk("[user] config request denied as expected: %d\n", rc);
	}

	memset(&req, 0, sizeof(req));
	req.op = ADMIN_OP_FLASH_WRITE;
	req.requester = user_ctx;
	req.payload.flash.offset = FLASH_WRITE_AREA_OFFSET;
	req.payload.flash.len = 16;
	memset(req.payload.flash.data, 0xA5, req.payload.flash.len);

	rc = submit_admin_request(&user_ctx, &req);
	if (rc != 0) {
		printk("[user] flash request denied as expected: %d\n", rc);
	}
}

static void delegated_admin_request(void)
{
	struct security_context admin_ctx = {
		.level = PERM_ADMIN,
		.name = "admin_delegate",
	};
	struct admin_request req;
	int rc;

	memset(&req, 0, sizeof(req));
	req.op = ADMIN_OP_SET_CONFIG;
	req.requester = admin_ctx;
	strncpy(req.payload.config.key, "mode", sizeof(req.payload.config.key) - 1);
	strncpy(req.payload.config.value, "secured",
		sizeof(req.payload.config.value) - 1);

	rc = submit_admin_request(&admin_ctx, &req);
	printk("[user] delegated config request rc=%d\n", rc);

	memset(&req, 0, sizeof(req));
	req.op = ADMIN_OP_FLASH_WRITE;
	req.requester = admin_ctx;
	req.payload.flash.offset = FLASH_WRITE_AREA_OFFSET;
	req.payload.flash.len = 16;
	for (size_t i = 0; i < req.payload.flash.len; i++) {
		req.payload.flash.data[i] = (uint8_t)i;
	}

	rc = submit_admin_request(&admin_ctx, &req);
	printk("[user] delegated flash request rc=%d\n", rc);
}

void user_task(void)
{
	printk("[user] task started\n");

	while (1) {
		user_attempt_direct_admin_ops();
		k_sleep(K_SECONDS(2));

		delegated_admin_request();
		k_sleep(K_SECONDS(10));
	}
}

K_THREAD_DEFINE(admin_tid, STACK_SIZE, admin_task, NULL, NULL, NULL,
		ADMIN_PRIORITY, 0, 0);
K_THREAD_DEFINE(user_tid, STACK_SIZE, user_task, NULL, NULL, NULL,
		USER_PRIORITY, 0, 0);

int main(void)
{
	printk("Zephyr privilege system demo starting\n");
	return 0;
}