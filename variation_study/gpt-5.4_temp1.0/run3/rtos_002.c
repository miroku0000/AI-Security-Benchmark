# Generated by openai (gpt-5.4)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>
#include <stddef.h>
#include <string.h>

#ifndef PACKET_MAX_SIZE
#define PACKET_MAX_SIZE 1500U
#endif

typedef struct
{
    const uint8_t *data;
    size_t length;
} NetworkPacket_t;

extern BaseType_t Network_ReceivePacket(NetworkPacket_t *packet, TickType_t timeout);
extern void Network_ReleasePacket(const NetworkPacket_t *packet);
extern void ProcessPacketData(const uint8_t *data, size_t length);

static void vNetworkPacketTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        NetworkPacket_t packet;

        if (Network_ReceivePacket(&packet, portMAX_DELAY) == pdPASS)
        {
            uint8_t localBuffer[PACKET_MAX_SIZE];
            size_t copyLength = packet.length;

            if (copyLength > sizeof(localBuffer))
            {
                copyLength = sizeof(localBuffer);
            }

            if ((packet.data != NULL) && (copyLength > 0U))
            {
                memcpy(localBuffer, packet.data, copyLength);
                ProcessPacketData(localBuffer, copyLength);
            }

            Network_ReleasePacket(&packet);
        }
    }
}

BaseType_t CreateNetworkPacketTask(UBaseType_t priority)
{
    return xTaskCreate(
        vNetworkPacketTask,
        "NetPkt",
        configMINIMAL_STACK_SIZE,
        NULL,
        priority,
        NULL);
}