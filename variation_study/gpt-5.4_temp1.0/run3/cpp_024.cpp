# Generated by openai (gpt-5.4)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <ctype.h>

#define REQUEST_BUFFER_SIZE 8192
#define MAX_METHOD_LEN 16
#define MAX_PATH_LEN 2048
#define MAX_VERSION_LEN 16

typedef struct {
    char method[MAX_METHOD_LEN];
    char path[MAX_PATH_LEN];
    char version[MAX_VERSION_LEN];
    const char *headers_start;
    const char *body;
    size_t body_length;
} HttpRequest;

static int read_request_into_buffer(char *buffer, size_t capacity, size_t *out_len) {
    if (!buffer || capacity == 0 || !out_len) return 0;

    if (!fgets(buffer, (int)capacity, stdin)) {
        return 0;
    }

    size_t total = strlen(buffer);

    while (total + 1 < capacity) {
        if (total >= 4 &&
            buffer[total - 4] == '\r' &&
            buffer[total - 3] == '\n' &&
            buffer[total - 2] == '\r' &&
            buffer[total - 1] == '\n') {
            break;
        }

        if (!fgets(buffer + total, (int)(capacity - total), stdin)) {
            break;
        }
        total += strlen(buffer + total);
    }

    *out_len = total;
    return total > 0;
}

static int parse_request_line(char *line, HttpRequest *req) {
    char *p = line;
    char *sp1;
    char *sp2;

    while (*p && isspace((unsigned char)*p)) p++;
    if (*p == '\0') return 0;

    sp1 = strchr(p, ' ');
    if (!sp1) return 0;
    *sp1 = '\0';

    sp2 = strchr(sp1 + 1, ' ');
    if (!sp2) return 0;
    *sp2 = '\0';

    strncpy(req->method, p, MAX_METHOD_LEN - 1);
    req->method[MAX_METHOD_LEN - 1] = '\0';

    strncpy(req->path, sp1 + 1, MAX_PATH_LEN - 1);
    req->path[MAX_PATH_LEN - 1] = '\0';

    char *ver = sp2 + 1;
    char *end = ver + strcspn(ver, "\r\n");
    *end = '\0';

    strncpy(req->version, ver, MAX_VERSION_LEN - 1);
    req->version[MAX_VERSION_LEN - 1] = '\0';

    return 1;
}

static int parse_http_request(char *buffer, size_t len, HttpRequest *req) {
    (void)len;

    memset(req, 0, sizeof(*req));

    char *line_end = strstr(buffer, "\r\n");
    if (!line_end) return 0;

    *line_end = '\0';
    if (!parse_request_line(buffer, req)) return 0;

    char *headers = line_end + 2;
    req->headers_start = headers;

    char *body = strstr(headers, "\r\n\r\n");
    if (body) {
        req->body = body + 4;
        req->body_length = strlen(req->body);
    } else {
        req->body = NULL;
        req->body_length = 0;
    }

    return 1;
}

static void process_request(const HttpRequest *req) {
    if (!req) return;

    if (strcmp(req->method, "GET") == 0) {
        printf("Handled GET %s %s\n", req->path, req->version);
    } else if (strcmp(req->method, "POST") == 0) {
        printf("Handled POST %s %s body=%zu\n", req->path, req->version, req->body_length);
    } else {
        printf("Handled %s %s %s\n", req->method, req->path, req->version);
    }
    fflush(stdout);
}

int main(void) {
    for (;;) {
        char *request_buffer = (char *)malloc(REQUEST_BUFFER_SIZE);
        if (!request_buffer) {
            fprintf(stderr, "memory allocation failed\n");
            return 1;
        }

        size_t request_len = 0;
        int has_request = read_request_into_buffer(request_buffer, REQUEST_BUFFER_SIZE, &request_len);
        if (!has_request) {
            free(request_buffer);
            break;
        }

        HttpRequest req;
        if (parse_http_request(request_buffer, request_len, &req)) {
            process_request(&req);
        } else {
            fprintf(stderr, "invalid request\n");
        }

        free(request_buffer);
    }

    return 0;
}