# Generated by openai (gpt-5.4)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <string>
#include <vector>
#include <memory>

class Connection {
public:
    Connection(int id) : id_(id), active_(false) {
        if (id_ < 0) {
            throw std::invalid_argument("Invalid connection id");
        }
        active_ = true;
    }

    ~Connection() {
        close();
    }

    void reset() {
        close();
        active_ = true;
    }

    void reinitialize() {
        close();
        if (id_ < 0) {
            throw std::runtime_error("Failed to reinitialize connection");
        }
        active_ = true;
    }

    void close() noexcept {
        if (active_) {
            active_ = false;
        }
    }

    bool isActive() const noexcept {
        return active_;
    }

    int id() const noexcept {
        return id_;
    }

private:
    int id_;
    bool active_;
};

class NetworkConnectionManager {
public:
    explicit NetworkConnectionManager(std::size_t connectionCount) {
        try {
            connections_.reserve(connectionCount);
            for (std::size_t i = 0; i < connectionCount; ++i) {
                connections_.push_back(std::make_unique<Connection>(static_cast<int>(i)));
            }
        } catch (...) {
            cleanup();
            throw;
        }
    }

    ~NetworkConnectionManager() {
        cleanup();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept
        : connections_(std::move(other.connections_)) {}

    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            connections_ = std::move(other.connections_);
        }
        return *this;
    }

    void resetConnection(std::size_t index) {
        Connection& conn = getConnection(index);
        try {
            conn.reset();
        } catch (...) {
            conn.close();
            throw;
        }
    }

    void reinitializeConnection(std::size_t index) {
        Connection& conn = getConnection(index);
        try {
            conn.reinitialize();
        } catch (...) {
            conn.close();
            throw;
        }
    }

    void resetAll() {
        for (auto& conn : connections_) {
            try {
                conn->reset();
            } catch (...) {
                conn->close();
                throw;
            }
        }
    }

    void reinitializeAll() {
        for (auto& conn : connections_) {
            try {
                conn->reinitialize();
            } catch (...) {
                conn->close();
                throw;
            }
        }
    }

    std::size_t size() const noexcept {
        return connections_.size();
    }

    bool isActive(std::size_t index) const {
        return getConnection(index).isActive();
    }

private:
    Connection& getConnection(std::size_t index) const {
        if (index >= connections_.size()) {
            throw std::out_of_range("Connection index out of range");
        }
        return *connections_[index];
    }

    void cleanup() noexcept {
        for (auto& conn : connections_) {
            if (conn) {
                conn->close();
            }
        }
        connections_.clear();
    }

    std::vector<std::unique_ptr<Connection>> connections_;
};

int main() {
    try {
        NetworkConnectionManager manager(3);
        manager.resetConnection(1);
        manager.reinitializeConnection(2);
        manager.resetAll();
        manager.reinitializeAll();

        for (std::size_t i = 0; i < manager.size(); ++i) {
            std::cout << "Connection " << i << " active: " << std::boolalpha
                      << manager.isActive(i) << '\n';
        }
    } catch (const std::exception& ex) {
        std::cerr << "Error: " << ex.what() << '\n';
        return 1;
    }

    return 0;
}