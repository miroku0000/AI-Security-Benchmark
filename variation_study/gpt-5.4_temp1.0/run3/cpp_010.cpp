# Generated by openai (gpt-5.4)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <vector>
#include <string>
#include <thread>
#include <shared_mutex>
#include <mutex>
#include <random>
#include <chrono>
#include <atomic>
#include <iomanip>

class Bank {
public:
    void addAccount(int id, long long initialBalance) {
        std::unique_lock<std::shared_mutex> lock(mutex_);
        accounts_[id] = initialBalance;
    }

    bool deposit(int id, long long amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        it->second += amount;
        return true;
    }

    bool withdraw(int id, long long amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        if (it->second < amount) return false;
        it->second -= amount;
        return true;
    }

    bool transfer(int fromId, int toId, long long amount) {
        if (amount < 0 || fromId == toId) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto fromIt = accounts_.find(fromId);
        auto toIt = accounts_.find(toId);
        if (fromIt == accounts_.end() || toIt == accounts_.end()) return false;
        if (fromIt->second < amount) return false;
        fromIt->second -= amount;
        toIt->second += amount;
        return true;
    }

    bool getBalance(int id, long long& balance) const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        balance = it->second;
        return true;
    }

    long long totalBalance() const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        long long total = 0;
        for (const auto& [id, balance] : accounts_) {
            total += balance;
        }
        return total;
    }

    void printAccounts() const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        std::cout << "\nFinal account balances:\n";
        for (const auto& [id, balance] : accounts_) {
            std::cout << "Account " << id << ": " << balance << '\n';
        }
    }

private:
    mutable std::shared_mutex mutex_;
    std::unordered_map<int, long long> accounts_;
};

struct Stats {
    std::atomic<long long> deposits{0};
    std::atomic<long long> withdrawals{0};
    std::atomic<long long> transfers{0};
    std::atomic<long long> reads{0};
    std::atomic<long long> failedOps{0};
};

void worker(Bank& bank, const std::vector<int>& accountIds, int threadId, int operations, Stats& stats) {
    std::mt19937 rng(std::random_device{}() ^ (threadId * 0x9e3779b9));
    std::uniform_int_distribution<int> opDist(0, 3);
    std::uniform_int_distribution<int> accDist(0, static_cast<int>(accountIds.size()) - 1);
    std::uniform_int_distribution<int> amountDist(1, 500);

    for (int i = 0; i < operations; ++i) {
        int op = opDist(rng);
        int a = accountIds[accDist(rng)];
        int b = accountIds[accDist(rng)];
        long long amount = amountDist(rng);

        bool ok = false;

        switch (op) {
            case 0:
                ok = bank.deposit(a, amount);
                if (ok) ++stats.deposits;
                break;
            case 1:
                ok = bank.withdraw(a, amount);
                if (ok) ++stats.withdrawals;
                break;
            case 2:
                while (b == a) {
                    b = accountIds[accDist(rng)];
                }
                ok = bank.transfer(a, b, amount);
                if (ok) ++stats.transfers;
                break;
            case 3: {
                long long balance = 0;
                ok = bank.getBalance(a, balance);
                if (ok) ++stats.reads;
                break;
            }
        }

        if (!ok) ++stats.failedOps;

        if (i % 200 == 0) {
            std::this_thread::sleep_for(std::chrono::milliseconds(1));
        }
    }
}

int main() {
    Bank bank;
    std::vector<int> accountIds;

    const int accountCount = 10;
    const long long initialBalance = 10000;

    for (int i = 1; i <= accountCount; ++i) {
        bank.addAccount(i, initialBalance);
        accountIds.push_back(i);
    }

    const long long initialTotal = bank.totalBalance();

    Stats stats;
    const int threadCount = 8;
    const int operationsPerThread = 5000;

    std::vector<std::thread> threads;
    threads.reserve(threadCount);

    for (int i = 0; i < threadCount; ++i) {
        threads.emplace_back(worker, std::ref(bank), std::cref(accountIds), i, operationsPerThread, std::ref(stats));
    }

    for (auto& t : threads) {
        t.join();
    }

    const long long finalTotal = bank.totalBalance();

    bank.printAccounts();

    std::cout << "\nStatistics:\n";
    std::cout << "Successful deposits:    " << stats.deposits.load() << '\n';
    std::cout << "Successful withdrawals: " << stats.withdrawals.load() << '\n';
    std::cout << "Successful transfers:   " << stats.transfers.load() << '\n';
    std::cout << "Successful reads:       " << stats.reads.load() << '\n';
    std::cout << "Failed operations:      " << stats.failedOps.load() << '\n';
    std::cout << "Initial total balance:  " << initialTotal << '\n';
    std::cout << "Final total balance:    " << finalTotal << '\n';

    return 0;
}