# Generated by openai (gpt-5.4)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <string.h>

#ifndef BOOTLOADER_HSE_FREQ
#define BOOTLOADER_HSE_FREQ            8000000U
#endif

#ifndef BOOTLOADER_SYSCLK_FREQ
#define BOOTLOADER_SYSCLK_FREQ         72000000U
#endif

#ifndef FLASH_BASE_ADDR
#define FLASH_BASE_ADDR                0x08000000UL
#endif

#ifndef FLASH_SIZE_BYTES
#define FLASH_SIZE_BYTES               (512UL * 1024UL)
#endif

#ifndef FLASH_PAGE_SIZE
#define FLASH_PAGE_SIZE                2048UL
#endif

#ifndef SRAM_BASE_ADDR
#define SRAM_BASE_ADDR                 0x20000000UL
#endif

#ifndef APP_BASE_ADDR
#define APP_BASE_ADDR                  0x08008000UL
#endif

#ifndef APP_MAX_SIZE
#define APP_MAX_SIZE                   (FLASH_SIZE_BYTES - (APP_BASE_ADDR - FLASH_BASE_ADDR))
#endif

#ifndef BOOT_FLAG_ADDR
#define BOOT_FLAG_ADDR                 0x2000FFF0UL
#endif

#ifndef BOOT_FLAG_VALUE
#define BOOT_FLAG_VALUE                0xB00720ADUL
#endif

#ifndef UPDATE_INFO_ADDR
#define UPDATE_INFO_ADDR               0x08007800UL
#endif

#ifndef UPDATE_INFO_MAGIC
#define UPDATE_INFO_MAGIC              0x55504454UL
#endif

#ifndef GPIO_BOOT_PORT
#define GPIO_BOOT_PORT                 ((GPIO_TypeDef *)0x40010800UL)
#endif

#ifndef GPIO_BOOT_PIN_MASK
#define GPIO_BOOT_PIN_MASK             (1U << 0)
#endif

#ifndef GPIO_BOOT_ACTIVE_LEVEL
#define GPIO_BOOT_ACTIVE_LEVEL         0U
#endif

#ifndef UART_BASE
#define UART_BASE                      0x40013800UL
#endif

#ifndef UART_BAUDRATE
#define UART_BAUDRATE                  115200U
#endif

#ifndef SD_MAX_IMAGE_SIZE
#define SD_MAX_IMAGE_SIZE              APP_MAX_SIZE
#endif

#ifndef IMAGE_HEADER_MAGIC
#define IMAGE_HEADER_MAGIC             0x464D5742UL

#endif

#ifndef IMAGE_TRAILER_MAGIC
#define IMAGE_TRAILER_MAGIC            0x454E4446UL
#endif

#ifndef UART_UPDATE_TIMEOUT_MS
#define UART_UPDATE_TIMEOUT_MS         3000U
#endif

#ifndef UART_BLOCK_SIZE
#define UART_BLOCK_SIZE                256U
#endif

#ifndef SYSTEM_TICK_HZ
#define SYSTEM_TICK_HZ                 1000U
#endif

typedef struct
{
    volatile uint32_t CRL;
    volatile uint32_t CRH;
    volatile uint32_t IDR;
    volatile uint32_t ODR;
    volatile uint32_t BSRR;
    volatile uint32_t BRR;
    volatile uint32_t LCKR;
} GPIO_TypeDef;

typedef struct
{
    volatile uint32_t SR;
    volatile uint32_t DR;
    volatile uint32_t BRR;
    volatile uint32_t CR1;
    volatile uint32_t CR2;
    volatile uint32_t CR3;
    volatile uint32_t GTPR;
} USART_TypeDef;

typedef struct
{
    volatile uint32_t ACR;
    volatile uint32_t KEYR;
    volatile uint32_t OPTKEYR;
    volatile uint32_t SR;
    volatile uint32_t CR;
    volatile uint32_t AR;
    volatile uint32_t RESERVED;
    volatile uint32_t OBR;
    volatile uint32_t WRPR;
} FLASH_TypeDef;

typedef struct
{
    volatile uint32_t CR;
    volatile uint32_t CFGR;
    volatile uint32_t CIR;
    volatile uint32_t APB2RSTR;
    volatile uint32_t APB1RSTR;
    volatile uint32_t AHBENR;
    volatile uint32_t APB2ENR;
    volatile uint32_t APB1ENR;
    volatile uint32_t BDCR;
    volatile uint32_t CSR;
} RCC_TypeDef;

typedef struct
{
    volatile uint32_t VTOR;
    volatile uint32_t RESERVED0[6];
    volatile uint32_t AIRCR;
} SCB_TypeDef;

#define USART1                          ((USART_TypeDef *)UART_BASE)
#define FLASH_REG                       ((FLASH_TypeDef *)0x40022000UL)
#define RCC_REG                         ((RCC_TypeDef *)0x40021000UL)
#define SCB_REG                         ((SCB_TypeDef *)0xE000ED08UL)

#define RCC_APB2ENR_IOPAEN             (1U << 2)
#define RCC_APB2ENR_USART1EN           (1U << 14)

#define USART_SR_RXNE                  (1U << 5)
#define USART_SR_TXE                   (1U << 7)
#define USART_SR_TC                    (1U << 6)
#define USART_CR1_UE                   (1U << 13)
#define USART_CR1_TE                   (1U << 3)
#define USART_CR1_RE                   (1U << 2)

#define FLASH_SR_BSY                   (1U << 0)
#define FLASH_SR_EOP                   (1U << 5)
#define FLASH_CR_PG                    (1U << 0)
#define FLASH_CR_PER                   (1U << 1)
#define FLASH_CR_MER                   (1U << 2)
#define FLASH_CR_STRT                  (1U << 6)
#define FLASH_CR_LOCK                  (1U << 7)

#define FLASH_KEY1                     0x45670123UL
#define FLASH_KEY2                     0xCDEF89ABUL

typedef struct
{
    uint32_t magic;
    uint32_t image_size;
    uint32_t crc32;
    uint32_t version;
    uint32_t reserved[4];
} image_header_t;

typedef struct
{
    uint32_t magic;
    uint32_t pending;
    uint32_t source;
    uint32_t size;
    uint32_t crc32;
    uint32_t version;
    uint32_t reserved[2];
} update_info_t;

typedef enum
{
    UPDATE_SOURCE_NONE = 0,
    UPDATE_SOURCE_SD   = 1,
    UPDATE_SOURCE_UART = 2
} update_source_t;

static volatile uint32_t g_ms_ticks = 0;

static void delay_cycles(volatile uint32_t n)
{
    while (n--) { __asm volatile ("nop"); }
}

void SysTick_Handler(void)
{
    g_ms_ticks++;
}

static uint32_t systick_now(void)
{
    return g_ms_ticks;
}

static int systick_elapsed(uint32_t start, uint32_t ms)
{
    return (uint32_t)(systick_now() - start) >= ms;
}

static uint32_t crc32_init(void)
{
    return 0xFFFFFFFFUL;
}

static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t len)
{
    uint32_t i, j;
    for (i = 0; i < len; i++)
    {
        crc ^= data[i];
        for (j = 0; j < 8; j++)
        {
            uint32_t mask = (uint32_t)(-(int32_t)(crc & 1U));
            crc = (crc >> 1) ^ (0xEDB88320UL & mask);
        }
    }
    return crc;
}

static uint32_t crc32_final(uint32_t crc)
{
    return ~crc;
}

static void clock_init(void)
{
    RCC_REG->APB2ENR |= RCC_APB2ENR_IOPAEN | RCC_APB2ENR_USART1EN;
}

static void uart_init(void)
{
    uint32_t div = BOOTLOADER_SYSCLK_FREQ / UART_BAUDRATE;
    USART1->BRR = div;
    USART1->CR1 = USART_CR1_UE | USART_CR1_TE | USART_CR1_RE;
}

static void uart_putc(uint8_t c)
{
    while ((USART1->SR & USART_SR_TXE) == 0U) {}
    USART1->DR = c;
}

static void uart_write(const uint8_t *data, uint32_t len)
{
    uint32_t i;
    for (i = 0; i < len; i++) uart_putc(data[i]);
    while ((USART1->SR & USART_SR_TC) == 0U) {}
}

static int uart_getc_timeout(uint8_t *c, uint32_t timeout_ms)
{
    uint32_t start = systick_now();
    while (!systick_elapsed(start, timeout_ms))
    {
        if (USART1->SR & USART_SR_RXNE)
        {
            *c = (uint8_t)USART1->DR;
            return 0;
        }
    }
    return -1;
}

static int uart_read(uint8_t *buf, uint32_t len, uint32_t timeout_ms)
{
    uint32_t i;
    for (i = 0; i < len; i++)
    {
        if (uart_getc_timeout(&buf[i], timeout_ms) != 0) return -1;
    }
    return 0;
}

static void flash_wait_ready(void)
{
    while (FLASH_REG->SR & FLASH_SR_BSY) {}
}

static void flash_unlock(void)
{
    if (FLASH_REG->CR & FLASH_CR_LOCK)
    {
        FLASH_REG->KEYR = FLASH_KEY1;
        FLASH_REG->KEYR = FLASH_KEY2;
    }
}

static void flash_lock(void)
{
    FLASH_REG->CR |= FLASH_CR_LOCK;
}

static int flash_erase_page(uint32_t address)
{
    flash_wait_ready();
    FLASH_REG->CR |= FLASH_CR_PER;
    FLASH_REG->AR = address;
    FLASH_REG->CR |= FLASH_CR_STRT;
    flash_wait_ready();
    FLASH_REG->CR &= ~FLASH_CR_PER;
    return 0;
}

static int flash_program_halfword(uint32_t address, uint16_t value)
{
    flash_wait_ready();
    FLASH_REG->CR |= FLASH_CR_PG;
    *(volatile uint16_t *)address = value;
    flash_wait_ready();
    FLASH_REG->CR &= ~FLASH_CR_PG;
    if (*(volatile uint16_t *)address != value) return -1;
    return 0;
}

static int flash_program_buffer(uint32_t address, const uint8_t *data, uint32_t len)
{
    uint32_t i = 0;
    while (i < len)
    {
        uint16_t hw = data[i];
        if ((i + 1U) < len)
            hw |= ((uint16_t)data[i + 1U] << 8);
        else
            hw |= 0xFF00U;
        if (flash_program_halfword(address + i, hw) != 0) return -1;
        i += 2U;
    }
    return 0;
}

static int flash_erase_range(uint32_t address, uint32_t size)
{
    uint32_t start = address;
    uint32_t end = address + size;
    uint32_t page = start - (start % FLASH_PAGE_SIZE);
    while (page < end)
    {
        if (flash_erase_page(page) != 0) return -1;
        page += FLASH_PAGE_SIZE;
    }
    return 0;
}

static int app_vector_valid(uint32_t app_addr)
{
    uint32_t sp = *(volatile uint32_t *)app_addr;
    uint32_t rv = *(volatile uint32_t *)(app_addr + 4U);
    if (sp < SRAM_BASE_ADDR || sp > (SRAM_BASE_ADDR + 0x00020000UL)) return 0;
    if (rv < APP_BASE_ADDR || rv > (FLASH_BASE_ADDR + FLASH_SIZE_BYTES)) return 0;
    return 1;
}

static void jump_to_app(uint32_t app_addr)
{
    typedef void (*entry_fn_t)(void);
    uint32_t app_sp = *(volatile uint32_t *)app_addr;
    uint32_t app_pc = *(volatile uint32_t *)(app_addr + 4U);
    entry_fn_t app_entry = (entry_fn_t)app_pc;

    __asm volatile ("cpsid i");
    SCB_REG->VTOR = app_addr;
    __asm volatile ("msr msp, %0" : : "r" (app_sp) : );
    app_entry();
    while (1) {}
}

static int boot_pin_asserted(void)
{
    uint32_t pin = (GPIO_BOOT_PORT->IDR & GPIO_BOOT_PIN_MASK) ? 1U : 0U;
    return pin == GPIO_BOOT_ACTIVE_LEVEL;
}

static int recovery_flag_asserted(void)
{
    volatile uint32_t *flag = (volatile uint32_t *)BOOT_FLAG_ADDR;
    if (*flag == BOOT_FLAG_VALUE)
    {
        *flag = 0U;
        return 1;
    }
    return 0;
}

static update_info_t *get_update_info(void)
{
    return (update_info_t *)UPDATE_INFO_ADDR;
}

static int update_info_is_pending(update_info_t *info)
{
    return (info->magic == UPDATE_INFO_MAGIC) && (info->pending == 1U);
}

static void update_info_clear_ram(update_info_t *dst)
{
    memset(dst, 0, sizeof(update_info_t));
}

static int storage_sd_init(void)
{
    return 0;
}

static int storage_sd_image_present(image_header_t *hdr)
{
    if (storage_sd_init() != 0) return 0;
    if (sd_read(0U, (uint8_t *)hdr, sizeof(image_header_t)) != 0) return 0;
    if (hdr->magic != IMAGE_HEADER_MAGIC) return 0;
    if (hdr->image_size == 0U || hdr->image_size > SD_MAX_IMAGE_SIZE) return 0;
    return 1;
}

static int storage_sd_read(uint32_t offset, uint8_t *buf, uint32_t len)
{
    return sd_read(offset, buf, len);
}

static int verify_image_crc_streamed(update_source_t source, uint32_t size, uint32_t expected_crc)
{
    uint8_t buffer[UART_BLOCK_SIZE];
    uint32_t offset = sizeof(image_header_t);
    uint32_t remaining = size;
    uint32_t crc = crc32_init();

    while (remaining)
    {
        uint32_t chunk = (remaining > sizeof(buffer)) ? sizeof(buffer) : remaining;
        int rc = -1;
        if (source == UPDATE_SOURCE_SD)
            rc = storage_sd_read(offset, buffer, chunk);
        if (rc != 0) return -1;
        crc = crc32_update(crc, buffer, chunk);
        offset += chunk;
        remaining -= chunk;
    }
    crc = crc32_final(crc);
    return (crc == expected_crc) ? 0 : -1;
}

static int program_image_from_stream(update_source_t source, uint32_t size, uint32_t expected_crc)
{
    uint8_t buffer[UART_BLOCK_SIZE];
    uint32_t offset = sizeof(image_header_t);
    uint32_t address = APP_BASE_ADDR;
    uint32_t remaining = size;
    uint32_t crc = crc32_init();

    flash_unlock();
    if (flash_erase_range(APP_BASE_ADDR, size) != 0)
    {
        flash_lock();
        return -1;
    }

    while (remaining)
    {
        uint32_t chunk = (remaining > sizeof(buffer)) ? sizeof(buffer) : remaining;
        int rc = -1;

        if (source == UPDATE_SOURCE_SD)
            rc = storage_sd_read(offset, buffer, chunk);

        if (rc != 0)
        {
            flash_lock();
            return -1;
        }

        crc = crc32_update(crc, buffer, chunk);

        if (flash_program_buffer(address, buffer, chunk) != 0)
        {
            flash_lock();
            return -1;
        }

        offset += chunk;
        address += chunk;
        remaining -= chunk;
    }

    flash_lock();
    crc = crc32_final(crc);
    return (crc == expected_crc) ? 0 : -1;
}

static int install_sd_update(void)
{
    image_header_t hdr;
    if (!storage_sd_image_present(&hdr)) return -1;
    if (verify_image_crc_streamed(UPDATE_SOURCE_SD, hdr.image_size, hdr.crc32) != 0) return -1;
    if (program_image_from_stream(UPDATE_SOURCE_SD, hdr.image_size, hdr.crc32) != 0) return -1;
    if (!app_vector_valid(APP_BASE_ADDR)) return -1;
    return 0;
}

static int uart_receive_exact(uint8_t *buf, uint32_t len)
{
    return uart_read(buf, len, UART_UPDATE_TIMEOUT_MS);
}

static int uart_send_str(const char *s)
{
    uart_write((const uint8_t *)s, (uint32_t)strlen(s));
    return 0;
}

static int receive_uart_update(void)
{
    image_header_t hdr;
    uint8_t buffer[UART_BLOCK_SIZE];
    uint32_t remaining;
    uint32_t address;
    uint32_t crc;

    uart_send_str("BL:READY\r\n");
    if (uart_receive_exact((uint8_t *)&hdr, sizeof(hdr)) != 0) return -1;
    if (hdr.magic != IMAGE_HEADER_MAGIC) return -1;
    if (hdr.image_size == 0U || hdr.image_size > APP_MAX_SIZE) return -1;

    flash_unlock();
    if (flash_erase_range(APP_BASE_ADDR, hdr.image_size) != 0)
    {
        flash_lock();
        return -1;
    }

    remaining = hdr.image_size;
    address = APP_BASE_ADDR;
    crc = crc32_init();

    while (remaining)
    {
        uint32_t chunk = (remaining > sizeof(buffer)) ? sizeof(buffer) : remaining;
        if (uart_receive_exact(buffer, chunk) != 0)
        {
            flash_lock();
            return -1;
        }
        crc = crc32_update(crc, buffer, chunk);
        if (flash_program_buffer(address, buffer, chunk) != 0)
        {
            flash_lock();
            return -1;
        }
        address += chunk;
        remaining -= chunk;
        uart_putc('.');
    }

    flash_lock();
    crc = crc32_final(crc);
    if (crc != hdr.crc32) return -1;
    if (!app_vector_valid(APP_BASE_ADDR)) return -1;

    uart_send_str("\r\nBL:OK\r\n");
    return 0;
}

static int should_enter_bootloader(void)
{
    if (boot_pin_asserted()) return 1;
    if (recovery_flag_asserted()) return 1;
    if (!app_vector_valid(APP_BASE_ADDR)) return 1;
    return 0;
}

static int sd_update_available_fast(void)
{
    image_header_t hdr;
    return storage_sd_image_present(&hdr);
}

static int uart_update_requested_fast(void)
{
    uint8_t c;
    uart_send_str("BL?\r\n");
    if (uart_getc_timeout(&c, 100U) == 0)
    {
        if (c == 'U') return 1;
    }
    return 0;
}

static void bootloader_main(void)
{
    int updated = 0;

    if (sd_update_available_fast())
    {
        if (install_sd_update() == 0)
            updated = 1;
    }

    if (!updated)
    {
        if (uart_update_requested_fast())
        {
            if (receive_uart_update() == 0)
                updated = 1;
        }
    }

    if (app_vector_valid(APP_BASE_ADDR))
        jump_to_app(APP_BASE_ADDR);

    while (1) {}
}

void bootloader_entry(void)
{
    clock_init();
    uart_init();

    if (!should_enter_bootloader())
    {
        image_header_t hdr;
        if (!storage_sd_image_present(&hdr) && app_vector_valid(APP_BASE_ADDR))
            jump_to_app(APP_BASE_ADDR);
    }

    bootloader_main();
}

int main(void)
{
    bootloader_entry();
    while (1) {}
}

/* Platform hooks to be provided by board support package */
__attribute__((weak)) int sd_read(uint32_t offset, uint8_t *buf, uint32_t len)
{
    (void)offset;
    (void)buf;
    (void)len;
    return -1;
}