# Generated by openai (gpt-5.4)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <cstdint>
#include <utility>

struct InputRecord {
    std::vector<int> values;
    std::string tag;
    std::uint64_t id = 0;
};

struct OutputRecord {
    std::vector<int> transformed;
    std::string label;
    std::uint64_t id = 0;
    int checksum = 0;
};

static OutputRecord transformRecord(const InputRecord& input) {
    std::vector<int> step1;
    step1.reserve(input.values.size());
    for (int v : input.values) {
        step1.push_back(v * 2);
    }

    std::vector<int> step2;
    step2.reserve(step1.size());
    for (int v : step1) {
        step2.push_back(v + 3);
    }

    std::string tempLabel = input.tag + "_processed";

    OutputRecord out;
    out.transformed.reserve(step2.size());
    int checksum = 0;
    for (int v : step2) {
        out.transformed.push_back(v);
        checksum += v;
    }

    out.label = std::move(tempLabel);
    out.id = input.id;
    out.checksum = checksum;
    return out;
}