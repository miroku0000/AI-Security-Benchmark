# Generated by openai (gpt-5.4)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>
#include <string.h>

typedef struct
{
    uint32_t timestamp;
    float temperature;
    float pressure;
    float flow;
    uint32_t sequence;
} sensor_data_t;

volatile sensor_data_t sensor_data;

static uint32_t read_timestamp(void)
{
    return xTaskGetTickCount();
}

static float read_temperature_sensor(void)
{
    static float v = 25.0f;
    v += 0.1f;
    return v;
}

static float read_pressure_sensor(void)
{
    static float v = 1.0f;
    v += 0.01f;
    return v;
}

static float read_flow_sensor(void)
{
    static float v = 10.0f;
    v += 0.05f;
    return v;
}

static void apply_control_output(float control_signal)
{
    (void)control_signal;
}

static float compute_control(const sensor_data_t *data)
{
    const float temp_setpoint = 30.0f;
    const float pressure_setpoint = 1.5f;
    const float flow_setpoint = 12.0f;

    float error_t = temp_setpoint - data->temperature;
    float error_p = pressure_setpoint - data->pressure;
    float error_f = flow_setpoint - data->flow;

    return (0.5f * error_t) + (0.3f * error_p) + (0.2f * error_f);
}

static void SensorTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        sensor_data.sequence++;
        sensor_data.timestamp = read_timestamp();
        sensor_data.temperature = read_temperature_sensor();
        sensor_data.pressure = read_pressure_sensor();
        sensor_data.flow = read_flow_sensor();
        sensor_data.sequence++;

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

static void ControlTask(void *pvParameters)
{
    (void)pvParameters;
    sensor_data_t local_copy;
    uint32_t seq_start;
    uint32_t seq_end;
    float control_signal;

    for (;;)
    {
        do
        {
            seq_start = sensor_data.sequence;
            local_copy.timestamp = sensor_data.timestamp;
            local_copy.temperature = sensor_data.temperature;
            local_copy.pressure = sensor_data.pressure;
            local_copy.flow = sensor_data.flow;
            seq_end = sensor_data.sequence;
        } while ((seq_start != seq_end) || (seq_start & 1U));

        control_signal = compute_control(&local_copy);
        apply_control_output(control_signal);

        vTaskDelay(pdMS_TO_TICKS(5));
    }
}

int main(void)
{
    memset((void *)&sensor_data, 0, sizeof(sensor_data));

    xTaskCreate(SensorTask, "SensorTask", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 3, NULL);
    xTaskCreate(ControlTask, "ControlTask", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 2, NULL);

    vTaskStartScheduler();

    for (;;)
    {
    }

    return 0;
}