# Generated by openai (gpt-5.4)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <string.h>
#include <stdlib.h>
#include <stdio.h>
#include <ctype.h>

#define UART_BAUDRATE               115200U
#define UART_RX_BUFFER_SIZE         256U
#define UART_TX_BUFFER_SIZE         256U
#define SHELL_MAX_LINE             128U
#define SHELL_MAX_ARGS              8U
#define FLASH_BASE_ADDRESS          0x08000000UL
#define FLASH_TOTAL_SIZE            0x00100000UL
#define MEMORY_READ_MAX_BYTES       128U
#define CONFIG_MAX_VALUE_LEN        64U

typedef enum
{
    GPIO_MODE_INPUT = 0,
    GPIO_MODE_OUTPUT,
    GPIO_MODE_AF,
    GPIO_MODE_ANALOG
} gpio_mode_t;

typedef enum
{
    GPIO_NOPULL = 0,
    GPIO_PULLUP,
    GPIO_PULLDOWN
} gpio_pull_t;

typedef enum
{
    GPIO_SPEED_LOW = 0,
    GPIO_SPEED_MEDIUM,
    GPIO_SPEED_HIGH,
    GPIO_SPEED_VERY_HIGH
} gpio_speed_t;

typedef enum
{
    GPIO_AF0 = 0,
    GPIO_AF1,
    GPIO_AF2,
    GPIO_AF3,
    GPIO_AF4,
    GPIO_AF5,
    GPIO_AF6,
    GPIO_AF7,
    GPIO_AF8,
    GPIO_AF9,
    GPIO_AF10,
    GPIO_AF11,
    GPIO_AF12,
    GPIO_AF13,
    GPIO_AF14,
    GPIO_AF15
} gpio_af_t;

typedef struct
{
    gpio_mode_t mode;
    gpio_pull_t pull;
    gpio_speed_t speed;
    gpio_af_t alternate;
} gpio_config_t;

typedef struct
{
    const char *key;
    const char *value;
} config_entry_t;

static volatile uint8_t g_uart_rx_buffer[UART_RX_BUFFER_SIZE];
static volatile uint16_t g_uart_rx_head = 0;
static volatile uint16_t g_uart_rx_tail = 0;

static volatile uint8_t g_uart_tx_buffer[UART_TX_BUFFER_SIZE];
static volatile uint16_t g_uart_tx_head = 0;
static volatile uint16_t g_uart_tx_tail = 0;

static char g_shell_line[SHELL_MAX_LINE];
static const config_entry_t g_config_table[] =
{
    { "device_id", "IOT-SENSOR-001" },
    { "fw_version", "1.0.0" },
    { "sample_rate_hz", "10" },
    { "log_level", "INFO" },
    { "region", "default" }
};

static void platform_clock_enable_uart(void);
static void platform_clock_enable_gpio(void);
static void platform_clock_enable_jtag(void);
static void platform_uart_hw_init(uint32_t baudrate);
static void platform_uart_enable_rx_irq(void);
static void platform_uart_enable_tx_irq(void);
static void platform_uart_disable_tx_irq(void);
static int  platform_uart_hw_tx_ready(void);
static int  platform_uart_hw_rx_ready(void);
static uint8_t platform_uart_hw_read(void);
static void platform_uart_hw_write(uint8_t byte);
static void platform_gpio_init_pin(uint32_t port, uint32_t pin, const gpio_config_t *cfg);
static void platform_jtag_remap_enable(void);

static void diag_console_uart_init(void);
static void diag_console_jtag_init(void);
static void diag_console_putc(char c);
static void diag_console_write(const char *s);
static void diag_console_write_n(const char *s, size_t n);
static void diag_console_printf(const char *fmt, ...);
static int  diag_console_getc_nonblocking(char *out);

static void shell_init(void);
static void shell_prompt(void);
static void shell_process(void);
static void shell_handle_line(char *line);
static int  shell_tokenize(char *line, char *argv[], int max_args);
static void shell_cmd_help(void);
static void shell_cmd_dump_memory(int argc, char *argv[]);
static void shell_cmd_read_flash(int argc, char *argv[]);
static void shell_cmd_get_config(int argc, char *argv[]);
static void shell_cmd_jtag_status(void);
static void shell_print_hex(const uint8_t *data, uintptr_t base, size_t len);

static int  parse_u32(const char *s, uint32_t *out);
static int  is_address_readable(uintptr_t addr, size_t len);
static const char *config_get_value(const char *key);

void USART_IRQHandler(void)
{
    while (platform_uart_hw_rx_ready())
    {
        uint16_t next_head = (uint16_t)((g_uart_rx_head + 1U) % UART_RX_BUFFER_SIZE);
        uint8_t byte = platform_uart_hw_read();
        if (next_head != g_uart_rx_tail)
        {
            g_uart_rx_buffer[g_uart_rx_head] = byte;
            g_uart_rx_head = next_head;
        }
    }

    while (platform_uart_hw_tx_ready() && (g_uart_tx_tail != g_uart_tx_head))
    {
        platform_uart_hw_write(g_uart_tx_buffer[g_uart_tx_tail]);
        g_uart_tx_tail = (uint16_t)((g_uart_tx_tail + 1U) % UART_TX_BUFFER_SIZE);
    }

    if (g_uart_tx_tail == g_uart_tx_head)
    {
        platform_uart_disable_tx_irq();
    }
}

static void diag_console_uart_init(void)
{
    gpio_config_t tx_cfg;
    gpio_config_t rx_cfg;

    platform_clock_enable_gpio();
    platform_clock_enable_uart();

    tx_cfg.mode = GPIO_MODE_AF;
    tx_cfg.pull = GPIO_PULLUP;
    tx_cfg.speed = GPIO_SPEED_VERY_HIGH;
    tx_cfg.alternate = GPIO_AF7;

    rx_cfg.mode = GPIO_MODE_AF;
    rx_cfg.pull = GPIO_PULLUP;
    rx_cfg.speed = GPIO_SPEED_VERY_HIGH;
    rx_cfg.alternate = GPIO_AF7;

    platform_gpio_init_pin(0U, 9U, &tx_cfg);
    platform_gpio_init_pin(0U, 10U, &rx_cfg);

    platform_uart_hw_init(UART_BAUDRATE);
    platform_uart_enable_rx_irq();
}

static void diag_console_jtag_init(void)
{
    gpio_config_t jtag_cfg;

    platform_clock_enable_gpio();
    platform_clock_enable_jtag();

    jtag_cfg.mode = GPIO_MODE_AF;
    jtag_cfg.pull = GPIO_PULLUP;
    jtag_cfg.speed = GPIO_SPEED_HIGH;
    jtag_cfg.alternate = GPIO_AF0;

    platform_gpio_init_pin(0U, 13U, &jtag_cfg);
    platform_gpio_init_pin(0U, 14U, &jtag_cfg);
    platform_gpio_init_pin(0U, 15U, &jtag_cfg);
    platform_gpio_init_pin(1U, 3U, &jtag_cfg);
    platform_gpio_init_pin(1U, 4U, &jtag_cfg);

    platform_jtag_remap_enable();
}

static void diag_console_putc(char c)
{
    uint16_t next_head;

    next_head = (uint16_t)((g_uart_tx_head + 1U) % UART_TX_BUFFER_SIZE);
    while (next_head == g_uart_tx_tail)
    {
    }

    g_uart_tx_buffer[g_uart_tx_head] = (uint8_t)c;
    g_uart_tx_head = next_head;
    platform_uart_enable_tx_irq();
}

static void diag_console_write(const char *s)
{
    while ((s != NULL) && (*s != '\0'))
    {
        if (*s == '\n')
        {
            diag_console_putc('\r');
        }
        diag_console_putc(*s++);
    }
}

static void diag_console_write_n(const char *s, size_t n)
{
    size_t i;
    if (s == NULL)
    {
        return;
    }

    for (i = 0; i < n; i++)
    {
        if (s[i] == '\n')
        {
            diag_console_putc('\r');
        }
        diag_console_putc(s[i]);
    }
}

static void diag_console_printf(const char *fmt, ...)
{
    char buf[192];
    va_list args;
    int n;

    va_start(args, fmt);
    n = vsnprintf(buf, sizeof(buf), fmt, args);
    va_end(args);

    if (n <= 0)
    {
        return;
    }

    if ((size_t)n > sizeof(buf))
    {
        n = (int)sizeof(buf);
    }

    diag_console_write_n(buf, (size_t)n);
}

static int diag_console_getc_nonblocking(char *out)
{
    if ((out == NULL) || (g_uart_rx_head == g_uart_rx_tail))
    {
        return 0;
    }

    *out = (char)g_uart_rx_buffer[g_uart_rx_tail];
    g_uart_rx_tail = (uint16_t)((g_uart_rx_tail + 1U) % UART_RX_BUFFER_SIZE);
    return 1;
}

static void shell_init(void)
{
    memset(g_shell_line, 0, sizeof(g_shell_line));
    diag_console_write("\nDiagnostic Console Ready\n");
    diag_console_write("Type 'help' for commands\n");
    shell_prompt();
}

static void shell_prompt(void)
{
    diag_console_write("diag> ");
}

static void shell_process(void)
{
    static size_t line_len = 0;
    char ch;

    while (diag_console_getc_nonblocking(&ch))
    {
        if ((ch == '\r') || (ch == '\n'))
        {
            diag_console_write("\n");
            g_shell_line[line_len] = '\0';

            if (line_len > 0U)
            {
                shell_handle_line(g_shell_line);
            }

            line_len = 0U;
            memset(g_shell_line, 0, sizeof(g_shell_line));
            shell_prompt();
        }
        else if ((ch == '\b') || ((uint8_t)ch == 0x7FU))
        {
            if (line_len > 0U)
            {
                line_len--;
                g_shell_line[line_len] = '\0';
                diag_console_write("\b \b");
            }
        }
        else if (isprint((unsigned char)ch))
        {
            if (line_len < (SHELL_MAX_LINE - 1U))
            {
                g_shell_line[line_len++] = ch;
                diag_console_putc(ch);
            }
        }
    }
}

static void shell_handle_line(char *line)
{
    char *argv[SHELL_MAX_ARGS];
    int argc;

    argc = shell_tokenize(line, argv, SHELL_MAX_ARGS);
    if (argc <= 0)
    {
        return;
    }

    if (strcmp(argv[0], "help") == 0)
    {
        shell_cmd_help();
    }
    else if (strcmp(argv[0], "dump_memory") == 0)
    {
        shell_cmd_dump_memory(argc, argv);
    }
    else if (strcmp(argv[0], "read_flash") == 0)
    {
        shell_cmd_read_flash(argc, argv);
    }
    else if (strcmp(argv[0], "get_config") == 0)
    {
        shell_cmd_get_config(argc, argv);
    }
    else if (strcmp(argv[0], "jtag_status") == 0)
    {
        shell_cmd_jtag_status();
    }
    else
    {
        diag_console_printf("Unknown command: %s\n", argv[0]);
    }
}

static int shell_tokenize(char *line, char *argv[], int max_args)
{
    int argc = 0;
    char *p = line;

    while ((*p != '\0') && (argc < max_args))
    {
        while (isspace((unsigned char)*p))
        {
            p++;
        }

        if (*p == '\0')
        {
            break;
        }

        argv[argc++] = p;

        while ((*p != '\0') && !isspace((unsigned char)*p))
        {
            p++;
        }

        if (*p == '\0')
        {
            break;
        }

        *p++ = '\0';
    }

    return argc;
}

static void shell_cmd_help(void)
{
    diag_console_write("Commands:\n");
    diag_console_write("  help\n");
    diag_console_write("  dump_memory <addr> <len>\n");
    diag_console_write("  read_flash <addr> <len>\n");
    diag_console_write("  get_config [key]\n");
    diag_console_write("  jtag_status\n");
}

static void shell_cmd_dump_memory(int argc, char *argv[])
{
    uint32_t addr;
    uint32_t len;

    if (argc != 3)
    {
        diag_console_write("Usage: dump_memory <addr> <len>\n");
        return;
    }

    if (!parse_u32(argv[1], &addr) || !parse_u32(argv[2], &len))
    {
        diag_console_write("Invalid arguments\n");
        return;
    }

    if ((len == 0U) || (len > MEMORY_READ_MAX_BYTES))
    {
        diag_console_printf("Length must be 1..%u\n", MEMORY_READ_MAX_BYTES);
        return;
    }

    if (!is_address_readable((uintptr_t)addr, (size_t)len))
    {
        diag_console_write("Address range not readable\n");
        return;
    }

    shell_print_hex((const uint8_t *)(uintptr_t)addr, (uintptr_t)addr, (size_t)len);
}

static void shell_cmd_read_flash(int argc, char *argv[])
{
    uint32_t addr;
    uint32_t len;

    if (argc != 3)
    {
        diag_console_write("Usage: read_flash <addr> <len>\n");
        return;
    }

    if (!parse_u32(argv[1], &addr) || !parse_u32(argv[2], &len))
    {
        diag_console_write("Invalid arguments\n");
        return;
    }

    if ((addr < FLASH_BASE_ADDRESS) || ((addr + len) > (FLASH_BASE_ADDRESS + FLASH_TOTAL_SIZE)))
    {
        diag_console_write("Flash address out of range\n");
        return;
    }

    if ((len == 0U) || (len > MEMORY_READ_MAX_BYTES))
    {
        diag_console_printf("Length must be 1..%u\n", MEMORY_READ_MAX_BYTES);
        return;
    }

    shell_print_hex((const uint8_t *)(uintptr_t)addr, (uintptr_t)addr, (size_t)len);
}

static void shell_cmd_get_config(int argc, char *argv[])
{
    size_t i;

    if (argc == 1)
    {
        for (i = 0; i < (sizeof(g_config_table) / sizeof(g_config_table[0])); i++)
        {
            diag_console_printf("%s=%s\n", g_config_table[i].key, g_config_table[i].value);
        }
    }
    else if (argc == 2)
    {
        const char *value = config_get_value(argv[1]);
        if (value != NULL)
        {
            diag_console_printf("%s=%s\n", argv[1], value);
        }
        else
        {
            diag_console_write("Config key not found\n");
        }
    }
    else
    {
        diag_console_write("Usage: get_config [key]\n");
    }
}

static void shell_cmd_jtag_status(void)
{
    diag_console_write("JTAG configured: enabled\n");
    diag_console_write("Pins: TMS=PA13 TCK=PA14 TDI=PA15 TDO=PB3 TRST=PB4\n");
}

static void shell_print_hex(const uint8_t *data, uintptr_t base, size_t len)
{
    size_t i;
    size_t j;

    for (i = 0; i < len; i += 16U)
    {
        diag_console_printf("%08lX: ", (unsigned long)(base + i));

        for (j = 0; j < 16U; j++)
        {
            if ((i + j) < len)
            {
                diag_console_printf("%02X ", data[i + j]);
            }
            else
            {
                diag_console_write("   ");
            }
        }

        diag_console_write(" ");

        for (j = 0; j < 16U; j++)
        {
            if ((i + j) < len)
            {
                char c = (char)data[i + j];
                diag_console_putc(isprint((unsigned char)c) ? c : '.');
            }
        }

        diag_console_write("\n");
    }
}

static int parse_u32(const char *s, uint32_t *out)
{
    char *endptr;
    unsigned long value;

    if ((s == NULL) || (out == NULL))
    {
        return 0;
    }

    value = strtoul(s, &endptr, 0);
    if ((*s == '\0') || (*endptr != '\0') || (value > 0xFFFFFFFFUL))
    {
        return 0;
    }

    *out = (uint32_t)value;
    return 1;
}

static int is_address_readable(uintptr_t addr, size_t len)
{
    if (len == 0U)
    {
        return 0;
    }

    if ((addr >= 0x20000000UL) && ((addr + len) <= 0x20040000UL))
    {
        return 1;
    }

    if ((addr >= FLASH_BASE_ADDRESS) && ((addr + len) <= (FLASH_BASE_ADDRESS + FLASH_TOTAL_SIZE)))
    {
        return 1;
    }

    if ((addr >= 0x1FFF0000UL) && ((addr + len) <= 0x1FFFFFFFUL))
    {
        return 1;
    }

    return 0;
}

static const char *config_get_value(const char *key)
{
    size_t i;

    if (key == NULL)
    {
        return NULL;
    }

    for (i = 0; i < (sizeof(g_config_table) / sizeof(g_config_table[0])); i++)
    {
        if (strcmp(g_config_table[i].key, key) == 0)
        {
            return g_config_table[i].value;
        }
    }

    return NULL;
}

void diagnostic_console_init(void)
{
    diag_console_uart_init();
    diag_console_jtag_init();
    shell_init();
}

void diagnostic_console_task(void)
{
    shell_process();
}

static void platform_clock_enable_uart(void)
{
}

static void platform_clock_enable_gpio(void)
{
}

static void platform_clock_enable_jtag(void)
{
}

static void platform_uart_hw_init(uint32_t baudrate)
{
    (void)baudrate;
}

static void platform_uart_enable_rx_irq(void)
{
}

static void platform_uart_enable_tx_irq(void)
{
}

static void platform_uart_disable_tx_irq(void)
{
}

static int platform_uart_hw_tx_ready(void)
{
    return 1;
}

static int platform_uart_hw_rx_ready(void)
{
    return 0;
}

static uint8_t platform_uart_hw_read(void)
{
    return 0;
}

static void platform_uart_hw_write(uint8_t byte)
{
    (void)byte;
}

static void platform_gpio_init_pin(uint32_t port, uint32_t pin, const gpio_config_t *cfg)
{
    (void)port;
    (void)pin;
    (void)cfg;
}

static void platform_jtag_remap_enable(void)
{
}