# Generated by openai (gpt-5.4)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>
#include <stdlib.h>

#define UART_RX_BUFFER_SIZE        256U
#define UART_TX_BUFFER_SIZE        256U
#define UART_CMD_MAX_LEN           128U
#define UART_BAUDRATE              115200U

#define FLASH_BASE_ADDR            0x08000000UL
#define FLASH_SIZE_BYTES           (512UL * 1024UL)
#define SRAM_BASE_ADDR             0x20000000UL
#define SRAM_SIZE_BYTES            (128UL * 1024UL)

#define CONFIG_MAGIC               0x43464731UL

#define JTAG_TCK_PIN               0U
#define JTAG_TMS_PIN               1U
#define JTAG_TDI_PIN               2U
#define JTAG_TDO_PIN               3U
#define JTAG_TRST_PIN              4U

typedef struct
{
    uint32_t magic;
    uint32_t device_id;
    uint32_t fw_version;
    uint32_t sample_rate_hz;
    uint32_t flags;
    char serial[24];
} device_config_t;

static volatile uint8_t g_uart_rx_buf[UART_RX_BUFFER_SIZE];
static volatile uint16_t g_uart_rx_head = 0U;
static volatile uint16_t g_uart_rx_tail = 0U;

static char g_cmd_buffer[UART_CMD_MAX_LEN];
static size_t g_cmd_index = 0U;

static const device_config_t g_device_config =
{
    .magic = CONFIG_MAGIC,
    .device_id = 0x1234ABCDUL,
    .fw_version = 0x00010002UL,
    .sample_rate_hz = 1000UL,
    .flags = 0x00000005UL,
    .serial = "SN-IND-000042"
};

static void uart_hw_init(uint32_t baudrate);
static void uart_hw_send_byte(uint8_t byte);
static bool uart_hw_byte_available(void);
static uint8_t uart_hw_read_byte(void);

static void gpio_config_jtag_pin(uint32_t pin);
static void board_enable_debug_power_domain(void);

static void diag_uart_init(void);
static void diag_jtag_init(void);
static void diag_console_task(void);

static void diag_putc(char c);
static void diag_write(const char *s);
static void diag_write_n(const char *s, size_t len);
static void diag_printf(const char *fmt, ...);

static void rx_push_byte(uint8_t byte);
static bool rx_pop_byte(uint8_t *byte);

static void process_input_byte(uint8_t byte);
static void execute_command(char *line);

static void cmd_help(void);
static void cmd_dump_memory(char *args);
static void cmd_read_flash(char *args);
static void cmd_get_config(void);

static bool parse_u32(const char *s, uint32_t *out);
static bool is_valid_memory_range(uint32_t addr, uint32_t len, bool flash_only);
static void hexdump_region(const uint8_t *ptr, uint32_t addr, uint32_t len);

int main(void)
{
    diag_uart_init();
    diag_jtag_init();

    diag_write("\r\nDIAG CONSOLE READY\r\n");
    diag_write("Type 'help' for commands.\r\n> ");

    for (;;)
    {
        diag_console_task();
    }

    return 0;
}

static void diag_uart_init(void)
{
    g_uart_rx_head = 0U;
    g_uart_rx_tail = 0U;
    g_cmd_index = 0U;
    uart_hw_init(UART_BAUDRATE);
}

static void diag_jtag_init(void)
{
    board_enable_debug_power_domain();
    gpio_config_jtag_pin(JTAG_TCK_PIN);
    gpio_config_jtag_pin(JTAG_TMS_PIN);
    gpio_config_jtag_pin(JTAG_TDI_PIN);
    gpio_config_jtag_pin(JTAG_TDO_PIN);
    gpio_config_jtag_pin(JTAG_TRST_PIN);
}

static void diag_console_task(void)
{
    while (uart_hw_byte_available())
    {
        rx_push_byte(uart_hw_read_byte());
    }

    uint8_t byte;
    while (rx_pop_byte(&byte))
    {
        process_input_byte(byte);
    }
}

static void diag_putc(char c)
{
    if (c == '\n')
    {
        uart_hw_send_byte((uint8_t)'\r');
    }
    uart_hw_send_byte((uint8_t)c);
}

static void diag_write(const char *s)
{
    while ((s != NULL) && (*s != '\0'))
    {
        diag_putc(*s++);
    }
}

static void diag_write_n(const char *s, size_t len)
{
    if (s == NULL)
    {
        return;
    }

    for (size_t i = 0U; i < len; ++i)
    {
        diag_putc(s[i]);
    }
}

static void diag_printf(const char *fmt, ...)
{
    char buf[192];
    va_list ap;
    va_start(ap, fmt);
    (void)vsnprintf(buf, sizeof(buf), fmt, ap);
    va_end(ap);
    diag_write(buf);
}

static void rx_push_byte(uint8_t byte)
{
    uint16_t next = (uint16_t)((g_uart_rx_head + 1U) % UART_RX_BUFFER_SIZE);
    if (next != g_uart_rx_tail)
    {
        g_uart_rx_buf[g_uart_rx_head] = byte;
        g_uart_rx_head = next;
    }
}

static bool rx_pop_byte(uint8_t *byte)
{
    if ((byte == NULL) || (g_uart_rx_tail == g_uart_rx_head))
    {
        return false;
    }

    *byte = g_uart_rx_buf[g_uart_rx_tail];
    g_uart_rx_tail = (uint16_t)((g_uart_rx_tail + 1U) % UART_RX_BUFFER_SIZE);
    return true;
}

static void process_input_byte(uint8_t byte)
{
    if ((byte == '\r') || (byte == '\n'))
    {
        diag_write("\r\n");
        g_cmd_buffer[g_cmd_index] = '\0';

        if (g_cmd_index > 0U)
        {
            execute_command(g_cmd_buffer);
        }

        g_cmd_index = 0U;
        diag_write("> ");
        return;
    }

    if ((byte == '\b') || (byte == 0x7FU))
    {
        if (g_cmd_index > 0U)
        {
            g_cmd_index--;
            diag_write("\b \b");
        }
        return;
    }

    if ((byte >= 32U) && (byte <= 126U))
    {
        if (g_cmd_index < (UART_CMD_MAX_LEN - 1U))
        {
            g_cmd_buffer[g_cmd_index++] = (char)byte;
            diag_putc((char)byte);
        }
    }
}

static void execute_command(char *line)
{
    char *cmd = line;
    char *args = NULL;

    while ((*cmd == ' ') || (*cmd == '\t'))
    {
        cmd++;
    }

    args = cmd;
    while ((*args != '\0') && (*args != ' ') && (*args != '\t'))
    {
        args++;
    }

    if (*args != '\0')
    {
        *args++ = '\0';
        while ((*args == ' ') || (*args == '\t'))
        {
            args++;
        }
    }
    else
    {
        args = NULL;
    }

    if (strcmp(cmd, "help") == 0)
    {
        cmd_help();
    }
    else if (strcmp(cmd, "dump_memory") == 0)
    {
        cmd_dump_memory(args);
    }
    else if (strcmp(cmd, "read_flash") == 0)
    {
        cmd_read_flash(args);
    }
    else if (strcmp(cmd, "get_config") == 0)
    {
        cmd_get_config();
    }
    else
    {
        diag_write("ERR unknown command\r\n");
    }
}

static void cmd_help(void)
{
    diag_write("Commands:\r\n");
    diag_write("  help\r\n");
    diag_write("  dump_memory <addr> <len>\r\n");
    diag_write("  read_flash <addr> <len>\r\n");
    diag_write("  get_config\r\n");
}

static void cmd_dump_memory(char *args)
{
    char *arg1;
    char *arg2;
    uint32_t addr;
    uint32_t len;

    if (args == NULL)
    {
        diag_write("ERR usage: dump_memory <addr> <len>\r\n");
        return;
    }

    arg1 = args;
    while ((*args != '\0') && (*args != ' ') && (*args != '\t'))
    {
        args++;
    }

    if (*args == '\0')
    {
        diag_write("ERR usage: dump_memory <addr> <len>\r\n");
        return;
    }

    *args++ = '\0';
    while ((*args == ' ') || (*args == '\t'))
    {
        args++;
    }
    arg2 = args;

    if ((!parse_u32(arg1, &addr)) || (!parse_u32(arg2, &len)))
    {
        diag_write("ERR invalid args\r\n");
        return;
    }

    if ((len == 0U) || (len > 256U))
    {
        diag_write("ERR len out of range\r\n");
        return;
    }

    if (!is_valid_memory_range(addr, len, false))
    {
        diag_write("ERR invalid memory range\r\n");
        return;
    }

    hexdump_region((const uint8_t *)(uintptr_t)addr, addr, len);
}

static void cmd_read_flash(char *args)
{
    char *arg1;
    char *arg2;
    uint32_t addr;
    uint32_t len;

    if (args == NULL)
    {
        diag_write("ERR usage: read_flash <addr> <len>\r\n");
        return;
    }

    arg1 = args;
    while ((*args != '\0') && (*args != ' ') && (*args != '\t'))
    {
        args++;
    }

    if (*args == '\0')
    {
        diag_write("ERR usage: read_flash <addr> <len>\r\n");
        return;
    }

    *args++ = '\0';
    while ((*args == ' ') || (*args == '\t'))
    {
        args++;
    }
    arg2 = args;

    if ((!parse_u32(arg1, &addr)) || (!parse_u32(arg2, &len)))
    {
        diag_write("ERR invalid args\r\n");
        return;
    }

    if ((len == 0U) || (len > 256U))
    {
        diag_write("ERR len out of range\r\n");
        return;
    }

    if (!is_valid_memory_range(addr, len, true))
    {
        diag_write("ERR invalid flash range\r\n");
        return;
    }

    hexdump_region((const uint8_t *)(uintptr_t)addr, addr, len);
}

static void cmd_get_config(void)
{
    diag_printf("magic=0x%08lX\r\n", (unsigned long)g_device_config.magic);
    diag_printf("device_id=0x%08lX\r\n", (unsigned long)g_device_config.device_id);
    diag_printf("fw_version=0x%08lX\r\n", (unsigned long)g_device_config.fw_version);
    diag_printf("sample_rate_hz=%lu\r\n", (unsigned long)g_device_config.sample_rate_hz);
    diag_printf("flags=0x%08lX\r\n", (unsigned long)g_device_config.flags);
    diag_printf("serial=%s\r\n", g_device_config.serial);
}

static bool parse_u32(const char *s, uint32_t *out)
{
    char *endptr;
    unsigned long value;

    if ((s == NULL) || (out == NULL) || (*s == '\0'))
    {
        return false;
    }

    value = strtoul(s, &endptr, 0);
    if (*endptr != '\0')
    {
        return false;
    }

    *out = (uint32_t)value;
    return true;
}

static bool is_valid_memory_range(uint32_t addr, uint32_t len, bool flash_only)
{
    uint32_t end_addr;

    if (len == 0U)
    {
        return false;
    }

    end_addr = addr + len - 1U;
    if (end_addr < addr)
    {
        return false;
    }

    if ((addr >= FLASH_BASE_ADDR) && (end_addr < (FLASH_BASE_ADDR + FLASH_SIZE_BYTES)))
    {
        return true;
    }

    if (!flash_only)
    {
        if ((addr >= SRAM_BASE_ADDR) && (end_addr < (SRAM_BASE_ADDR + SRAM_SIZE_BYTES)))
        {
            return true;
        }
    }

    return false;
}

static void hexdump_region(const uint8_t *ptr, uint32_t addr, uint32_t len)
{
    uint32_t offset = 0U;
    char ascii[17];

    while (offset < len)
    {
        uint32_t line_len = ((len - offset) > 16U) ? 16U : (len - offset);
        diag_printf("%08lX  ", (unsigned long)(addr + offset));

        for (uint32_t i = 0U; i < 16U; ++i)
        {
            if (i < line_len)
            {
                uint8_t b = ptr[offset + i];
                diag_printf("%02X ", b);
                ascii[i] = ((b >= 32U) && (b <= 126U)) ? (char)b : '.';
            }
            else
            {
                diag_write("   ");
                ascii[i] = ' ';
            }
        }

        ascii[16] = '\0';
        diag_write(" ");
        diag_write_n(ascii, 16U);
        diag_write("\r\n");

        offset += line_len;
    }
}

static void uart_hw_init(uint32_t baudrate)
{
    (void)baudrate;
}

static void uart_hw_send_byte(uint8_t byte)
{
    (void)byte;
}

static bool uart_hw_byte_available(void)
{
    return false;
}

static uint8_t uart_hw_read_byte(void)
{
    return 0U;
}

static void gpio_config_jtag_pin(uint32_t pin)
{
    (void)pin;
}

static void board_enable_debug_power_domain(void)
{
}