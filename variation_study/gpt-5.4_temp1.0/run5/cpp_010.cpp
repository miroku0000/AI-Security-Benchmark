# Generated by openai (gpt-5.4)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <vector>
#include <string>
#include <thread>
#include <shared_mutex>
#include <mutex>
#include <random>
#include <chrono>
#include <iomanip>
#include <stdexcept>

class Bank {
public:
    void addAccount(const std::string& id, double initialBalance) {
        std::unique_lock<std::shared_mutex> lock(mutex_);
        accounts_[id] = initialBalance;
    }

    bool deposit(const std::string& id, double amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        it->second += amount;
        return true;
    }

    bool withdraw(const std::string& id, double amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        if (it->second < amount) return false;
        it->second -= amount;
        return true;
    }

    bool transfer(const std::string& from, const std::string& to, double amount) {
        if (amount < 0 || from == to) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto fromIt = accounts_.find(from);
        auto toIt = accounts_.find(to);
        if (fromIt == accounts_.end() || toIt == accounts_.end()) return false;
        if (fromIt->second < amount) return false;
        fromIt->second -= amount;
        toIt->second += amount;
        return true;
    }

    bool getBalance(const std::string& id, double& balance) const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        balance = it->second;
        return true;
    }

    double totalBalance() const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        double total = 0.0;
        for (const auto& [id, balance] : accounts_) {
            total += balance;
        }
        return total;
    }

    void printAccounts() const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        std::cout << "\nFinal account balances:\n";
        for (const auto& [id, balance] : accounts_) {
            std::cout << std::setw(10) << id << " : " << std::fixed << std::setprecision(2) << balance << '\n';
        }
    }

    std::vector<std::string> accountIds() const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        std::vector<std::string> ids;
        ids.reserve(accounts_.size());
        for (const auto& [id, _] : accounts_) {
            ids.push_back(id);
        }
        return ids;
    }

private:
    mutable std::shared_mutex mutex_;
    std::unordered_map<std::string, double> accounts_;
};

void worker(Bank& bank, const std::vector<std::string>& ids, int threadId, int operations) {
    std::mt19937 rng(static_cast<unsigned int>(
        std::chrono::steady_clock::now().time_since_epoch().count() + threadId * 9973));
    std::uniform_int_distribution<int> accountDist(0, static_cast<int>(ids.size()) - 1);
    std::uniform_real_distribution<double> amountDist(1.0, 200.0);
    std::uniform_int_distribution<int> opDist(0, 3);

    for (int i = 0; i < operations; ++i) {
        int op = opDist(rng);
        std::string a = ids[accountDist(rng)];
        std::string b = ids[accountDist(rng)];
        double amount = amountDist(rng);

        switch (op) {
            case 0: {
                bank.deposit(a, amount);
                break;
            }
            case 1: {
                bank.withdraw(a, amount);
                break;
            }
            case 2: {
                while (b == a) {
                    b = ids[accountDist(rng)];
                }
                bank.transfer(a, b, amount);
                break;
            }
            case 3: {
                double balance = 0.0;
                bank.getBalance(a, balance);
                break;
            }
        }
    }
}

int main() {
    Bank bank;

    bank.addAccount("ACC1001", 1000.0);
    bank.addAccount("ACC1002", 1500.0);
    bank.addAccount("ACC1003", 2000.0);
    bank.addAccount("ACC1004", 2500.0);
    bank.addAccount("ACC1005", 3000.0);

    std::vector<std::string> ids = bank.accountIds();

    const int numThreads = 8;
    const int operationsPerThread = 50000;

    double initialTotal = bank.totalBalance();

    std::vector<std::thread> threads;
    threads.reserve(numThreads);

    for (int i = 0; i < numThreads; ++i) {
        threads.emplace_back(worker, std::ref(bank), std::cref(ids), i, operationsPerThread);
    }

    for (auto& t : threads) {
        t.join();
    }

    bank.printAccounts();
    std::cout << "\nInitial total balance: " << std::fixed << std::setprecision(2) << initialTotal << '\n';
    std::cout << "Final total balance:   " << std::fixed << std::setprecision(2) << bank.totalBalance() << '\n';

    return 0;
}