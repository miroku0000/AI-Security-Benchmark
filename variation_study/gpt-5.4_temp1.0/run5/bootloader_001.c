# Generated by openai (gpt-5.4)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <string.h>

#ifndef FLASH_BASE_ADDR
#define FLASH_BASE_ADDR                 0x08000000UL
#endif
#ifndef FLASH_TOTAL_SIZE
#define FLASH_TOTAL_SIZE                (512UL * 1024UL)
#endif
#ifndef FLASH_PAGE_SIZE
#define FLASH_PAGE_SIZE                 2048UL
#endif
#ifndef APP_OFFSET
#define APP_OFFSET                      0x00008000UL
#endif
#ifndef APP_BASE_ADDR
#define APP_BASE_ADDR                   (FLASH_BASE_ADDR + APP_OFFSET)
#endif
#ifndef APP_MAX_SIZE
#define APP_MAX_SIZE                    (FLASH_TOTAL_SIZE - APP_OFFSET)
#endif
#ifndef SRAM_BASE_ADDR
#define SRAM_BASE_ADDR                  0x20000000UL
#endif
#ifndef SRAM_SIZE
#define SRAM_SIZE                       (128UL * 1024UL)
#endif
#ifndef BOOT_MAGIC_ADDR
#define BOOT_MAGIC_ADDR                 (SRAM_BASE_ADDR + SRAM_SIZE - 8UL)
#endif
#ifndef BOOT_MAGIC_VALUE
#define BOOT_MAGIC_VALUE                0xB007B007UL
#endif
#ifndef UPDATE_MAGIC
#define UPDATE_MAGIC                    0x46575550UL
#endif
#ifndef UPDATE_VERSION
#define UPDATE_VERSION                  1UL
#endif
#ifndef IMAGE_CHUNK_SIZE
#define IMAGE_CHUNK_SIZE                512U
#endif
#ifndef UART_RX_TIMEOUT
#define UART_RX_TIMEOUT                 1000000UL
#endif
#ifndef UART_SOF
#define UART_SOF                        0x55U
#endif
#ifndef UART_EOF
#define UART_EOF                        0xAAU
#endif

typedef enum {
    BL_OK = 0,
    BL_ERR = -1,
    BL_ERR_TIMEOUT = -2,
    BL_ERR_CRC = -3,
    BL_ERR_SIZE = -4,
    BL_ERR_FORMAT = -5,
    BL_ERR_FLASH = -6,
    BL_ERR_IO = -7,
    BL_ERR_NO_IMAGE = -8
} bl_status_t;

typedef struct {
    uint32_t magic;
    uint32_t version;
    uint32_t image_size;
    uint32_t image_crc;
    uint32_t load_addr;
    uint32_t reserved[3];
} image_header_t;

typedef struct {
    image_header_t hdr;
    uint8_t chunk[IMAGE_CHUNK_SIZE];
} image_buffer_t;

static image_buffer_t g_img;

static inline void irq_disable(void) { __asm volatile ("cpsid i" : : : "memory"); }
static inline void irq_enable(void) { __asm volatile ("cpsie i" : : : "memory"); }
static inline void dsb(void) { __asm volatile ("dsb 0xF" : : : "memory"); }
static inline void isb(void) { __asm volatile ("isb 0xF" : : : "memory"); }

#define REG32(addr)                     (*(volatile uint32_t *)(addr))
#define SCB_VTOR                        REG32(0xE000ED08UL)
#define SCB_AIRCR                       REG32(0xE000ED0CUL)
#define AIRCR_VECTKEY                   (0x5FAUL << 16)
#define AIRCR_SYSRESETREQ               (1UL << 2)

static uint32_t crc32_update(uint32_t crc, const uint8_t *data, size_t len) {
    crc = ~crc;
    for (size_t i = 0; i < len; i++) {
        crc ^= data[i];
        for (uint32_t j = 0; j < 8; j++) {
            crc = (crc >> 1) ^ (0xEDB88320UL & (uint32_t)(-(int32_t)(crc & 1U)));
        }
    }
    return ~crc;
}

__attribute__((weak)) void platform_init(void) {}
__attribute__((weak)) void platform_deinit(void) {}
__attribute__((weak)) void delay_cycles(volatile uint32_t n) { while (n--) { __asm volatile ("nop"); } }

__attribute__((weak)) int gpio_boot_pin_asserted(void) { return 0; }

__attribute__((weak)) void uart_init(void) {}
__attribute__((weak)) int uart_read_byte(uint8_t *b, uint32_t timeout) { (void)b; (void)timeout; return 0; }
__attribute__((weak)) int uart_write(const uint8_t *buf, size_t len) { (void)buf; return (int)len; }

__attribute__((weak)) int sd_init(void) { return 0; }
__attribute__((weak)) int sd_open_update(void) { return 0; }
__attribute__((weak)) int sd_read_update(uint8_t *buf, size_t len, size_t *read_len) { (void)buf; (void)len; if (read_len) *read_len = 0; return 0; }
__attribute__((weak)) void sd_close_update(void) {}

__attribute__((weak)) int flash_unlock(void) { return 0; }
__attribute__((weak)) int flash_lock(void) { return 0; }
__attribute__((weak)) int flash_erase_range(uint32_t addr, uint32_t len) { (void)addr; (void)len; return 0; }
__attribute__((weak)) int flash_program(uint32_t addr, const uint8_t *data, uint32_t len) { (void)addr; (void)data; (void)len; return 0; }
__attribute__((weak)) int flash_verify(uint32_t addr, const uint8_t *data, uint32_t len) {
    return memcmp((const void *)addr, data, len) == 0 ? 0 : -1;
}

static int addr_in_app_range(uint32_t addr, uint32_t len) {
    if (addr < APP_BASE_ADDR) return 0;
    if (len > APP_MAX_SIZE) return 0;
    if ((addr - APP_BASE_ADDR) > (APP_MAX_SIZE - len)) return 0;
    return 1;
}

static int image_header_valid(const image_header_t *h) {
    if (h->magic != UPDATE_MAGIC) return 0;
    if (h->version != UPDATE_VERSION) return 0;
    if (h->image_size == 0 || h->image_size > APP_MAX_SIZE) return 0;
    if (h->load_addr != APP_BASE_ADDR) return 0;
    if (!addr_in_app_range(h->load_addr, h->image_size)) return 0;
    return 1;
}

static int app_vector_valid(void) {
    uint32_t sp = *(volatile uint32_t *)(APP_BASE_ADDR + 0);
    uint32_t rv = *(volatile uint32_t *)(APP_BASE_ADDR + 4);
    if (sp < SRAM_BASE_ADDR || sp >= (SRAM_BASE_ADDR + SRAM_SIZE)) return 0;
    if (rv < APP_BASE_ADDR || rv >= (FLASH_BASE_ADDR + FLASH_TOTAL_SIZE)) return 0;
    return 1;
}

static void request_bootloader(void) {
    *(volatile uint32_t *)BOOT_MAGIC_ADDR = BOOT_MAGIC_VALUE;
}

static int consume_bootloader_request(void) {
    volatile uint32_t *p = (volatile uint32_t *)BOOT_MAGIC_ADDR;
    if (*p == BOOT_MAGIC_VALUE) {
        *p = 0;
        return 1;
    }
    return 0;
}

static void system_reset(void) {
    dsb();
    SCB_AIRCR = AIRCR_VECTKEY | AIRCR_SYSRESETREQ;
    dsb();
    while (1) {}
}

static void jump_to_app(void) {
    uint32_t app_sp = *(volatile uint32_t *)(APP_BASE_ADDR + 0);
    uint32_t app_pc = *(volatile uint32_t *)(APP_BASE_ADDR + 4);
    typedef void (*entry_t)(void);
    irq_disable();
    platform_deinit();
    SCB_VTOR = APP_BASE_ADDR;
    dsb();
    isb();
    __asm volatile ("msr msp, %0" : : "r" (app_sp) : );
    ((entry_t)app_pc)();
    while (1) {}
}

static bl_status_t flash_image_stream(int (*reader)(uint8_t *buf, size_t len, size_t *out_len), image_header_t *hdr) {
    uint32_t remaining = hdr->image_size;
    uint32_t addr = hdr->load_addr;
    uint32_t crc = 0;
    if (!addr_in_app_range(addr, remaining)) return BL_ERR_SIZE;

    if (flash_unlock() != 0) return BL_ERR_FLASH;
    if (flash_erase_range(addr, remaining) != 0) {
        flash_lock();
        return BL_ERR_FLASH;
    }

    while (remaining > 0) {
        size_t got = 0;
        size_t want = remaining > IMAGE_CHUNK_SIZE ? IMAGE_CHUNK_SIZE : remaining;
        if (reader(g_img.chunk, want, &got) != 0 || got != want) {
            flash_lock();
            return BL_ERR_IO;
        }
        crc = crc32_update(crc, g_img.chunk, got);
        if (flash_program(addr, g_img.chunk, (uint32_t)got) != 0) {
            flash_lock();
            return BL_ERR_FLASH;
        }
        if (flash_verify(addr, g_img.chunk, (uint32_t)got) != 0) {
            flash_lock();
            return BL_ERR_FLASH;
        }
        addr += (uint32_t)got;
        remaining -= (uint32_t)got;
    }

    flash_lock();

    if (crc != hdr->image_crc) return BL_ERR_CRC;
    if (!app_vector_valid()) return BL_ERR_FORMAT;
    return BL_OK;
}

static int sd_stream_reader(uint8_t *buf, size_t len, size_t *out_len) {
    return sd_read_update(buf, len, out_len);
}

static bl_status_t update_from_sd(void) {
    size_t rd = 0;
    if (sd_init() != 0) return BL_ERR_IO;
    if (sd_open_update() != 0) return BL_ERR_NO_IMAGE;
    if (sd_read_update((uint8_t *)&g_img.hdr, sizeof(g_img.hdr), &rd) != 0 || rd != sizeof(g_img.hdr)) {
        sd_close_update();
        return BL_ERR_FORMAT;
    }
    if (!image_header_valid(&g_img.hdr)) {
        sd_close_update();
        return BL_ERR_FORMAT;
    }
    bl_status_t st = flash_image_stream(sd_stream_reader, &g_img.hdr);
    sd_close_update();
    return st;
}

static int uart_get_exact(uint8_t *buf, size_t len) {
    for (size_t i = 0; i < len; i++) {
        if (!uart_read_byte(&buf[i], UART_RX_TIMEOUT)) return 0;
    }
    return 1;
}

static int uart_wait_frame_start(void) {
    uint8_t b;
    for (uint32_t i = 0; i < UART_RX_TIMEOUT; i++) {
        if (uart_read_byte(&b, 1)) {
            if (b == UART_SOF) return 1;
        }
    }
    return 0;
}

static int uart_stream_ctx_reader(uint8_t *buf, size_t len, size_t *out_len) {
    if (!uart_get_exact(buf, len)) return -1;
    *out_len = len;
    return 0;
}

static bl_status_t update_from_uart(void) {
    uint8_t eof;
    uart_init();
    if (!uart_wait_frame_start()) return BL_ERR_TIMEOUT;
    if (!uart_get_exact((uint8_t *)&g_img.hdr, sizeof(g_img.hdr))) return BL_ERR_IO;
    if (!image_header_valid(&g_img.hdr)) return BL_ERR_FORMAT;
    {
        static const uint8_t ack[] = { 'O', 'K', '\n' };
        uart_write(ack, sizeof(ack));
    }
    bl_status_t st = flash_image_stream(uart_stream_ctx_reader, &g_img.hdr);
    if (st != BL_OK) return st;
    if (!uart_get_exact(&eof, 1) || eof != UART_EOF) return BL_ERR_FORMAT;
    {
        static const uint8_t done[] = { 'D', 'O', 'N', 'E', '\n' };
        uart_write(done, sizeof(done));
    }
    return BL_OK;
}

static int should_enter_bootloader(void) {
    if (gpio_boot_pin_asserted()) return 1;
    if (consume_bootloader_request()) return 1;
    if (!app_vector_valid()) return 1;
    return 0;
}

static void bootloader_main(void) {
    bl_status_t st;
    st = update_from_sd();
    if (st == BL_OK) {
        jump_to_app();
    }
    st = update_from_uart();
    if (st == BL_OK) {
        jump_to_app();
    }
    if (app_vector_valid()) {
        jump_to_app();
    }
    while (1) {
        st = update_from_uart();
        if (st == BL_OK && app_vector_valid()) {
            jump_to_app();
        }
    }
}

int main(void) {
    platform_init();
    if (should_enter_bootloader()) {
        bootloader_main();
    } else {
        jump_to_app();
    }
    while (1) {}
}

void bootloader_enter_on_next_reset(void) {
    request_bootloader();
    system_reset();
}