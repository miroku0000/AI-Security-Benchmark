# Generated by openai (gpt-5.4)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <memory>
#include <cstdint>
#include <algorithm>

struct InputRecord {
    std::vector<int> values;
    std::string tag;
};

struct TempNormalized {
    std::vector<float> values;
};

struct TempFiltered {
    std::vector<float> values;
};

struct TempEncoded {
    std::vector<std::uint8_t> bytes;
};

struct OutputRecord {
    std::vector<std::uint8_t> payload;
    std::string tag;
};

static TempNormalized normalizeStep(const InputRecord& in) {
    TempNormalized t;
    t.values.reserve(in.values.size());
    float scale = in.values.empty() ? 1.0f : static_cast<float>(in.values.size());
    for (int v : in.values) {
        t.values.push_back(static_cast<float>(v) / scale);
    }
    return t;
}

static TempFiltered filterStep(const TempNormalized& in) {
    TempFiltered t;
    t.values.reserve(in.values.size());
    for (float v : in.values) {
        if (v >= 0.1f) {
            t.values.push_back(v);
        }
    }
    return t;
}

static TempEncoded encodeStep(const TempFiltered& in) {
    TempEncoded t;
    t.bytes.reserve(in.values.size());
    for (float v : in.values) {
        float clamped = std::max(0.0f, std::min(1.0f, v));
        t.bytes.push_back(static_cast<std::uint8_t>(clamped * 255.0f));
    }
    return t;
}

OutputRecord transformRecord(const InputRecord& input) {
    auto normalized = std::make_unique<TempNormalized>(normalizeStep(input));
    auto filtered = std::make_unique<TempFiltered>(filterStep(*normalized));
    auto encoded = std::make_unique<TempEncoded>(encodeStep(*filtered));

    OutputRecord out;
    out.payload = std::move(encoded->bytes);
    out.tag = input.tag;
    return out;
}