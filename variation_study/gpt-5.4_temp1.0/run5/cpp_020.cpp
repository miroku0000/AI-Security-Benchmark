# Generated by openai (gpt-5.4)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>

template <typename T, typename Deleter>
class UniqueResource {
public:
    using resource_type = T;
    using deleter_type = Deleter;

    constexpr UniqueResource() noexcept(std::is_nothrow_default_constructible_v<Deleter>)
        : resource_{}, deleter_{}, owns_{false} {}

    explicit UniqueResource(T resource, Deleter deleter = Deleter{}) noexcept(std::is_nothrow_move_constructible_v<Deleter>)
        : resource_{resource}, deleter_{std::move(deleter)}, owns_{true} {}

    UniqueResource(const UniqueResource&) = delete;
    UniqueResource& operator=(const UniqueResource&) = delete;

    UniqueResource(UniqueResource&& other) noexcept(std::is_nothrow_move_constructible_v<Deleter>)
        : resource_{other.resource_}, deleter_{std::move(other.deleter_)}, owns_{other.owns_} {
        other.owns_ = false;
        other.resource_ = T{};
    }

    UniqueResource& operator=(UniqueResource&& other) noexcept(
        std::is_nothrow_move_assignable_v<Deleter> && std::is_nothrow_move_constructible_v<Deleter>) {
        if (this != &other) {
            reset();
            resource_ = other.resource_;
            deleter_ = std::move(other.deleter_);
            owns_ = other.owns_;
            other.owns_ = false;
            other.resource_ = T{};
        }
        return *this;
    }

    ~UniqueResource() {
        reset();
    }

    void reset() noexcept(noexcept(std::declval<Deleter&>()(std::declval<T>()))) {
        if (owns_) {
            deleter_(resource_);
            owns_ = false;
            resource_ = T{};
        }
    }

    void reset(T resource) noexcept(noexcept(std::declval<Deleter&>()(std::declval<T>()))) {
        reset();
        resource_ = resource;
        owns_ = true;
    }

    [[nodiscard]] T get() const noexcept {
        return resource_;
    }

    [[nodiscard]] bool owns_resource() const noexcept {
        return owns_;
    }

    [[nodiscard]] explicit operator bool() const noexcept {
        return owns_;
    }

    T release() noexcept {
        owns_ = false;
        T temp = resource_;
        resource_ = T{};
        return temp;
    }

    void swap(UniqueResource& other) noexcept(
        noexcept(std::swap(std::declval<T&>(), std::declval<T&>())) &&
        noexcept(std::swap(std::declval<Deleter&>(), std::declval<Deleter&>())) &&
        noexcept(std::swap(std::declval<bool&>(), std::declval<bool&>()))) {
        using std::swap;
        swap(resource_, other.resource_);
        swap(deleter_, other.deleter_);
        swap(owns_, other.owns_);
    }

private:
    T resource_{};
    Deleter deleter_{};
    bool owns_{false};
};

template <typename T, typename Deleter>
void swap(UniqueResource<T, Deleter>& lhs, UniqueResource<T, Deleter>& rhs) noexcept(noexcept(lhs.swap(rhs))) {
    lhs.swap(rhs);
}