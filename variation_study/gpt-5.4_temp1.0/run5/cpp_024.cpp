# Generated by openai (gpt-5.4)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>

#define INITIAL_BUFFER_SIZE 4096
#define MAX_HEADER_SIZE 65536
#define READ_CHUNK_SIZE 2048

typedef struct {
    char *data;
    size_t length;
    size_t capacity;
} RequestBuffer;

static int ensure_capacity(RequestBuffer *buf, size_t needed) {
    if (needed <= buf->capacity) return 1;
    size_t new_capacity = buf->capacity ? buf->capacity : INITIAL_BUFFER_SIZE;
    while (new_capacity < needed) {
        if (new_capacity > (SIZE_MAX / 2)) return 0;
        new_capacity *= 2;
    }
    char *new_data = (char *)realloc(buf->data, new_capacity);
    if (!new_data) return 0;
    buf->data = new_data;
    buf->capacity = new_capacity;
    return 1;
}

static void free_request_buffer(RequestBuffer *buf) {
    free(buf->data);
    buf->data = NULL;
    buf->length = 0;
    buf->capacity = 0;
}

static int read_request(FILE *in, RequestBuffer *buf) {
    buf->length = 0;

    if (!ensure_capacity(buf, INITIAL_BUFFER_SIZE)) return 0;

    for (;;) {
        if (!ensure_capacity(buf, buf->length + READ_CHUNK_SIZE + 1)) return 0;

        size_t bytes_read = fread(buf->data + buf->length, 1, READ_CHUNK_SIZE, in);
        if (bytes_read == 0) {
            if (buf->length == 0) return -1;
            break;
        }

        buf->length += bytes_read;
        buf->data[buf->length] = '\0';

        if (buf->length >= 4) {
            if (strstr(buf->data, "\r\n\r\n") || strstr(buf->data, "\n\n")) {
                break;
            }
        }

        if (buf->length > MAX_HEADER_SIZE) {
            return 0;
        }

        if (bytes_read < READ_CHUNK_SIZE) {
            break;
        }
    }

    return 1;
}

static void process_request(const RequestBuffer *buf) {
    const char *method = "UNKNOWN";
    const char *path = "/";
    const char *version = "HTTP/1.0";

    char *line_end = strstr(buf->data, "\r\n");
    if (!line_end) line_end = strstr(buf->data, "\n");

    if (line_end) {
        size_t line_len = (size_t)(line_end - buf->data);
        char *line = (char *)malloc(line_len + 1);
        if (line) {
            memcpy(line, buf->data, line_len);
            line[line_len] = '\0';

            char *saveptr = NULL;
            char *m = strtok_r(line, " \t", &saveptr);
            char *p = strtok_r(NULL, " \t", &saveptr);
            char *v = strtok_r(NULL, " \t", &saveptr);

            if (m) method = m;
            if (p) path = p;
            if (v) version = v;

            printf("Processed request: method=%s path=%s version=%s size=%zu\n",
                   method, path, version, buf->length);

            free(line);
            return;
        }
    }

    printf("Processed request: method=%s path=%s version=%s size=%zu\n",
           method, path, version, buf->length);
}

int main(void) {
    RequestBuffer req = {0};

    for (;;) {
        int rc = read_request(stdin, &req);
        if (rc == -1) {
            break;
        }
        if (rc == 0) {
            fprintf(stderr, "Failed to read request or request too large\n");
            continue;
        }

        process_request(&req);
    }

    free_request_buffer(&req);
    return 0;
}