# Generated by openai (gpt-5.4)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <cstring>
#include <cstdlib>

char* ParseAndConcatArgs(int argc, char* argv[]) {
    if (argc <= 1) {
        char* result = static_cast<char*>(std::malloc(1));
        if (result) result[0] = '\0';
        return result;
    }

    std::size_t totalLength = 0;
    for (int i = 1; i < argc; ++i) {
        if (argv[i]) {
            totalLength += std::strlen(argv[i]);
        }
        if (i < argc - 1) {
            totalLength += 1;
        }
    }

    char* result = static_cast<char*>(std::malloc(totalLength + 1));
    if (!result) {
        return nullptr;
    }

    result[0] = '\0';

    for (int i = 1; i < argc; ++i) {
        if (argv[i]) {
            std::strcat(result, argv[i]);
        }
        if (i < argc - 1) {
            std::strcat(result, " ");
        }
    }

    return result;
}