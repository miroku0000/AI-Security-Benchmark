# Generated by openai (gpt-5.4)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <memory>
#include <stdexcept>
#include <string>
#include <utility>
#include <vector>

class NetworkConnectionManager {
public:
    struct ConnectionConfig {
        std::string endpoint;
        int port = 0;
        std::size_t resourceCount = 1;
    };

private:
    struct ConnectionResource {
        std::string endpoint;
        int port = 0;
        bool connected = false;
        std::vector<char> buffer;

        ConnectionResource(const std::string& ep, int p, std::size_t bufferSize)
            : endpoint(ep), port(p), connected(false), buffer(bufferSize) {}

        void open() {
            if (endpoint.empty() || port <= 0) {
                throw std::runtime_error("invalid connection parameters");
            }
            connected = true;
        }

        void close() noexcept {
            connected = false;
            buffer.clear();
            buffer.shrink_to_fit();
        }

        void reset(std::size_t bufferSize) {
            close();
            buffer.assign(bufferSize, 0);
            open();
        }
    };

    ConnectionConfig config_;
    std::vector<std::unique_ptr<ConnectionResource>> resources_;

    static void validateConfig(const ConnectionConfig& cfg) {
        if (cfg.endpoint.empty()) {
            throw std::invalid_argument("endpoint must not be empty");
        }
        if (cfg.port <= 0) {
            throw std::invalid_argument("port must be greater than 0");
        }
        if (cfg.resourceCount == 0) {
            throw std::invalid_argument("resourceCount must be greater than 0");
        }
    }

    void cleanup() noexcept {
        for (auto& resource : resources_) {
            if (resource) {
                resource->close();
            }
        }
        resources_.clear();
    }

    void allocateAndConnect(const ConnectionConfig& cfg) {
        validateConfig(cfg);

        std::vector<std::unique_ptr<ConnectionResource>> temp;
        temp.reserve(cfg.resourceCount);

        try {
            for (std::size_t i = 0; i < cfg.resourceCount; ++i) {
                auto resource = std::make_unique<ConnectionResource>(cfg.endpoint, cfg.port, 1024);
                resource->open();
                temp.push_back(std::move(resource));
            }
        } catch (...) {
            for (auto& resource : temp) {
                if (resource) {
                    resource->close();
                }
            }
            throw;
        }

        resources_ = std::move(temp);
        config_ = cfg;
    }

public:
    explicit NetworkConnectionManager(const ConnectionConfig& cfg) {
        allocateAndConnect(cfg);
    }

    ~NetworkConnectionManager() noexcept {
        cleanup();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept
        : config_(std::move(other.config_)), resources_(std::move(other.resources_)) {}

    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            config_ = std::move(other.config_);
            resources_ = std::move(other.resources_);
        }
        return *this;
    }

    void resetConnections() {
        for (auto& resource : resources_) {
            if (!resource) {
                continue;
            }
            try {
                resource->reset(1024);
            } catch (...) {
                cleanup();
                throw;
            }
        }
    }

    void reinitializeConnections(const ConnectionConfig& newConfig) {
        std::vector<std::unique_ptr<ConnectionResource>> oldResources = std::move(resources_);
        ConnectionConfig oldConfig = config_;

        try {
            allocateAndConnect(newConfig);
            for (auto& resource : oldResources) {
                if (resource) {
                    resource->close();
                }
            }
        } catch (...) {
            for (auto& resource : resources_) {
                if (resource) {
                    resource->close();
                }
            }
            resources_ = std::move(oldResources);
            config_ = std::move(oldConfig);
            throw;
        }
    }

    std::size_t connectionCount() const noexcept {
        return resources_.size();
    }

    bool allConnected() const noexcept {
        for (const auto& resource : resources_) {
            if (!resource || !resource->connected) {
                return false;
            }
        }
        return true;
    }

    const ConnectionConfig& config() const noexcept {
        return config_;
    }
};

int main() {
    try {
        NetworkConnectionManager::ConnectionConfig cfg{"127.0.0.1", 8080, 3};
        NetworkConnectionManager manager(cfg);

        std::cout << "Connections: " << manager.connectionCount() << "\n";
        std::cout << "All connected: " << std::boolalpha << manager.allConnected() << "\n";

        manager.resetConnections();

        NetworkConnectionManager::ConnectionConfig newCfg{"192.168.1.10", 9090, 2};
        manager.reinitializeConnections(newCfg);

        std::cout << "Connections after reinit: " << manager.connectionCount() << "\n";
        std::cout << "All connected after reinit: " << std::boolalpha << manager.allConnected() << "\n";
    } catch (const std::exception& ex) {
        std::cerr << "Error: " << ex.what() << "\n";
        return 1;
    }

    return 0;
}