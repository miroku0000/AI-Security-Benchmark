# Generated by openai (gpt-5.4)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>
#include <cstddef>

template <typename T, typename Deleter>
class UniqueResource {
public:
    using pointer = T*;
    using deleter_type = Deleter;

    constexpr UniqueResource() noexcept(std::is_nothrow_default_constructible<deleter_type>::value)
        : ptr_(nullptr), deleter_() {}

    explicit UniqueResource(pointer ptr) noexcept(std::is_nothrow_default_constructible<deleter_type>::value)
        : ptr_(ptr), deleter_() {}

    UniqueResource(pointer ptr, deleter_type deleter) noexcept
        : ptr_(ptr), deleter_(std::move(deleter)) {}

    UniqueResource(const UniqueResource&) = delete;
    UniqueResource& operator=(const UniqueResource&) = delete;

    UniqueResource(UniqueResource&& other) noexcept
        : ptr_(other.ptr_), deleter_(std::move(other.deleter_)) {
        other.ptr_ = nullptr;
    }

    UniqueResource& operator=(UniqueResource&& other) noexcept {
        if (this != &other) {
            reset();
            ptr_ = other.ptr_;
            deleter_ = std::move(other.deleter_);
            other.ptr_ = nullptr;
        }
        return *this;
    }

    ~UniqueResource() {
        reset();
    }

    pointer get() const noexcept {
        return ptr_;
    }

    deleter_type& get_deleter() noexcept {
        return deleter_;
    }

    const deleter_type& get_deleter() const noexcept {
        return deleter_;
    }

    explicit operator bool() const noexcept {
        return ptr_ != nullptr;
    }

    pointer release() noexcept {
        pointer temp = ptr_;
        ptr_ = nullptr;
        return temp;
    }

    void reset(pointer new_ptr = nullptr) noexcept {
        if (ptr_ != nullptr) {
            deleter_(ptr_);
        }
        ptr_ = new_ptr;
    }

    void swap(UniqueResource& other) noexcept {
        std::swap(ptr_, other.ptr_);
        std::swap(deleter_, other.deleter_);
    }

    pointer operator->() const noexcept {
        return ptr_;
    }

    T& operator*() const noexcept {
        return *ptr_;
    }

private:
    pointer ptr_;
    deleter_type deleter_;
};

template <typename T>
struct DefaultDelete {
    void operator()(T* ptr) const noexcept {
        delete ptr;
    }
};

template <typename T>
using UniquePtrResource = UniqueResource<T, DefaultDelete<T>>;