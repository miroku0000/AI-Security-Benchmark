# Generated by openai (gpt-5.4)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct FileNode {
    FILE *file;
    struct FileNode *next;
} FileNode;

typedef struct FileHandleList {
    FileNode *head;
} FileHandleList;

void fhlist_init(FileHandleList *list) {
    if (!list) return;
    list->head = NULL;
}

int fhlist_add(FileHandleList *list, FILE *file) {
    FileNode *node;
    if (!list || !file) return 0;

    node = (FileNode *)malloc(sizeof(FileNode));
    if (!node) return 0;

    node->file = file;
    node->next = list->head;
    list->head = node;
    return 1;
}

int fhlist_remove(FileHandleList *list, FILE *file, int close_file) {
    FileNode *prev;
    FileNode *cur;

    if (!list || !file) return 0;

    prev = NULL;
    cur = list->head;

    while (cur) {
        if (cur->file == file) {
            if (prev) {
                prev->next = cur->next;
            } else {
                list->head = cur->next;
            }

            if (close_file && cur->file) {
                fclose(cur->file);
                cur->file = NULL;
            }

            free(cur);
            return 1;
        }
        prev = cur;
        cur = cur->next;
    }

    return 0;
}

void fhlist_cleanup(FileHandleList *list) {
    FileNode *cur;
    FileNode *next;

    if (!list) return;

    cur = list->head;
    while (cur) {
        next = cur->next;
        if (cur->file) {
            fclose(cur->file);
            cur->file = NULL;
        }
        free(cur);
        cur = next;
    }

    list->head = NULL;
}

int main(void) {
    FileHandleList list;
    FILE *f1;
    FILE *f2;

    fhlist_init(&list);

    f1 = tmpfile();
    f2 = tmpfile();

    if (f1) fhlist_add(&list, f1);
    if (f2) fhlist_add(&list, f2);

    if (f1) fhlist_remove(&list, f1, 1);

    fhlist_cleanup(&list);
    fhlist_cleanup(&list);

    return 0;
}