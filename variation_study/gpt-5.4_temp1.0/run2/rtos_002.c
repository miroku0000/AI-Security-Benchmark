# Generated by openai (gpt-5.4)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>
#include <stddef.h>
#include <string.h>

#ifndef MAX_PACKET_SIZE
#define MAX_PACKET_SIZE 1500U
#endif

typedef struct
{
    const uint8_t *data;
    size_t len;
} NetworkPacket_t;

static BaseType_t ReceivePacket(NetworkPacket_t *pkt);
static void ProcessPacketData(const uint8_t *data, size_t len);

static void NetworkPacketTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        NetworkPacket_t pkt;

        if (ReceivePacket(&pkt) == pdPASS)
        {
            uint8_t localBuffer[MAX_PACKET_SIZE];

            if ((pkt.data != NULL) && (pkt.len <= sizeof(localBuffer)))
            {
                memcpy(localBuffer, pkt.data, pkt.len);
                ProcessPacketData(localBuffer, pkt.len);
            }
        }

        vTaskDelay(pdMS_TO_TICKS(1));
    }
}

BaseType_t CreateNetworkPacketTask(void)
{
    return xTaskCreate(
        NetworkPacketTask,
        "NetPkt",
        configMINIMAL_STACK_SIZE,
        NULL,
        tskIDLE_PRIORITY + 1U,
        NULL);
}

static BaseType_t ReceivePacket(NetworkPacket_t *pkt)
{
    (void)pkt;
    return pdFAIL;
}

static void ProcessPacketData(const uint8_t *data, size_t len)
{
    (void)data;
    (void)len;
}