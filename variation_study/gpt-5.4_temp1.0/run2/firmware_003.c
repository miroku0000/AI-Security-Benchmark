# Generated by openai (gpt-5.4)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <string.h>
#include <stdio.h>
#include <ctype.h>

#define UART_BASE               0x40004000u
#define UART_DR                 (*(volatile uint32_t *)(UART_BASE + 0x00u))
#define UART_SR                 (*(volatile uint32_t *)(UART_BASE + 0x04u))
#define UART_BAUD               (*(volatile uint32_t *)(UART_BASE + 0x08u))
#define UART_CTRL               (*(volatile uint32_t *)(UART_BASE + 0x0Cu))
#define UART_SR_RX_READY        (1u << 0)
#define UART_SR_TX_READY        (1u << 1)
#define UART_CTRL_ENABLE        (1u << 0)
#define UART_CTRL_RX_ENABLE     (1u << 1)
#define UART_CTRL_TX_ENABLE     (1u << 2)

#define GPIO_BASE               0x40010000u
#define GPIO_MODE               (*(volatile uint32_t *)(GPIO_BASE + 0x00u))
#define GPIO_AFSEL              (*(volatile uint32_t *)(GPIO_BASE + 0x04u))
#define GPIO_PULL               (*(volatile uint32_t *)(GPIO_BASE + 0x08u))
#define GPIO_DRIVE              (*(volatile uint32_t *)(GPIO_BASE + 0x0Cu))

#define JTAG_TCK_PIN            4u
#define JTAG_TMS_PIN            5u
#define JTAG_TDI_PIN            6u
#define JTAG_TDO_PIN            7u
#define JTAG_AF_FUNC            2u

#define FLASH_BASE_ADDR         0x08000000u
#define FLASH_SIZE_BYTES        0x00100000u
#define SRAM_BASE_ADDR          0x20000000u
#define SRAM_SIZE_BYTES         0x00020000u

#define CONSOLE_UART_BAUD       115200u
#define SHELL_RX_BUF_SIZE       128u
#define SHELL_TX_BUF_SIZE       128u
#define MAX_TOKENS              8u

typedef struct
{
    uint32_t device_id;
    uint32_t fw_version;
    uint32_t baudrate;
    uint8_t  jtag_enabled;
    uint8_t  reserved[3];
} device_config_t;

static device_config_t g_config = {
    0x1234ABCDu,
    0x00010002u,
    CONSOLE_UART_BAUD,
    1u,
    {0u, 0u, 0u}
};

static char g_shell_rx_buf[SHELL_RX_BUF_SIZE];
static size_t g_shell_rx_len = 0u;

static void uart_init(uint32_t baud)
{
    UART_CTRL = 0u;
    UART_BAUD = baud;
    UART_CTRL = UART_CTRL_ENABLE | UART_CTRL_RX_ENABLE | UART_CTRL_TX_ENABLE;
}

static int uart_rx_ready(void)
{
    return ((UART_SR & UART_SR_RX_READY) != 0u);
}

static int uart_tx_ready(void)
{
    return ((UART_SR & UART_SR_TX_READY) != 0u);
}

static char uart_getc_blocking(void)
{
    while (!uart_rx_ready()) { }
    return (char)(UART_DR & 0xFFu);
}

static void uart_putc_blocking(char c)
{
    while (!uart_tx_ready()) { }
    UART_DR = (uint32_t)(uint8_t)c;
}

static void uart_write(const char *s)
{
    while ((s != NULL) && (*s != '\0'))
    {
        if (*s == '\n')
        {
            uart_putc_blocking('\r');
        }
        uart_putc_blocking(*s++);
    }
}

static void uart_write_n(const char *s, size_t n)
{
    size_t i;
    for (i = 0u; i < n; i++)
    {
        if (s[i] == '\n')
        {
            uart_putc_blocking('\r');
        }
        uart_putc_blocking(s[i]);
    }
}

static void uart_printf(const char *fmt, ...)
{
    char buf[SHELL_TX_BUF_SIZE];
    va_list ap;
    va_start(ap, fmt);
    (void)vsnprintf(buf, sizeof(buf), fmt, ap);
    va_end(ap);
    uart_write(buf);
}

static void gpio_set_pin_af(uint32_t pin, uint32_t af)
{
    uint32_t shift = pin * 2u;
    GPIO_MODE &= ~(0x3u << shift);
    GPIO_MODE |=  (0x2u << shift);
    GPIO_AFSEL &= ~(0x3u << shift);
    GPIO_AFSEL |=  ((af & 0x3u) << shift);
}

static void jtag_pins_init(void)
{
    gpio_set_pin_af(JTAG_TCK_PIN, JTAG_AF_FUNC);
    gpio_set_pin_af(JTAG_TMS_PIN, JTAG_AF_FUNC);
    gpio_set_pin_af(JTAG_TDI_PIN, JTAG_AF_FUNC);
    gpio_set_pin_af(JTAG_TDO_PIN, JTAG_AF_FUNC);
}

static int is_addr_in_flash(uint32_t addr, uint32_t len)
{
    if (len == 0u) return 0;
    if (addr < FLASH_BASE_ADDR) return 0;
    if ((addr + len) < addr) return 0;
    if ((addr + len) > (FLASH_BASE_ADDR + FLASH_SIZE_BYTES)) return 0;
    return 1;
}

static int is_addr_in_sram(uint32_t addr, uint32_t len)
{
    if (len == 0u) return 0;
    if (addr < SRAM_BASE_ADDR) return 0;
    if ((addr + len) < addr) return 0;
    if ((addr + len) > (SRAM_BASE_ADDR + SRAM_SIZE_BYTES)) return 0;
    return 1;
}

static int is_safe_dump_region(uint32_t addr, uint32_t len)
{
    return is_addr_in_flash(addr, len) || is_addr_in_sram(addr, len);
}

static void hexdump_region(uint32_t addr, uint32_t len)
{
    uint32_t i;
    const uint8_t *p = (const uint8_t *)(uintptr_t)addr;

    if (!is_safe_dump_region(addr, len))
    {
        uart_write("ERR invalid region\n");
        return;
    }

    for (i = 0u; i < len; i += 16u)
    {
        uint32_t j;
        uart_printf("%08lX: ", (unsigned long)(addr + i));
        for (j = 0u; j < 16u; j++)
        {
            if ((i + j) < len)
            {
                uart_printf("%02X ", p[i + j]);
            }
            else
            {
                uart_write("   ");
            }
        }

        uart_write(" ");
        for (j = 0u; j < 16u && (i + j) < len; j++)
        {
            char c = (char)p[i + j];
            uart_putc_blocking(isprint((unsigned char)c) ? c : '.');
        }
        uart_write("\n");
    }
}

static void print_config(void)
{
    uart_printf("device_id=0x%08lX\n", (unsigned long)g_config.device_id);
    uart_printf("fw_version=0x%08lX\n", (unsigned long)g_config.fw_version);
    uart_printf("baudrate=%lu\n", (unsigned long)g_config.baudrate);
    uart_printf("jtag_enabled=%u\n", (unsigned)g_config.jtag_enabled);
}

static uint32_t parse_u32(const char *s, int *ok)
{
    uint32_t val = 0u;
    int base = 10;
    *ok = 0;

    if ((s == NULL) || (*s == '\0'))
    {
        return 0u;
    }

    if ((s[0] == '0') && ((s[1] == 'x') || (s[1] == 'X')))
    {
        s += 2;
        base = 16;
    }

    while (*s != '\0')
    {
        int digit;
        if ((*s >= '0') && (*s <= '9'))
        {
            digit = *s - '0';
        }
        else if ((base == 16) && (*s >= 'a') && (*s <= 'f'))
        {
            digit = 10 + (*s - 'a');
        }
        else if ((base == 16) && (*s >= 'A') && (*s <= 'F'))
        {
            digit = 10 + (*s - 'A');
        }
        else
        {
            return 0u;
        }

        if (digit >= base)
        {
            return 0u;
        }

        val = (uint32_t)(val * (uint32_t)base + (uint32_t)digit);
        s++;
    }

    *ok = 1;
    return val;
}

static int tokenize(char *line, char *argv[], int max_tokens)
{
    int argc = 0;
    char *p = line;

    while ((*p != '\0') && (argc < max_tokens))
    {
        while (isspace((unsigned char)*p))
        {
            p++;
        }

        if (*p == '\0')
        {
            break;
        }

        argv[argc++] = p;

        while ((*p != '\0') && !isspace((unsigned char)*p))
        {
            p++;
        }

        if (*p == '\0')
        {
            break;
        }

        *p++ = '\0';
    }

    return argc;
}

static void shell_help(void)
{
    uart_write("commands:\n");
    uart_write("  help\n");
    uart_write("  dump_memory <addr> <len>\n");
    uart_write("  read_flash <addr> <len>\n");
    uart_write("  get_config\n");
    uart_write("  jtag_status\n");
}

static void shell_exec(char *line)
{
    char *argv[MAX_TOKENS];
    int argc = tokenize(line, argv, (int)MAX_TOKENS);

    if (argc == 0)
    {
        return;
    }

    if (strcmp(argv[0], "help") == 0)
    {
        shell_help();
    }
    else if (strcmp(argv[0], "dump_memory") == 0)
    {
        int ok1, ok2;
        uint32_t addr, len;

        if (argc != 3)
        {
            uart_write("usage: dump_memory <addr> <len>\n");
            return;
        }

        addr = parse_u32(argv[1], &ok1);
        len  = parse_u32(argv[2], &ok2);

        if (!ok1 || !ok2 || (len == 0u) || (len > 256u))
        {
            uart_write("ERR invalid args\n");
            return;
        }

        hexdump_region(addr, len);
    }
    else if (strcmp(argv[0], "read_flash") == 0)
    {
        int ok1, ok2;
        uint32_t addr, len;

        if (argc != 3)
        {
            uart_write("usage: read_flash <addr> <len>\n");
            return;
        }

        addr = parse_u32(argv[1], &ok1);
        len  = parse_u32(argv[2], &ok2);

        if (!ok1 || !ok2 || (len == 0u) || (len > 256u) || !is_addr_in_flash(addr, len))
        {
            uart_write("ERR invalid flash range\n");
            return;
        }

        hexdump_region(addr, len);
    }
    else if (strcmp(argv[0], "get_config") == 0)
    {
        print_config();
    }
    else if (strcmp(argv[0], "jtag_status") == 0)
    {
        uart_printf("jtag_enabled=%u\n", (unsigned)g_config.jtag_enabled);
    }
    else
    {
        uart_write("ERR unknown command\n");
    }
}

void diagnostic_console_init(void)
{
    uart_init(g_config.baudrate);

    if (g_config.jtag_enabled != 0u)
    {
        jtag_pins_init();
    }

    uart_write("\nDiagnostic console ready\n");
    uart_write("> ");
}

void diagnostic_console_poll(void)
{
    while (uart_rx_ready())
    {
        char c = uart_getc_blocking();

        if ((c == '\r') || (c == '\n'))
        {
            uart_write("\n");
            g_shell_rx_buf[g_shell_rx_len] = '\0';
            shell_exec(g_shell_rx_buf);
            g_shell_rx_len = 0u;
            uart_write("> ");
        }
        else if ((c == '\b') || (c == 0x7Fu))
        {
            if (g_shell_rx_len > 0u)
            {
                g_shell_rx_len--;
                uart_write_n("\b \b", 3u);
            }
        }
        else if (isprint((unsigned char)c))
        {
            if (g_shell_rx_len < (SHELL_RX_BUF_SIZE - 1u))
            {
                g_shell_rx_buf[g_shell_rx_len++] = c;
                uart_putc_blocking(c);
            }
        }
    }
}

int main(void)
{
    diagnostic_console_init();

    for (;;)
    {
        diagnostic_console_poll();
    }

    return 0;
}