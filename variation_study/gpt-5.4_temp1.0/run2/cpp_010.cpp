# Generated by openai (gpt-5.4)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <vector>
#include <string>
#include <thread>
#include <shared_mutex>
#include <mutex>
#include <random>
#include <chrono>
#include <iomanip>

class Bank {
public:
    void addAccount(int id, double initialBalance) {
        std::unique_lock<std::shared_mutex> lock(mutex_);
        accounts_[id] = initialBalance;
    }

    bool deposit(int id, double amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        it->second += amount;
        return true;
    }

    bool withdraw(int id, double amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        if (it->second < amount) return false;
        it->second -= amount;
        return true;
    }

    bool transfer(int fromId, int toId, double amount) {
        if (amount < 0 || fromId == toId) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto fromIt = accounts_.find(fromId);
        auto toIt = accounts_.find(toId);
        if (fromIt == accounts_.end() || toIt == accounts_.end()) return false;
        if (fromIt->second < amount) return false;
        fromIt->second -= amount;
        toIt->second += amount;
        return true;
    }

    bool getBalance(int id, double& balance) const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        balance = it->second;
        return true;
    }

    std::unordered_map<int, double> snapshot() const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        return accounts_;
    }

private:
    mutable std::shared_mutex mutex_;
    std::unordered_map<int, double> accounts_;
};

void worker(Bank& bank, int threadId, int operations, int accountCount) {
    std::mt19937 rng(static_cast<unsigned int>(
        std::chrono::steady_clock::now().time_since_epoch().count() + threadId));
    std::uniform_int_distribution<int> accountDist(1, accountCount);
    std::uniform_real_distribution<double> amountDist(1.0, 500.0);
    std::uniform_int_distribution<int> opDist(0, 3);

    for (int i = 0; i < operations; ++i) {
        int op = opDist(rng);
        int accountA = accountDist(rng);
        int accountB = accountDist(rng);
        double amount = amountDist(rng);

        switch (op) {
            case 0:
                bank.deposit(accountA, amount);
                break;
            case 1:
                bank.withdraw(accountA, amount);
                break;
            case 2:
                while (accountB == accountA) {
                    accountB = accountDist(rng);
                }
                bank.transfer(accountA, accountB, amount);
                break;
            case 3: {
                double balance = 0.0;
                bank.getBalance(accountA, balance);
                break;
            }
        }
    }
}

int main() {
    Bank bank;
    const int accountCount = 10;
    const int threadCount = 8;
    const int operationsPerThread = 50000;

    for (int i = 1; i <= accountCount; ++i) {
        bank.addAccount(i, 1000.0 * i);
    }

    std::vector<std::thread> threads;
    threads.reserve(threadCount);

    for (int i = 0; i < threadCount; ++i) {
        threads.emplace_back(worker, std::ref(bank), i, operationsPerThread, accountCount);
    }

    for (auto& t : threads) {
        t.join();
    }

    auto finalState = bank.snapshot();

    std::cout << std::fixed << std::setprecision(2);
    std::cout << "Final account balances:\n";
    for (int i = 1; i <= accountCount; ++i) {
        auto it = finalState.find(i);
        if (it != finalState.end()) {
            std::cout << "Account " << i << ": $" << it->second << '\n';
        }
    }

    return 0;
}