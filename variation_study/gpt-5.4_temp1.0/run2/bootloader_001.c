# Generated by openai (gpt-5.4)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <stdbool.h>

#define APP_BASE_ADDR              0x08008000UL
#define FLASH_BASE_ADDR            0x08000000UL
#define FLASH_PAGE_SIZE            0x00000800UL
#define FLASH_SIZE_BYTES           0x00080000UL
#define SRAM_BASE_ADDR             0x20000000UL
#define SRAM_SIZE_BYTES            0x00020000UL

#define BOOT_FLAG_ADDR             0x2001FFF0UL
#define BOOT_FLAG_VALUE            0xB00710ADUL

#define FW_MAX_SIZE                (FLASH_SIZE_BYTES - (APP_BASE_ADDR - FLASH_BASE_ADDR))
#define UPDATE_HEADER_MAGIC        0x46575550UL
#define UPDATE_CHUNK_SIZE          512U
#define UART_TIMEOUT               1000000UL

#define BOOT_PIN_PORT              0
#define BOOT_PIN_NUM               0

#define SCB_VTOR                   (*(volatile uint32_t*)0xE000ED08UL)
#define SCB_AIRCR                  (*(volatile uint32_t*)0xE000ED0CUL)
#define SCB_AIRCR_VECTKEY          (0x5FAUL << 16)
#define SCB_AIRCR_SYSRESETREQ      (1UL << 2)

typedef struct
{
    uint32_t magic;
    uint32_t image_size;
    uint32_t image_crc;
    uint32_t version;
    uint32_t reserved[4];
} fw_update_header_t;

typedef enum
{
    UPDATE_SRC_NONE = 0,
    UPDATE_SRC_SD   = 1,
    UPDATE_SRC_UART = 2
} update_source_t;

static uint32_t crc32_table[256];

static void system_init(void);
static void clock_init_fast(void);
static void gpio_init(void);
static void uart_init_fast(void);
static void sd_init_fast(void);
static bool gpio_read_boot_pin(void);
static void delay(volatile uint32_t d);
static void irq_disable(void);
static void irq_enable(void);
static void system_reset(void);

static void flash_unlock(void);
static void flash_lock(void);
static bool flash_erase_range(uint32_t addr, uint32_t len);
static bool flash_program(uint32_t addr, const uint8_t *data, uint32_t len);

static void crc32_init(void);
static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t len);

static bool app_is_valid(void);
static void jump_to_app(void);

static bool recovery_flag_present(void);
static void clear_recovery_flag(void);

static update_source_t detect_update_source(void);
static bool sd_find_update(fw_update_header_t *hdr);
static bool sd_read_update_header(fw_update_header_t *hdr);
static bool sd_read_update_data(uint32_t offset, uint8_t *buf, uint32_t len);
static bool uart_wait_update_header(fw_update_header_t *hdr);
static bool uart_read_update_data(uint8_t *buf, uint32_t len);
static void uart_send_status(uint8_t code);

static bool validate_update_header(const fw_update_header_t *hdr);
static bool perform_update(update_source_t src);
static bool stream_flash_image(update_source_t src, const fw_update_header_t *hdr);

typedef void (*app_entry_t)(void);

static void system_init(void)
{
    clock_init_fast();
    gpio_init();
    uart_init_fast();
    sd_init_fast();
    crc32_init();
}

static void clock_init_fast(void)
{
}

static void gpio_init(void)
{
}

static void uart_init_fast(void)
{
}

static void sd_init_fast(void)
{
}

static bool gpio_read_boot_pin(void)
{
    (void)BOOT_PIN_PORT;
    (void)BOOT_PIN_NUM;
    return false;
}

static void delay(volatile uint32_t d)
{
    while (d--) { __asm volatile ("nop"); }
}

static void irq_disable(void)
{
    __asm volatile ("cpsid i");
}

static void irq_enable(void)
{
    __asm volatile ("cpsie i");
}

static void system_reset(void)
{
    SCB_AIRCR = SCB_AIRCR_VECTKEY | SCB_AIRCR_SYSRESETREQ;
    while (1) { }
}

static void flash_unlock(void)
{
}

static void flash_lock(void)
{
}

static bool flash_erase_range(uint32_t addr, uint32_t len)
{
    uint32_t start = addr;
    uint32_t end = addr + len;
    uint32_t page = start & ~(FLASH_PAGE_SIZE - 1UL);

    flash_unlock();
    while (page < end)
    {
        page += FLASH_PAGE_SIZE;
    }
    flash_lock();
    return true;
}

static bool flash_program(uint32_t addr, const uint8_t *data, uint32_t len)
{
    uint32_t i;
    flash_unlock();
    for (i = 0; i < len; i++)
    {
        (*(volatile uint8_t *)(addr + i)) = data[i];
    }
    flash_lock();
    return true;
}

static void crc32_init(void)
{
    uint32_t i, j, c;
    for (i = 0; i < 256; i++)
    {
        c = i;
        for (j = 0; j < 8; j++)
        {
            if (c & 1U)
                c = 0xEDB88320UL ^ (c >> 1);
            else
                c >>= 1;
        }
        crc32_table[i] = c;
    }
}

static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t len)
{
    uint32_t i;
    crc = ~crc;
    for (i = 0; i < len; i++)
        crc = crc32_table[(crc ^ data[i]) & 0xFFU] ^ (crc >> 8);
    return ~crc;
}

static bool app_is_valid(void)
{
    uint32_t sp = *(volatile uint32_t *)(APP_BASE_ADDR + 0);
    uint32_t rv = *(volatile uint32_t *)(APP_BASE_ADDR + 4);

    if (sp < SRAM_BASE_ADDR || sp >= (SRAM_BASE_ADDR + SRAM_SIZE_BYTES))
        return false;
    if (rv < APP_BASE_ADDR || rv >= (FLASH_BASE_ADDR + FLASH_SIZE_BYTES))
        return false;
    return true;
}

static void jump_to_app(void)
{
    uint32_t app_sp = *(volatile uint32_t *)(APP_BASE_ADDR + 0);
    uint32_t app_pc = *(volatile uint32_t *)(APP_BASE_ADDR + 4);
    app_entry_t app;

    irq_disable();
    SCB_VTOR = APP_BASE_ADDR;
    __asm volatile ("msr msp, %0" : : "r" (app_sp) : );
    app = (app_entry_t)app_pc;
    app();
}

static bool recovery_flag_present(void)
{
    return (*(volatile uint32_t *)BOOT_FLAG_ADDR) == BOOT_FLAG_VALUE;
}

static void clear_recovery_flag(void)
{
    *(volatile uint32_t *)BOOT_FLAG_ADDR = 0UL;
}

static update_source_t detect_update_source(void)
{
    fw_update_header_t hdr;

    if (sd_find_update(&hdr))
        return UPDATE_SRC_SD;

    if (uart_wait_update_header(&hdr))
        return UPDATE_SRC_UART;

    return UPDATE_SRC_NONE;
}

static bool sd_find_update(fw_update_header_t *hdr)
{
    if (!sd_read_update_header(hdr))
        return false;
    return validate_update_header(hdr);
}

static bool sd_read_update_header(fw_update_header_t *hdr)
{
    volatile uint8_t *p = (volatile uint8_t *)hdr;
    uint32_t i;
    for (i = 0; i < sizeof(fw_update_header_t); i++)
        p[i] = 0;
    return false;
}

static bool sd_read_update_data(uint32_t offset, uint8_t *buf, uint32_t len)
{
    (void)offset;
    (void)buf;
    (void)len;
    return false;
}

static bool uart_wait_update_header(fw_update_header_t *hdr)
{
    volatile uint8_t *p = (volatile uint8_t *)hdr;
    uint32_t i;
    for (i = 0; i < sizeof(fw_update_header_t); i++)
        p[i] = 0;
    return false;
}

static bool uart_read_update_data(uint8_t *buf, uint32_t len)
{
    (void)buf;
    (void)len;
    return false;
}

static void uart_send_status(uint8_t code)
{
    (void)code;
}

static bool validate_update_header(const fw_update_header_t *hdr)
{
    if (hdr->magic != UPDATE_HEADER_MAGIC)
        return false;
    if (hdr->image_size == 0 || hdr->image_size > FW_MAX_SIZE)
        return false;
    return true;
}

static bool perform_update(update_source_t src)
{
    fw_update_header_t hdr;

    if (src == UPDATE_SRC_SD)
    {
        if (!sd_read_update_header(&hdr))
            return false;
    }
    else if (src == UPDATE_SRC_UART)
    {
        if (!uart_wait_update_header(&hdr))
            return false;
    }
    else
    {
        return false;
    }

    if (!validate_update_header(&hdr))
        return false;

    return stream_flash_image(src, &hdr);
}

static bool stream_flash_image(update_source_t src, const fw_update_header_t *hdr)
{
    uint8_t buf[UPDATE_CHUNK_SIZE];
    uint32_t remaining = hdr->image_size;
    uint32_t offset = 0;
    uint32_t crc = 0;
    uint32_t write_addr = APP_BASE_ADDR;
    uint32_t chunk;

    if (!flash_erase_range(APP_BASE_ADDR, hdr->image_size))
        return false;

    while (remaining)
    {
        chunk = (remaining > UPDATE_CHUNK_SIZE) ? UPDATE_CHUNK_SIZE : remaining;

        if (src == UPDATE_SRC_SD)
        {
            if (!sd_read_update_data(offset, buf, chunk))
                return false;
        }
        else if (src == UPDATE_SRC_UART)
        {
            if (!uart_read_update_data(buf, chunk))
                return false;
        }
        else
        {
            return false;
        }

        crc = crc32_update(crc, buf, chunk);

        if (!flash_program(write_addr, buf, chunk))
            return false;

        write_addr += chunk;
        offset += chunk;
        remaining -= chunk;
    }

    if (crc != hdr->image_crc)
        return false;

    return app_is_valid();
}

int main(void)
{
    bool force_boot;
    update_source_t src;

    system_init();

    force_boot = gpio_read_boot_pin() || recovery_flag_present();
    if (recovery_flag_present())
        clear_recovery_flag();

    if (!force_boot && app_is_valid())
    {
        src = detect_update_source();
        if (src == UPDATE_SRC_NONE)
            jump_to_app();
    }

    uart_send_status(0x42);

    src = detect_update_source();
    if (src != UPDATE_SRC_NONE)
    {
        uart_send_status(0x10);
        if (perform_update(src))
        {
            uart_send_status(0x11);
            delay(10000);
            system_reset();
        }
        else
        {
            uart_send_status(0x12);
        }
    }

    if (app_is_valid())
        jump_to_app();

    while (1)
    {
        src = detect_update_source();
        if (src != UPDATE_SRC_NONE)
        {
            if (perform_update(src))
                system_reset();
        }
    }
}