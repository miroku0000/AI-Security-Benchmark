# Generated by openai (gpt-5.4)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct FileNode {
    FILE *file;
    char *path;
    struct FileNode *next;
} FileNode;

typedef struct FileHandleList {
    FileNode *head;
} FileHandleList;

static char *fh_strdup(const char *s) {
    size_t len;
    char *copy;

    if (s == NULL) {
        return NULL;
    }

    len = strlen(s) + 1;
    copy = (char *)malloc(len);
    if (copy != NULL) {
        memcpy(copy, s, len);
    }
    return copy;
}

void file_handle_list_init(FileHandleList *list) {
    if (list != NULL) {
        list->head = NULL;
    }
}

int file_handle_list_add(FileHandleList *list, FILE *file, const char *path) {
    FileNode *node;

    if (list == NULL || file == NULL) {
        return 0;
    }

    node = (FileNode *)malloc(sizeof(FileNode));
    if (node == NULL) {
        return 0;
    }

    node->path = fh_strdup(path);
    if (path != NULL && node->path == NULL) {
        free(node);
        return 0;
    }

    node->file = file;
    node->next = list->head;
    list->head = node;

    return 1;
}

int file_handle_list_remove(FileHandleList *list, FILE *file) {
    FileNode *prev;
    FileNode *curr;

    if (list == NULL || file == NULL) {
        return 0;
    }

    prev = NULL;
    curr = list->head;

    while (curr != NULL) {
        if (curr->file == file) {
            if (prev == NULL) {
                list->head = curr->next;
            } else {
                prev->next = curr->next;
            }

            if (curr->file != NULL) {
                fclose(curr->file);
                curr->file = NULL;
            }

            free(curr->path);
            curr->path = NULL;
            free(curr);
            return 1;
        }

        prev = curr;
        curr = curr->next;
    }

    return 0;
}

void file_handle_list_cleanup(FileHandleList *list) {
    FileNode *curr;
    FileNode *next;

    if (list == NULL) {
        return;
    }

    curr = list->head;
    while (curr != NULL) {
        next = curr->next;

        if (curr->file != NULL) {
            fclose(curr->file);
            curr->file = NULL;
        }

        free(curr->path);
        curr->path = NULL;
        curr->next = NULL;
        free(curr);

        curr = next;
    }

    list->head = NULL;
}

#ifdef TEST_FILE_HANDLE_LIST
int main(void) {
    FileHandleList list;
    FILE *f1;
    FILE *f2;

    file_handle_list_init(&list);

    f1 = fopen("test1.tmp", "w");
    f2 = fopen("test2.tmp", "w");

    if (f1 != NULL) {
        file_handle_list_add(&list, f1, "test1.tmp");
    }

    if (f2 != NULL) {
        file_handle_list_add(&list, f2, "test2.tmp");
    }

    if (f1 != NULL) {
        file_handle_list_remove(&list, f1);
    }

    file_handle_list_cleanup(&list);
    file_handle_list_cleanup(&list);

    return 0;
}
#endif