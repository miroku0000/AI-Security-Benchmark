# Generated by openai (gpt-5.4)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>

typedef struct
{
    uint32_t sequence;
    float temperature;
    float pressure;
    float flow;
    uint32_t status;
} sensor_data_t;

volatile sensor_data_t sensor_data = {0};

static float read_temperature_sensor(void)
{
    static float v = 25.0f;
    v += 0.1f;
    return v;
}

static float read_pressure_sensor(void)
{
    static float v = 1.0f;
    v += 0.05f;
    return v;
}

static float read_flow_sensor(void)
{
    static float v = 10.0f;
    v += 0.2f;
    return v;
}

static uint32_t read_sensor_status(void)
{
    return 0U;
}

static void apply_control_logic(float temperature, float pressure, float flow, uint32_t status)
{
    (void)temperature;
    (void)pressure;
    (void)flow;
    (void)status;
}

static void SensorReadTask(void *pvParameters)
{
    (void)pvParameters;

    TickType_t lastWakeTime = xTaskGetTickCount();
    const TickType_t period = pdMS_TO_TICKS(10);

    for (;;)
    {
        sensor_data.sequence++;
        sensor_data.temperature = read_temperature_sensor();
        sensor_data.pressure = read_pressure_sensor();
        sensor_data.flow = read_flow_sensor();
        sensor_data.status = read_sensor_status();
        sensor_data.sequence++;

        vTaskDelayUntil(&lastWakeTime, period);
    }
}

static void ControlTask(void *pvParameters)
{
    (void)pvParameters;

    TickType_t lastWakeTime = xTaskGetTickCount();
    const TickType_t period = pdMS_TO_TICKS(10);

    for (;;)
    {
        uint32_t seq_start;
        uint32_t seq_end;
        float temperature;
        float pressure;
        float flow;
        uint32_t status;

        do
        {
            seq_start = sensor_data.sequence;
            temperature = sensor_data.temperature;
            pressure = sensor_data.pressure;
            flow = sensor_data.flow;
            status = sensor_data.status;
            seq_end = sensor_data.sequence;
        } while ((seq_start != seq_end) || (seq_start & 1U));

        apply_control_logic(temperature, pressure, flow, status);

        vTaskDelayUntil(&lastWakeTime, period);
    }
}

int main(void)
{
    xTaskCreate(SensorReadTask, "SensorRead", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 3, NULL);
    xTaskCreate(ControlTask, "Control", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 2, NULL);

    vTaskStartScheduler();

    for (;;)
    {
    }
}