# Generated by openai (gpt-5.4)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>

#define REQUEST_BUFFER_SIZE 8192
#define MAX_METHOD_LEN 8
#define MAX_PATH_LEN 256
#define MAX_VERSION_LEN 16

typedef struct {
    char method[MAX_METHOD_LEN];
    char path[MAX_PATH_LEN];
    char version[MAX_VERSION_LEN];
    char *raw;
    size_t raw_len;
} HttpRequest;

static int read_request(char *buffer, size_t capacity, size_t *out_len) {
    if (!buffer || capacity == 0 || !out_len) return 0;

    if (!fgets(buffer, (int)capacity, stdin)) {
        return 0;
    }

    size_t len = strlen(buffer);

    while (len + 1 < capacity) {
        if (len >= 4 && memcmp(buffer + len - 4, "\r\n\r\n", 4) == 0) break;
        if (len >= 2 && memcmp(buffer + len - 2, "\n\n", 2) == 0) break;

        if (!fgets(buffer + len, (int)(capacity - len), stdin)) break;
        len = strlen(buffer);
    }

    *out_len = len;
    return 1;
}

static int parse_request_line(HttpRequest *req) {
    if (!req || !req->raw) return 0;

    const char *line_end = strstr(req->raw, "\r\n");
    size_t line_len = line_end ? (size_t)(line_end - req->raw) : strcspn(req->raw, "\n");

    char line[512];
    if (line_len >= sizeof(line)) return 0;

    memcpy(line, req->raw, line_len);
    line[line_len] = '\0';

    if (sscanf(line, "%7s %255s %15s", req->method, req->path, req->version) != 3) {
        return 0;
    }

    return 1;
}

static void process_request(const HttpRequest *req) {
    if (!req) return;

    if (strcmp(req->method, "GET") == 0) {
        printf("200 OK: GET %s\n", req->path);
    } else if (strcmp(req->method, "POST") == 0) {
        printf("200 OK: POST %s\n", req->path);
    } else {
        printf("405 Method Not Allowed: %s\n", req->method);
    }
}

int main(void) {
    for (;;) {
        char *request_buffer = (char *)malloc(REQUEST_BUFFER_SIZE);
        if (!request_buffer) {
            fprintf(stderr, "Failed to allocate request buffer\n");
            return 1;
        }

        size_t request_len = 0;
        if (!read_request(request_buffer, REQUEST_BUFFER_SIZE, &request_len)) {
            free(request_buffer);
            break;
        }

        HttpRequest req;
        memset(&req, 0, sizeof(req));
        req.raw = request_buffer;
        req.raw_len = request_len;

        if (parse_request_line(&req)) {
            process_request(&req);
        } else {
            printf("400 Bad Request\n");
        }

        free(request_buffer);
    }

    return 0;
}