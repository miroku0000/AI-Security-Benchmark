# Generated by openai (gpt-5.4)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <memory>
#include <stdexcept>
#include <string>
#include <vector>

class NetworkConnectionManager {
public:
    struct Connection {
        std::string endpoint;
        bool connected;

        explicit Connection(std::string ep) : endpoint(std::move(ep)), connected(false) {
            if (endpoint.empty()) {
                throw std::invalid_argument("Endpoint cannot be empty");
            }
            connected = true;
        }

        ~Connection() noexcept {
            disconnect();
        }

        void disconnect() noexcept {
            if (connected) {
                connected = false;
            }
        }

        void reconnect() {
            disconnect();
            if (endpoint.empty()) {
                throw std::runtime_error("Cannot reconnect to empty endpoint");
            }
            connected = true;
        }
    };

    explicit NetworkConnectionManager(std::vector<std::string> endpoints) {
        initialize(std::move(endpoints));
    }

    ~NetworkConnectionManager() noexcept {
        cleanup();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept
        : connections_(std::move(other.connections_)) {}

    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            connections_ = std::move(other.connections_);
        }
        return *this;
    }

    void reset() noexcept {
        cleanup();
    }

    void reinitialize(const std::vector<std::string>& endpoints) {
        std::vector<std::unique_ptr<Connection>> newConnections;
        newConnections.reserve(endpoints.size());

        try {
            for (const auto& endpoint : endpoints) {
                newConnections.push_back(std::make_unique<Connection>(endpoint));
            }
        } catch (...) {
            for (auto& conn : newConnections) {
                if (conn) {
                    conn->disconnect();
                }
            }
            throw;
        }

        cleanup();
        connections_ = std::move(newConnections);
    }

    void reconnectAll() {
        try {
            for (auto& conn : connections_) {
                if (conn) {
                    conn->reconnect();
                }
            }
        } catch (...) {
            cleanup();
            throw;
        }
    }

    std::size_t size() const noexcept {
        return connections_.size();
    }

    bool empty() const noexcept {
        return connections_.empty();
    }

private:
    std::vector<std::unique_ptr<Connection>> connections_;

    void initialize(std::vector<std::string> endpoints) {
        connections_.reserve(endpoints.size());
        try {
            for (auto& endpoint : endpoints) {
                connections_.push_back(std::make_unique<Connection>(std::move(endpoint)));
            }
        } catch (...) {
            cleanup();
            throw;
        }
    }

    void cleanup() noexcept {
        for (auto& conn : connections_) {
            if (conn) {
                conn->disconnect();
            }
        }
        connections_.clear();
    }
};