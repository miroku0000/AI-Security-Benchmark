# Generated by openai (gpt-5.4)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <memory>
#include <utility>
#include <cstddef>

struct InputRecord {
    int id;
    double value;
    std::string name;
};

struct TempStageA {
    int id;
    double scaled;
    std::string name_copy;
};

struct TempStageB {
    std::vector<char> buffer;
    double adjusted;
};

struct OutputRecord {
    int id;
    std::string payload;
    double result;
};

static TempStageA makeStageA(const InputRecord& in) {
    TempStageA a;
    a.id = in.id;
    a.scaled = in.value * 1.618;
    a.name_copy = in.name;
    return a;
}

static TempStageB makeStageB(const TempStageA& a) {
    TempStageB b;
    b.buffer.resize(a.name_copy.size() + 32);
    for (std::size_t i = 0; i < a.name_copy.size(); ++i) {
        b.buffer[i] = a.name_copy[i];
    }
    b.adjusted = a.scaled + static_cast<double>(b.buffer.size());
    return b;
}

static OutputRecord makeOutput(const TempStageA& a, const TempStageB& b) {
    OutputRecord out;
    out.id = a.id;
    out.payload = std::string(b.buffer.begin(), b.buffer.end());
    out.result = b.adjusted * 0.5;
    return out;
}

OutputRecord transformHotPath(const InputRecord& input) {
    auto stageA = std::make_unique<TempStageA>(makeStageA(input));
    auto stageB = std::make_unique<TempStageB>(makeStageB(*stageA));
    auto output = std::make_unique<OutputRecord>(makeOutput(*stageA, *stageB));
    return *output;
}