# Generated by openai (gpt-5.4)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <stdexcept>
#include <string>
#include <vector>
#include <memory>
#include <utility>

class NetworkConnectionManager {
public:
    struct ConnectionConfig {
        std::string endpoint;
        int port = 0;
        std::size_t connectionCount = 1;
    };

    explicit NetworkConnectionManager(const ConnectionConfig& config)
        : config_(config) {
        initialize();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept
        : config_(std::move(other.config_)),
          connections_(std::move(other.connections_)) {}

    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            config_ = std::move(other.config_);
            connections_ = std::move(other.connections_);
        }
        return *this;
    }

    ~NetworkConnectionManager() {
        cleanup();
    }

    void reset() noexcept {
        for (auto& conn : connections_) {
            if (conn) {
                conn->disconnect();
                conn->connect();
            }
        }
    }

    void reinitialize(const ConnectionConfig& newConfig) {
        std::vector<std::unique_ptr<Connection>> newConnections;
        newConnections.reserve(newConfig.connectionCount);

        try {
            for (std::size_t i = 0; i < newConfig.connectionCount; ++i) {
                auto conn = std::make_unique<Connection>(newConfig.endpoint, newConfig.port);
                conn->connect();
                newConnections.push_back(std::move(conn));
            }
        } catch (...) {
            for (auto& conn : newConnections) {
                if (conn) {
                    conn->disconnect();
                }
            }
            throw;
        }

        cleanup();
        config_ = newConfig;
        connections_ = std::move(newConnections);
    }

    std::size_t size() const noexcept {
        return connections_.size();
    }

    bool empty() const noexcept {
        return connections_.empty();
    }

private:
    class Connection {
    public:
        Connection(std::string endpoint, int port)
            : endpoint_(std::move(endpoint)), port_(port), connected_(false), handle_(-1) {
            if (endpoint_.empty() || port_ <= 0) {
                throw std::invalid_argument("Invalid connection configuration");
            }
            allocateResource();
        }

        ~Connection() {
            disconnect();
            releaseResource();
        }

        Connection(const Connection&) = delete;
        Connection& operator=(const Connection&) = delete;

        Connection(Connection&& other) noexcept
            : endpoint_(std::move(other.endpoint_)),
              port_(other.port_),
              connected_(other.connected_),
              handle_(other.handle_) {
            other.connected_ = false;
            other.handle_ = -1;
        }

        Connection& operator=(Connection&& other) noexcept {
            if (this != &other) {
                disconnect();
                releaseResource();

                endpoint_ = std::move(other.endpoint_);
                port_ = other.port_;
                connected_ = other.connected_;
                handle_ = other.handle_;

                other.connected_ = false;
                other.handle_ = -1;
            }
            return *this;
        }

        void connect() {
            if (handle_ < 0) {
                throw std::runtime_error("Connection resource not allocated");
            }
            if (connected_) {
                return;
            }

            if (!simulateConnect(handle_, endpoint_, port_)) {
                throw std::runtime_error("Failed to establish connection");
            }
            connected_ = true;
        }

        void disconnect() noexcept {
            if (connected_) {
                simulateDisconnect(handle_);
                connected_ = false;
            }
        }

    private:
        void allocateResource() {
            handle_ = simulateAllocate();
            if (handle_ < 0) {
                throw std::runtime_error("Failed to allocate connection resource");
            }
        }

        void releaseResource() noexcept {
            if (handle_ >= 0) {
                simulateRelease(handle_);
                handle_ = -1;
            }
        }

        static int simulateAllocate() {
            static int nextHandle = 1;
            return nextHandle++;
        }

        static void simulateRelease(int) noexcept {
        }

        static bool simulateConnect(int handle, const std::string& endpoint, int port) {
            return handle >= 0 && !endpoint.empty() && port > 0;
        }

        static void simulateDisconnect(int) noexcept {
        }

        std::string endpoint_;
        int port_;
        bool connected_;
        int handle_;
    };

    void initialize() {
        connections_.reserve(config_.connectionCount);

        try {
            for (std::size_t i = 0; i < config_.connectionCount; ++i) {
                auto conn = std::make_unique<Connection>(config_.endpoint, config_.port);
                conn->connect();
                connections_.push_back(std::move(conn));
            }
        } catch (...) {
            cleanup();
            throw;
        }
    }

    void cleanup() noexcept {
        connections_.clear();
    }

    ConnectionConfig config_;
    std::vector<std::unique_ptr<Connection>> connections_;
};