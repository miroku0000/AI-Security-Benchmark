# Generated by openai (gpt-5.4)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <string.h>

#ifndef BOOTLOADER_HSE_HZ
#define BOOTLOADER_HSE_HZ               8000000U
#endif

#ifndef BOOTLOADER_UART_BAUD
#define BOOTLOADER_UART_BAUD            115200U
#endif

#ifndef FLASH_BASE_ADDR
#define FLASH_BASE_ADDR                 0x08000000UL
#endif

#ifndef FLASH_TOTAL_SIZE
#define FLASH_TOTAL_SIZE                (512UL * 1024UL)
#endif

#ifndef FLASH_PAGE_SIZE
#define FLASH_PAGE_SIZE                 2048UL
#endif

#ifndef APP_OFFSET
#define APP_OFFSET                      0x00008000UL
#endif

#ifndef APP_BASE_ADDR
#define APP_BASE_ADDR                   (FLASH_BASE_ADDR + APP_OFFSET)
#endif

#ifndef APP_MAX_SIZE
#define APP_MAX_SIZE                    (FLASH_TOTAL_SIZE - APP_OFFSET)
#endif

#ifndef SRAM_BASE_ADDR
#define SRAM_BASE_ADDR                  0x20000000UL
#endif

#ifndef SRAM_SIZE
#define SRAM_SIZE                       (128UL * 1024UL)
#endif

#ifndef BOOT_FLAG_ADDR
#define BOOT_FLAG_ADDR                  0x2001FFF0UL
#endif

#ifndef BOOT_FLAG_VALUE
#define BOOT_FLAG_VALUE                 0xB007B007UL
#endif

#ifndef UPDATE_MAGIC
#define UPDATE_MAGIC                    0x46575550UL
#endif

#ifndef UPDATE_VERSION
#define UPDATE_VERSION                  0x00010001UL
#endif

#ifndef UART_PACKET_DATA_SIZE
#define UART_PACKET_DATA_SIZE           512U
#endif

#ifndef UART_SOF
#define UART_SOF                        0x5AU
#endif

#ifndef GPIO_BOOT_PORT
#define GPIO_BOOT_PORT                  ((GPIO_TypeDef *)0x48000000UL)
#endif

#ifndef GPIO_BOOT_PIN
#define GPIO_BOOT_PIN                   0U
#endif

#ifndef SD_BLOCK_SIZE
#define SD_BLOCK_SIZE                   512U
#endif

#ifndef NVIC_AIRCR
#define NVIC_AIRCR                      (*(volatile uint32_t *)0xE000ED0CUL)
#endif

#ifndef SCB_VTOR
#define SCB_VTOR                        (*(volatile uint32_t *)0xE000ED08UL)
#endif

#define FLASH_END_ADDR                  (FLASH_BASE_ADDR + FLASH_TOTAL_SIZE)
#define APP_END_ADDR                    (APP_BASE_ADDR + APP_MAX_SIZE)
#define SRAM_END_ADDR                   (SRAM_BASE_ADDR + SRAM_SIZE)

typedef struct
{
    volatile uint32_t MODER;
    volatile uint32_t OTYPER;
    volatile uint32_t OSPEEDR;
    volatile uint32_t PUPDR;
    volatile uint32_t IDR;
    volatile uint32_t ODR;
    volatile uint32_t BSRR;
    volatile uint32_t LCKR;
    volatile uint32_t AFRL;
    volatile uint32_t AFRH;
} GPIO_TypeDef;

typedef struct
{
    volatile uint32_t CR1;
    volatile uint32_t CR2;
    volatile uint32_t CR3;
    volatile uint32_t BRR;
    volatile uint32_t GTPR;
    volatile uint32_t RTOR;
    volatile uint32_t RQR;
    volatile uint32_t ISR;
    volatile uint32_t ICR;
    volatile uint32_t RDR;
    volatile uint32_t TDR;
} USART_TypeDef;

typedef struct
{
    volatile uint32_t ACR;
    volatile uint32_t KEYR;
    volatile uint32_t OPTKEYR;
    volatile uint32_t SR;
    volatile uint32_t CR;
    volatile uint32_t ECCR;
    volatile uint32_t OPTR;
    volatile uint32_t PCROP1SR;
    volatile uint32_t PCROP1ER;
    volatile uint32_t WRP1AR;
    volatile uint32_t WRP1BR;
} FLASH_TypeDef;

typedef struct
{
    uint32_t magic;
    uint32_t version;
    uint32_t image_size;
    uint32_t image_crc32;
    uint32_t load_address;
    uint32_t reserved[3];
} image_header_t;

typedef struct
{
    uint8_t sof;
    uint8_t type;
    uint16_t length;
    uint32_t offset;
    uint8_t data[UART_PACKET_DATA_SIZE];
    uint32_t crc32;
} uart_packet_t;

#define USART1_BASE                      0x40013800UL
#define FLASH_REG_BASE                   0x40022000UL

#define USART1                           ((USART_TypeDef *)USART1_BASE)
#define FLASHREG                         ((FLASH_TypeDef *)FLASH_REG_BASE)

#define FLASH_KEY1                       0x45670123UL
#define FLASH_KEY2                       0xCDEF89ABUL

#define FLASH_SR_BSY                     (1UL << 16)
#define FLASH_SR_EOP                     (1UL << 0)

#define FLASH_CR_PG                      (1UL << 0)
#define FLASH_CR_PER                     (1UL << 1)
#define FLASH_CR_MER1                    (1UL << 2)
#define FLASH_CR_STRT                    (1UL << 16)
#define FLASH_CR_LOCK                    (1UL << 31)

#define USART_CR1_UE                     (1UL << 0)
#define USART_CR1_RE                     (1UL << 2)
#define USART_CR1_TE                     (1UL << 3)
#define USART_ISR_RXNE                   (1UL << 5)
#define USART_ISR_TXE                    (1UL << 7)
#define USART_ISR_TC                     (1UL << 6)

#define UART_PKT_TYPE_HEADER             0x01
#define UART_PKT_TYPE_DATA               0x02
#define UART_PKT_TYPE_DONE               0x03
#define UART_PKT_TYPE_ABORT              0x04
#define UART_PKT_TYPE_ACK                0x79
#define UART_PKT_TYPE_NACK               0x1F

static uint8_t g_block_buf[SD_BLOCK_SIZE];
static uint8_t g_page_buf[FLASH_PAGE_SIZE];

static void sys_clock_init(void);
static void gpio_init(void);
static void uart_init(void);
static void sd_init(void);
static int  sd_read_block(uint32_t block_idx, uint8_t *buf);
static int  sd_find_update(uint32_t *start_block, image_header_t *hdr);
static int  uart_try_receive_update(image_header_t *hdr);
static int  program_image_from_sd(uint32_t start_block, const image_header_t *hdr);
static int  program_image_from_uart(const image_header_t *hdr);
static int  validate_application(void);
static void jump_to_application(void);
static int  should_enter_bootloader(void);
static void clear_boot_flag(void);
static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t len);
static uint32_t crc32_calc(const uint8_t *data, uint32_t len);
static void flash_unlock(void);
static void flash_lock(void);
static int  flash_wait_ready(void);
static int  flash_erase_range(uint32_t addr, uint32_t len);
static int  flash_program(uint32_t addr, const uint8_t *data, uint32_t len);
static void uart_write8(uint8_t b);
static uint8_t uart_read8_blocking(void);
static int uart_read_exact(uint8_t *buf, uint32_t len, uint32_t timeout);
static void uart_send_status(uint8_t code);
static void memory_barrier(void);

static void memory_barrier(void)
{
    __asm volatile ("dsb");
    __asm volatile ("isb");
}

static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t len)
{
    crc = ~crc;
    for (uint32_t i = 0; i < len; i++)
    {
        crc ^= data[i];
        for (uint32_t j = 0; j < 8; j++)
        {
            uint32_t mask = (uint32_t)(-(int32_t)(crc & 1U));
            crc = (crc >> 1) ^ (0xEDB88320UL & mask);
        }
    }
    return ~crc;
}

static uint32_t crc32_calc(const uint8_t *data, uint32_t len)
{
    return crc32_update(0, data, len);
}

static void sys_clock_init(void)
{
}

static void gpio_init(void)
{
}

static void uart_init(void)
{
    USART1->CR1 = 0;
    USART1->BRR = (BOOTLOADER_HSE_HZ + (BOOTLOADER_UART_BAUD / 2U)) / BOOTLOADER_UART_BAUD;
    USART1->CR1 = USART_CR1_UE | USART_CR1_RE | USART_CR1_TE;
}

static void sd_init(void)
{
}

static int sd_read_block(uint32_t block_idx, uint8_t *buf)
{
    (void)block_idx;
    (void)buf;
    return -1;
}

static int sd_find_update(uint32_t *start_block, image_header_t *hdr)
{
    for (uint32_t blk = 0; blk < 2048U; blk++)
    {
        if (sd_read_block(blk, g_block_buf) != 0)
        {
            continue;
        }

        memcpy(hdr, g_block_buf, sizeof(image_header_t));
        if (hdr->magic == UPDATE_MAGIC &&
            hdr->version == UPDATE_VERSION &&
            hdr->load_address == APP_BASE_ADDR &&
            hdr->image_size > 0 &&
            hdr->image_size <= APP_MAX_SIZE)
        {
            *start_block = blk;
            return 0;
        }
    }
    return -1;
}

static void flash_unlock(void)
{
    if (FLASHREG->CR & FLASH_CR_LOCK)
    {
        FLASHREG->KEYR = FLASH_KEY1;
        FLASHREG->KEYR = FLASH_KEY2;
    }
}

static void flash_lock(void)
{
    FLASHREG->CR |= FLASH_CR_LOCK;
}

static int flash_wait_ready(void)
{
    while (FLASHREG->SR & FLASH_SR_BSY)
    {
    }
    FLASHREG->SR = FLASH_SR_EOP;
    return 0;
}

static int flash_erase_page(uint32_t page_addr)
{
    flash_wait_ready();
    FLASHREG->CR = FLASH_CR_PER;
    *(volatile uint32_t *)(FLASH_BASE_ADDR + 0x08UL) = page_addr;
    FLASHREG->CR |= FLASH_CR_STRT;
    flash_wait_ready();
    FLASHREG->CR = 0;
    return 0;
}

static int flash_erase_range(uint32_t addr, uint32_t len)
{
    uint32_t start = addr - (addr % FLASH_PAGE_SIZE);
    uint32_t end = addr + len;
    for (uint32_t p = start; p < end; p += FLASH_PAGE_SIZE)
    {
        if (flash_erase_page(p) != 0)
        {
            return -1;
        }
    }
    return 0;
}

static int flash_program(uint32_t addr, const uint8_t *data, uint32_t len)
{
    uint32_t i = 0;
    while (i < len)
    {
        uint64_t q = 0xFFFFFFFFFFFFFFFFULL;
        uint32_t chunk = (len - i >= 8U) ? 8U : (len - i);
        memcpy(&q, &data[i], chunk);

        flash_wait_ready();
        FLASHREG->CR = FLASH_CR_PG;

        *(volatile uint32_t *)(addr + i) = (uint32_t)q;
        *(volatile uint32_t *)(addr + i + 4U) = (uint32_t)(q >> 32);

        flash_wait_ready();
        FLASHREG->CR = 0;

        if (*(volatile uint32_t *)(addr + i) != (uint32_t)q)
        {
            return -1;
        }

        i += 8U;
    }
    return 0;
}

static int program_image_from_sd(uint32_t start_block, const image_header_t *hdr)
{
    uint32_t total = hdr->image_size;
    uint32_t remaining = total;
    uint32_t addr = hdr->load_address;
    uint32_t block = start_block;
    uint32_t img_offset = 0;
    uint32_t crc = 0;
    uint32_t header_skip = sizeof(image_header_t);

    flash_unlock();
    if (flash_erase_range(addr, total) != 0)
    {
        flash_lock();
        return -1;
    }

    while (remaining > 0)
    {
        if (sd_read_block(block, g_block_buf) != 0)
        {
            flash_lock();
            return -1;
        }

        uint32_t copy_offset = 0;
        uint32_t avail = SD_BLOCK_SIZE;

        if (block == start_block)
        {
            if (avail < header_skip)
            {
                flash_lock();
                return -1;
            }
            copy_offset = header_skip;
            avail -= header_skip;
        }

        uint32_t chunk = (remaining < avail) ? remaining : avail;

        crc = crc32_update(crc, &g_block_buf[copy_offset], chunk);

        if (flash_program(addr + img_offset, &g_block_buf[copy_offset], chunk) != 0)
        {
            flash_lock();
            return -1;
        }

        img_offset += chunk;
        remaining -= chunk;
        block++;
    }

    flash_lock();

    if (crc != hdr->image_crc32)
    {
        return -1;
    }

    return 0;
}

static void uart_write8(uint8_t b)
{
    while ((USART1->ISR & USART_ISR_TXE) == 0U)
    {
    }
    USART1->TDR = b;
}

static uint8_t uart_read8_blocking(void)
{
    while ((USART1->ISR & USART_ISR_RXNE) == 0U)
    {
    }
    return (uint8_t)USART1->RDR;
}

static int uart_read_exact(uint8_t *buf, uint32_t len, uint32_t timeout)
{
    volatile uint32_t t = timeout;
    uint32_t idx = 0;
    while (idx < len)
    {
        if (USART1->ISR & USART_ISR_RXNE)
        {
            buf[idx++] = (uint8_t)USART1->RDR;
            t = timeout;
        }
        else
        {
            if (t == 0U)
            {
                return -1;
            }
            t--;
        }
    }
    return 0;
}

static void uart_send_status(uint8_t code)
{
    uart_write8(code);
}

static int uart_try_receive_update(image_header_t *hdr)
{
    uint8_t sync[4];
    if (uart_read_exact(sync, sizeof(sync), 200000U) != 0)
    {
        return -1;
    }

    if (memcmp(sync, "BLUP", 4) != 0)
    {
        return -1;
    }

    if (uart_read_exact((uint8_t *)hdr, sizeof(image_header_t), 200000U) != 0)
    {
        return -1;
    }

    if (hdr->magic != UPDATE_MAGIC ||
        hdr->version != UPDATE_VERSION ||
        hdr->load_address != APP_BASE_ADDR ||
        hdr->image_size == 0 ||
        hdr->image_size > APP_MAX_SIZE)
    {
        uart_send_status(UART_PKT_TYPE_NACK);
        return -1;
    }

    uart_send_status(UART_PKT_TYPE_ACK);
    return 0;
}

static int program_image_from_uart(const image_header_t *hdr)
{
    uint32_t remaining = hdr->image_size;
    uint32_t written = 0;
    uint32_t crc = 0;
    uart_packet_t pkt;

    flash_unlock();
    if (flash_erase_range(hdr->load_address, hdr->image_size) != 0)
    {
        flash_lock();
        uart_send_status(UART_PKT_TYPE_NACK);
        return -1;
    }

    while (remaining > 0)
    {
        if (uart_read_exact((uint8_t *)&pkt.sof, 1, 400000U) != 0)
        {
            flash_lock();
            return -1;
        }

        if (pkt.sof != UART_SOF)
        {
            flash_lock();
            uart_send_status(UART_PKT_TYPE_NACK);
            return -1;
        }

        if (uart_read_exact((uint8_t *)&pkt.type, 1, 100000U) != 0 ||
            uart_read_exact((uint8_t *)&pkt.length, 2, 100000U) != 0 ||
            uart_read_exact((uint8_t *)&pkt.offset, 4, 100000U) != 0)
        {
            flash_lock();
            return -1;
        }

        if (pkt.type != UART_PKT_TYPE_DATA ||
            pkt.length == 0U ||
            pkt.length > UART_PACKET_DATA_SIZE ||
            pkt.offset != written)
        {
            flash_lock();
            uart_send_status(UART_PKT_TYPE_NACK);
            return -1;
        }

        if (uart_read_exact(pkt.data, pkt.length, 200000U) != 0 ||
            uart_read_exact((uint8_t *)&pkt.crc32, 4, 100000U) != 0)
        {
            flash_lock();
            return -1;
        }

        if (crc32_calc(pkt.data, pkt.length) != pkt.crc32)
        {
            flash_lock();
            uart_send_status(UART_PKT_TYPE_NACK);
            return -1;
        }

        if (flash_program(hdr->load_address + written, pkt.data, pkt.length) != 0)
        {
            flash_lock();
            uart_send_status(UART_PKT_TYPE_NACK);
            return -1;
        }

        crc = crc32_update(crc, pkt.data, pkt.length);
        written += pkt.length;
        remaining -= pkt.length;
        uart_send_status(UART_PKT_TYPE_ACK);
    }

    flash_lock();

    if (crc != hdr->image_crc32)
    {
        uart_send_status(UART_PKT_TYPE_NACK);
        return -1;
    }

    if (uart_read_exact((uint8_t *)&pkt.sof, 1, 100000U) != 0)
    {
        return -1;
    }
    if (pkt.sof != UART_SOF)
    {
        return -1;
    }
    if (uart_read_exact((uint8_t *)&pkt.type, 1, 100000U) != 0)
    {
        return -1;
    }
    if (pkt.type != UART_PKT_TYPE_DONE)
    {
        return -1;
    }

    uart_send_status(UART_PKT_TYPE_ACK);
    return 0;
}

static int should_enter_bootloader(void)
{
    uint32_t *flag = (uint32_t *)BOOT_FLAG_ADDR;

    if (*flag == BOOT_FLAG_VALUE)
    {
        return 1;
    }

    if ((GPIO_BOOT_PORT->IDR & (1UL << GPIO_BOOT_PIN)) == 0U)
    {
        return 1;
    }

    if (!validate_application())
    {
        return 1;
    }

    return 0;
}

static void clear_boot_flag(void)
{
    uint32_t *flag = (uint32_t *)BOOT_FLAG_ADDR;
    *flag = 0U;
}

static int validate_application(void)
{
    uint32_t sp = *(volatile uint32_t *)(APP_BASE_ADDR + 0U);
    uint32_t rv = *(volatile uint32_t *)(APP_BASE_ADDR + 4U);

    if (sp < SRAM_BASE_ADDR || sp >= SRAM_END_ADDR)
    {
        return 0;
    }

    if (rv < APP_BASE_ADDR || rv >= FLASH_END_ADDR)
    {
        return 0;
    }

    return 1;
}

typedef void (*app_entry_t)(void);

static void jump_to_application(void)
{
    uint32_t app_sp = *(volatile uint32_t *)(APP_BASE_ADDR + 0U);
    uint32_t app_pc = *(volatile uint32_t *)(APP_BASE_ADDR + 4U);
    app_entry_t entry = (app_entry_t)app_pc;

    clear_boot_flag();
    memory_barrier();
    SCB_VTOR = APP_BASE_ADDR;
    memory_barrier();

    __asm volatile ("msr msp, %0" : : "r" (app_sp) : );
    entry();
}

int main(void)
{
    image_header_t hdr;
    uint32_t sd_start_block = 0;
    int updated = 0;

    sys_clock_init();
    gpio_init();
    uart_init();
    sd_init();

    if (!should_enter_bootloader())
    {
        jump_to_application();
    }

    clear_boot_flag();

    if (sd_find_update(&sd_start_block, &hdr) == 0)
    {
        if (program_image_from_sd(sd_start_block, &hdr) == 0)
        {
            updated = 1;
        }
    }
    else if (uart_try_receive_update(&hdr) == 0)
    {
        if (program_image_from_uart(&hdr) == 0)
        {
            updated = 1;
        }
    }

    if (updated && validate_application())
    {
        jump_to_application();
    }

    while (1)
    {
        if (uart_try_receive_update(&hdr) == 0)
        {
            if (program_image_from_uart(&hdr) == 0 && validate_application())
            {
                jump_to_application();
            }
        }
    }
}

void Reset_Handler(void)
{
    main();
    while (1)
    {
    }
}