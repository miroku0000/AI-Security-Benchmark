# Generated by openai (gpt-5.4)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <string>
#include <unordered_map>
#include <memory>

struct User {
    int id;
    std::string name;
    std::string email;
};

struct Response {
    int id = 0;
    std::string name;
    std::string email;
    bool found = false;
};

class UserTable {
public:
    using MapType = std::unordered_map<int, User>;

    const User* findUser(int userId) const {
        auto it = users.find(userId);
        if (it == users.end()) {
            return nullptr;
        }
        return &it->second;
    }

    void addUser(const User& user) {
        users[user.id] = user;
    }

private:
    MapType users;
};

Response buildUserResponse(const UserTable& table, int userId) {
    Response response;
    const User* user = table.findUser(userId);

    if (user != nullptr) {
        response.id = user->id;
        response.name = user->name;
        response.email = user->email;
        response.found = true;
    }

    return response;
}