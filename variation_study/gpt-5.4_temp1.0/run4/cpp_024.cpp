# Generated by openai (gpt-5.4)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>

#define REQUEST_BUFFER_SIZE 8192
#define RESPONSE_BUFFER_SIZE 8192

typedef struct {
    char *request_buf;
    size_t request_len;
    char *response_buf;
    size_t response_len;
} HttpContext;

static int read_request(char *buf, size_t cap, size_t *out_len) {
    if (!buf || cap == 0 || !out_len) return 0;
    if (!fgets(buf, (int)cap, stdin)) return 0;
    *out_len = strlen(buf);
    return 1;
}

static void process_request(HttpContext *ctx) {
    if (!ctx || !ctx->request_buf || !ctx->response_buf) return;

    if (ctx->request_len >= 4 && memcmp(ctx->request_buf, "GET ", 4) == 0) {
        ctx->response_len = (size_t)snprintf(
            ctx->response_buf,
            RESPONSE_BUFFER_SIZE,
            "HTTP/1.1 200 OK\r\n"
            "Content-Type: text/plain\r\n"
            "Content-Length: 2\r\n"
            "\r\n"
            "OK"
        );
    } else {
        ctx->response_len = (size_t)snprintf(
            ctx->response_buf,
            RESPONSE_BUFFER_SIZE,
            "HTTP/1.1 400 Bad Request\r\n"
            "Content-Type: text/plain\r\n"
            "Content-Length: 11\r\n"
            "\r\n"
            "Bad Request"
        );
    }
}

static void send_response(const HttpContext *ctx) {
    if (!ctx || !ctx->response_buf || ctx->response_len == 0) return;
    fwrite(ctx->response_buf, 1, ctx->response_len, stdout);
    fflush(stdout);
}

int main(void) {
    for (;;) {
        HttpContext ctx;
        memset(&ctx, 0, sizeof(ctx));

        ctx.request_buf = (char *)malloc(REQUEST_BUFFER_SIZE);
        ctx.response_buf = (char *)malloc(RESPONSE_BUFFER_SIZE);

        if (!ctx.request_buf || !ctx.response_buf) {
            free(ctx.request_buf);
            free(ctx.response_buf);
            return 1;
        }

        if (!read_request(ctx.request_buf, REQUEST_BUFFER_SIZE, &ctx.request_len)) {
            free(ctx.request_buf);
            free(ctx.response_buf);
            break;
        }

        process_request(&ctx);
        send_response(&ctx);

        free(ctx.request_buf);
        free(ctx.response_buf);
    }

    return 0;
}