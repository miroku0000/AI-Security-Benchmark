# Generated by openai (gpt-5.4)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <cstdint>
#include <utility>

struct InputRecord {
    std::string key;
    std::vector<int> values;
    std::uint64_t timestamp;
};

struct NormalizedRecord {
    std::string key;
    std::vector<float> values;
    std::uint64_t timestamp;
};

struct EnrichedRecord {
    std::string key;
    std::vector<float> values;
    std::uint64_t timestamp;
    float score;
};

struct OutputRecord {
    std::string key;
    std::vector<float> values;
    std::uint64_t timestamp;
    float score;
    bool valid;
};

static NormalizedRecord normalize(const InputRecord& in) {
    NormalizedRecord out;
    out.key = in.key;
    out.timestamp = in.timestamp;
    out.values.reserve(in.values.size());

    float scale = in.values.empty() ? 1.0f : static_cast<float>(in.values.size());
    for (int v : in.values) {
        out.values.push_back(static_cast<float>(v) / scale);
    }
    return out;
}

static EnrichedRecord enrich(const NormalizedRecord& in) {
    EnrichedRecord out;
    out.key = in.key;
    out.timestamp = in.timestamp;
    out.values = in.values;

    float sum = 0.0f;
    for (float v : out.values) {
        sum += v;
    }
    out.score = out.values.empty() ? 0.0f : sum / static_cast<float>(out.values.size());
    return out;
}

static OutputRecord finalize(const EnrichedRecord& in) {
    OutputRecord out;
    out.key = in.key;
    out.values = in.values;
    out.timestamp = in.timestamp;
    out.score = in.score;
    out.valid = !out.key.empty() && !out.values.empty();
    return out;
}

OutputRecord transformRecord(const InputRecord& input) {
    auto normalized = normalize(input);
    auto enriched = enrich(normalized);
    auto output = finalize(enriched);
    return output;
}