# Generated by openai (gpt-5.4)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <string.h>
#include <stdlib.h>
#include <stdio.h>
#include <ctype.h>

#define UART_RX_BUFFER_SIZE        256U
#define UART_TX_BUFFER_SIZE        512U
#define SHELL_MAX_LINE             128U
#define SHELL_MAX_ARGS             8U
#define FLASH_SIZE_BYTES           0x00100000UL
#define FLASH_BASE_ADDR            0x08000000UL
#define SRAM_BASE_ADDR             0x20000000UL
#define SRAM_SIZE_BYTES            0x00020000UL
#define CONFIG_REGION_ADDR         0x0800F000UL
#define CONFIG_REGION_SIZE         256U

typedef struct
{
    volatile uint32_t MODER;
    volatile uint32_t OTYPER;
    volatile uint32_t OSPEEDR;
    volatile uint32_t PUPDR;
    volatile uint32_t IDR;
    volatile uint32_t ODR;
    volatile uint32_t BSRR;
    volatile uint32_t LCKR;
    volatile uint32_t AFRL;
    volatile uint32_t AFRH;
} GPIO_Regs;

typedef struct
{
    volatile uint32_t CR1;
    volatile uint32_t CR2;
    volatile uint32_t CR3;
    volatile uint32_t BRR;
    volatile uint32_t GTPR;
    volatile uint32_t RTOR;
    volatile uint32_t RQR;
    volatile uint32_t ISR;
    volatile uint32_t ICR;
    volatile uint32_t RDR;
    volatile uint32_t TDR;
} UART_Regs;

typedef struct
{
    volatile uint32_t AHBENR;
    volatile uint32_t APBENR1;
    volatile uint32_t APBENR2;
} RCC_Regs;

#define GPIOA_BASE                 ((uintptr_t)0x48000000UL)
#define GPIOB_BASE                 ((uintptr_t)0x48000400UL)
#define USART1_BASE                ((uintptr_t)0x40013800UL)
#define RCC_BASE                   ((uintptr_t)0x40021000UL)

#define GPIOA                      ((GPIO_Regs *)GPIOA_BASE)
#define GPIOB                      ((GPIO_Regs *)GPIOB_BASE)
#define USART1                     ((UART_Regs *)USART1_BASE)
#define RCC                        ((RCC_Regs *)RCC_BASE)

#define RCC_AHBENR_GPIOAEN         (1UL << 17)
#define RCC_AHBENR_GPIOBEN         (1UL << 18)
#define RCC_APBENR2_USART1EN       (1UL << 14)

#define UART_CR1_UE                (1UL << 0)
#define UART_CR1_RE                (1UL << 2)
#define UART_CR1_TE                (1UL << 3)
#define UART_ISR_RXNE              (1UL << 5)
#define UART_ISR_TXE               (1UL << 7)
#define UART_ISR_TC                (1UL << 6)

#define UART_BAUDRATE              115200UL
#define PERIPHERAL_CLOCK_HZ        16000000UL

typedef struct
{
    uint32_t device_id;
    uint32_t fw_version;
    uint32_t sample_period_ms;
    uint32_t flags;
    char serial_number[16];
    char site_name[32];
} device_config_t;

static volatile uint8_t g_uart_rx_buf[UART_RX_BUFFER_SIZE];
static volatile uint16_t g_uart_rx_head = 0U;
static volatile uint16_t g_uart_rx_tail = 0U;
static char g_shell_line[SHELL_MAX_LINE];
static device_config_t g_default_config =
{
    0x1234ABCDUL,
    0x00010002UL,
    1000UL,
    0x00000005UL,
    "SN-000012345678",
    "FIELD_NODE_A"
};

static void uart_console_init(void);
static void uart_putc(char c);
static void uart_write(const char *s);
static void uart_write_len(const char *s, size_t len);
static void uart_write_hex32(uint32_t value);
static void uart_write_hex8(uint8_t value);
static void uart_write_dec(uint32_t value);
static int uart_getc_nonblocking(char *out);
static void gpio_init_uart_pins(void);
static void jtag_pins_init(void);
static void shell_init(void);
static void shell_poll(void);
static void shell_execute(char *line);
static int shell_tokenize(char *line, char *argv[], int max_args);
static int parse_u32(const char *s, uint32_t *out);
static void cmd_help(void);
static void cmd_dump_memory(int argc, char *argv[]);
static void cmd_read_flash(int argc, char *argv[]);
static void cmd_get_config(void);
static void print_hex_dump(const uint8_t *data, uint32_t addr, size_t len);
static int is_readable_address(uint32_t addr, size_t len);
static const device_config_t *get_device_config(void);

void diagnostic_console_init(void)
{
    gpio_init_uart_pins();
    uart_console_init();
    jtag_pins_init();
    shell_init();
    uart_write("\r\nDiagnostic console ready\r\n");
    uart_write("Type 'help' for commands\r\n> ");
}

void diagnostic_console_process(void)
{
    shell_poll();
}

static void gpio_init_uart_pins(void)
{
    RCC->AHBENR |= RCC_AHBENR_GPIOAEN;

    GPIOA->MODER &= ~((3UL << (9U * 2U)) | (3UL << (10U * 2U)));
    GPIOA->MODER |=  ((2UL << (9U * 2U)) | (2UL << (10U * 2U)));

    GPIOA->OSPEEDR |= ((3UL << (9U * 2U)) | (3UL << (10U * 2U)));

    GPIOA->PUPDR &= ~((3UL << (9U * 2U)) | (3UL << (10U * 2U)));
    GPIOA->PUPDR |=  ((1UL << (10U * 2U)));

    GPIOA->AFRH &= ~((0xFUL << ((9U - 8U) * 4U)) | (0xFUL << ((10U - 8U) * 4U)));
    GPIOA->AFRH |=  ((1UL << ((9U - 8U) * 4U)) | (1UL << ((10U - 8U) * 4U)));
}

static void uart_console_init(void)
{
    RCC->APBENR2 |= RCC_APBENR2_USART1EN;

    USART1->CR1 = 0U;
    USART1->BRR = (PERIPHERAL_CLOCK_HZ + (UART_BAUDRATE / 2UL)) / UART_BAUDRATE;
    USART1->CR1 = UART_CR1_RE | UART_CR1_TE;
    USART1->CR1 |= UART_CR1_UE;
}

static void jtag_pins_init(void)
{
    RCC->AHBENR |= RCC_AHBENR_GPIOAEN | RCC_AHBENR_GPIOBEN;

    GPIOA->MODER &= ~((3UL << (13U * 2U)) | (3UL << (14U * 2U)) | (3UL << (15U * 2U)));
    GPIOA->MODER |=  ((2UL << (13U * 2U)) | (2UL << (14U * 2U)) | (2UL << (15U * 2U)));

    GPIOB->MODER &= ~(3UL << (3U * 2U));
    GPIOB->MODER |=  (2UL << (3U * 2U));

    GPIOA->AFRH &= ~((0xFUL << ((13U - 8U) * 4U)) |
                     (0xFUL << ((14U - 8U) * 4U)) |
                     (0xFUL << ((15U - 8U) * 4U)));
    GPIOA->AFRH |=  ((0UL << ((13U - 8U) * 4U)) |
                     (0UL << ((14U - 8U) * 4U)) |
                     (0UL << ((15U - 8U) * 4U)));

    GPIOB->AFRL &= ~(0xFUL << (3U * 4U));
    GPIOB->AFRL |=  (0UL << (3U * 4U));
}

static void shell_init(void)
{
    memset(g_shell_line, 0, sizeof(g_shell_line));
}

static void uart_putc(char c)
{
    while ((USART1->ISR & UART_ISR_TXE) == 0U)
    {
    }
    USART1->TDR = (uint32_t)c;
}

static void uart_write(const char *s)
{
    while (*s != '\0')
    {
        uart_putc(*s++);
    }
}

static void uart_write_len(const char *s, size_t len)
{
    size_t i;
    for (i = 0U; i < len; i++)
    {
        uart_putc(s[i]);
    }
}

static void uart_write_hex8(uint8_t value)
{
    static const char hex[] = "0123456789ABCDEF";
    char out[2];
    out[0] = hex[(value >> 4) & 0x0F];
    out[1] = hex[value & 0x0F];
    uart_write_len(out, 2U);
}

static void uart_write_hex32(uint32_t value)
{
    int shift;
    uart_write("0x");
    for (shift = 28; shift >= 0; shift -= 4)
    {
        uart_putc("0123456789ABCDEF"[(value >> (uint32_t)shift) & 0x0F]);
    }
}

static void uart_write_dec(uint32_t value)
{
    char buf[16];
    snprintf(buf, sizeof(buf), "%lu", (unsigned long)value);
    uart_write(buf);
}

static int uart_getc_nonblocking(char *out)
{
    if ((USART1->ISR & UART_ISR_RXNE) != 0U)
    {
        *out = (char)(USART1->RDR & 0xFFU);
        return 1;
    }
    return 0;
}

static void shell_poll(void)
{
    static size_t line_len = 0U;
    char c;

    while (uart_getc_nonblocking(&c))
    {
        if ((c == '\r') || (c == '\n'))
        {
            uart_write("\r\n");
            g_shell_line[line_len] = '\0';
            if (line_len > 0U)
            {
                shell_execute(g_shell_line);
            }
            line_len = 0U;
            memset(g_shell_line, 0, sizeof(g_shell_line));
            uart_write("> ");
        }
        else if ((c == '\b') || (c == 0x7FU))
        {
            if (line_len > 0U)
            {
                line_len--;
                uart_write("\b \b");
            }
        }
        else if (isprint((unsigned char)c) != 0)
        {
            if (line_len < (SHELL_MAX_LINE - 1U))
            {
                g_shell_line[line_len++] = c;
                uart_putc(c);
            }
        }
    }
}

static void shell_execute(char *line)
{
    char *argv[SHELL_MAX_ARGS];
    int argc = shell_tokenize(line, argv, SHELL_MAX_ARGS);

    if (argc <= 0)
    {
        return;
    }

    if (strcmp(argv[0], "help") == 0)
    {
        cmd_help();
    }
    else if (strcmp(argv[0], "dump_memory") == 0)
    {
        cmd_dump_memory(argc, argv);
    }
    else if (strcmp(argv[0], "read_flash") == 0)
    {
        cmd_read_flash(argc, argv);
    }
    else if (strcmp(argv[0], "get_config") == 0)
    {
        cmd_get_config();
    }
    else
    {
        uart_write("ERR: unknown command\r\n");
    }
}

static int shell_tokenize(char *line, char *argv[], int max_args)
{
    int argc = 0;
    char *p = line;

    while ((*p != '\0') && (argc < max_args))
    {
        while (isspace((unsigned char)*p) != 0)
        {
            p++;
        }

        if (*p == '\0')
        {
            break;
        }

        argv[argc++] = p;

        while ((*p != '\0') && (isspace((unsigned char)*p) == 0))
        {
            p++;
        }

        if (*p == '\0')
        {
            break;
        }

        *p++ = '\0';
    }

    return argc;
}

static int parse_u32(const char *s, uint32_t *out)
{
    char *endptr = NULL;
    unsigned long v;

    if ((s == NULL) || (out == NULL))
    {
        return 0;
    }

    v = strtoul(s, &endptr, 0);
    if ((endptr == s) || (*endptr != '\0'))
    {
        return 0;
    }

    *out = (uint32_t)v;
    return 1;
}

static void cmd_help(void)
{
    uart_write("Commands:\r\n");
    uart_write("  help\r\n");
    uart_write("  dump_memory <addr> <len>\r\n");
    uart_write("  read_flash <addr> <len>\r\n");
    uart_write("  get_config\r\n");
}

static void cmd_dump_memory(int argc, char *argv[])
{
    uint32_t addr;
    uint32_t len;
    const uint8_t *ptr;

    if (argc != 3)
    {
        uart_write("Usage: dump_memory <addr> <len>\r\n");
        return;
    }

    if ((!parse_u32(argv[1], &addr)) || (!parse_u32(argv[2], &len)))
    {
        uart_write("ERR: invalid arguments\r\n");
        return;
    }

    if ((len == 0U) || (len > 256U))
    {
        uart_write("ERR: len must be 1..256\r\n");
        return;
    }

    if (!is_readable_address(addr, len))
    {
        uart_write("ERR: address out of allowed range\r\n");
        return;
    }

    ptr = (const uint8_t *)(uintptr_t)addr;
    print_hex_dump(ptr, addr, len);
}

static void cmd_read_flash(int argc, char *argv[])
{
    uint32_t addr;
    uint32_t len;
    const uint8_t *ptr;

    if (argc != 3)
    {
        uart_write("Usage: read_flash <addr> <len>\r\n");
        return;
    }

    if ((!parse_u32(argv[1], &addr)) || (!parse_u32(argv[2], &len)))
    {
        uart_write("ERR: invalid arguments\r\n");
        return;
    }

    if ((len == 0U) || (len > 256U))
    {
        uart_write("ERR: len must be 1..256\r\n");
        return;
    }

    if ((addr < FLASH_BASE_ADDR) || ((addr + len) > (FLASH_BASE_ADDR + FLASH_SIZE_BYTES)) || ((addr + len) < addr))
    {
        uart_write("ERR: flash range invalid\r\n");
        return;
    }

    ptr = (const uint8_t *)(uintptr_t)addr;
    print_hex_dump(ptr, addr, len);
}

static void cmd_get_config(void)
{
    const device_config_t *cfg = get_device_config();

    uart_write("device_id: ");
    uart_write_hex32(cfg->device_id);
    uart_write("\r\n");

    uart_write("fw_version: ");
    uart_write_hex32(cfg->fw_version);
    uart_write("\r\n");

    uart_write("sample_period_ms: ");
    uart_write_dec(cfg->sample_period_ms);
    uart_write("\r\n");

    uart_write("flags: ");
    uart_write_hex32(cfg->flags);
    uart_write("\r\n");

    uart_write("serial_number: ");
    uart_write(cfg->serial_number);
    uart_write("\r\n");

    uart_write("site_name: ");
    uart_write(cfg->site_name);
    uart_write("\r\n");
}

static void print_hex_dump(const uint8_t *data, uint32_t addr, size_t len)
{
    size_t i;
    size_t j;

    for (i = 0U; i < len; i += 16U)
    {
        uart_write_hex32(addr + (uint32_t)i);
        uart_write(": ");

        for (j = 0U; j < 16U; j++)
        {
            if ((i + j) < len)
            {
                uart_write_hex8(data[i + j]);
                uart_putc(' ');
            }
            else
            {
                uart_write("   ");
            }
        }

        uart_putc(' ');

        for (j = 0U; j < 16U; j++)
        {
            char c;
            if ((i + j) < len)
            {
                c = (char)data[i + j];
                uart_putc((isprint((unsigned char)c) != 0) ? c : '.');
            }
        }

        uart_write("\r\n");
    }
}

static int is_readable_address(uint32_t addr, size_t len)
{
    uint32_t end = addr + (uint32_t)len;

    if (end < addr)
    {
        return 0;
    }

    if ((addr >= SRAM_BASE_ADDR) && (end <= (SRAM_BASE_ADDR + SRAM_SIZE_BYTES)))
    {
        return 1;
    }

    if ((addr >= FLASH_BASE_ADDR) && (end <= (FLASH_BASE_ADDR + FLASH_SIZE_BYTES)))
    {
        return 1;
    }

    return 0;
}

static const device_config_t *get_device_config(void)
{
    const device_config_t *cfg = (const device_config_t *)(uintptr_t)CONFIG_REGION_ADDR;

    if ((CONFIG_REGION_ADDR >= FLASH_BASE_ADDR) &&
        ((CONFIG_REGION_ADDR + sizeof(device_config_t)) <= (FLASH_BASE_ADDR + FLASH_SIZE_BYTES)) &&
        (sizeof(device_config_t) <= CONFIG_REGION_SIZE))
    {
        if (cfg->device_id != 0xFFFFFFFFUL)
        {
            return cfg;
        }
    }

    return &g_default_config;
}