# Generated by openai (gpt-5.4)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <vector>
#include <thread>
#include <shared_mutex>
#include <mutex>
#include <random>
#include <string>
#include <iomanip>
#include <stdexcept>
#include <chrono>

class Bank {
public:
    void addAccount(int accountId, double initialBalance) {
        std::unique_lock<std::shared_mutex> lock(mutex_);
        accounts_[accountId] = initialBalance;
    }

    bool deposit(int accountId, double amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(accountId);
        if (it == accounts_.end()) return false;
        it->second += amount;
        return true;
    }

    bool withdraw(int accountId, double amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(accountId);
        if (it == accounts_.end()) return false;
        if (it->second < amount) return false;
        it->second -= amount;
        return true;
    }

    bool transfer(int fromId, int toId, double amount) {
        if (amount < 0 || fromId == toId) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto fromIt = accounts_.find(fromId);
        auto toIt = accounts_.find(toId);
        if (fromIt == accounts_.end() || toIt == accounts_.end()) return false;
        if (fromIt->second < amount) return false;
        fromIt->second -= amount;
        toIt->second += amount;
        return true;
    }

    bool getBalance(int accountId, double& balance) const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(accountId);
        if (it == accounts_.end()) return false;
        balance = it->second;
        return true;
    }

    double totalBalance() const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        double total = 0.0;
        for (const auto& [id, balance] : accounts_) {
            total += balance;
        }
        return total;
    }

    void printAccounts() const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        std::cout << "\nFinal account balances:\n";
        for (const auto& [id, balance] : accounts_) {
            std::cout << "Account " << id << ": $" << std::fixed << std::setprecision(2) << balance << '\n';
        }
    }

private:
    mutable std::shared_mutex mutex_;
    std::unordered_map<int, double> accounts_;
};

void transactionWorker(Bank& bank, const std::vector<int>& accountIds, int operations, int workerId) {
    std::mt19937 rng(std::random_device{}() + workerId);
    std::uniform_int_distribution<int> actionDist(0, 3);
    std::uniform_int_distribution<int> accountDist(0, static_cast<int>(accountIds.size()) - 1);
    std::uniform_real_distribution<double> amountDist(1.0, 500.0);

    for (int i = 0; i < operations; ++i) {
        int action = actionDist(rng);
        int acc1 = accountIds[accountDist(rng)];
        int acc2 = accountIds[accountDist(rng)];
        double amount = amountDist(rng);

        switch (action) {
            case 0: {
                bank.deposit(acc1, amount);
                break;
            }
            case 1: {
                bank.withdraw(acc1, amount);
                break;
            }
            case 2: {
                bank.transfer(acc1, acc2, amount);
                break;
            }
            case 3: {
                double balance = 0.0;
                bank.getBalance(acc1, balance);
                break;
            }
        }
    }
}

void readerWorker(const Bank& bank, const std::vector<int>& accountIds, int reads, int readerId) {
    std::mt19937 rng(std::random_device{}() + readerId * 101);
    std::uniform_int_distribution<int> accountDist(0, static_cast<int>(accountIds.size()) - 1);

    for (int i = 0; i < reads; ++i) {
        double balance = 0.0;
        bank.getBalance(accountIds[accountDist(rng)], balance);
        if (i % 100 == 0) {
            volatile double snapshot = bank.totalBalance();
            (void)snapshot;
        }
    }
}

int main() {
    Bank bank;

    const int numAccounts = 10;
    const double initialBalance = 1000.0;

    std::vector<int> accountIds;
    accountIds.reserve(numAccounts);

    for (int i = 1; i <= numAccounts; ++i) {
        bank.addAccount(i, initialBalance);
        accountIds.push_back(i);
    }

    const int numTransactionThreads = 6;
    const int numReaderThreads = 4;
    const int operationsPerTransactionThread = 5000;
    const int readsPerReaderThread = 3000;

    std::vector<std::thread> threads;

    for (int i = 0; i < numTransactionThreads; ++i) {
        threads.emplace_back(transactionWorker, std::ref(bank), std::cref(accountIds), operationsPerTransactionThread, i);
    }

    for (int i = 0; i < numReaderThreads; ++i) {
        threads.emplace_back(readerWorker, std::cref(bank), std::cref(accountIds), readsPerReaderThread, i);
    }

    for (auto& t : threads) {
        t.join();
    }

    bank.printAccounts();
    std::cout << "Total balance across all accounts: $" << std::fixed << std::setprecision(2) << bank.totalBalance() << '\n';

    return 0;
}