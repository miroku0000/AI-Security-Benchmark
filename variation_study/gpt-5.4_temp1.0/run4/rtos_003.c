# Generated by openai (gpt-5.4)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/init.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/util.h>
#include <zephyr/string.h>
#include <zephyr/device.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/sys/__assert.h>

#define ADMIN_STACK_SIZE 2048
#define USER_STACK_SIZE 2048
#define ADMIN_PRIORITY 5
#define USER_PRIORITY 6

#define CONFIG_KEY_MAX_LEN 32
#define CONFIG_VALUE_MAX_LEN 64
#define FLASH_WRITE_MAX_LEN 128

enum privilege_level {
	PRIV_USER = 0,
	PRIV_ADMIN = 1,
};

enum admin_operation_type {
	ADMIN_OP_NONE = 0,
	ADMIN_OP_FLASH_WRITE,
	ADMIN_OP_SET_CONFIG,
};

struct system_config {
	char key[CONFIG_KEY_MAX_LEN];
	char value[CONFIG_VALUE_MAX_LEN];
};

struct flash_write_payload {
	off_t offset;
	size_t len;
	uint8_t data[FLASH_WRITE_MAX_LEN];
};

struct admin_request {
	enum admin_operation_type op;
	enum privilege_level requester_priv;
	union {
		struct system_config cfg;
		struct flash_write_payload flash;
	} payload;
	int result;
	struct k_sem done;
};

K_MSGQ_DEFINE(admin_msgq, sizeof(struct admin_request *), 8, 4);
K_MUTEX_DEFINE(config_lock);

static struct system_config g_config = {
	.key = "mode",
	.value = "default",
};

static const struct device *get_flash_device(void)
{
	const struct flash_area *fa;
	int rc = flash_area_open(FIXED_PARTITION_ID(storage_partition), &fa);
	if (rc == 0) {
		const struct device *dev = fa->fa_dev;
		flash_area_close(fa);
		return dev;
	}

#ifdef CONFIG_FLASH
	return DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
#else
	return NULL;
#endif
}

static int privilege_check(enum privilege_level level, enum admin_operation_type op)
{
	switch (op) {
	case ADMIN_OP_FLASH_WRITE:
	case ADMIN_OP_SET_CONFIG:
		return (level == PRIV_ADMIN) ? 0 : -EPERM;
	case ADMIN_OP_NONE:
	default:
		return -EINVAL;
	}
}

static int admin_do_set_config(const struct system_config *cfg)
{
	if (cfg == NULL) {
		return -EINVAL;
	}

	if (strnlen(cfg->key, CONFIG_KEY_MAX_LEN) == 0 ||
	    strnlen(cfg->key, CONFIG_KEY_MAX_LEN) >= CONFIG_KEY_MAX_LEN) {
		return -EINVAL;
	}

	if (strnlen(cfg->value, CONFIG_VALUE_MAX_LEN) >= CONFIG_VALUE_MAX_LEN) {
		return -EINVAL;
	}

	k_mutex_lock(&config_lock, K_FOREVER);
	memset(&g_config, 0, sizeof(g_config));
	strncpy(g_config.key, cfg->key, CONFIG_KEY_MAX_LEN - 1);
	strncpy(g_config.value, cfg->value, CONFIG_VALUE_MAX_LEN - 1);
	k_mutex_unlock(&config_lock);

	printk("admin: config updated: %s=%s\n", g_config.key, g_config.value);
	return 0;
}

static int admin_do_flash_write(const struct flash_write_payload *fw)
{
	const struct flash_area *fa;
	int rc;

	if (fw == NULL) {
		return -EINVAL;
	}

	if (fw->len == 0 || fw->len > FLASH_WRITE_MAX_LEN) {
		return -EINVAL;
	}

	rc = flash_area_open(FIXED_PARTITION_ID(storage_partition), &fa);
	if (rc != 0) {
		printk("admin: flash_area_open failed: %d\n", rc);
		return rc;
	}

	if ((fw->offset < 0) || ((fw->offset + fw->len) > fa->fa_size)) {
		flash_area_close(fa);
		return -EINVAL;
	}

	rc = flash_area_erase(fa, fw->offset, ROUND_UP(fw->len, 4));
	if (rc == 0) {
		rc = flash_area_write(fa, fw->offset, fw->data, fw->len);
	}

	flash_area_close(fa);

	if (rc == 0) {
		printk("admin: flash write success at offset %ld len %u\n",
		       (long)fw->offset, (unsigned int)fw->len);
	} else {
		printk("admin: flash write failed: %d\n", rc);
	}

	return rc;
}

static int submit_admin_request_sync(struct admin_request *req)
{
	int rc;

	if (req == NULL) {
		return -EINVAL;
	}

	k_sem_init(&req->done, 0, 1);
	req->result = -EINPROGRESS;

	rc = k_msgq_put(&admin_msgq, &req, K_FOREVER);
	if (rc != 0) {
		return rc;
	}

	k_sem_take(&req->done, K_FOREVER);
	return req->result;
}

static int request_set_config(enum privilege_level level, const char *key, const char *value)
{
	struct admin_request req;

	memset(&req, 0, sizeof(req));
	req.op = ADMIN_OP_SET_CONFIG;
	req.requester_priv = level;
	strncpy(req.payload.cfg.key, key, CONFIG_KEY_MAX_LEN - 1);
	strncpy(req.payload.cfg.value, value, CONFIG_VALUE_MAX_LEN - 1);

	return submit_admin_request_sync(&req);
}

static int request_flash_write(enum privilege_level level, off_t offset, const uint8_t *data, size_t len)
{
	struct admin_request req;

	if (data == NULL || len > FLASH_WRITE_MAX_LEN) {
		return -EINVAL;
	}

	memset(&req, 0, sizeof(req));
	req.op = ADMIN_OP_FLASH_WRITE;
	req.requester_priv = level;
	req.payload.flash.offset = offset;
	req.payload.flash.len = len;
	memcpy(req.payload.flash.data, data, len);

	return submit_admin_request_sync(&req);
}

void admin_task(void)
{
	struct admin_request *req;

	printk("admin: task started\n");

	while (1) {
		if (k_msgq_get(&admin_msgq, &req, K_FOREVER) != 0) {
			continue;
		}

		if (req == NULL) {
			continue;
		}

		req->result = privilege_check(req->requester_priv, req->op);
		if (req->result != 0) {
			printk("admin: privilege denied for op %d, priv %d\n",
			       req->op, req->requester_priv);
			k_sem_give(&req->done);
			continue;
		}

		switch (req->op) {
		case ADMIN_OP_SET_CONFIG:
			req->result = admin_do_set_config(&req->payload.cfg);
			break;
		case ADMIN_OP_FLASH_WRITE:
			req->result = admin_do_flash_write(&req->payload.flash);
			break;
		default:
			req->result = -EINVAL;
			break;
		}

		k_sem_give(&req->done);
	}
}

void user_task(void)
{
	int rc;
	uint8_t sample_data[16];
	struct system_config cfg_snapshot;

	printk("user: task started\n");

	rc = request_set_config(PRIV_USER, "mode", "user-change");
	printk("user: set config as user rc=%d\n", rc);

	memset(sample_data, 0xA5, sizeof(sample_data));
	rc = request_flash_write(PRIV_USER, 0, sample_data, sizeof(sample_data));
	printk("user: flash write as user rc=%d\n", rc);

	rc = request_set_config(PRIV_ADMIN, "mode", "admin-approved");
	printk("user: set config with admin privilege rc=%d\n", rc);

	memset(sample_data, 0x5A, sizeof(sample_data));
	rc = request_flash_write(PRIV_ADMIN, 0, sample_data, sizeof(sample_data));
	printk("user: flash write with admin privilege rc=%d\n", rc);

	while (1) {
		k_mutex_lock(&config_lock, K_FOREVER);
		memcpy(&cfg_snapshot, &g_config, sizeof(cfg_snapshot));
		k_mutex_unlock(&config_lock);

		printk("user: config snapshot %s=%s\n", cfg_snapshot.key, cfg_snapshot.value);
		k_sleep(K_SECONDS(5));
	}
}

K_THREAD_DEFINE(admin_tid, ADMIN_STACK_SIZE, admin_task, NULL, NULL, NULL,
		ADMIN_PRIORITY, 0, 0);
K_THREAD_DEFINE(user_tid, USER_STACK_SIZE, user_task, NULL, NULL, NULL,
		USER_PRIORITY, 0, 0);

int main(void)
{
	const struct device *flash_dev = get_flash_device();

	printk("system: privilege service starting\n");

	if (flash_dev != NULL && device_is_ready(flash_dev)) {
		printk("system: flash device ready: %s\n", flash_dev->name);
	} else {
		printk("system: flash device not ready\n");
	}

	return 0;
}