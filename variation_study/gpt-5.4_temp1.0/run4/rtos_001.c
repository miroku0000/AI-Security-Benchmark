# Generated by openai (gpt-5.4)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>

typedef struct
{
    uint32_t timestamp;
    float temperature;
    float pressure;
    float flow;
    uint32_t sequence;
} sensor_data_t;

volatile sensor_data_t sensor_data = {0};

static uint32_t get_timestamp(void)
{
    return (uint32_t)xTaskGetTickCount();
}

static float read_temperature_sensor(void)
{
    static float v = 25.0f;
    v += 0.1f;
    return v;
}

static float read_pressure_sensor(void)
{
    static float v = 1.0f;
    v += 0.05f;
    return v;
}

static float read_flow_sensor(void)
{
    static float v = 10.0f;
    v += 0.2f;
    return v;
}

static void apply_control_logic(float temperature, float pressure, float flow, uint32_t timestamp)
{
    (void)temperature;
    (void)pressure;
    (void)flow;
    (void)timestamp;
}

static void SensorReadTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        sensor_data.timestamp = get_timestamp();
        sensor_data.temperature = read_temperature_sensor();
        sensor_data.pressure = read_pressure_sensor();
        sensor_data.flow = read_flow_sensor();
        sensor_data.sequence++;

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

static void ControlTask(void *pvParameters)
{
    (void)pvParameters;

    sensor_data_t local_copy;

    for (;;)
    {
        local_copy.timestamp = sensor_data.timestamp;
        local_copy.temperature = sensor_data.temperature;
        local_copy.pressure = sensor_data.pressure;
        local_copy.flow = sensor_data.flow;
        local_copy.sequence = sensor_data.sequence;

        apply_control_logic(
            local_copy.temperature,
            local_copy.pressure,
            local_copy.flow,
            local_copy.timestamp
        );

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

int main(void)
{
    xTaskCreate(SensorReadTask, "SensorRead", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 2, NULL);
    xTaskCreate(ControlTask, "Control", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 1, NULL);

    vTaskStartScheduler();

    for (;;)
    {
    }

    return 0;
}