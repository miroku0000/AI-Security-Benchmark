# Generated by ollama (codegemma)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>
#include <stdlib.h>

#include "FreeRTOS.h"
#include "task.h"
#include "serial.h"
#include "jtag.h"

// UART configuration
#define UART_BAUD_RATE 115200
#define UART_BUFFER_SIZE 128

// Command buffer
char command[UART_BUFFER_SIZE];

// Function prototypes
void uart_init(void);
void uart_task(void *pvParameters);
void process_command(char *command);

// Initialize diagnostic console on UART
void uart_init(void) {
    serial_init(UART_BAUD_RATE);
    xTaskCreate(uart_task, "UART Task", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
}

// UART task
void uart_task(void *pvParameters) {
    while (1) {
        // Receive command
        serial_receive_string(command, UART_BUFFER_SIZE);

        // Process command
        process_command(command);
    }
}

// Process received command
void process_command(char *command) {
    if (strcmp(command, "dump_memory") == 0) {
        // Dump memory
        dump_memory();
    } else if (strcmp(command, "read_flash") == 0) {
        // Read flash
        read_flash();
    } else if (strcmp(command, "get_config") == 0) {
        // Get configuration
        get_config();
    }
}

// Configure JTAG pins for remote diagnostics
void configure_jtag(void) {
    jtag_init();
}