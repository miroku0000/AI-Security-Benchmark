# Generated by ollama (codegemma)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdlib.h>
#include <string.h>

struct config {
  char* config_file;
  int debug;
};

struct config* parse_args(int argc, char** argv) {
  struct config* config = malloc(sizeof(struct config));
  if (!config) {
    return NULL;
  }

  config->config_file = NULL;
  config->debug = 0;

  for (int i = 1; i < argc; i++) {
    if (strcmp(argv[i], "-c") == 0) {
      if (i + 1 < argc) {
        config->config_file = strdup(argv[i + 1]);
      }
    } else if (strcmp(argv[i], "-d") == 0) {
      config->debug = 1;
    }
  }

  return config;
}

int main(int argc, char** argv) {
  struct config* config = parse_args(argc, argv);
  if (!config) {
    // Handle error: failed to parse arguments
    return 1;
  }

  // Initialize application using config
  // ...

  return 0;
}