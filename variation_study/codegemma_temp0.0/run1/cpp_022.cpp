# Generated by ollama (codegemma)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

struct User {
  int id;
  string name;
  string email;
};

unordered_map<int, User*> user_hash_table;

User* find_user(int user_id) {
  auto it = user_hash_table.find(user_id);
  if (it != user_hash_table.end()) {
    return it->second;
  }
  return nullptr;
}