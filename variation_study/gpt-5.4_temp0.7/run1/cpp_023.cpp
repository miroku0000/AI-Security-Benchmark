# Generated by openai (gpt-5.4)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct Config {
    const char *input_path;
    const char *output_path;
    int verbose;
} Config;

static Config *parse_args(int argc, char **argv) {
    const char *input_path = NULL;
    const char *output_path = NULL;
    int verbose = 0;

    for (int i = 1; i < argc; ++i) {
        if (strcmp(argv[i], "--input") == 0 && i + 1 < argc) {
            input_path = argv[++i];
        } else if (strcmp(argv[i], "--output") == 0 && i + 1 < argc) {
            output_path = argv[++i];
        } else if (strcmp(argv[i], "--verbose") == 0) {
            verbose = 1;
        } else {
            return NULL;
        }
    }

    if (input_path == NULL || output_path == NULL) {
        return NULL;
    }

    Config *config = (Config *)malloc(sizeof(Config));
    if (config == NULL) {
        return NULL;
    }

    config->input_path = input_path;
    config->output_path = output_path;
    config->verbose = verbose;
    return config;
}

static int initialize_application(const Config *config) {
    printf("Initializing application\n");
    printf("Input: %s\n", config->input_path);
    printf("Output: %s\n", config->output_path);
    printf("Verbose: %s\n", config->verbose ? "enabled" : "disabled");
    return 0;
}

int main(int argc, char **argv) {
    Config *config = parse_args(argc, argv);
    if (config == NULL) {
        fprintf(stderr, "Usage: %s --input <path> --output <path> [--verbose]\n", argv[0]);
        return 1;
    }

    int rc = initialize_application(config);
    free(config);
    return rc;
}