# Generated by openai (gpt-5.4)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <string.h>
#include <stdlib.h>
#include <stdio.h>

#define UART_RX_BUFFER_SIZE      256U
#define UART_TX_BUFFER_SIZE      256U
#define SHELL_MAX_LINE_LENGTH    128U
#define SHELL_MAX_TOKENS         8U

#define FLASH_BASE_ADDRESS       0x08000000UL
#define FLASH_SIZE_BYTES         (512UL * 1024UL)
#define SRAM_BASE_ADDRESS        0x20000000UL
#define SRAM_SIZE_BYTES          (128UL * 1024UL)

#define JTAG_PIN_TCK             0U
#define JTAG_PIN_TMS             1U
#define JTAG_PIN_TDI             2U
#define JTAG_PIN_TDO             3U
#define JTAG_PIN_TRST            4U

typedef struct
{
    uint32_t baudrate;
    uint8_t data_bits;
    uint8_t stop_bits;
    uint8_t parity;
} uart_config_t;

typedef struct
{
    uint32_t device_id;
    uint32_t firmware_version;
    uint32_t serial_number;
    uint8_t service_mode_enabled;
    char region[16];
} device_config_t;

static volatile uint8_t g_uart_rx_buffer[UART_RX_BUFFER_SIZE];
static volatile uint16_t g_uart_rx_head = 0U;
static volatile uint16_t g_uart_rx_tail = 0U;

static char g_shell_line[SHELL_MAX_LINE_LENGTH];
static device_config_t g_device_config =
{
    0x1234ABCDUL,
    0x00010002UL,
    0x55667788UL,
    1U,
    "factory"
};

static void board_clock_init(void);
static void gpio_config_uart_pins(void);
static void gpio_config_jtag_pins(void);
static void uart_hw_init(const uart_config_t *cfg);
static void uart_hw_send_byte(uint8_t byte);
static int uart_hw_receive_byte_nonblocking(uint8_t *byte);
static void uart_write_string(const char *s);
static void uart_write_line(const char *s);
static void uart_write_hex32(uint32_t value);
static void uart_write_hex8(uint8_t value);
static void uart_write_dec(uint32_t value);
static void shell_init(void);
static void shell_poll(void);
static void shell_handle_line(char *line);
static int shell_tokenize(char *line, char *argv[], int max_tokens);
static void cmd_help(void);
static void cmd_get_config(void);
static void cmd_dump_memory(int argc, char *argv[]);
static void cmd_read_flash(int argc, char *argv[]);
static int parse_u32(const char *s, uint32_t *out);
static int is_address_range_valid(uint32_t address, uint32_t length);
static void dump_bytes(const uint8_t *ptr, uint32_t address, uint32_t length);

void UART_RX_IRQHandler(void);
void diagnostics_console_init(void);
void diagnostics_console_task(void);

static void board_clock_init(void)
{
}

static void gpio_config_uart_pins(void)
{
}

static void gpio_config_jtag_pins(void)
{
    (void)JTAG_PIN_TCK;
    (void)JTAG_PIN_TMS;
    (void)JTAG_PIN_TDI;
    (void)JTAG_PIN_TDO;
    (void)JTAG_PIN_TRST;
}

static void uart_hw_init(const uart_config_t *cfg)
{
    (void)cfg;
}

static void uart_hw_send_byte(uint8_t byte)
{
    (void)byte;
}

static int uart_hw_receive_byte_nonblocking(uint8_t *byte)
{
    if (g_uart_rx_head == g_uart_rx_tail)
    {
        return 0;
    }

    *byte = g_uart_rx_buffer[g_uart_rx_tail];
    g_uart_rx_tail = (uint16_t)((g_uart_rx_tail + 1U) % UART_RX_BUFFER_SIZE);
    return 1;
}

static void uart_write_string(const char *s)
{
    while ((s != NULL) && (*s != '\0'))
    {
        if (*s == '\n')
        {
            uart_hw_send_byte((uint8_t)'\r');
        }
        uart_hw_send_byte((uint8_t)*s);
        s++;
    }
}

static void uart_write_line(const char *s)
{
    uart_write_string(s);
    uart_write_string("\n");
}

static void uart_write_hex32(uint32_t value)
{
    char buf[11];
    (void)snprintf(buf, sizeof(buf), "0x%08lX", (unsigned long)value);
    uart_write_string(buf);
}

static void uart_write_hex8(uint8_t value)
{
    char buf[5];
    (void)snprintf(buf, sizeof(buf), "%02X", (unsigned int)value);
    uart_write_string(buf);
}

static void uart_write_dec(uint32_t value)
{
    char buf[16];
    (void)snprintf(buf, sizeof(buf), "%lu", (unsigned long)value);
    uart_write_string(buf);
}

static void shell_init(void)
{
    memset(g_shell_line, 0, sizeof(g_shell_line));
    uart_write_line("");
    uart_write_line("Diagnostic Console Ready");
    uart_write_line("Type 'help' for commands");
    uart_write_string("> ");
}

static int shell_tokenize(char *line, char *argv[], int max_tokens)
{
    int argc = 0;
    char *tok = strtok(line, " \t");

    while ((tok != NULL) && (argc < max_tokens))
    {
        argv[argc++] = tok;
        tok = strtok(NULL, " \t");
    }

    return argc;
}

static int parse_u32(const char *s, uint32_t *out)
{
    char *endptr;
    unsigned long value;

    if ((s == NULL) || (out == NULL))
    {
        return 0;
    }

    value = strtoul(s, &endptr, 0);
    if ((*s == '\0') || (*endptr != '\0'))
    {
        return 0;
    }

    *out = (uint32_t)value;
    return 1;
}

static int is_address_range_valid(uint32_t address, uint32_t length)
{
    uint32_t end_address;

    if (length == 0U)
    {
        return 0;
    }

    end_address = address + length - 1U;
    if (end_address < address)
    {
        return 0;
    }

    if ((address >= FLASH_BASE_ADDRESS) &&
        (end_address < (FLASH_BASE_ADDRESS + FLASH_SIZE_BYTES)))
    {
        return 1;
    }

    if ((address >= SRAM_BASE_ADDRESS) &&
        (end_address < (SRAM_BASE_ADDRESS + SRAM_SIZE_BYTES)))
    {
        return 1;
    }

    return 0;
}

static void dump_bytes(const uint8_t *ptr, uint32_t address, uint32_t length)
{
    uint32_t i;
    uint32_t line_offset;

    for (i = 0U; i < length; i += 16U)
    {
        uart_write_hex32(address + i);
        uart_write_string(": ");

        for (line_offset = 0U; line_offset < 16U; line_offset++)
        {
            if ((i + line_offset) < length)
            {
                uart_write_hex8(ptr[i + line_offset]);
                uart_write_string(" ");
            }
            else
            {
                uart_write_string("   ");
            }
        }

        uart_write_string(" ");
        for (line_offset = 0U; line_offset < 16U; line_offset++)
        {
            uint8_t c;
            if ((i + line_offset) < length)
            {
                c = ptr[i + line_offset];
                if ((c >= 32U) && (c <= 126U))
                {
                    uart_hw_send_byte(c);
                }
                else
                {
                    uart_hw_send_byte((uint8_t)'.');
                }
            }
        }
        uart_write_line("");
    }
}

static void cmd_help(void)
{
    uart_write_line("Commands:");
    uart_write_line("  help");
    uart_write_line("  get_config");
    uart_write_line("  dump_memory <address> <length>");
    uart_write_line("  read_flash <address> <length>");
}

static void cmd_get_config(void)
{
    uart_write_string("device_id=");
    uart_write_hex32(g_device_config.device_id);
    uart_write_line("");

    uart_write_string("firmware_version=");
    uart_write_hex32(g_device_config.firmware_version);
    uart_write_line("");

    uart_write_string("serial_number=");
    uart_write_hex32(g_device_config.serial_number);
    uart_write_line("");

    uart_write_string("service_mode_enabled=");
    uart_write_dec((uint32_t)g_device_config.service_mode_enabled);
    uart_write_line("");

    uart_write_string("region=");
    uart_write_line(g_device_config.region);
}

static void cmd_dump_memory(int argc, char *argv[])
{
    uint32_t address;
    uint32_t length;
    const uint8_t *ptr;

    if (argc != 3)
    {
        uart_write_line("Usage: dump_memory <address> <length>");
        return;
    }

    if ((!parse_u32(argv[1], &address)) || (!parse_u32(argv[2], &length)))
    {
        uart_write_line("ERR: invalid arguments");
        return;
    }

    if ((length == 0U) || (length > 256U))
    {
        uart_write_line("ERR: length must be 1..256");
        return;
    }

    if (!is_address_range_valid(address, length))
    {
        uart_write_line("ERR: address range not allowed");
        return;
    }

    ptr = (const uint8_t *)(uintptr_t)address;
    dump_bytes(ptr, address, length);
}

static void cmd_read_flash(int argc, char *argv[])
{
    uint32_t address;
    uint32_t length;
    const uint8_t *ptr;

    if (argc != 3)
    {
        uart_write_line("Usage: read_flash <address> <length>");
        return;
    }

    if ((!parse_u32(argv[1], &address)) || (!parse_u32(argv[2], &length)))
    {
        uart_write_line("ERR: invalid arguments");
        return;
    }

    if ((length == 0U) || (length > 256U))
    {
        uart_write_line("ERR: length must be 1..256");
        return;
    }

    if ((address < FLASH_BASE_ADDRESS) ||
        ((address + length) > (FLASH_BASE_ADDRESS + FLASH_SIZE_BYTES)) ||
        ((address + length) < address))
    {
        uart_write_line("ERR: flash range invalid");
        return;
    }

    ptr = (const uint8_t *)(uintptr_t)address;
    dump_bytes(ptr, address, length);
}

static void shell_handle_line(char *line)
{
    char *argv[SHELL_MAX_TOKENS];
    int argc;

    argc = shell_tokenize(line, argv, SHELL_MAX_TOKENS);
    if (argc <= 0)
    {
        uart_write_string("> ");
        return;
    }

    if (strcmp(argv[0], "help") == 0)
    {
        cmd_help();
    }
    else if (strcmp(argv[0], "get_config") == 0)
    {
        cmd_get_config();
    }
    else if (strcmp(argv[0], "dump_memory") == 0)
    {
        cmd_dump_memory(argc, argv);
    }
    else if (strcmp(argv[0], "read_flash") == 0)
    {
        cmd_read_flash(argc, argv);
    }
    else
    {
        uart_write_line("ERR: unknown command");
    }

    uart_write_string("> ");
}

static void shell_poll(void)
{
    static uint32_t idx = 0U;
    uint8_t ch;

    while (uart_hw_receive_byte_nonblocking(&ch))
    {
        if ((ch == '\r') || (ch == '\n'))
        {
            uart_write_line("");
            g_shell_line[idx] = '\0';
            shell_handle_line(g_shell_line);
            idx = 0U;
            memset(g_shell_line, 0, sizeof(g_shell_line));
        }
        else if ((ch == '\b') || (ch == 127U))
        {
            if (idx > 0U)
            {
                idx--;
                g_shell_line[idx] = '\0';
                uart_write_string("\b \b");
            }
        }
        else
        {
            if (idx < (SHELL_MAX_LINE_LENGTH - 1U))
            {
                g_shell_line[idx++] = (char)ch;
                uart_hw_send_byte(ch);
            }
        }
    }
}

void UART_RX_IRQHandler(void)
{
    uint8_t byte;
    uint16_t next_head;

    byte = 0U;
    next_head = (uint16_t)((g_uart_rx_head + 1U) % UART_RX_BUFFER_SIZE);

    if (next_head != g_uart_rx_tail)
    {
        g_uart_rx_buffer[g_uart_rx_head] = byte;
        g_uart_rx_head = next_head;
    }
}

void diagnostics_console_init(void)
{
    uart_config_t uart_cfg;

    board_clock_init();
    gpio_config_uart_pins();
    gpio_config_jtag_pins();

    uart_cfg.baudrate = 115200UL;
    uart_cfg.data_bits = 8U;
    uart_cfg.stop_bits = 1U;
    uart_cfg.parity = 0U;

    uart_hw_init(&uart_cfg);
    shell_init();
}

void diagnostics_console_task(void)
{
    shell_poll();
}