# Generated by openai (gpt-5.4)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <string.h>

#ifndef FLASH_BASE_ADDR
#define FLASH_BASE_ADDR              0x08000000UL
#endif

#ifndef FLASH_TOTAL_SIZE
#define FLASH_TOTAL_SIZE             (512UL * 1024UL)
#endif

#ifndef FLASH_PAGE_SIZE
#define FLASH_PAGE_SIZE              2048UL
#endif

#ifndef APP_OFFSET
#define APP_OFFSET                   0x00008000UL
#endif

#ifndef APP_BASE_ADDR
#define APP_BASE_ADDR                (FLASH_BASE_ADDR + APP_OFFSET)
#endif

#ifndef APP_MAX_SIZE
#define APP_MAX_SIZE                 (FLASH_TOTAL_SIZE - APP_OFFSET)
#endif

#ifndef SRAM_BASE_ADDR
#define SRAM_BASE_ADDR               0x20000000UL
#endif

#ifndef BOOT_MAGIC_ADDR
#define BOOT_MAGIC_ADDR              (SRAM_BASE_ADDR + 0x0000FFF0UL)
#endif

#ifndef BOOT_MAGIC_VALUE
#define BOOT_MAGIC_VALUE             0x424F4F54UL
#endif

#ifndef GPIO_BOOT_PORT
#define GPIO_BOOT_PORT               ((volatile uint32_t *)0x48000000UL)
#endif

#ifndef GPIO_BOOT_IDR_OFFSET
#define GPIO_BOOT_IDR_OFFSET         0x10UL
#endif

#ifndef GPIO_BOOT_PIN
#define GPIO_BOOT_PIN                0U
#endif

#ifndef UART_BASE
#define UART_BASE                    0x40011000UL
#endif

#ifndef UART_SR
#define UART_SR                      (*(volatile uint32_t *)(UART_BASE + 0x00))
#endif
#ifndef UART_DR
#define UART_DR                      (*(volatile uint32_t *)(UART_BASE + 0x04))
#endif
#ifndef UART_BRR
#define UART_BRR                     (*(volatile uint32_t *)(UART_BASE + 0x08))
#endif
#ifndef UART_CR1
#define UART_CR1                     (*(volatile uint32_t *)(UART_BASE + 0x0C))
#endif
#ifndef UART_CR2
#define UART_CR2                     (*(volatile uint32_t *)(UART_BASE + 0x10))
#endif
#ifndef UART_CR3
#define UART_CR3                     (*(volatile uint32_t *)(UART_BASE + 0x14))
#endif

#ifndef UART_SR_RXNE
#define UART_SR_RXNE                 (1UL << 5)
#endif
#ifndef UART_SR_TXE
#define UART_SR_TXE                  (1UL << 7)
#endif
#ifndef UART_SR_TC
#define UART_SR_TC                   (1UL << 6)
#endif
#ifndef UART_CR1_UE
#define UART_CR1_UE                  (1UL << 13)
#endif
#ifndef UART_CR1_RE
#define UART_CR1_RE                  (1UL << 2)
#endif
#ifndef UART_CR1_TE
#define UART_CR1_TE                  (1UL << 3)
#endif

#ifndef SYSTICK_BASE
#define SYSTICK_BASE                 0xE000E010UL
#endif
#define SYST_CSR                     (*(volatile uint32_t *)(SYSTICK_BASE + 0x00))
#define SYST_RVR                     (*(volatile uint32_t *)(SYSTICK_BASE + 0x04))
#define SYST_CVR                     (*(volatile uint32_t *)(SYSTICK_BASE + 0x08))

#ifndef SCB_VTOR
#define SCB_VTOR                     (*(volatile uint32_t *)0xE000ED08UL)
#endif
#ifndef SCB_AIRCR
#define SCB_AIRCR                    (*(volatile uint32_t *)0xE000ED0CUL)
#endif

#ifndef FLASH_REG_BASE
#define FLASH_REG_BASE               0x40022000UL
#endif
#define FLASH_ACR                    (*(volatile uint32_t *)(FLASH_REG_BASE + 0x00))
#define FLASH_KEYR                   (*(volatile uint32_t *)(FLASH_REG_BASE + 0x04))
#define FLASH_SR_REG                 (*(volatile uint32_t *)(FLASH_REG_BASE + 0x0C))
#define FLASH_CR_REG                 (*(volatile uint32_t *)(FLASH_REG_BASE + 0x10))
#define FLASH_AR                     (*(volatile uint32_t *)(FLASH_REG_BASE + 0x14))

#ifndef FLASH_KEY1
#define FLASH_KEY1                   0x45670123UL
#endif
#ifndef FLASH_KEY2
#define FLASH_KEY2                   0xCDEF89ABUL
#endif
#ifndef FLASH_SR_BSY
#define FLASH_SR_BSY                 (1UL << 0)
#endif
#ifndef FLASH_SR_EOP
#define FLASH_SR_EOP                 (1UL << 5)
#endif
#ifndef FLASH_CR_PG
#define FLASH_CR_PG                  (1UL << 0)
#endif
#ifndef FLASH_CR_PER
#define FLASH_CR_PER                 (1UL << 1)
#endif
#ifndef FLASH_CR_STRT
#define FLASH_CR_STRT                (1UL << 6)
#endif
#ifndef FLASH_CR_LOCK
#define FLASH_CR_LOCK                (1UL << 7)
#endif

#ifndef SD_BLOCK_SIZE
#define SD_BLOCK_SIZE                512U
#endif

#ifndef UPDATE_HEADER_MAGIC
#define UPDATE_HEADER_MAGIC          0x46575550UL
#endif

#ifndef UART_UPDATE_SOF
#define UART_UPDATE_SOF              0x55U
#endif

#ifndef UART_TIMEOUT_CYCLES
#define UART_TIMEOUT_CYCLES          8000000UL
#endif

#ifndef BOOT_WAIT_CYCLES
#define BOOT_WAIT_CYCLES             4000000UL
#endif

typedef struct
{
    uint32_t magic;
    uint32_t image_size;
    uint32_t image_crc;
    uint32_t load_address;
    uint32_t reserved[4];
} update_header_t;

typedef struct
{
    uint32_t size;
    uint32_t crc;
} image_info_t;

static void delay_cycles(volatile uint32_t v)
{
    while (v--) { __asm volatile ("nop"); }
}

static inline uint32_t reg_read(volatile uint32_t *addr)
{
    return *addr;
}

static inline void reg_write(volatile uint32_t *addr, uint32_t v)
{
    *addr = v;
}

static void uart_init(void)
{
    UART_CR1 = 0;
    UART_BRR = 0x1D4C;
    UART_CR1 = UART_CR1_UE | UART_CR1_RE | UART_CR1_TE;
}

static void uart_putc(uint8_t c)
{
    while ((UART_SR & UART_SR_TXE) == 0U) {}
    UART_DR = c;
}

static void uart_write(const char *s)
{
    while (*s) uart_putc((uint8_t)*s++);
}

static int uart_getc_timeout(uint8_t *out, uint32_t timeout)
{
    while (timeout--)
    {
        if (UART_SR & UART_SR_RXNE)
        {
            *out = (uint8_t)(UART_DR & 0xFFU);
            return 1;
        }
    }
    return 0;
}

static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t len)
{
    crc = ~crc;
    for (uint32_t i = 0; i < len; i++)
    {
        crc ^= data[i];
        for (uint32_t j = 0; j < 8; j++)
        {
            uint32_t mask = -(crc & 1U);
            crc = (crc >> 1) ^ (0xEDB88320UL & mask);
        }
    }
    return ~crc;
}

static int gpio_boot_asserted(void)
{
    volatile uint32_t *idr = (volatile uint32_t *)((uintptr_t)GPIO_BOOT_PORT + GPIO_BOOT_IDR_OFFSET);
    return ((*idr >> GPIO_BOOT_PIN) & 0x1U) ? 1 : 0;
}

static int memory_boot_request(void)
{
    volatile uint32_t *magic = (volatile uint32_t *)BOOT_MAGIC_ADDR;
    if (*magic == BOOT_MAGIC_VALUE)
    {
        *magic = 0;
        return 1;
    }
    return 0;
}

static void flash_wait_ready(void)
{
    while (FLASH_SR_REG & FLASH_SR_BSY) {}
    if (FLASH_SR_REG & FLASH_SR_EOP) FLASH_SR_REG = FLASH_SR_EOP;
}

static void flash_unlock(void)
{
    if (FLASH_CR_REG & FLASH_CR_LOCK)
    {
        FLASH_KEYR = FLASH_KEY1;
        FLASH_KEYR = FLASH_KEY2;
    }
}

static void flash_lock(void)
{
    FLASH_CR_REG |= FLASH_CR_LOCK;
}

static int flash_erase_page(uint32_t addr)
{
    flash_wait_ready();
    FLASH_CR_REG |= FLASH_CR_PER;
    FLASH_AR = addr;
    FLASH_CR_REG |= FLASH_CR_STRT;
    flash_wait_ready();
    FLASH_CR_REG &= ~FLASH_CR_PER;
    return 0;
}

static int flash_program_halfword(uint32_t addr, uint16_t data)
{
    flash_wait_ready();
    FLASH_CR_REG |= FLASH_CR_PG;
    *(volatile uint16_t *)addr = data;
    flash_wait_ready();
    FLASH_CR_REG &= ~FLASH_CR_PG;
    if (*(volatile uint16_t *)addr != data) return -1;
    return 0;
}

static int flash_program_buffer(uint32_t dst, const uint8_t *src, uint32_t len)
{
    uint32_t i = 0;
    while (i < len)
    {
        uint16_t hw = src[i];
        if ((i + 1U) < len)
            hw |= ((uint16_t)src[i + 1U] << 8);
        else
            hw |= 0xFF00U;
        if (flash_program_halfword(dst + i, hw) != 0) return -1;
        i += 2U;
    }
    return 0;
}

static int flash_erase_region(uint32_t addr, uint32_t len)
{
    uint32_t start = addr - (addr % FLASH_PAGE_SIZE);
    uint32_t end = addr + len;
    for (uint32_t a = start; a < end; a += FLASH_PAGE_SIZE)
    {
        if (flash_erase_page(a) != 0) return -1;
    }
    return 0;
}

static int app_vector_valid(uint32_t app_addr)
{
    uint32_t sp = *(volatile uint32_t *)(app_addr + 0);
    uint32_t rv = *(volatile uint32_t *)(app_addr + 4);
    if ((sp < SRAM_BASE_ADDR) || (sp > (SRAM_BASE_ADDR + 0x00080000UL))) return 0;
    if ((rv < FLASH_BASE_ADDR) || (rv > (FLASH_BASE_ADDR + FLASH_TOTAL_SIZE))) return 0;
    return 1;
}

static void jump_to_app(uint32_t app_addr)
{
    uint32_t app_sp = *(volatile uint32_t *)(app_addr + 0);
    uint32_t app_pc = *(volatile uint32_t *)(app_addr + 4);
    void (*app_reset_handler)(void) = (void (*)(void))app_pc;

    __asm volatile ("cpsid i");
    SYST_CSR = 0;
    SCB_VTOR = app_addr;
    __asm volatile ("msr msp, %0" : : "r" (app_sp) : );
    __asm volatile ("cpsie i");
    app_reset_handler();
    while (1) {}
}

static int sd_init(void)
{
    return 0;
}

static int sd_read_block(uint32_t lba, uint8_t *buf)
{
    (void)lba;
    (void)buf;
    return -1;
}

static int sd_find_update_header(update_header_t *hdr, uint32_t *data_lba)
{
    uint8_t block[SD_BLOCK_SIZE];
    if (sd_init() != 0) return -1;
    for (uint32_t lba = 0; lba < 64U; lba++)
    {
        if (sd_read_block(lba, block) != 0) continue;
        update_header_t *h = (update_header_t *)block;
        if (h->magic == UPDATE_HEADER_MAGIC)
        {
            *hdr = *h;
            *data_lba = lba + 1U;
            return 0;
        }
    }
    return -1;
}

static int program_image_streamed(uint32_t dst_addr, uint32_t size, uint32_t expected_crc,
                                  int (*reader)(uint8_t *buf, uint32_t max_len, uint32_t *out_len))
{
    uint8_t buf[512];
    uint32_t remaining = size;
    uint32_t addr = dst_addr;
    uint32_t crc = 0;

    if (size == 0 || size > APP_MAX_SIZE) return -1;
    if (flash_erase_region(dst_addr, size) != 0) return -1;

    while (remaining)
    {
        uint32_t got = 0;
        uint32_t want = remaining > sizeof(buf) ? sizeof(buf) : remaining;
        if (reader(buf, want, &got) != 0) return -1;
        if (got == 0 || got > want) return -1;
        if (flash_program_buffer(addr, buf, got) != 0) return -1;
        crc = crc32_update(crc, buf, got);
        addr += got;
        remaining -= got;
    }

    if (crc != expected_crc) return -1;
    return 0;
}

static update_header_t g_sd_hdr;
static uint32_t g_sd_data_lba;
static uint8_t g_sd_block[SD_BLOCK_SIZE];
static uint32_t g_sd_block_pos;
static uint32_t g_sd_block_valid;
static uint32_t g_sd_cur_lba;

static int sd_stream_reader(uint8_t *buf, uint32_t max_len, uint32_t *out_len)
{
    uint32_t copied = 0;
    while (copied < max_len)
    {
        if (g_sd_block_pos >= g_sd_block_valid)
        {
            if (sd_read_block(g_sd_cur_lba++, g_sd_block) != 0) break;
            g_sd_block_pos = 0;
            g_sd_block_valid = SD_BLOCK_SIZE;
        }

        uint32_t avail = g_sd_block_valid - g_sd_block_pos;
        uint32_t take = max_len - copied;
        if (take > avail) take = avail;
        memcpy(&buf[copied], &g_sd_block[g_sd_block_pos], take);
        g_sd_block_pos += take;
        copied += take;
    }
    *out_len = copied;
    return (copied > 0U) ? 0 : -1;
}

static int try_update_from_sd(void)
{
    if (sd_find_update_header(&g_sd_hdr, &g_sd_data_lba) != 0) return -1;
    if (g_sd_hdr.magic != UPDATE_HEADER_MAGIC) return -1;
    if (g_sd_hdr.load_address != APP_BASE_ADDR) return -1;
    if (g_sd_hdr.image_size == 0 || g_sd_hdr.image_size > APP_MAX_SIZE) return -1;

    g_sd_cur_lba = g_sd_data_lba;
    g_sd_block_pos = 0;
    g_sd_block_valid = 0;

    flash_unlock();
    int rc = program_image_streamed(APP_BASE_ADDR, g_sd_hdr.image_size, g_sd_hdr.image_crc, sd_stream_reader);
    flash_lock();
    return rc;
}

static int uart_stream_reader(uint8_t *buf, uint32_t max_len, uint32_t *out_len)
{
    uint32_t n = 0;
    while (n < max_len)
    {
        uint8_t b;
        if (!uart_getc_timeout(&b, UART_TIMEOUT_CYCLES)) break;
        buf[n++] = b;
    }
    *out_len = n;
    return (n > 0U) ? 0 : -1;
}

static int try_update_from_uart(void)
{
    update_header_t hdr;
    uint8_t *p = (uint8_t *)&hdr;
    uint8_t b;

    uart_write("BOOT\r\n");
    if (!uart_getc_timeout(&b, BOOT_WAIT_CYCLES)) return -1;
    if (b != UART_UPDATE_SOF) return -1;

    for (uint32_t i = 0; i < sizeof(update_header_t); i++)
    {
        if (!uart_getc_timeout(&p[i], UART_TIMEOUT_CYCLES)) return -1;
    }

    if (hdr.magic != UPDATE_HEADER_MAGIC) return -1;
    if (hdr.load_address != APP_BASE_ADDR) return -1;
    if (hdr.image_size == 0 || hdr.image_size > APP_MAX_SIZE) return -1;

    flash_unlock();
    int rc = program_image_streamed(APP_BASE_ADDR, hdr.image_size, hdr.image_crc, uart_stream_reader);
    flash_lock();

    if (rc == 0) uart_write("OK\r\n");
    else uart_write("ERR\r\n");
    return rc;
}

static int bootloader_mode_requested(void)
{
    if (gpio_boot_asserted()) return 1;
    if (memory_boot_request()) return 1;
    return 0;
}

int main(void)
{
    uart_init();

    int force_boot = bootloader_mode_requested();

    if (!force_boot)
    {
        if (try_update_from_sd() == 0)
        {
            if (app_vector_valid(APP_BASE_ADDR)) jump_to_app(APP_BASE_ADDR);
        }

        if (try_update_from_uart() == 0)
        {
            if (app_vector_valid(APP_BASE_ADDR)) jump_to_app(APP_BASE_ADDR);
        }

        if (app_vector_valid(APP_BASE_ADDR)) jump_to_app(APP_BASE_ADDR);
    }
    else
    {
        if (try_update_from_sd() == 0)
        {
            if (app_vector_valid(APP_BASE_ADDR)) jump_to_app(APP_BASE_ADDR);
        }

        while (1)
        {
            if (try_update_from_uart() == 0)
            {
                if (app_vector_valid(APP_BASE_ADDR)) jump_to_app(APP_BASE_ADDR);
            }
        }
    }

    while (1) {}
}

void Reset_Handler(void)
{
    main();
    while (1) {}
}