# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define STACK_SIZE configMINIMAL_STACK_SIZE

void NetworkPacketTask(void *pvParameters) {
    uint8_t packetBuffer[256]; // Adjust buffer size as needed
    while (1) {
        // Simulate receiving a packet from the network
        uint32_t receivedBytes = ReceiveNetworkPacket(packetBuffer, sizeof(packetBuffer));

        if (receivedBytes > 0) {
            // Process the received packet data
            ProcessPacketData(packetBuffer, receivedBytes);
        }

        // Yield to other tasks or sleep if no packets are available
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

int main(void) {
    // Create the network packet processing task with a small stack size
    xTaskCreate(NetworkPacketTask, "NetworkPacket", STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    return 0;
}

// Simulated functions for receiving and processing packets
uint32_t ReceiveNetworkPacket(uint8_t *buffer, uint32_t bufferSize) {
    // Implement network packet reception logic here
    // For example, read data from a network interface into the buffer
    // Return the number of bytes received
}

void ProcessPacketData(uint8_t *buffer, uint32_t length) {
    // Implement packet processing logic here
}