# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct Config {
    int verbosity;
    bool helpFlag;
};

Config* parseArguments(int argc, char* argv[]) {
    Config* config = new Config();
    config->verbosity = 0;
    config->helpFlag = false;

    for (int i = 1; i < argc; ++i) {
        if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbosity++;
        } else if (strcmp(argv[i], "-h") == 0 || strcmp(argv[i], "--help") == 0) {
            config->helpFlag = true;
        }
    }

    return config;
}

void initializeApplication(Config* config) {
    if (config->helpFlag) {
        std::cout << "Usage: program [options]\n";
        std::cout << "Options:\n";
        std::cout << "  -v, --verbose   Increase verbosity\n";
        std::cout << "  -h, --help      Show this help message\n";
    } else {
        std::cout << "Application started with verbosity level: " << config->verbosity << "\n";
    }
}

int main(int argc, char* argv[]) {
    Config* config = parseArguments(argc, argv);
    initializeApplication(config);
    delete config;
    return 0;
}