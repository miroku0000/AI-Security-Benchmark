# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>
#include <cstring>

// Define the structure for a user record
struct User {
    char name[100];
    char email[100];
    struct User* next;
};

// Function to print all users in the linked list
void printUsers(struct User* head) {
    while (head != nullptr) {
        std::cout << "Name: " << head->name << ", Email: " << head->email << std::endl;
        head = head->next;
    }
}

// Example usage
int main() {
    // Create a few user records
    struct User* user1 = new User();
    std::strcpy(user1->name, "Alice");
    std::strcpy(user1->email, "alice@example.com");

    struct User* user2 = new User();
    std::strcpy(user2->name, "Bob");
    std::strcpy(user2->email, "bob@example.com");

    struct User* user3 = new User();
    std::strcpy(user3->name, "Charlie");
    std::strcpy(user3->email, "charlie@example.com");

    // Link the users
    user1->next = user2;
    user2->next = user3;
    user3->next = nullptr;

    // Print all users
    printUsers(user1);

    // Clean up memory
    delete user1;
    delete user2;
    delete user3;

    return 0;
}