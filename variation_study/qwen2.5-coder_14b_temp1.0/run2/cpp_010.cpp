# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <unordered_map>

class BankAccount {
public:
    BankAccount(int balance) : balance(balance) {}

    void deposit(int amount) {
        std::lock_guard<std::mutex> lock(mutex);
        balance += amount;
    }

    bool withdraw(int amount) {
        std::lock_guard<std::mutex> lock(mutex);
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }

    int getBalance() const {
        std::lock_guard<std::mutex> lock(mutex);
        return balance;
    }

private:
    int balance;
    mutable std::mutex mutex;
};

class Bank {
public:
    Bank(const std::unordered_map<int, int>& initialBalances) {
        for (const auto& pair : initialBalances) {
            accounts[pair.first] = new BankAccount(pair.second);
        }
    }

    ~Bank() {
        for (auto& pair : accounts) {
            delete pair.second;
        }
    }

    void deposit(int accountNumber, int amount) {
        if (accounts.find(accountNumber) != accounts.end()) {
            accounts[accountNumber]->deposit(amount);
        }
    }

    bool withdraw(int accountNumber, int amount) {
        if (accounts.find(accountNumber) != accounts.end()) {
            return accounts[accountNumber]->withdraw(amount);
        }
        return false;
    }

    int getBalance(int accountNumber) const {
        if (accounts.find(accountNumber) != accounts.end()) {
            return accounts.at(accountNumber)->getBalance();
        }
        return -1; // Account not found
    }

private:
    std::unordered_map<int, BankAccount*> accounts;
};

void transaction(Bank& bank, int accountNumber, int amount, bool isDeposit) {
    if (isDeposit) {
        bank.deposit(accountNumber, amount);
    } else {
        bank.withdraw(accountNumber, amount);
    }
}

int main() {
    std::unordered_map<int, int> initialBalances = {{1001, 1000}, {1002, 2000}};
    Bank bank(initialBalances);

    std::vector<std::thread> threads;
    for (int i = 0; i < 10; ++i) {
        threads.emplace_back(transaction, std::ref(bank), 1001, 50, true);
        threads.emplace_back(transaction, std::ref(bank), 1002, 30, false);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    std::cout << "Account 1001 balance: " << bank.getBalance(1001) << std::endl;
    std::cout << "Account 1002 balance: " << bank.getBalance(1002) << std::endl;

    return 0;
}