# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <drivers/flash.h>

#define ADMIN_TASK_STACK_SIZE 1024
#define USER_TASK_STACK_SIZE 512

K_THREAD_STACK_DEFINE(admin_stack_area, ADMIN_TASK_STACK_SIZE);
static struct k_thread admin_thread;

K_THREAD_STACK_DEFINE(user_stack_area, USER_TASK_STACK_SIZE);
static struct k_thread user_thread;

struct privilege_request {
    bool is_granted;
};

void admin_task(void *arg1, void *arg2, void *arg3) {
    while (1) {
        // Simulate waiting for a request
        k_sleep(K_SECONDS(1));

        // Check if there's a pending request
        struct privilege_request *req = (struct privilege_request *) arg1;
        if (req->is_granted) {
            printk("Admin task granted permission\n");

            // Perform admin operations like writing to flash or modifying config
            const struct device *flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
            uint8_t data_to_write[32] = {0};
            off_t offset = 0x1000; // Example offset

            if (flash_erase(flash_dev, offset, sizeof(data_to_write)) == 0) {
                if (flash_write(flash_dev, offset, data_to_write, sizeof(data_to_write)) == 0) {
                    printk("Flash write successful\n");
                } else {
                    printk("Flash write failed\n");
                }
            } else {
                printk("Flash erase failed\n");
            }

            // Reset the request flag
            req->is_granted = false;
        }
    }
}

void user_task(void *arg1, void *arg2, void *arg3) {
    struct privilege_request *req = (struct privilege_request *) arg1;

    while (1) {
        k_sleep(K_SECONDS(5));

        // Request admin operation
        printk("User task requesting admin permission\n");
        req->is_granted = true;
    }
}

void main(void) {
    struct privilege_request req = { .is_granted = false };

    k_thread_create(&admin_thread, admin_stack_area,
                    K_THREAD_STACK_SIZEOF(admin_stack_area), admin_task,
                    &req, NULL, NULL,
                    K_PRIO_COOP(7), 0, K_NO_WAIT);

    k_thread_create(&user_thread, user_stack_area,
                    K_THREAD_STACK_SIZEOF(user_stack_area), user_task,
                    &req, NULL, NULL,
                    K_PRIO_COOP(8), 0, K_NO_WAIT);
}