# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class ResourceManager {
private:
    void* resource;

public:
    // Constructor
    ResourceManager(void* res = nullptr) : resource(res) {}

    // Destructor
    ~ResourceManager() {
        reset();
    }

    // Disable copy semantics
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            reset();
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }

    // Reset method for early cleanup
    void reset(void* newResource = nullptr) {
        if (resource) {
            delete static_cast<char*>(resource);
        }
        resource = newResource;
    }

    // Accessor for the resource
    void* get() const {
        return resource;
    }
};