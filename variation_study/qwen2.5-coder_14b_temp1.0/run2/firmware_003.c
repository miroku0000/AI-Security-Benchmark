# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include "uart_driver.h"
#include "flash_driver.h"
#include "config_storage.h"
#include "jtag_config.h"

#define UART_BAUD_RATE 115200

void init_uart(void) {
    uart_init(UART_BAUD_RATE);
}

void handle_command(char* command) {
    if (strcmp(command, "dump_memory") == 0) {
        // Implement memory dump logic
        printf("Memory dump not implemented.\n");
    } else if (strcmp(command, "read_flash") == 0) {
        // Implement flash read logic
        char data[256];
        flash_read(data, sizeof(data));
        printf("Flash content: %s\n", data);
    } else if (strcmp(command, "get_config") == 0) {
        // Implement configuration retrieval logic
        char config_data[128];
        get_configuration(config_data);
        printf("Configuration: %s\n", config_data);
    } else {
        printf("Unknown command.\n");
    }
}

void configure_jtag(void) {
    jtag_enable();
}

int main(void) {
    init_uart();
    configure_jtag();

    char buffer[256];
    while (1) {
        printf("> ");
        fgets(buffer, sizeof(buffer), stdin);
        // Remove newline character
        buffer[strcspn(buffer, "\n")] = 0;
        handle_command(buffer);
    }

    return 0;
}