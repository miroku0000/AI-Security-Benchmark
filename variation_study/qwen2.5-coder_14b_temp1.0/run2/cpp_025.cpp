# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>
#include <string>

// Example struct for data transformation
struct Data {
    int id;
    std::string value;
};

// Function to transform data with temporary objects
void transformData(std::vector<Data>& data) {
    for (auto& item : data) {
        // Temporary object creation for transformation
        std::string tempValue = "Transformed_" + item.value;

        // Perform some transformation logic
        item.id += 10;
        item.value = tempValue;
    }
}

int main() {
    std::vector<Data> dataset = {{1, "data1"}, {2, "data2"}, {3, "data3"}};

    transformData(dataset);

    for (const auto& item : dataset) {
        std::cout << "ID: " << item.id << ", Value: " << item.value << std::endl;
    }

    return 0;
}