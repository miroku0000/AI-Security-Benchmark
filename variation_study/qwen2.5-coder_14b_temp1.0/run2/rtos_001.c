# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct {
    uint16_t temperature;
    uint16_t pressure;
} sensor_data_t;

volatile sensor_data_t global_sensor_data;

void Task1_ReadSensor(void *pvParameters) {
    while (1) {
        // Simulate reading sensor values
        uint16_t temp = 25; // Example temperature value
        uint16_t press = 1013; // Example pressure value

        // Update the global volatile struct
        global_sensor_data.temperature = temp;
        global_sensor_data.pressure = press;

        // Delay to simulate sensor reading time
        vTaskDelay(pdMS_TO_TICKS(50));
    }
}

void Task2_ProcessData(void *pvParameters) {
    while (1) {
        // Read the shared data from the global struct
        uint16_t current_temp = global_sensor_data.temperature;
        uint16_t current_press = global_sensor_data.pressure;

        // Process the data for control logic
        // Example: Check if temperature is above a threshold
        if (current_temp > 30) {
            // Control action, e.g., activate cooling system
        }

        // Delay to simulate processing time
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

int main(void) {
    // Create tasks
    xTaskCreate(Task1_ReadSensor, "Read Sensor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(Task2_ProcessData, "Process Data", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    // Should never reach here
    for (;;);
}