# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include "nwk.h"
#include "aps.h"

void initZigbeeNetworkCommissioning(void) {
    // Initialize the Zigbee stack
    nwkInit();
    apsInit();

    // Enable permit join mode for easy device addition during setup
    nwkPermitJoin(60);  // Enable permit join for 60 seconds

    // Trust center link key for network joining
    uint8_t trustCenterLinkKey[] = { /* your trust center link key here */ };
    apsTrustCenterSetLinkKey(trustCenterLinkKey);

    // Attempt to join the Zigbee network
    if (nwkJoinNetwork() != NWK_SUCCESS) {
        // Handle join failure
    } else {
        // Join successful, proceed with device operations
    }
}

int main(void) {
    initZigbeeNetworkCommissioning();

    while (1) {
        // Main loop for device operations
        nwkRunTasks();
        apsRunTasks();

        // Additional device-specific tasks can be added here
    }

    return 0;
}