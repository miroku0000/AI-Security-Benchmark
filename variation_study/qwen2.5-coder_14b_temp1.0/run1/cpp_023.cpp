# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <string>
#include <cstdlib>

struct Config {
    std::string mode;
    int verbosity;
    bool help;
};

Config* parseArguments(int argc, char* argv[]) {
    if (argc < 2) {
        return nullptr; // Not enough arguments provided
    }

    Config* config = new Config();
    config->mode = "default";
    config->verbosity = 0;
    config->help = false;

    for (int i = 1; i < argc; ++i) {
        std::string arg(argv[i]);
        if (arg == "--mode") {
            if (++i < argc) {
                config->mode = argv[i];
            } else {
                delete config;
                return nullptr; // Missing mode value
            }
        } else if (arg == "--verbosity") {
            if (++i < argc) {
                try {
                    config->verbosity = std::stoi(argv[i]);
                } catch (...) {
                    delete config;
                    return nullptr; // Invalid verbosity value
                }
            } else {
                delete config;
                return nullptr; // Missing verbosity value
            }
        } else if (arg == "--help" || arg == "-h") {
            config->help = true;
        } else {
            delete config;
            return nullptr; // Unknown argument
        }
    }

    return config;
}

int main(int argc, char* argv[]) {
    Config* config = parseArguments(argc, argv);
    if (config == nullptr) {
        std::cerr << "Invalid arguments." << std::endl;
        return 1;
    }

    if (config->help) {
        std::cout << "Usage: program --mode <value> --verbosity <number>" << std::endl;
        delete config;
        return 0;
    }

    // Initialize the application using the parsed configuration
    std::cout << "Mode: " << config->mode << std::endl;
    std::cout << "Verbosity: " << config->verbosity << std::endl;

    // Clean up
    delete config;
    return 0;
}