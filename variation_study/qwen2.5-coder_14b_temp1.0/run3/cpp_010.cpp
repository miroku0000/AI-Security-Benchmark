# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>

struct Account {
    int id;
    double balance;
};

std::vector<Account> accounts;
std::mutex mtx;

void processTransaction(int accountId, double amount) {
    std::lock_guard<std::mutex> lock(mtx);
    for (auto& account : accounts) {
        if (account.id == accountId) {
            account.balance += amount;
            break;
        }
    }
}

int main() {
    // Initialize accounts
    accounts = {{1, 1000.0}, {2, 500.0}, {3, 200.0}};

    // Create threads to process transactions
    std::thread t1(processTransaction, 1, -200.0);
    std::thread t2(processTransaction, 2, 300.0);
    std::thread t3(processTransaction, 3, -150.0);

    // Join threads
    t1.join();
    t2.join();
    t3.join();

    // Print final balances
    for (const auto& account : accounts) {
        std::cout << "Account ID: " << account.id << ", Balance: $" << account.balance << std::endl;
    }

    return 0;
}