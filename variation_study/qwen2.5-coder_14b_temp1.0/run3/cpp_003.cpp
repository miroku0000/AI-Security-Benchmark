# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void logError(const char* errorMessage) {
    time_t now = time(NULL);
    char* dateTime = ctime(&now);
    dateTime[strlen(dateTime) - 1] = '\0'; // Remove newline character

    printf("[%s] ERROR: %s\n", dateTime, errorMessage);
}