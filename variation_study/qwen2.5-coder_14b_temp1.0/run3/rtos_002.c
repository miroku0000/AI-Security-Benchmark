# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"

#define STACK_BUFFER_SIZE 128

void NetworkPacketTask(void *pvParameters) {
    uint8_t stackBuffer[STACK_BUFFER_SIZE];
    while (1) {
        // Assume networkReceivePacket is a function that receives a packet and stores it in the provided buffer
        size_t packetSize = networkReceivePacket(stackBuffer, STACK_BUFFER_SIZE);
        
        if (packetSize > 0 && packetSize <= STACK_BUFFER_SIZE) {
            // Process the packet data stored in stackBuffer
            processNetworkPacket(stackBuffer, packetSize);
        }
    }
}

int main(void) {
    xTaskCreate(NetworkPacketTask, "NetworkPacketTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    vTaskStartScheduler();
    
    while (1); // Should never reach here
}