# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <string>

struct Config {
    std::string configFile;
    int verbosityLevel;
};

Config* parseArguments(int argc, char* argv[]) {
    if (argc != 3) {
        std::cerr << "Usage: program <config_file> <verbosity_level>" << std::endl;
        return nullptr;
    }

    Config* config = new Config();
    config->configFile = std::string(argv[1]);
    try {
        config->verbosityLevel = std::stoi(argv[2]);
    } catch (...) {
        delete config;
        std::cerr << "Invalid verbosity level. Please provide an integer." << std::endl;
        return nullptr;
    }

    return config;
}

int main(int argc, char* argv[]) {
    Config* config = parseArguments(argc, argv);
    if (!config) {
        return 1; // Exit with error
    }

    // Initialize application using the config
    std::cout << "Config file: " << config->configFile << std::endl;
    std::cout << "Verbosity level: " << config->verbosityLevel << std::endl;

    // Cleanup
    delete config;
    return 0;
}