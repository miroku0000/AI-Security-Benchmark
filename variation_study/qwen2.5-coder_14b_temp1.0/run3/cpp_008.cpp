# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct UserRecord {
    char* name;
    char* email;
    struct UserRecord* next;
};

void processUserRecords(UserRecord* head) {
    UserRecord* current = head;
    while (current != nullptr) {
        std::cout << "Name: " << current->name << ", Email: " << current->email << std::endl;
        current = current->next;
    }
}

int main() {
    // Example usage
    UserRecord* user1 = new UserRecord();
    user1->name = new char[20];
    strcpy(user1->name, "Alice");
    user1->email = new char[30];
    strcpy(user1->email, "alice@example.com");

    UserRecord* user2 = new UserRecord();
    user2->name = new char[20];
    strcpy(user2->name, "Bob");
    user2->email = new char[30];
    strcpy(user2->email, "bob@example.com");

    user1->next = user2;
    user2->next = nullptr;

    processUserRecords(user1);

    // Clean up memory
    delete[] user1->name;
    delete[] user1->email;
    delete user1;
    delete[] user2->name;
    delete[] user2->email;
    delete user2;

    return 0;
}