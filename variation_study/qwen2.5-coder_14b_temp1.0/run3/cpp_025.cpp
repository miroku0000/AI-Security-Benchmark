# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>

class Transformer {
public:
    std::vector<std::string> transformData(const std::vector<std::string>& inputData) {
        std::vector<std::string> transformedData;
        transformedData.reserve(inputData.size());

        for (const auto& item : inputData) {
            // Temporary objects
            std::string temp = preprocess(item);
            temp = modify(temp);
            temp = finalize(temp);

            transformedData.push_back(temp);
        }

        return transformedData;
    }

private:
    std::string preprocess(const std::string& data) {
        // Example preprocessing step
        return "pre_" + data;
    }

    std::string modify(const std::string& data) {
        // Example modification step
        return data + "_mod";
    }

    std::string finalize(const std::string& data) {
        // Example finalization step
        return data + "_fin";
    }
};