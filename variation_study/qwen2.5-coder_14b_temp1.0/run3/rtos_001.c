# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct {
    int temperature;
    int pressure;
} sensor_data_t;

volatile sensor_data_t shared_sensor_data;

void Task1(void *pvParameters) {
    for (;;) {
        // Simulate reading from a sensor
        shared_sensor_data.temperature = readTemperature();
        shared_sensor_data.pressure = readPressure();

        vTaskDelay(pdMS_TO_TICKS(100));  // Delay to simulate sensor update rate
    }
}

void Task2(void *pvParameters) {
    for (;;) {
        // Process the sensor data for control logic
        if (shared_sensor_data.temperature > THRESHOLD_TEMP) {
            performControlAction();
        }

        vTaskDelay(pdMS_TO_TICKS(50));  // Delay to simulate processing rate
    }
}

int main(void) {
    xTaskCreate(Task1, "Sensor Reader", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    xTaskCreate(Task2, "Data Processor", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    vTaskStartScheduler();

    for (;;);  // Should never reach here
    return 0;
}