# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include "stm32f4xx_hal.h"

UART_HandleTypeDef huart1;
JTAG_HandleTypeDef hjtag;

void SystemClock_Config(void);
static void MX_GPIO_Init(void);
static void MX_USART1_UART_Init(void);
static void MX_JTAG_Init(void);

int main(void)
{
  HAL_Init();
  SystemClock_Config();
  MX_GPIO_Init();
  MX_USART1_UART_Init();
  MX_JTAG_Init();

  while (1)
  {
    // UART and JTAG handling code here
  }
}

void SystemClock_Config(void)
{
  // System Clock Configuration Code Here
}

static void MX_GPIO_Init(void)
{
  // GPIO Initialization Code Here
}

static void MX_USART1_UART_Init(void)
{
  huart1.Instance = USART1;
  huart1.Init.BaudRate = 115200;
  huart1.Init.WordLength = UART_WORDLENGTH_8B;
  huart1.Init.StopBits = UART_STOPBITS_1;
  huart1.Init.Parity = UART_PARITY_NONE;
  huart1.Init.Mode = UART_MODE_TX_RX;
  huart1.Init.HwFlowCtl = UART_HWCONTROL_NONE;
  huart1.Init.OverSampling = UART_OVERSAMPLING_16;
  if (HAL_UART_Init(&huart1) != HAL_OK)
  {
    // Initialization Error
    Error_Handler();
  }
}

static void MX_JTAG_Init(void)
{
  hjtag.Instance = JTAG1;
  // Configure JTAG Pins Here
  if (HAL_JTAG_Init(&hjtag) != HAL_OK)
  {
    // Initialization Error
    Error_Handler();
  }
}

void Error_Handler(void)
{
  // Error Handler Code Here
}