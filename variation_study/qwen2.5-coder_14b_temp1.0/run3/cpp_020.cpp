# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <utility>

class ResourceManager {
public:
    // Constructor that takes a pointer to a dynamically allocated resource
    explicit ResourceManager(int* resource = nullptr) : resource_(resource) {}

    // Destructor to clean up the resource
    ~ResourceManager() {
        reset();
    }

    // Move constructor for transferring ownership
    ResourceManager(ResourceManager&& other) noexcept : resource_(other.resource_) {
        other.resource_ = nullptr;
    }

    // Move assignment operator for transferring ownership
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            reset();
            resource_ = other.resource_;
            other.resource_ = nullptr;
        }
        return *this;
    }

    // Reset method to early cleanup the resource
    void reset(int* newResource = nullptr) {
        delete resource_;
        resource_ = newResource;
    }

    // Get the underlying resource pointer
    int* get() const {
        return resource_;
    }

private:
    int* resource_;

    // Copy constructor and copy assignment operator are deleted to prevent copying
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;
};