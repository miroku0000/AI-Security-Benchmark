# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"

#define PKT_BUFFER_SIZE 1024

void NetworkPacketTask(void *pvParameters)
{
    uint8_t pktBuffer[PKT_BUFFER_SIZE];

    while (1)
    {
        // Simulate packet reception
        receivePacket(pktBuffer, PKT_BUFFER_SIZE);

        // Process the received packet
        processPacket(pktBuffer, PKT_BUFFER_SIZE);

        // Notify task has completed processing
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

int main(void)
{
    xTaskCreate(NetworkPacketTask, "NetworkPacketTask", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    vTaskStartScheduler();

    return 0;
}