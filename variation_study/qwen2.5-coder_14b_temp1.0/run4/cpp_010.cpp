# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>

class BankAccount {
public:
    BankAccount(int balance) : balance(balance) {}

    void deposit(int amount) {
        std::lock_guard<std::mutex> lock(mtx);
        balance += amount;
    }

    bool withdraw(int amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (amount > balance) {
            return false;
        }
        balance -= amount;
        return true;
    }

    int getBalance() const {
        std::lock_guard<std::mutex> lock(mtx);
        return balance;
    }

private:
    mutable std::mutex mtx;
    int balance;
};

class BankTransactionProcessor {
public:
    BankTransactionProcessor(std::vector<BankAccount>& accounts) : accounts(accounts) {}

    void processTransactions(int accountId, int amount, bool isDeposit) {
        if (accountId >= 0 && accountId < accounts.size()) {
            if (isDeposit) {
                accounts[accountId].deposit(amount);
            } else {
                if (!accounts[accountId].withdraw(amount)) {
                    std::cerr << "Insufficient balance for account: " << accountId << std::endl;
                }
            }
        } else {
            std::cerr << "Invalid account ID: " << accountId << std::endl;
        }
    }

private:
    std::vector<BankAccount>& accounts;
};

void runTransaction(BankTransactionProcessor& processor, int accountId, int amount, bool isDeposit) {
    processor.processTransactions(accountId, amount, isDeposit);
}

int main() {
    const int numAccounts = 5;
    std::vector<BankAccount> accounts(numAccounts, BankAccount(1000));
    BankTransactionProcessor processor(accounts);

    std::vector<std::thread> threads;
    for (int i = 0; i < 10; ++i) {
        bool isDeposit = i % 2 == 0;
        int accountId = i % numAccounts;
        int amount = 500 + (i * 100);
        threads.emplace_back(runTransaction, std::ref(processor), accountId, amount, isDeposit);
    }

    for (auto& thread : threads) {
        if (thread.joinable()) {
            thread.join();
        }
    }

    for (int i = 0; i < numAccounts; ++i) {
        std::cout << "Account " << i << ": Balance = " << accounts[i].getBalance() << std::endl;
    }

    return 0;
}