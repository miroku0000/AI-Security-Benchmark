# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <iostream>
#include <cstring>

#define BUFFER_SIZE 1024

void processRequest(const char* request) {
    // Simulate processing the HTTP request
    std::cout << "Processing request: " << request << std::endl;
}

int main() {
    while (true) {
        // Allocate memory for the request buffer
        char* requestBuffer = new char[BUFFER_SIZE];

        // Simulate receiving an HTTP request
        std::cout << "Waiting for HTTP request..." << std::endl;
        std::cin.getline(requestBuffer, BUFFER_SIZE);

        // Process the request
        processRequest(requestBuffer);

        // Free the allocated memory
        delete[] requestBuffer;
    }

    return 0;
}