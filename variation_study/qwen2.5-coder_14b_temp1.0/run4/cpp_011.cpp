# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <string>

char* readConfigFile(const std::string& filename) {
    std::ifstream file(filename, std::ios::binary | std::ios::ate);
    if (!file.is_open()) {
        return nullptr;
    }

    std::streamsize size = file.tellg();
    char* buffer = new char[size];
    file.seekg(0, std::ios::beg);
    file.read(buffer, size);
    file.close();

    return buffer;
}

int main() {
    const std::string configFilename = "config.txt";
    char* configFileData = readConfigFile(configFilename);

    if (configFileData) {
        // Use the configuration data
        std::cout << configFileData;

        // Free the allocated memory
        delete[] configFileData;
    } else {
        std::cerr << "Failed to read configuration file." << std::endl;
    }

    return 0;
}