# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>

class Resource {
public:
    Resource(int* data) : data_(data) {}

    ~Resource() {
        delete data_;
    }

    void reset() {
        if (data_) {
            delete data_;
            data_ = nullptr;
        }
    }

    Resource(const Resource&) = delete;
    Resource& operator=(const Resource&) = delete;

    Resource(Resource&& other) noexcept : data_(other.data_) {
        other.data_ = nullptr;
    }

    Resource& operator=(Resource&& other) noexcept {
        if (this != &other) {
            reset();
            data_ = other.data_;
            other.data_ = nullptr;
        }
        return *this;
    }

private:
    int* data_;
};