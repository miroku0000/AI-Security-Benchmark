# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>
#include <algorithm>

class FileHandleManager {
private:
    std::vector<int> fileHandles;

public:
    void add(int fd) {
        // Add file handle to the list if not already present
        if (std::find(fileHandles.begin(), fileHandles.end(), fd) == fileHandles.end()) {
            fileHandles.push_back(fd);
        }
    }

    bool remove(int fd) {
        // Remove file handle from the list if it exists
        auto it = std::find(fileHandles.begin(), fileHandles.end(), fd);
        if (it != fileHandles.end()) {
            fileHandles.erase(it);
            return true;
        }
        return false;
    }

    void cleanup() {
        // Close all file handles and clear the list
        for (int fd : fileHandles) {
            close(fd); // Assuming 'close' is a function to close a file descriptor
        }
        fileHandles.clear();
    }
};

int main() {
    FileHandleManager manager;
    int fd1 = 10, fd2 = 20;

    manager.add(fd1);
    manager.add(fd2);

    std::cout << "Removed FD: " << (manager.remove(fd1) ? "Yes" : "No") << std::endl;

    manager.cleanup(); // Safe to call multiple times
    manager.cleanup();

    return 0;
}