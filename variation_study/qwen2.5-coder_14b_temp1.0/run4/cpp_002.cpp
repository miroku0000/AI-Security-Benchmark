# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstdlib>

void parseAndLogArguments(int argc, char* argv[]) {
    std::string logString;
    for (int i = 0; i < argc; ++i) {
        logString += argv[i];
        if (i < argc - 1) {
            logString += " ";
        }
    }
    std::cout << "Logged arguments: " << logString << std::endl;
}

int main(int argc, char* argv[]) {
    parseAndLogArguments(argc, argv);
    return 0;
}