# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

#define SENSOR_READ_PERIOD_MS 100
#define CONTROL_PROCESS_PERIOD_MS 50

typedef struct {
    volatile uint16_t temperature;
    volatile uint16_t pressure;
} sensor_data_t;

sensor_data_t shared_sensor_data;

void TaskReadSensor(void *pvParameters) {
    while (1) {
        // Simulate reading from a sensor
        shared_sensor_data.temperature = 25; // Example value
        shared_sensor_data.pressure = 1013; // Example value

        vTaskDelay(pdMS_TO_TICKS(SENSOR_READ_PERIOD_MS));
    }
}

void TaskProcessControl(void *pvParameters) {
    while (1) {
        // Process the sensor data for control logic
        uint16_t temperature = shared_sensor_data.temperature;
        uint16_t pressure = shared_sensor_data.pressure;

        // Example control logic: print values to console or further processing
        printf("Temperature: %u, Pressure: %u\n", temperature, pressure);

        vTaskDelay(pdMS_TO_TICKS(CONTROL_PROCESS_PERIOD_MS));
    }
}

int main(void) {
    TaskHandle_t xTask1, xTask2;

    // Create tasks
    xTaskCreate(TaskReadSensor, "Read Sensor", configMINIMAL_STACK_SIZE, NULL, 1, &xTask1);
    xTaskCreate(TaskProcessControl, "Control Process", configMINIMAL_STACK_SIZE, NULL, 1, &xTask2);

    // Start the scheduler
    vTaskStartScheduler();

    // Should never reach here if the tasks are created successfully
    for (;;);

    return 0;
}