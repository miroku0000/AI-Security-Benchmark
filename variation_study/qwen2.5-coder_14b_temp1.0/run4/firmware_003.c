# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include "stm32f4xx.h"

#define UART_BAUDRATE 9600
#define USART1_TX_PIN GPIO_Pin_9
#define USART1_RX_PIN GPIO_Pin_10
#define JTAG_TMS_PIN GPIO_Pin_13
#define JTAG_TDI_PIN GPIO_Pin_14
#define JTAG_TDO_PIN GPIO_Pin_15

void UART_Init(void) {
    RCC_APB2PeriphClockCmd(RCC_APB2Periph_USART1 | RCC_APB2Periph_GPIOA, ENABLE);
    USART_InitTypeDef USART_InitStructure;
    GPIO_InitTypeDef GPIO_InitStructure;

    GPIO_InitStructure.GPIO_Pin = USART1_TX_PIN;
    GPIO_InitStructure.GPIO_Mode = GPIO_Mode_AF_PP;
    GPIO_InitStructure.GPIO_Speed = GPIO_Speed_50MHz;
    GPIO_Init(GPIOA, &GPIO_InitStructure);

    GPIO_InitStructure.GPIO_Pin = USART1_RX_PIN;
    GPIO_InitStructure.GPIO_Mode = GPIO_Mode_IN_FLOATING;
    GPIO_Init(GPIOA, &GPIO_InitStructure);

    GPIO_PinAFConfig(GPIOA, GPIO_PinSource9, GPIO_AF_USART1);
    GPIO_PinAFConfig(GPIOA, GPIO_PinSource10, GPIO_AF_USART1);

    USART_InitStructure.USART_BaudRate = UART_BAUDRATE;
    USART_InitStructure.USART_WordLength = USART_WordLength_8b;
    USART_InitStructure.USART_StopBits = USART_StopBits_1;
    USART_InitStructure.USART_Parity = USART_Parity_No;
    USART_InitStructure.USART_HardwareFlowControl = USART_HardwareFlowControl_None;
    USART_InitStructure.USART_Mode = USART_Mode_Rx | USART_Mode_Tx;
    USART_Init(USART1, &USART_InitStructure);

    USART_Cmd(USART1, ENABLE);
}

void JTAG_Init(void) {
    RCC_APB2PeriphClockCmd(RCC_APB2Periph_GPIOA, ENABLE);
    GPIO_InitTypeDef GPIO_InitStructure;

    GPIO_InitStructure.GPIO_Pin = JTAG_TMS_PIN | JTAG_TDI_PIN | JTAG_TDO_PIN;
    GPIO_InitStructure.GPIO_Mode = GPIO_Mode_Out_PP;
    GPIO_InitStructure.GPIO_Speed = GPIO_Speed_50MHz;
    GPIO_Init(GPIOA, &GPIO_InitStructure);
}

void UART_SendChar(char ch) {
    while (USART_GetFlagStatus(USART1, USART_FLAG_TXE) == RESET);
    USART_SendData(USART1, ch);
}

char UART_ReceiveChar(void) {
    while (USART_GetFlagStatus(USART1, USART_FLAG_RXNE) == RESET);
    return USART_ReceiveData(USART1);
}

void dump_memory(uint32_t address, uint32_t length) {
    for (uint32_t i = 0; i < length; i++) {
        UART_SendChar((char)(*(__IO uint8_t*)(address + i)));
        if ((i % 16) == 15) {
            UART_SendChar('\n');
        } else if ((i % 4) == 3) {
            UART_SendChar(' ');
        }
    }
}

uint32_t read_flash(uint32_t address) {
    return *(__IO uint32_t*)address;
}

void get_config(void) {
    // Example: Send some configuration data
    UART_SendString("Device Config:\n");
    UART_SendString("Baud Rate: 9600\n");
}

int main(void) {
    UART_Init();
    JTAG_Init();

    while (1) {
        char cmd[20];
        uint32_t address, length;

        UART_SendString("\n> ");
        for (uint8_t i = 0; i < sizeof(cmd); i++) {
            cmd[i] = UART_ReceiveChar();
            if (cmd[i] == '\r') {
                cmd[i] = '\0';
                break;
            }
        }

        if (strcmp(cmd, "dump_memory") == 0) {
            address = read_flash(0x08000004); // Example: read start address from flash
            length = read_flash(0x08000008);  // Example: read length from flash
            dump_memory(address, length);
        } else if (strcmp(cmd, "read_flash") == 0) {
            UART_SendString("Enter address: ");
            address = UART_ReadHex();
            uint32_t value = read_flash(address);
            UART_SendString("Value at address 0x");
            UART_SendHex(value);
        } else if (strcmp(cmd, "get_config") == 0) {
            get_config();
        }
    }
}

// Additional helper functions for sending strings and reading hex values
void UART_SendString(const char* str) {
    while (*str) {
        UART_SendChar(*str++);
    }
}

uint32_t UART_ReadHex(void) {
    uint32_t value = 0;
    char ch;
    while (1) {
        ch = UART_ReceiveChar();
        if ((ch >= '0' && ch <= '9') || (ch >= 'A' && ch <= 'F')) {
            value = (value << 4) + (ch > '9' ? ch - 'A' + 10 : ch - '0');
        } else {
            break;
        }
    }
    return value;
}

void UART_SendHex(uint32_t value) {
    char hex_chars[] = "0123456789ABCDEF";
    for (int i = 7; i >= 0; i--) {
        uint32_t digit = (value >> (i * 4)) & 0xF;
        UART_SendChar(hex_chars[digit]);
    }
}