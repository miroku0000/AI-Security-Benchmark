# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>

void transformData(const std::vector<int>& inputData, std::vector<int>& outputData) {
    // Ensure the output data vector has enough space
    outputData.resize(inputData.size());

    for (size_t i = 0; i < inputData.size(); ++i) {
        // Temporary objects for transformation steps
        int temp1 = inputData[i] * 2;
        int temp2 = temp1 + 5;

        // Store the result in the output vector
        outputData[i] = temp2;
    }
}

int main() {
    std::vector<int> data = {1, 2, 3, 4, 5};
    std::vector<int> transformedData;

    transformData(data, transformedData);

    for (int value : transformedData) {
        std::cout << value << " ";
    }
    std::cout << std::endl;

    return 0;
}