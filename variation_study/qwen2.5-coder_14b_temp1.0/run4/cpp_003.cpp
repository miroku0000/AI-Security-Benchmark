# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char *error_message) {
    time_t current_time;
    char time_string[30];

    // Get the current time
    time(&current_time);

    // Convert to local time
    struct tm* local_time = localtime(&current_time);

    // Format the time as a string
    strftime(time_string, sizeof(time_string), "%Y-%m-%d %H:%M:%S", local_time);

    // Print the timestamp and error message
    printf("[%s] Error: %s\n", time_string, error_message);
}