# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <string.h>
#include <fs/fs.h>
#include <device.h>

#define ADMIN_TASK_PRIORITY 10
#define USER_TASK_PRIORITY 20

struct admin_operation {
    int op_code; // Operation code (e.g., 0 for write to flash, 1 for modify system config)
    void *data;   // Data pointer or parameters needed for the operation
};

K_SEM_DEFINE(admin_op_sem, 0, 1);
struct admin_operation current_admin_op;

void admin_task(void *arg1, void *arg2, void *arg3) {
    while (1) {
        k_sem_take(&admin_op_sem, K_FOREVER);

        switch (current_admin_op.op_code) {
            case 0:
                // Implement flash memory write operation
                printk("Admin task: Writing to flash memory\n");
                // Example: Write data to flash using fs API or device driver
                break;
            case 1:
                // Implement system config modification
                printk("Admin task: Modifying system configuration\n");
                // Example: Modify system parameters or settings
                break;
            default:
                printk("Admin task: Unknown operation code\n");
        }
    }
}

void user_task(void *arg1, void *arg2, void *arg3) {
    while (1) {
        // User task logic to request admin operations
        int op_code = /* Determine operation code */;
        void *data = /* Prepare data for the operation */;

        struct admin_operation requested_op = { .op_code = op_code, .data = data };

        if (op_code == 0 || op_code == 1) {
            printk("User task: Requesting admin operation\n");
            current_admin_op = requested_op;
            k_sem_give(&admin_op_sem);
        } else {
            printk("User task: Invalid operation code\n");
        }

        // Simulate some user work
        k_sleep(K_MSEC(1000));
    }
}

void main(void) {
    printk("Zephyr RTOS Admin/User Task Application\n");

    struct admin_operation initial_op = { .op_code = -1, .data = NULL };
    current_admin_op = initial_op;

    // Create admin task
    k_thread_create(&admin_task_data, admin_stack_area, K_THREAD_STACK_SIZEOF(admin_stack_area),
                    admin_task, NULL, NULL, NULL,
                    ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);

    // Create user task
    k_thread_create(&user_task_data, user_stack_area, K_THREAD_STACK_SIZEOF(user_stack_area),
                    user_task, NULL, NULL, NULL,
                    USER_TASK_PRIORITY, 0, K_NO_WAIT);
}