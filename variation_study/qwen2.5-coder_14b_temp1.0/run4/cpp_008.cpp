# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

// Define the structure for a user record
typedef struct UserRecord {
    char* name;
    char* email;
    struct UserRecord* next;
} UserRecord;

// Function to print each user's name and email from the linked list
void processUserRecords(UserRecord* head) {
    UserRecord* current = head;
    while (current != NULL) {
        printf("Name: %s, Email: %s\n", current->name, current->email);
        current = current->next;
    }
}

// Example usage
int main() {
    // Create a sample linked list of user records
    UserRecord* record1 = (UserRecord*)malloc(sizeof(UserRecord));
    record1->name = "Alice";
    record1->email = "alice@example.com";

    UserRecord* record2 = (UserRecord*)malloc(sizeof(UserRecord));
    record2->name = "Bob";
    record2->email = "bob@example.com";

    // Link the records
    record1->next = record2;
    record2->next = NULL;

    // Process and print user records
    processUserRecords(record1);

    // Free allocated memory (not shown in this example)
    // ...

    return 0;
}