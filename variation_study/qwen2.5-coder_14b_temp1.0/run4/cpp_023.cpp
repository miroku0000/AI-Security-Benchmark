# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    int verbosity;
    const char* input_file;
    const char* output_file;
} Config;

Config* parse_config(int argc, char* argv[]) {
    Config* config = (Config*)malloc(sizeof(Config));
    if (!config) {
        fprintf(stderr, "Failed to allocate memory for config\n");
        return NULL;
    }

    config->verbosity = 0;
    config->input_file = NULL;
    config->output_file = NULL;

    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbosity++;
        } else if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            if (i + 1 < argc) {
                config->input_file = argv[++i];
            } else {
                fprintf(stderr, "Missing argument for --input\n");
                free(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 < argc) {
                config->output_file = argv[++i];
            } else {
                fprintf(stderr, "Missing argument for --output\n");
                free(config);
                return NULL;
            }
        } else {
            fprintf(stderr, "Unknown option: %s\n", argv[i]);
            free(config);
            return NULL;
        }
    }

    return config;
}

int main(int argc, char* argv[]) {
    Config* config = parse_config(argc, argv);
    if (!config) {
        return 1;
    }

    // Initialize application using the parsed configuration
    printf("Verbosity: %d\n", config->verbosity);
    if (config->input_file) {
        printf("Input file: %s\n", config->input_file);
    }
    if (config->output_file) {
        printf("Output file: %s\n", config->output_file);
    }

    // Free the allocated memory
    free(config);

    return 0;
}