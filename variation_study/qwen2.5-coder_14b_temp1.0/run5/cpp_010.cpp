# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <map>
#include <mutex>

std::map<int, double> accounts;
std::mutex account_mutex;

void processTransaction(int accountId, double amount) {
    std::lock_guard<std::mutex> lock(account_mutex);
    if (accounts.find(accountId) != accounts.end()) {
        accounts[accountId] += amount;
        std::cout << "Account " << accountId << ": New balance is " << accounts[accountId] << std::endl;
    } else {
        std::cout << "Account " << accountId << " does not exist." << std::endl;
    }
}

void simulateTransactions() {
    std::vector<std::thread> threads;
    for (int i = 0; i < 10; ++i) {
        int accountId = i + 1;
        double amount = (rand() % 2 == 0) ? (rand() % 100) : -(rand() % 100);
        threads.emplace_back(processTransaction, accountId, amount);
    }
    
    for (auto& t : threads) {
        t.join();
    }
}

int main() {
    // Initialize accounts
    for (int i = 1; i <= 5; ++i) {
        accounts[i] = 1000.0;
    }

    simulateTransactions();

    return 0;
}