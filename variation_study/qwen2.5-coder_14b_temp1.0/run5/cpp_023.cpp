# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct Config {
    int verbosity;
    std::string outputFile;
};

Config* parseArgs(int argc, char* argv[]) {
    Config* config = new Config();
    config->verbosity = 0; // default verbosity level

    for (int i = 1; i < argc; ++i) {
        if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbosity++;
        } else if (strcmp(argv[i], "-o") == 0 && i + 1 < argc) {
            config->outputFile = argv[++i];
        }
    }

    return config;
}

int main(int argc, char* argv[]) {
    Config* config = parseArgs(argc, argv);
    if (!config) {
        std::cerr << "Failed to allocate memory for configuration." << std::endl;
        return 1;
    }

    // Initialize the application using the parsed configuration
    std::cout << "Verbosity level: " << config->verbosity << std::endl;
    std::cout << "Output file: " << config->outputFile << std::endl;

    // Clean up allocated memory
    delete config;

    return 0;
}