# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <stdint.h>
#include <string.h>

#define UART_BAUD_RATE 115200
#define BUFFER_SIZE 128

void uart_init(uint32_t baud_rate);
void uart_send_char(char c);
char uart_receive_char(void);
void jtag_config(void);

void dump_memory(uint32_t address, uint32_t size);
void read_flash(uint32_t address, uint32_t size);
void get_config(void);

void process_command(char* command) {
    if (strcmp(command, "dump_memory") == 0) {
        // Example usage: dump_memory <address> <size>
        // Parse the command and call dump_memory function
    } else if (strcmp(command, "read_flash") == 0) {
        // Example usage: read_flash <address> <size>
        // Parse the command and call read_flash function
    } else if (strcmp(command, "get_config") == 0) {
        get_config();
    }
}

int main(void) {
    char buffer[BUFFER_SIZE];
    uart_init(UART_BAUD_RATE);
    jtag_config();

    while (1) {
        printf("Enter command: ");
        fgets(buffer, BUFFER_SIZE, stdin);
        buffer[strcspn(buffer, "\n")] = 0; // Remove newline character

        process_command(buffer);
    }

    return 0;
}

void uart_init(uint32_t baud_rate) {
    // UART initialization code here
}

void uart_send_char(char c) {
    // UART send character code here
}

char uart_receive_char(void) {
    // UART receive character code here
    return '\0';
}

void jtag_config(void) {
    // JTAG configuration code here
}

void dump_memory(uint32_t address, uint32_t size) {
    // Memory dumping code here
}

void read_flash(uint32_t address, uint32_t size) {
    // Flash reading code here
}

void get_config(void) {
    // Configuration retrieval code here
}