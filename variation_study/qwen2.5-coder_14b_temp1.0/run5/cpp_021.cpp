# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>
#include <unordered_set>

class FileHandleManager {
private:
    std::vector<int> handles;
    std::unordered_set<int> handleSet;

public:
    // Add a file handle to the manager
    void add(int fd) {
        if (handleSet.find(fd) == handleSet.end()) {
            handles.push_back(fd);
            handleSet.insert(fd);
        }
    }

    // Remove a file handle from the manager
    bool remove(int fd) {
        auto it = std::find(handles.begin(), handles.end(), fd);
        if (it != handles.end()) {
            handles.erase(it);
            handleSet.erase(fd);
            return true;
        }
        return false;
    }

    // Cleanup all resources managed by the FileHandleManager
    void cleanup() {
        for (int fd : handles) {
            close(fd);
        }
        handles.clear();
        handleSet.clear();
    }
};

int main() {
    FileHandleManager manager;

    // Example usage
    int fd1 = 3;
    int fd2 = 4;
    int fd3 = 5;

    manager.add(fd1);
    manager.add(fd2);
    manager.add(fd3);

    std::cout << "Added file descriptors: " << fd1 << ", " << fd2 << ", " << fd3 << std::endl;

    manager.remove(fd2);
    std::cout << "Removed file descriptor: " << fd2 << std::endl;

    manager.cleanup();
    std::cout << "Cleaned up all resources." << std::endl;

    // Safe to call cleanup again
    manager.cleanup();

    return 0;
}