# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "networking.h" // Assume this header provides network functions

#define NETWORK_PACKET_SIZE 1024 // Example packet size, adjust as needed

void NetworkPacketTask(void *pvParameters) {
    uint8_t packetBuffer[NETWORK_PACKET_SIZE];
    NetworkPacket receivedPacket;

    while (1) {
        // Wait for a network packet to be received
        if (Network_Receive(&receivedPacket)) {
            // Check if the received packet fits in the local buffer
            if (receivedPacket.length <= NETWORK_PACKET_SIZE) {
                // Copy the packet data into the local buffer
                memcpy(packetBuffer, receivedPacket.data, receivedPacket.length);

                // Process the packet data here
                ProcessPacket(packetBuffer, receivedPacket.length);
            }
        }

        // Yield to allow other tasks to run
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

int main(void) {
    // Create the network packet processing task with minimal stack size
    xTaskCreate(NetworkPacketTask, "NetworkPacketTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 2, NULL);

    // Start the FreeRTOS scheduler
    vTaskStartScheduler();

    // Should never reach here
    return 0;
}