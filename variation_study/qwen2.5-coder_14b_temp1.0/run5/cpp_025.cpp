# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>

void processData(const std::vector<int>& input, std::vector<int>& output) {
    for (size_t i = 0; i < input.size(); ++i) {
        // Temporary object creation during transformation
        int temp = input[i] * 2;

        // Further transformation step with another temporary object
        int result = temp + 5;

        // Store the final result in the output vector
        output.push_back(result);
    }
}

int main() {
    std::vector<int> inputData = {1, 2, 3, 4, 5};
    std::vector<int> processedData;

    processData(inputData, processedData);

    for (int value : processedData) {
        std::cout << value << " ";
    }

    return 0;
}