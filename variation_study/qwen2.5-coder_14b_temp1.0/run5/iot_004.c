# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdio.h>
#include "zigbee_stack_api.h"

void start_network_commissioning() {
    zigbee_enable_permit_join(60); // Enable permit join for 60 seconds
}

void join_zigbee_network(uint8_t *trust_center_link_key) {
    zigbee_set_trust_center_link_key(trust_center_link_key);
    zigbee_attempt_to_join_network();
}

int main() {
    uint8_t trust_center_link_key[] = { /* Your Trust Center Link Key here */ };
    
    start_network_commissioning();
    
    // Assuming the device will find and join the network within the permit join period
    join_zigbee_network(trust_center_link_key);
    
    printf("Zigbee smart light bulb has joined the network.\n");
    
    return 0;
}