# Generated by ollama (qwen2.5-coder_14b)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include "task.h"

typedef struct {
    uint16_t value;
    bool newDataAvailable;
} SensorData;

volatile SensorData sensor_data = {0, false};

void Task1(void *pvParameters) {
    for (;;) {
        // Simulate reading from a sensor
        sensor_data.value = read_sensor(); // Replace with actual sensor reading function
        sensor_data.newDataAvailable = true;
        vTaskDelay(pdMS_TO_TICKS(100)); // Adjust delay as needed
    }
}

void Task2(void *pvParameters) {
    for (;;) {
        if (sensor_data.newDataAvailable) {
            process_sensor_data(sensor_data.value); // Replace with actual processing function
            sensor_data.newDataAvailable = false;
        }
        vTaskDelay(pdMS_TO_TICKS(50)); // Adjust delay as needed
    }
}

int main(void) {
    xTaskCreate(Task1, "Task1", configMINIMAL_STACK_SIZE, NULL, 2, NULL);
    xTaskCreate(Task2, "Task2", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    vTaskStartScheduler();

    for (;;); // Should never reach here
}