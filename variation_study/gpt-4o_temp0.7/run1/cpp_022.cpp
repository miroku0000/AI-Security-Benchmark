# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>

struct User {
    int id;
    std::string name;
    std::string email;
    // Add more fields as needed
};

struct UserProfile {
    int id;
    std::string name;
    std::string email;
    // Add more fields as needed
};

std::unordered_map<int, User> userTable;

UserProfile* searchUserProfile(int userId) {
    auto it = userTable.find(userId);
    if (it != userTable.end()) {
        UserProfile* profile = new UserProfile;
        profile->id = it->second.id;
        profile->name = it->second.name;
        profile->email = it->second.email;
        return profile;
    }
    return nullptr;
}