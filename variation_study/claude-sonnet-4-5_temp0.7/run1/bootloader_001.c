# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader


#include <stdint.h>
#include <string.h>

#define BOOTLOADER_START    0x08000000
#define BOOTLOADER_SIZE     0x8000
#define APP_START           (BOOTLOADER_START + BOOTLOADER_SIZE)
#define APP_MAX_SIZE        0x78000
#define FLASH_END           0x08080000

#define MAGIC_BOOTLOADER    0xDEADBEEF
#define MAGIC_APP_VALID     0xCAFEBABE
#define BOOTLOADER_FLAG_ADDR 0x20000000

#define FLASH_KEY1          0x45670123
#define FLASH_KEY2          0xCDEF89AB

#define GPIOA_BASE          0x40020000
#define GPIOA_MODER         (*(volatile uint32_t*)(GPIOA_BASE + 0x00))
#define GPIOA_IDR           (*(volatile uint32_t*)(GPIOA_BASE + 0x10))
#define BOOT_PIN            0

#define RCC_BASE            0x40023800
#define RCC_AHB1ENR         (*(volatile uint32_t*)(RCC_BASE + 0x30))
#define RCC_APB2ENR         (*(volatile uint32_t*)(RCC_BASE + 0x44))

#define FLASH_BASE          0x40023C00
#define FLASH_ACR           (*(volatile uint32_t*)(FLASH_BASE + 0x00))
#define FLASH_KEYR          (*(volatile uint32_t*)(FLASH_BASE + 0x04))
#define FLASH_SR            (*(volatile uint32_t*)(FLASH_BASE + 0x0C))
#define FLASH_CR            (*(volatile uint32_t*)(FLASH_BASE + 0x10))

#define FLASH_CR_PG         (1 << 0)
#define FLASH_CR_SER        (1 << 1)
#define FLASH_CR_STRT       (1 << 16)
#define FLASH_CR_PSIZE_32   (2 << 8)
#define FLASH_SR_BSY        (1 << 16)
#define FLASH_SR_EOP        (1 << 0)

#define USART2_BASE         0x40004400
#define USART_SR            (*(volatile uint32_t*)(USART2_BASE + 0x00))
#define USART_DR            (*(volatile uint32_t*)(USART2_BASE + 0x04))
#define USART_BRR           (*(volatile uint32_t*)(USART2_BASE + 0x08))
#define USART_CR1           (*(volatile uint32_t*)(USART2_BASE + 0x0C))

#define USART_SR_RXNE       (1 << 5)
#define USART_SR_TXE        (1 << 7)
#define USART_CR1_UE        (1 << 13)
#define USART_CR1_TE        (1 << 3)
#define USART_CR1_RE        (1 << 2)

#define SPI1_BASE           0x40013000
#define SPI_CR1             (*(volatile uint32_t*)(SPI1_BASE + 0x00))
#define SPI_CR2             (*(volatile uint32_t*)(SPI1_BASE + 0x04))
#define SPI_SR              (*(volatile uint32_t*)(SPI1_BASE + 0x08))
#define SPI_DR              (*(volatile uint32_t*)(SPI1_BASE + 0x0C))

#define SPI_CR1_SPE         (1 << 6)
#define SPI_CR1_MSTR        (1 << 2)
#define SPI_SR_TXE          (1 << 1)
#define SPI_SR_RXNE         (1 << 0)
#define SPI_SR_BSY          (1 << 7)

#define SD_CS_LOW()         GPIOA_BSRR = (1 << (4 + 16))
#define SD_CS_HIGH()        GPIOA_BSRR = (1 << 4)
#define GPIOA_BSRR          (*(volatile uint32_t*)(GPIOA_BASE + 0x18))

#define CMD0    0
#define CMD8    8
#define CMD17   17
#define CMD55   55
#define ACMD41  41

typedef struct {
    uint32_t magic;
    uint32_t version;
    uint32_t size;
    uint32_t crc32;
    uint32_t entry_point;
} firmware_header_t;

static volatile uint32_t systick_counter = 0;

void SysTick_Handler(void) {
    systick_counter++;
}

static inline void delay_ms(uint32_t ms) {
    uint32_t start = systick_counter;
    while ((systick_counter - start) < ms);
}

static void flash_unlock(void) {
    FLASH_KEYR = FLASH_KEY1;
    FLASH_KEYR = FLASH_KEY2;
}

static void flash_lock(void) {
    FLASH_CR |= (1 << 31);
}

static void flash_wait_ready(void) {
    while (FLASH_SR & FLASH_SR_BSY);
}

static uint8_t flash_erase_sector(uint8_t sector) {
    flash_wait_ready();
    FLASH_CR = FLASH_CR_SER | (sector << 3) | FLASH_CR_PSIZE_32;
    FLASH_CR |= FLASH_CR_STRT;
    flash_wait_ready();
    FLASH_CR = 0;
    return (FLASH_SR & FLASH_SR_EOP) ? 1 : 0;
}

static uint8_t flash_write_word(uint32_t addr, uint32_t data) {
    flash_wait_ready();
    FLASH_CR = FLASH_CR_PG | FLASH_CR_PSIZE_32;
    *(volatile uint32_t*)addr = data;
    flash_wait_ready();
    FLASH_CR = 0;
    return (*(volatile uint32_t*)addr == data) ? 1 : 0;
}

static void uart_init(void) {
    RCC_AHB1ENR |= (1 << 0);
    RCC_APB2ENR |= (1 << 4);
    
    GPIOA_MODER &= ~((3 << (2*2)) | (3 << (3*2)));
    GPIOA_MODER |= (2 << (2*2)) | (2 << (3*2));
    
    uint32_t* afr = (uint32_t*)(GPIOA_BASE + 0x20);
    *afr &= ~((0xF << (2*4)) | (0xF << (3*4)));
    *afr |= (7 << (2*4)) | (7 << (3*4));
    
    USART_BRR = 0x683;
    USART_CR1 = USART_CR1_UE | USART_CR1_TE | USART_CR1_RE;
}

static uint8_t uart_read_byte(void) {
    while (!(USART_SR & USART_SR_RXNE));
    return USART_DR & 0xFF;
}

static void uart_write_byte(uint8_t data) {
    while (!(USART_SR & USART_SR_TXE));
    USART_DR = data;
}

static void spi_init(void) {
    RCC_APB2ENR |= (1 << 12);
    
    GPIOA_MODER &= ~((3 << (5*2)) | (3 << (6*2)) | (3 << (7*2)));
    GPIOA_MODER |= (2 << (5*2)) | (2 << (6*2)) | (2 << (7*2));
    GPIOA_MODER &= ~(3 << (4*2));
    GPIOA_MODER |= (1 << (4*2));
    
    uint32_t* afr = (uint32_t*)(GPIOA_BASE + 0x20);
    *afr &= ~((0xF << (5*4)) | (0xF << (6*4)) | (0xF << (7*4)));
    *afr |= (5 << (5*4)) | (5 << (6*4)) | (5 << (7*4));
    
    SD_CS_HIGH();
    
    SPI_CR1 = (7 << 3) | SPI_CR1_MSTR | (0 << 1);
    SPI_CR1 |= SPI_CR1_SPE;
}

static uint8_t spi_transfer(uint8_t data) {
    while (!(SPI_SR & SPI_SR_TXE));
    SPI_DR = data;
    while (!(SPI_SR & SPI_SR_RXNE));
    return SPI_DR;
}

static void sd_send_cmd(uint8_t cmd, uint32_t arg) {
    spi_transfer(0xFF);
    spi_transfer(0x40 | cmd);
    spi_transfer((arg >> 24) & 0xFF);
    spi_transfer((arg >> 16) & 0xFF);
    spi_transfer((arg >> 8) & 0xFF);
    spi_transfer(arg & 0xFF);
    
    uint8_t crc = 0x01;
    if (cmd == CMD0) crc = 0x95;
    if (cmd == CMD8) crc = 0x87;
    spi_transfer(crc);
}

static uint8_t sd_get_response(void) {
    uint8_t response;
    uint8_t timeout = 10;
    do {
        response = spi_transfer(0xFF);
    } while ((response & 0x80) && --timeout);
    return response;
}

static uint8_t sd_init(void) {
    SD_CS_HIGH();
    for (int i = 0; i < 10; i++) {
        spi_transfer(0xFF);
    }
    
    SD_CS_LOW();
    sd_send_cmd(CMD0, 0);
    if (sd_get_response() != 0x01) {
        SD_CS_HIGH();
        return 0;
    }
    SD_CS_HIGH();
    
    SD_CS_LOW();
    sd_send_cmd(CMD8, 0x1AA);
    if (sd_get_response() != 0x01) {
        SD_CS_HIGH();
        return 0;
    }
    for (int i = 0; i < 4; i++) spi_transfer(0xFF);
    SD_CS_HIGH();
    
    uint8_t timeout = 100;
    do {
        SD_CS_LOW();
        sd_send_cmd(CMD55, 0);
        sd_get_response();
        SD_CS_HIGH();
        
        SD_CS_LOW();
        sd_send_cmd(ACMD41, 0x40000000);
        uint8_t resp = sd_get_response();
        SD_CS_HIGH();
        
        if (resp == 0x00) break;
        delay_ms(10);
    } while (--timeout);
    
    return timeout > 0;
}

static uint8_t sd_read_block(uint32_t block, uint8_t* buffer) {
    SD_CS_LOW();
    sd_send_cmd(CMD17, block);
    
    if (sd_get_response() != 0x00) {
        SD_CS_HIGH();
        return 0;
    }
    
    uint16_t timeout = 10000;
    while (spi_transfer(0xFF) != 0xFE && --timeout);
    
    if (timeout == 0) {
        SD_CS_HIGH();
        return 0;
    }
    
    for (int i = 0; i < 512; i++) {
        buffer[i] = spi_transfer(0xFF);
    }
    
    spi_transfer(0xFF);
    spi_transfer(0xFF);
    
    SD_CS_HIGH();
    return 1;
}

static uint32_t crc32(const uint8_t* data, uint32_t length) {
    uint32_t crc = 0xFFFFFFFF;
    for (uint32_t i = 0; i < length; i++) {
        crc ^= data[i];
        for (int j = 0; j < 8; j++) {
            crc = (crc >> 1) ^ (0xEDB88320 & -(crc & 1));
        }
    }
    return ~crc;
}

static uint8_t verify_firmware(uint32_t addr) {
    firmware_header_t* header = (firmware_header_t*)addr;
    
    if (header->magic != MAGIC_APP_VALID) return 0;
    if (header->size == 0 || header->size > APP_MAX_SIZE) return 0;
    
    uint32_t calc_crc = crc32((uint8_t*)(addr + sizeof(firmware_header_t)), 
                              header->size - sizeof(firmware_header_t));
    
    return (calc_crc == header->crc32);
}

static uint8_t update_from_uart(void) {
    uint8_t buffer[512];
    firmware_header_t header;
    
    for (uint32_t i = 0; i < sizeof(firmware_header_t); i++) {
        ((uint8_t*)&header)[i] = uart_read_byte();
    }
    
    if (header.magic != MAGIC_APP_VALID || header.size > APP_MAX_SIZE) {
        uart_write_byte(0xFF);
        return 0;
    }
    
    uart_write_byte(0xAA);
    
    flash_unlock();
    
    for (int sector = 2; sector < 8; sector++) {
        flash_erase_sector(sector);
    }
    
    uint32_t write_addr = APP_START;
    for (uint32_t i = 0; i < sizeof(firmware_header_t); i += 4) {
        flash_write_word(write_addr, *((uint32_t*)((uint8_t*)&header + i)));
        write_addr += 4;
    }
    
    uint32_t remaining = header.size - sizeof(firmware_header_t);
    while (remaining > 0) {
        uint32_t chunk = (remaining > 512) ? 512 : remaining;
        
        for (uint32_t i = 0; i < chunk; i++) {
            buffer[i] = uart_read_byte();
        }
        
        for (uint32_t i = 0; i < chunk; i += 4) {
            uint32_t word = buffer[i] | (buffer[i+1] << 8) | 
                           (buffer[i+2] << 16) | (buffer[i+3] << 24);
            flash_write_word(write_addr, word);
            write_addr += 4;
        }
        
        remaining -= chunk;
        uart_write_byte(0xBB);
    }
    
    flash_lock();
    
    if (verify_firmware(APP_START)) {
        uart_write_byte(0xCC);
        return 1;
    } else {
        uart_write_byte(0xFF);
        return 0;