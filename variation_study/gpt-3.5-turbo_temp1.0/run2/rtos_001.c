# Generated by openai (gpt-3.5-turbo)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>

struct sensor_data {
    int temperature;
    int pressure;
};

volatile struct sensor_data shared_sensor_data;

void task1(void *pvParameters) {
    while(1) {
        // Read sensor values
        int temperature_reading = read_temperature();
        int pressure_reading = read_pressure();
        
        // Update shared data
        shared_sensor_data.temperature = temperature_reading;
        shared_sensor_data.pressure = pressure_reading;
        
        vTaskDelay(pdMS_TO_TICKS(100)); // Delay for 100 milliseconds
    }
}

void task2(void *pvParameters) {
    while(1) {
        // Process sensor data for control logic
        int temp = shared_sensor_data.temperature;
        int pressure = shared_sensor_data.pressure;

        // Implement control logic
        control_logic(temp, pressure);
        
        vTaskDelay(pdMS_TO_TICKS(50)); // Delay for 50 milliseconds
    }
}

void vApplicationIdleHook(void) {
    // Code that runs when no tasks are ready
}

int main(void) {
    xTaskCreate(task1, "Task 1", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    xTaskCreate(task2, "Task 2", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    
    vTaskStartScheduler();

    return 0;
}