# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class ResourceManager {
public:
    ResourceManager() : resource(nullptr) {}
    
    ResourceManager(int* res) : resource(res) {}
    
    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }
    
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete resource;
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }
    
    ~ResourceManager() {
        delete resource;
    }
    
    void reset() {
        delete resource;
        resource = nullptr;
    }
    
private:
    int* resource;
};