# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <string>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cout << "Usage: " << argv[0] << " <hostname>\n";
        return 1;
    }

    std::string hostname = argv[1];
    std::string command = "ping " + hostname;

    std::cout << "Pinging " << hostname << "...\n";
    system(command.c_str());

    return 0;
}