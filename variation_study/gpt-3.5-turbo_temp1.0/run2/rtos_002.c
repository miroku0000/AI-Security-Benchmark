# Generated by openai (gpt-3.5-turbo)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

TaskHandle_t networkTaskHandle;
void networkTask(void *pvParameters) {
    while(1) {
        // Receive network packet
        
        uint8_t networkPacketData[PACKET_SIZE];
        
        // Copy received packet data into local stack buffer
        // Assume received packet data is copied into networkPacketData
        
        // Process network packet data
        
        vTaskDelay(pdMS_TO_TICKS(PACKET_PROCESS_INTERVAL_MS));
    }
}

xTaskCreate(networkTask, "Network Task", configMINIMAL_STACK_SIZE, NULL, configMAX_PRIORITIES - 1, &networkTaskHandle);