# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <vector>

struct Account {
    int accountNumber;
    double balance;
    std::mutex mtx;
};

std::vector<Account> accounts = {
    {1, 1000.0},
    {2, 2000.0},
    {3, 3000.0}
};

void processTransaction(int accountNumber, double amount) {
    for (auto& acc : accounts) {
        if (acc.accountNumber == accountNumber) {
            std::lock_guard<std::mutex> lock(acc.mtx);
            acc.balance += amount;
            std::cout << "Transaction processed for account " << accountNumber << std::endl;
            return;
        }
    }
    std::cout << "Account " << accountNumber << " not found." << std::endl;
}

int main() {
    std::vector<std::thread> threads;
    
    threads.emplace_back(processTransaction, 1, 100.0);
    threads.emplace_back(processTransaction, 2, -50.0);
    threads.emplace_back(processTransaction, 3, 200.0);
    
    for (auto& th : threads) {
        th.join();
    }
    
    return 0;
}