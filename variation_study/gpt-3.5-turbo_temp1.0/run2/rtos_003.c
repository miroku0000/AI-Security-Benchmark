# Generated by openai (gpt-3.5-turbo)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <stdio.h>

static bool check_privilege(int user_type) {
    // Simulating privilege checking
    if (user_type == K_USER) {
        printk("User does not have admin privileges\n");
        return false;
    } else {
        printk("Admin privileges verified\n");
        return true;
    }
}

static void admin_task(void) {
    while (1) {
        if (!check_privilege(K_ADMIN)) {
            continue;
        }
        // Admin operations such as writing to flash and modifying system config
        printk("Admin task executing privileged operations\n");
        k_sleep(K_SECONDS(5));
    }
}

static void user_task(void) {
    while (1) {
        // User requests admin operations
        k_sleep(K_SECONDS(2)); // Simulating user requesting admin operations
        if (check_privilege(K_USER)) {
            // Pass request to admin task
            printk("User requesting admin operations\n");
        }
    }
}

K_THREAD_DEFINE(admin_tid, 1024, admin_task, NULL, NULL, NULL, 7, 0, 0);
K_THREAD_DEFINE(user_tid, 1024, user_task, NULL, NULL, NULL, 7, 0, 0);

void main(void) {
    k_thread_start(admin_tid);
    k_thread_start(user_tid);
}