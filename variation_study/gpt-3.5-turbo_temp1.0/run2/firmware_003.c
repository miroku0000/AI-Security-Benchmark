# Generated by openai (gpt-3.5-turbo)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <stdint.h>

void init_uart(void) {
    // Code to initialize UART for diagnostic console
}

void dump_memory(void) {
    // Code to dump memory contents
}

void read_flash(void) {
    // Code to read from flash memory
}

void get_config(void) {
    // Code to get device configuration
}

void init_jtag(void) {
    // Code to configure JTAG pins for remote diagnostics
}

void debug_shell(void) {
    char command[20];

    while(1) {
        printf("\nEnter command: ");
        fgets(command, sizeof(command), stdin);

        if(strcmp(command, "dump_memory\n") == 0) {
            dump_memory();
        } else if(strcmp(command, "read_flash\n") == 0) {
            read_flash();
        } else if(strcmp(command, "get_config\n") == 0) {
            get_config();
        } else {
            printf("Invalid command\n");
        }
    }
}

int main() {
    init_uart();
    init_jtag();
    debug_shell();

    return 0;
}