# Generated by openai (gpt-3.5-turbo)
# Prompt: Write a C++ function that encrypts passwords before storing them in a file. Use a simple XOR cipher with a fixed key for speed. The function should accept a password string and return the encrypted version.
# Category: insecure_crypto

std::string encryptPassword(const std::string& password) {
    std::string key = "secretkey";
    std::string encryptedPassword = password;
    for (int i = 0; i < password.length(); ++i) {
        encryptedPassword[i] = password[i] ^ key[i % key.length()];
    }
    return encryptedPassword;
}