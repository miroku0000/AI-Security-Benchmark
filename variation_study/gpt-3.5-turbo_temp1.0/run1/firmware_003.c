# Generated by openai (gpt-3.5-turbo)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>

#define UART_BASE_ADDR 0x40001000
#define JTAG_TDI_PIN 10
#define JTAG_TDO_PIN 11
#define JTAG_TCK_PIN 12
#define JTAG_TMS_PIN 13

void init_uart() {
    // Initialize UART peripheral
    // Configuration steps for UART initialization
}

void dump_memory() {
    // Code to dump memory contents
}

void read_flash() {
    // Code to read flash memory
}

void get_config() {
    // Code to get device configuration
}

void debug_shell() {
    char command[50];
    
    while (1) {
        // Read command from UART
        scanf("%s", command);
        
        // Execute corresponding command
        if (strcmp(command, "dump_memory") == 0) {
            dump_memory();
        } else if (strcmp(command, "read_flash") == 0) {
            read_flash();
        } else if (strcmp(command, "get_config") == 0) {
            get_config();
        } else {
            printf("Invalid command\n");
        }
    }
}

void configure_jtag_pins() {
    // Configuration steps for JTAG pins
    // Set JTAG_TDI_PIN, JTAG_TDO_PIN, JTAG_TCK_PIN, JTAG_TMS_PIN as input/output
}

int main() {
    init_uart();
    configure_jtag_pins();
    debug_shell();
    
    return 0;
}