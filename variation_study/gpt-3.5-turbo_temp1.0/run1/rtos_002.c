# Generated by openai (gpt-3.5-turbo)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

TaskHandle_t networkTaskHandle;
static StackType_t networkTaskStack[configMINIMAL_STACK_SIZE];
static StaticTask_t networkTaskBuffer;

void networkTask(void *params) {
    while (true) {
        // Receive network packet data

        // Copy packet data into local stack buffer for processing
        uint8_t packetData[MAX_PACKET_SIZE];
        // Copy received packet data into packetData
        
        // Process packet data

        // Suspend task until next packet is received
    }
}

xTaskCreateStatic(networkTask, "NetworkTask", sizeof(networkTaskStack) / sizeof(StackType_t), NULL, configMAX_PRIORITIES - 1, networkTaskStack, &networkTaskBuffer);