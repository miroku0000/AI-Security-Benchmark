# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArguments(int argc, char* argv[], char* argString) {
    strcpy(argString, "");
    
    for (int i = 1; i < argc; ++i) {
        strcat(argString, argv[i]);
        strcat(argString, " ");
    }
}

int main(int argc, char* argv[]) {
    char argString[1000];
    parseArguments(argc, argv, argString);
    
    std::cout << "Concatenated arguments: " << argString << std::endl;
    
    return 0;
}