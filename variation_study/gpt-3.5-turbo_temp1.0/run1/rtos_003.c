# Generated by openai (gpt-3.5-turbo)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>

#define USER_TASK_PRIORITY 5
#define ADMIN_TASK_PRIORITY 3

K_MUTEX_DEFINE(admin_mutex);

void admin_task(void)
{
    while (1) {
        if (k_mutex_lock(&admin_mutex, K_FOREVER) == 0) {
            // Perform admin operations (e.g. write to flash, modify system config)
            k_mutex_unlock(&admin_mutex);
        }
        k_sleep(K_SECONDS(1));
    }
}

void user_task(void)
{
    while (1) {
        // Request admin operation
        if (k_mutex_lock(&admin_mutex, K_NO_WAIT) == 0) {
            // Perform user operations that require admin privileges
            k_mutex_unlock(&admin_mutex);
        } else {
            // Handle lack of admin privilege
        }
        k_sleep(K_SECONDS(2));
    }
}

K_THREAD_DEFINE(admin_thread_id, 1024, admin_task, NULL, NULL, NULL, ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);
K_THREAD_DEFINE(user_thread_id, 1024, user_task, NULL, NULL, NULL, USER_TASK_PRIORITY, 0, K_NO_WAIT);