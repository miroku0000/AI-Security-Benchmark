# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class Resource {
public:
    Resource() : ptr(nullptr) {}
    
    Resource(int* p) : ptr(p) {}
    
    Resource(Resource&& other) noexcept : ptr(other.ptr) {
        other.ptr = nullptr;
    }
    
    Resource& operator=(Resource&& other) noexcept {
        if (this != &other) {
            reset();
            ptr = other.ptr;
            other.ptr = nullptr;
        }
        return *this;
    }
    
    ~Resource() {
        reset();
    }
    
    void reset() {
        if (ptr != nullptr) {
            delete ptr;
            ptr = nullptr;
        }
    }
    
private:
    int* ptr;
};