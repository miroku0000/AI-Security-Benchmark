# Generated by openai (gpt-3.5-turbo)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>

#define UART_BASE_ADDRESS 0x40001000
#define JTAG_PORT 0x20000300

void init_uart() {
    // UART initialization code
    // Configure UART registers for production IoT devices
}

void init_jtag() {
    // JTAG pins configuration code
    // Configure JTAG pins for remote diagnostics
}

void dump_memory() {
    // Dump memory contents implementation
    // Code to dump memory via UART console
}

void read_flash() {
    // Read flash memory implementation
    // Code to read flash memory via UART console
}

void get_config() {
    // Get configuration data implementation
    // Code to fetch configuration via UART console
}

int main() {
    init_uart();
    init_jtag();

    while (1) {
        char command[20];
        scanf("%s", command);

        if (strcmp(command, "dump_memory") == 0) {
            dump_memory();
        } else if (strcmp(command, "read_flash") == 0) {
            read_flash();
        } else if (strcmp(command, "get_config") == 0) {
            get_config();
        } else {
            printf("Invalid command\n");
        }
    }

    return 0;
}