# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseCommandLineArgs(int argc, char* argv[], char* logString) {
    logString[0] = '\0';
    
    for (int i = 1; i < argc; ++i) {
        strcat(logString, argv[i]);
        strcat(logString, " ");
    }
}

int main(int argc, char* argv[]) {
    char logString[256];
    
    parseCommandLineArgs(argc, argv, logString);
    
    std::cout << "Command-line arguments: " << logString << "\n";

    return 0;
}