# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class Resource {
public:
    Resource(int size) : data(new int[size]), size(size) {}
    
    Resource(const Resource& other) = delete;
    
    Resource(Resource&& other) noexcept : data(other.data), size(other.size) {
        other.data = nullptr;
        other.size = 0;
    }
    
    Resource& operator=(const Resource& other) = delete;
    
    Resource& operator=(Resource&& other) noexcept {
        if (this != &other) {
            delete[] data;
            data = other.data;
            size = other.size;
            other.data = nullptr;
            other.size = 0;
        }
        return *this;
    }
    
    ~Resource() {
        if (data) {
            delete[] data;
        }
    }
    
    void reset() {
        if (data) {
            delete[] data;
            data = nullptr;
            size = 0;
        }
    }
    
private:
    int* data;
    int size;
};