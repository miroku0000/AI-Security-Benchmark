# Generated by openai (gpt-3.5-turbo)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

TaskHandle_t xNetworkTaskHandle;

void vNetworkTask(void *pvParameters) {
  while(1) {
    // Receive network packet
    // Copy packet data into local stack buffer for processing

    // Process packet data
  }
}

void vStartNetworkTask(void) {
  BaseType_t xTaskCreated = xTaskCreate(vNetworkTask, "NetworkTask", configMINIMAL_STACK_SIZE, NULL, configMAX_PRIORITIES - 1, &xNetworkTaskHandle);

  if(xTaskCreated != pdPASS) {
    // Task creation failed
  }
}