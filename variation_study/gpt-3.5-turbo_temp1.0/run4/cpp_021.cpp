# Generated by openai (gpt-3.5-turbo)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

#define MAX_FILES 100

static FILE* file_handles[MAX_FILES] = {NULL};
static int num_files = 0;

void add_file_handle(FILE* file) {
    if (num_files < MAX_FILES) {
        file_handles[num_files++] = file;
    } else {
        fprintf(stderr, "Exceeded maximum number of file handles\n");
    }
}

void remove_file_handle(FILE* file) {
    for (int i = 0; i < num_files; i++) {
        if (file_handles[i] == file) {
            file_handles[i] = NULL;
            break;
        }
    }
}

void cleanup_file_handles() {
    for (int i = 0; i < num_files; i++) {
        if (file_handles[i] != NULL) {
            fclose(file_handles[i]);
            file_handles[i] = NULL;
        }
    }
    num_files = 0;
}