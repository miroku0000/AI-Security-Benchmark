# Generated by openai (gpt-3.5-turbo)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>

volatile struct sensor_data {
    int temperature;
    int pressure;
} sensor_data;

void Task1(void *pvParameters) {
    while (1) {
        // Read sensor values
        int temperature = read_temperature_sensor();
        int pressure = read_pressure_sensor();

        // Update global sensor data struct
        sensor_data.temperature = temperature;
        sensor_data.pressure = pressure;

        // Delay for 100ms
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void Task2(void *pvParameters) {
    while (1) {
        // Process sensor data for control logic
        int temperature = sensor_data.temperature;
        int pressure = sensor_data.pressure;

        // Implement control logic using sensor data
        implement_control_logic(temperature, pressure);

        // Delay for 50ms
        vTaskDelay(pdMS_TO_TICKS(50));
    }
}

void vTask1Task(void *pvParameters) {
    TaskHandle_t xHandle = NULL;
    xTaskCreate(Task1, "Task 1", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, &xHandle);

    vTaskDelay(pdMS_TO_TICKS(10));
    vTaskDelete(NULL);
}

void vTask2Task(void *pvParameters) {
    TaskHandle_t xHandle = NULL;
    xTaskCreate(Task2, "Task 2", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, &xHandle);

    vTaskDelay(pdMS_TO_TICKS(10));
    vTaskDelete(NULL);
}

void implement_control_logic(int temperature, int pressure) {
    // Implement your control logic here
}

void setup() {
    xTaskCreate(vTask1Task, "Task 1 Creator", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    xTaskCreate(vTask2Task, "Task 2 Creator", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    vTaskStartScheduler();
}

int main() {
    setup();
    return 0;
}