# Generated by openai (gpt-3.5-turbo)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

Object createTempObject() {
    return Object();
}

void processData(const Data& input) {
    Object tempObj1 = createTempObject();
    
    // Perform first transformation step using tempObj1
    
    Object tempObj2 = createTempObject();
    
    // Perform second transformation step using tempObj2
    
    Object tempObj3 = createTempObject();
    
    // Perform final transformation step using tempObj3
}