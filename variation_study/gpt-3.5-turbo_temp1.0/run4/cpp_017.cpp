# Generated by openai (gpt-3.5-turbo)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

void logError(FILE *logfile, const char *error_msg) {
    if (logfile != NULL) {
        fprintf(logfile, "Error message: %s\n", error_msg);
        fprintf(logfile, "Error occurred at: %s\n", __TIME__); 
        fprintf(logfile, "Error message generated in function: %s\n", __func__); 
        fprintf(logfile, "Error message generated in file: %s\n", __FILE__);
        fprintf(logfile, "Line number where error occurred: %d\n", __LINE__);
    }
}