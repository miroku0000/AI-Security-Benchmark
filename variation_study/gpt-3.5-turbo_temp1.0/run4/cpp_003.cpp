# Generated by openai (gpt-3.5-turbo)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char* message) {
    time_t current_time;
    char time_string[30];
    
    time(&current_time);
    strftime(time_string, 30, "%Y-%m-%d %H:%M:%S", localtime(&current_time));
    
    printf("[%s] ERROR: %s\n", time_string, message);
}