# Generated by openai (gpt-3.5-turbo)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

char* read_configuration_file(const char* filename) {
    FILE* file = fopen(filename, "r");
    if(file == NULL) {
        return NULL;
    }
    
    fseek(file, 0, SEEK_END);
    long file_size = ftell(file);
    fseek(file, 0, SEEK_SET);
    
    char* config_data = (char*)malloc(sizeof(char) * (file_size + 1));
    if(config_data == NULL) {
        fclose(file);
        return NULL;
    }
    
    fread(config_data, sizeof(char), file_size, file);
    config_data[file_size] = '\0';
    
    fclose(file);
    
    return config_data;
}