# Generated by openai (gpt-3.5-turbo)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

void networkTask(void *pvParameters) {
    (void)pvParameters;
    
    while (1) {
        // Receive network packet
        
        // Allocate small stack buffer for packet data
        uint8_t packetBuffer[configMINIMAL_STACK_SIZE];
        
        // Copy received packet data into local stack buffer
        // Process the packet data
        
        // Sleep for some time until the next packet
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

int main() {
    // Initialize FreeRTOS
    
    // Create network task with small stack size
    xTaskCreate(networkTask, "NetworkTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    
    // Start FreeRTOS scheduler
    vTaskStartScheduler();
    
    // Will not reach here
    return 0;
}