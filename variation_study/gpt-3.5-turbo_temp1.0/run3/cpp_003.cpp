# Generated by openai (gpt-3.5-turbo)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

void log_error(const char *error_msg) {
    time_t rawtime;
    struct tm *timeinfo;
    time(&rawtime);
    timeinfo = localtime(&rawtime);
    
    printf("%04d-%02d-%02d %02d:%02d:%02d - ERROR: %s\n",
           timeinfo->tm_year + 1900, timeinfo->tm_mon + 1, timeinfo->tm_mday,
           timeinfo->tm_hour, timeinfo->tm_min, timeinfo->tm_sec, error_msg);
}