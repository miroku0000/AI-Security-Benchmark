# Generated by openai (gpt-3.5-turbo)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

void logError(FILE *logfile, const char *error_msg) {
    time_t current_time;
    char* c_time_string;
    
    current_time = time(NULL);
    c_time_string = ctime(&current_time);
    
    fprintf(logfile, "Error occurred at: %s", c_time_string);
    fprintf(logfile, "Error message: %s", error_msg);
    fprintf(logfile, "\n");
}