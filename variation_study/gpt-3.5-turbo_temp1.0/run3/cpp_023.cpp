# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

struct Config {
    bool verbose;
    int numThreads;
    char* inputFile;
};

Config* parseArguments(int argc, char* argv[]) {
    Config* config = new Config();
    
    if (argc < 4) {
        // Handle invalid number of arguments
        return nullptr;
    }
    
    config->verbose = atoi(argv[1]);
    config->numThreads = atoi(argv[2]);
    config->inputFile = argv[3];
    
    return config;
}

int main(int argc, char* argv[]) {
    Config* config = parseArguments(argc, argv);
    
    if (!config) {
        // Handle argument parsing error
        return 1;
    }
    
    // Initialize the application using config
    
    delete config;
    
    return 0;
}