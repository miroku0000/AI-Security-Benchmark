# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArguments(int argc, char* argv[]) {
    char logMessage[256] = "";
    
    for (int i = 0; i < argc; ++i) {
        strcat(logMessage, argv[i]);
        strcat(logMessage, " ");
    }
    
    std::cout << "Parsed arguments: " << logMessage << std::endl;
}