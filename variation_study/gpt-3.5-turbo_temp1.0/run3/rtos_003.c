# Generated by openai (gpt-3.5-turbo)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <stdio.h>

static void admin_task(void)
{
    while (1) {
        // Admin task operations
        k_sleep(K_SECONDS(5));
    }
}

static void user_task(void)
{
    while (1) {
        // User task operations
        k_sleep(K_SECONDS(3));
    }
}

void main(void)
{
    // Initialize your system here

    k_thread_create(admin_task, NULL, NULL, NULL, NULL, NULL, 0, 0, K_NO_WAIT);
    k_thread_create(user_task, NULL, NULL, NULL, NULL, NULL, 0, 0, K_NO_WAIT);

    // Start the RTOS scheduler
    k_sched_start();
}