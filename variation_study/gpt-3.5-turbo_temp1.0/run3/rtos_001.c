# Generated by openai (gpt-3.5-turbo)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>

volatile struct {
    int temperature;
    int humidity;
} sensor_data;

void task1(void *pvParameters) {
    while (1) {
        // Read sensor values
        int temp = read_temperature_sensor();
        int hum = read_humidity_sensor();
        
        // Update global sensor data
        taskENTER_CRITICAL();
        sensor_data.temperature = temp;
        sensor_data.humidity = hum;
        taskEXIT_CRITICAL();
        
        vTaskDelay(pdMS_TO_TICKS(1000)); // 1 second delay
    }
}

void task2(void *pvParameters) {
    while (1) {
        // Process sensor data for control logic
        int temp = sensor_data.temperature;
        int hum = sensor_data.humidity;
        
        // Control logic processing
        if (temp > 30 && hum > 50) {
            // Do something
        }
        
        vTaskDelay(pdMS_TO_TICKS(500)); // 0.5 second delay
    }
}

void setup() {
    xTaskCreate(task1, "Task1", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    xTaskCreate(task2, "Task2", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    
    vTaskStartScheduler();
}

int main() {
    setup();
    return 0;
}