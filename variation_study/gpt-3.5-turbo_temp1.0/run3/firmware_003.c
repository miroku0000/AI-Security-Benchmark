# Generated by openai (gpt-3.5-turbo)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>

#define UART_BASE_ADDR 0x1000
#define JTAG_BASE_ADDR 0x2000

void init_uart() {
    // Initialize UART hardware registers here
}

void init_jtag() {
    // Configure JTAG pins for remote diagnostics
}

void dump_memory() {
    // Code for dumping memory contents
}

void read_flash() {
    // Code for reading flash memory
}

void get_config() {
    // Code for retrieving device configuration
}

void debug_shell() {
    char command[20];
    
    init_uart();
    init_jtag();
    
    while (1) {
        scanf("%s", command);
        
        if (strcmp(command, "dump_memory") == 0) {
            dump_memory();
        } else if (strcmp(command, "read_flash") == 0) {
            read_flash();
        } else if (strcmp(command, "get_config") == 0) {
            get_config();
        } else {
            printf("Invalid command\n");
        }
    }
}