# Generated by openai (gpt-3.5-turbo)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>

class UserSessionManager {
public:
    void addSession(UserSession* session) {
        sessions.push_back(session);
    }

    void removeSession(UserSession* session) {
        auto it = std::find(sessions.begin(), sessions.end(), session);
        if (it != sessions.end()) {
            sessions.erase(it);
            delete session;
        }
    }

    UserSession* getSession(int index) {
        if (index < 0 || index >= sessions.size()) {
            return nullptr;
        }
        return sessions[index];
    }

    ~UserSessionManager() {
        for (UserSession* session : sessions) {
            delete session;
        }
    }

private:
    std::vector<UserSession*> sessions;
};