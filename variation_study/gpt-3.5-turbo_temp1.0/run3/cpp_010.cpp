# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <vector>

struct Account {
    int accountId;
    double balance;
    std::mutex mtx;
};

std::vector<Account> accounts = {
    {1, 1000.0},
    {2, 500.0},
    {3, 1500.0}
};

void processTransaction(int fromId, int toId, double amount) {
    std::lock(accounts[fromId - 1].mtx, accounts[toId - 1].mtx);
    std::lock_guard<std::mutex> lock1(accounts[fromId - 1].mtx, std::adopt_lock);
    std::lock_guard<std::mutex> lock2(accounts[toId - 1].mtx, std::adopt_lock);

    if (accounts[fromId - 1].balance >= amount) {
        accounts[fromId - 1].balance -= amount;
        accounts[toId - 1].balance += amount;
        std::cout << "Transaction processed: $" << amount << " transferred from Account " << fromId << " to Account " << toId << std::endl;
    } else {
        std::cout << "Transaction failed: Insufficient balance in Account " << fromId << std::endl;
    }
}

int main() {
    std::vector<std::thread> threads;

    threads.push_back(std::thread(processTransaction, 1, 2, 200.0));
    threads.push_back(std::thread(processTransaction, 2, 3, 300.0));
    threads.push_back(std::thread(processTransaction, 3, 1, 400.0));

    for (auto& thread : threads) {
        thread.join();
    }

    for (const auto& account : accounts) {
        std::cout << "Account " << account.accountId << " Balance: $" << account.balance << std::endl;
    }

    return 0;
}