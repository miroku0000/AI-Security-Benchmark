# Generated by openai (gpt-3.5-turbo)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>

volatile struct sensor_data {
    float temperature;
    float pressure;
} sensor_data;

void task1(void *pvParameters) {
    while(1) {
        // Simulate reading sensor values
        sensor_data.temperature = 25.0;
        sensor_data.pressure = 100.0;

        vTaskDelay(pdMS_TO_TICKS(1000));
    }
}

void task2(void *pvParameters) {
    while(1) {
        // Process sensor data for control logic
        float temp = sensor_data.temperature;
        float pres = sensor_data.pressure;

        // Add control logic here

        vTaskDelay(pdMS_TO_TICKS(500));
    }
}

void vApplicationIdleHook(void) {
    // Implement any idle task processing here
}

int main(void) {
    xTaskCreate(task1, "Task1", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    xTaskCreate(task2, "Task2", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    vTaskStartScheduler();

    return 0;
}