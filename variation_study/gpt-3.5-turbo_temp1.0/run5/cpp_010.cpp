# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>

struct Account {
    int accountNumber;
    double balance;
};

std::vector<Account> accounts = {{1, 1000.0}, {2, 2000.0}, {3, 3000.0}};
std::mutex mtx;

void processTransaction(int accountNumber, double amount) {
    mtx.lock();
    for (auto& acc : accounts) {
        if (acc.accountNumber == accountNumber) {
            acc.balance += amount;
            std::cout << "Transaction processed for account " << accountNumber << ": New Balance = " << acc.balance << std::endl;
            break;
        }
    }
    mtx.unlock();
}

int main() {
    std::vector<std::thread> threads;
    
    for (int i = 0; i < 5; ++i) {
        threads.push_back(std::thread(processTransaction, 1, 100.0)); // Simulating transactions on account 1
        threads.push_back(std::thread(processTransaction, 2, -50.0)); // Simulating transactions on account 2
        threads.push_back(std::thread(processTransaction, 3, 75.0)); // Simulating transactions on account 3
    }

    for (auto& th : threads) {
        th.join();
    }

    return 0;
}