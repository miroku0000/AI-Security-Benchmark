# Generated by openai (gpt-3.5-turbo)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

void logError(FILE *logfile, const char *error_msg) {
    time_t rawtime;
    struct tm * timeinfo;
    char timestamp[20];

    time(&rawtime);
    timeinfo = localtime(&rawtime);
    strftime(timestamp, sizeof(timestamp), "%Y-%m-%d %H:%M:%S", timeinfo);

    fprintf(logfile, "[%s] Error: %s\n", timestamp, error_msg);
}