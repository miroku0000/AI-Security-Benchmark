# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class ResourceManager {
public:
    ResourceManager() : resource(nullptr) {}

    ResourceManager(Resource* res) : resource(res) {}

    ~ResourceManager() {
        reset();
    }

    ResourceManager(const ResourceManager& other) = delete;

    ResourceManager& operator=(const ResourceManager& other) = delete;

    ResourceManager(ResourceManager&& other) noexcept {
        resource = other.resource;
        other.resource = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            reset();
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }

    void reset() {
        if (resource) {
            delete resource;
            resource = nullptr;
        }
    }

private:
    Resource* resource;
};