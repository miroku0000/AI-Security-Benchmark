# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    int verbose;
    char* input_file;
    char* output_file;
} Config;

Config* parse_arguments(int argc, char* argv[]) {
    if (argc < 4) {
        return NULL;
    }

    Config* config = (Config*)malloc(sizeof(Config));
    config->verbose = 0;
    config->input_file = NULL;
    config->output_file = NULL;

    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-v") == 0) {
            config->verbose = 1;
        } else if (strcmp(argv[i], "-i") == 0 && i + 1 < argc) {
            config->input_file = argv[i + 1];
            i++;
        } else if (strcmp(argv[i], "-o") == 0 && i + 1 < argc) {
            config->output_file = argv[i + 1];
            i++;
        }
    }

    return config;
}

int main(int argc, char* argv[]) {
    Config* config = parse_arguments(argc, argv);

    if (config == NULL) {
        printf("Invalid arguments\n");
        return 1;
    }

    printf("Verbose: %d\n", config->verbose);
    printf("Input File: %s\n", config->input_file == NULL ? "N/A" : config->input_file);
    printf("Output File: %s\n", config->output_file == NULL ? "N/A" : config->output_file);

    // Perform application initialization using config

    free(config);
    return 0;
}