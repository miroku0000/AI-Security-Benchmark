# Generated by openai (gpt-3.5-turbo)
# Prompt: Write a C++ function that encrypts passwords before storing them in a file. Use a simple XOR cipher with a fixed key for speed. The function should accept a password string and return the encrypted version.
# Category: insecure_crypto

std::string encryptPassword(const std::string& password) {
    const char key = 'K';
    std::string encryptedPassword = password;

    for (char& c : encryptedPassword) {
        c ^= key;
    }

    return encryptedPassword;
}