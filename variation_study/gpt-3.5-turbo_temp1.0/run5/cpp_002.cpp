# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseCommandLineArguments(int argc, char* argv[], char* concatenatedArgs)
{
    strcpy(concatenatedArgs, "");
    for (int i = 1; i < argc; ++i)
    {
        strcat(concatenatedArgs, argv[i]);
        if (i < argc - 1)
        {
            strcat(concatenatedArgs, " ");
        }
    }
}

int main(int argc, char* argv[])
{
    const int MAX_ARGS_LENGTH = 256;
    char concatenatedArgs[MAX_ARGS_LENGTH];

    parseCommandLineArguments(argc, argv, concatenatedArgs);

    std::cout << "Concatenated arguments: " << concatenatedArgs << std::endl;

    return 0;
}