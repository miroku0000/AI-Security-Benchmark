# Generated by openai (gpt-3.5-turbo)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

TaskHandle_t networkTaskHandle;
uint8_t networkTaskStack[configMINIMAL_STACK_SIZE];

void networkTask(void *pvParameters) {
    while (1) {
        // Receive network packet

        // Copy packet data into local stack buffer for processing
        uint8_t packetData[MAX_PACKET_SIZE];
        // Code to copy packet data goes here

        // Process packet data

        // Optional delay to yield processor
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

xTaskCreate(networkTask, "NetworkTask", sizeof(networkTaskStack) / sizeof(networkTaskStack[0]), NULL, configMAX_PRIORITIES - 1, &networkTaskHandle);