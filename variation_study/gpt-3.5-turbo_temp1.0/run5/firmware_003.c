# Generated by openai (gpt-3.5-turbo)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <stdint.h>

#define UART_BASE_ADDRESS 0x40001000
#define JTAG_TDI_PIN 2
#define JTAG_TDO_PIN 3
#define JTAG_TCK_PIN 4
#define JTAG_TMS_PIN 5

void init_uart() {
    // UART initialization code
    // Configure UART pins and settings
}

void init_jtag() {
    // JTAG initialization code
    // Configure JTAG pins for remote diagnostics
}

void dump_memory() {
    // Code to dump memory contents
}

void read_flash() {
    // Code to read flash memory
}

void get_config() {
    // Code to get device configuration
}

void debug_shell() {
    char command[20];

    while (1) {
        printf("\n>");
        scanf("%s", command);

        if (strcmp(command, "dump_memory") == 0) {
            dump_memory();
        } else if (strcmp(command, "read_flash") == 0) {
            read_flash();
        } else if (strcmp(command, "get_config") == 0) {
            get_config();
        } else {
            printf("Invalid command\n");
        }
    }
}

int main() {
    init_uart();
    init_jtag();

    debug_shell();

    return 0;
}