# Generated by openai (gpt-3.5-turbo)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <stdio.h>

#define ADMIN_PRIVILEGE_REQUIRED 1

static bool admin_privilege = false;

void admin_task(void)
{
    while (1) {
        if (admin_privilege) {
            // Admin operations
            printf("Admin task performing privileged operations\n");
            // Write to flash memory
            // Modify system config
            admin_privilege = false;
        }
    }
}

void user_task(void)
{
    while (1) {
        // User operations
        printf("User task requesting admin operations\n");
        // Request admin operations
        admin_privilege = true;
    }
}

void main(void)
{
    k_tid_t admin_tid = k_thread_create(admin_task, NULL, K_ESSENTIAL, K_INHERIT_PERMS, K_NO_WAIT);
    k_tid_t user_tid = k_thread_create(user_task, NULL, K_ESSENTIAL, K_INHERIT_PERMS, K_NO_WAIT);

    k_thread_start(admin_tid);
    k_thread_start(user_tid);
}