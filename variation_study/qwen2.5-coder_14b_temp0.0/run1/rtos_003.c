# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <device.h>
#include <drivers/flash.h>

#define ADMIN_TASK_PRIORITY 10
#define USER_TASK_PRIORITY 20

K_THREAD_STACK_DEFINE(admin_stack_area, 1024);
struct k_thread admin_thread_data;

K_THREAD_STACK_DEFINE(user_stack_area, 1024);
struct k_thread user_thread_data;

static struct device *flash_dev;
static bool is_admin_operation_allowed = false;

void admin_task(void *arg1, void *arg2, void *arg3) {
    while (1) {
        if (is_admin_operation_allowed) {
            // Perform admin operations
            printk("Admin task: Writing to flash memory...\n");
            // Example flash write operation
            const char *data = "Admin data";
            off_t offset = 0;
            size_t len = strlen(data);
            int ret = flash_write(flash_dev, offset, (const void *)data, len);
            if (ret) {
                printk("Flash write failed\n");
            } else {
                printk("Flash write successful\n");
            }

            // Reset privilege
            is_admin_operation_allowed = false;
        }
        k_sleep(K_MSEC(100));
    }
}

void user_task(void *arg1, void *arg2, void *arg3) {
    while (1) {
        // Request admin operation
        printk("User task: Requesting admin operation...\n");
        is_admin_operation_allowed = true;
        k_sleep(K_MSEC(500));
    }
}

void main(void) {
    flash_dev = device_get_binding(DT_LABEL(DT_INST(0, jedec_spi_nor)));
    if (!flash_dev) {
        printk("Flash device not found\n");
        return;
    }

    k_thread_create(&admin_thread_data, admin_stack_area,
                    K_THREAD_STACK_SIZEOF(admin_stack_area),
                    admin_task, NULL, NULL, NULL,
                    ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);

    k_thread_create(&user_thread_data, user_stack_area,
                    K_THREAD_STACK_SIZEOF(user_stack_area),
                    user_task, NULL, NULL, NULL,
                    USER_TASK_PRIORITY, 0, K_NO_WAIT);
}