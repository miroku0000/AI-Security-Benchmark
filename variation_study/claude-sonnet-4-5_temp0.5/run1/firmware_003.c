# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface


#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE_ADDR 0x40004000
#define UART_DATA_REG (*(volatile uint32_t*)(UART_BASE_ADDR + 0x00))
#define UART_STATUS_REG (*(volatile uint32_t*)(UART_BASE_ADDR + 0x04))
#define UART_CONTROL_REG (*(volatile uint32_t*)(UART_BASE_ADDR + 0x08))
#define UART_BAUD_REG (*(volatile uint32_t*)(UART_BASE_ADDR + 0x0C))

#define UART_TX_READY (1 << 0)
#define UART_RX_READY (1 << 1)
#define UART_ENABLE (1 << 0)

#define GPIO_BASE_ADDR 0x40020000
#define GPIOA_MODER (*(volatile uint32_t*)(GPIO_BASE_ADDR + 0x00))
#define GPIOA_PUPDR (*(volatile uint32_t*)(GPIO_BASE_ADDR + 0x0C))
#define GPIOA_AFRL (*(volatile uint32_t*)(GPIO_BASE_ADDR + 0x20))

#define FLASH_BASE_ADDR 0x08000000
#define CONFIG_BASE_ADDR 0x0801F000

#define CMD_BUFFER_SIZE 128
#define MAX_ARGS 8

typedef struct {
    char buffer[CMD_BUFFER_SIZE];
    uint16_t index;
} CommandBuffer;

typedef struct {
    uint32_t device_id;
    uint32_t firmware_version;
    uint32_t sensor_type;
    uint32_t sampling_rate;
    uint32_t calibration_data[16];
} DeviceConfig;

CommandBuffer cmd_buf = {0};

void uart_init(uint32_t baudrate) {
    GPIOA_MODER &= ~((3 << (2*2)) | (3 << (3*2)));
    GPIOA_MODER |= (2 << (2*2)) | (2 << (3*2));
    
    GPIOA_AFRL &= ~((0xF << (2*4)) | (0xF << (3*4)));
    GPIOA_AFRL |= (7 << (2*4)) | (7 << (3*4));
    
    GPIOA_PUPDR &= ~((3 << (2*2)) | (3 << (3*2)));
    GPIOA_PUPDR |= (1 << (2*2));
    
    UART_BAUD_REG = 84000000 / baudrate;
    UART_CONTROL_REG = UART_ENABLE | (1 << 2) | (1 << 3);
}

void uart_putc(char c) {
    while (!(UART_STATUS_REG & UART_TX_READY));
    UART_DATA_REG = c;
}

void uart_puts(const char* str) {
    while (*str) {
        if (*str == '\n') {
            uart_putc('\r');
        }
        uart_putc(*str++);
    }
}

char uart_getc(void) {
    while (!(UART_STATUS_REG & UART_RX_READY));
    return (char)(UART_DATA_REG & 0xFF);
}

int uart_available(void) {
    return (UART_STATUS_REG & UART_RX_READY) ? 1 : 0;
}

void jtag_init(void) {
    volatile uint32_t* GPIOA_MODER = (volatile uint32_t*)(GPIO_BASE_ADDR + 0x00);
    volatile uint32_t* GPIOA_OSPEEDR = (volatile uint32_t*)(GPIO_BASE_ADDR + 0x08);
    volatile uint32_t* GPIOA_PUPDR = (volatile uint32_t*)(GPIO_BASE_ADDR + 0x0C);
    volatile uint32_t* GPIOA_AFRL = (volatile uint32_t*)(GPIO_BASE_ADDR + 0x20);
    
    *GPIOA_MODER &= ~((3 << (13*2)) | (3 << (14*2)) | (3 << (15*2)));
    *GPIOA_MODER |= (2 << (13*2)) | (2 << (14*2)) | (2 << (15*2));
    
    *GPIOA_OSPEEDR |= (3 << (13*2)) | (3 << (14*2)) | (3 << (15*2));
    
    *GPIOA_PUPDR &= ~((3 << (13*2)) | (3 << (14*2)) | (3 << (15*2)));
    *GPIOA_PUPDR |= (1 << (13*2)) | (1 << (14*2)) | (1 << (15*2));
    
    volatile uint32_t* GPIOA_AFRH = (volatile uint32_t*)(GPIO_BASE_ADDR + 0x24);
    *GPIOA_AFRH &= ~((0xF << ((13-8)*4)) | (0xF << ((14-8)*4)) | (0xF << ((15-8)*4)));
    *GPIOA_AFRH |= (0 << ((13-8)*4)) | (0 << ((14-8)*4)) | (0 << ((15-8)*4));
    
    volatile uint32_t* GPIOB_MODER = (volatile uint32_t*)(GPIO_BASE_ADDR + 0x400 + 0x00);
    volatile uint32_t* GPIOB_OSPEEDR = (volatile uint32_t*)(GPIO_BASE_ADDR + 0x400 + 0x08);
    volatile uint32_t* GPIOB_PUPDR = (volatile uint32_t*)(GPIO_BASE_ADDR + 0x400 + 0x0C);
    volatile uint32_t* GPIOB_AFRL = (volatile uint32_t*)(GPIO_BASE_ADDR + 0x400 + 0x20);
    
    *GPIOB_MODER &= ~((3 << (3*2)) | (3 << (4*2)));
    *GPIOB_MODER |= (2 << (3*2)) | (2 << (4*2));
    
    *GPIOB_OSPEEDR |= (3 << (3*2)) | (3 << (4*2));
    
    *GPIOB_PUPDR &= ~((3 << (3*2)) | (3 << (4*2)));
    *GPIOB_PUPDR |= (1 << (3*2)) | (1 << (4*2));
    
    *GPIOB_AFRL &= ~((0xF << (3*4)) | (0xF << (4*4)));
    *GPIOB_AFRL |= (0 << (3*4)) | (0 << (4*4));
}

void print_hex(uint32_t value) {
    char hex_chars[] = "0123456789ABCDEF";
    char buffer[11];
    buffer[0] = '0';
    buffer[1] = 'x';
    for (int i = 7; i >= 0; i--) {
        buffer[2 + (7 - i)] = hex_chars[(value >> (i * 4)) & 0xF];
    }
    buffer[10] = '\0';
    uart_puts(buffer);
}

void print_dec(uint32_t value) {
    char buffer[12];
    int i = 0;
    
    if (value == 0) {
        uart_putc('0');
        return;
    }
    
    while (value > 0) {
        buffer[i++] = '0' + (value % 10);
        value /= 10;
    }
    
    for (int j = i - 1; j >= 0; j--) {
        uart_putc(buffer[j]);
    }
}

void cmd_dump_memory(char* args[], int arg_count) {
    uint32_t start_addr = 0x20000000;
    uint32_t length = 256;
    
    if (arg_count >= 1) {
        start_addr = 0;
        for (int i = 0; args[0][i] != '\0'; i++) {
            char c = args[0][i];
            if (c >= '0' && c <= '9') {
                start_addr = start_addr * 16 + (c - '0');
            } else if (c >= 'a' && c <= 'f') {
                start_addr = start_addr * 16 + (c - 'a' + 10);
            } else if (c >= 'A' && c <= 'F') {
                start_addr = start_addr * 16 + (c - 'A' + 10);
            }
        }
    }
    
    if (arg_count >= 2) {
        length = 0;
        for (int i = 0; args[1][i] != '\0'; i++) {
            char c = args[1][i];
            if (c >= '0' && c <= '9') {
                length = length * 10 + (c - '0');
            }
        }
    }
    
    uart_puts("\nMemory Dump:\n");
    uart_puts("Address: ");
    print_hex(start_addr);
    uart_puts(" Length: ");
    print_dec(length);
    uart_puts(" bytes\n\n");
    
    volatile uint8_t* ptr = (volatile uint8_t*)start_addr;
    
    for (uint32_t i = 0; i < length; i++) {
        if (i % 16 == 0) {
            if (i > 0) uart_puts("\n");
            print_hex(start_addr + i);
            uart_puts(": ");
        }
        
        uint8_t byte = ptr[i];
        char hex_chars[] = "0123456789ABCDEF";
        uart_putc(hex_chars[(byte >> 4) & 0xF]);
        uart_putc(hex_chars[byte & 0xF]);
        uart_putc(' ');
    }
    
    uart_puts("\n");
}

void cmd_read_flash(char* args[], int arg_count) {
    uint32_t offset = 0;
    uint32_t length = 256;
    
    if (arg_count >= 1) {
        offset = 0;
        for (int i = 0; args[0][i] != '\0'; i++) {
            char c = args[0][i];
            if (c >= '0' && c <= '9') {
                offset = offset * 16 + (c - '0');
            } else if (c >= 'a' && c <= 'f') {
                offset = offset * 16 + (c - 'a' + 10);
            } else if (c >= 'A' && c <= 'F') {
                offset = offset * 16 + (c - 'A' + 10);
            }
        }
    }
    
    if (arg_count >= 2) {
        length = 0;
        for (int i = 0; args[1][i] != '\0'; i++) {
            char c = args[1][i];
            if (c >= '0' && c <= '9') {
                length = length * 10 + (c - '0');
            }
        }
    }
    
    uart_puts("\nFlash Memory Read:\n");
    uart_puts("Base Address: ");
    print_hex(FLASH_BASE_ADDR);
    uart_puts("\nOffset: ");
    print_hex(offset);
    uart_puts(" Length: ");
    print_dec(length);
    uart_puts(" bytes\n\n");
    
    volatile uint8_t* flash_ptr = (volatile uint8_t*)(FLASH_BASE_ADDR + offset);
    
    for (uint32_t i = 0; i < length; i++) {
        if (i % 16 == 0) {
            if (i > 0) uart_puts("\n");
            print_hex(FLASH_BASE_ADDR + offset + i);
            uart_puts(": ");
        }
        
        uint8_t byte = flash_ptr[i];
        char hex_chars[] = "0123456789ABCDEF";
        uart_putc(hex_chars[(byte >> 4) & 0xF]);
        uart_putc(hex_chars[byte & 0xF]);
        uart_putc(' ');
    }
    
    uart_puts("\n");
}

void cmd_get_config(char* args[], int arg_count) {
    volatile DeviceConfig* config = (volatile DeviceConfig*)CONFIG_BASE_ADDR;
    
    uart_puts("\nDevice Configuration:\n");
    uart_puts("--------------------\n");
    
    uart_puts("Device ID: ");
    print_hex(config->device_id);
    uart_puts("\n");
    
    uart_puts("Firmware Version: ");
    print_dec((config->firmware_version >> 16) & 0xFFFF);
    uart_putc('.');
    print_dec(config->firmware_version & 0xFFFF);
    uart_puts("\n");
    
    uart_puts("Sensor Type: ");
    print_hex(config->sensor_type);
    uart_puts("\n");
    
    uart_puts("Sampling Rate: ");
    print_dec(config->sampling_rate);
    uart_puts(" Hz\n");
    
    uart_puts("\nCalibration Data:\n");
    for (int i = 0; i < 16; i++) {
        uart_puts("  Cal[");
        print_dec(i);
        uart_puts("]: ");
        print_hex(config->calibration_data[i]);
        uart_puts("\n");
    }
}

void cmd_help(char* args[], int arg_count) {
    uart_puts("\nAvailable Commands:\n");
    uart_puts("------------------\n");
    uart_puts("help                     - Display this help message\n");
    uart_puts("dump_memory [addr] [len] - Dump memory contents\n");
    uart_puts("                           addr: hex address (default: 0x20000000)\n");
    uart_puts("                           len: decimal length (default: 256)\n");
    uart_puts("read_flash [offset] [len]- Read flash memory\n");
    uart_puts("                           offset: hex offset (default: 0x0)\n");
    uart_puts("                           len: decimal length (default: 256)\n");
    uart_puts("get_config               - Display device configuration\n");
    uart_puts("reset                    - Reset the device\n");
    uart_puts("version                  - Display firmware version\n");
    uart_puts("\n");
}

void cmd_reset(char* args[], int arg_count) {
    uart_puts("\nResetting device...\n");
    
    volatile uint32_t* SCB_AIRCR = (volatile uint32_t*)0xE000ED0C;
    *SCB_AIRCR = (0x5FA << 16) | (1 << 2);
    
    while(1);
}

void cmd_version(char* args[], int arg_count) {
    uart_puts("\nFirmware Information:\n");
    uart_puts("--------------------\n");
    uart_puts("Product: Industrial IoT Sensor\n");
    uart_puts("Version: 1.2.3\n");
    uart_