# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    uint32_t timestamp;
    uint8_t status;
} sensor_data_t;

volatile sensor_data_t sensor_data;
SemaphoreHandle_t xDataMutex;

float read_temperature_sensor(void) {
    return 25.5f + (float)(xTaskGetTickCount() % 100) / 10.0f;
}

float read_pressure_sensor(void) {
    return 101.3f + (float)(xTaskGetTickCount() % 50) / 10.0f;
}

float read_flow_rate_sensor(void) {
    return 50.0f + (float)(xTaskGetTickCount() % 30) / 10.0f;
}

void vSensorReadTask(void *pvParameters) {
    sensor_data_t local_data;
    
    while(1) {
        local_data.temperature = read_temperature_sensor();
        local_data.pressure = read_pressure_sensor();
        local_data.flow_rate = read_flow_rate_sensor();
        local_data.timestamp = xTaskGetTickCount();
        local_data.status = 1;
        
        if(xSemaphoreTake(xDataMutex, portMAX_DELAY) == pdTRUE) {
            sensor_data.temperature = local_data.temperature;
            sensor_data.pressure = local_data.pressure;
            sensor_data.flow_rate = local_data.flow_rate;
            sensor_data.timestamp = local_data.timestamp;
            sensor_data.status = local_data.status;
            xSemaphoreGive(xDataMutex);
        }
        
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void vControlProcessTask(void *pvParameters) {
    sensor_data_t local_copy;
    float control_output;
    
    while(1) {
        if(xSemaphoreTake(xDataMutex, portMAX_DELAY) == pdTRUE) {
            local_copy.temperature = sensor_data.temperature;
            local_copy.pressure = sensor_data.pressure;
            local_copy.flow_rate = sensor_data.flow_rate;
            local_copy.timestamp = sensor_data.timestamp;
            local_copy.status = sensor_data.status;
            xSemaphoreGive(xDataMutex);
        }
        
        if(local_copy.status == 1) {
            control_output = (local_copy.temperature * 0.5f) + 
                           (local_copy.pressure * 0.3f) + 
                           (local_copy.flow_rate * 0.2f);
            
            if(control_output > 100.0f) {
                control_output = 100.0f;
            } else if(control_output < 0.0f) {
                control_output = 0.0f;
            }
        }
        
        vTaskDelay(pdMS_TO_TICKS(150));
    }
}

int main(void) {
    sensor_data.temperature = 0.0f;
    sensor_data.pressure = 0.0f;
    sensor_data.flow_rate = 0.0f;
    sensor_data.timestamp = 0;
    sensor_data.status = 0;
    
    xDataMutex = xSemaphoreCreateMutex();
    
    if(xDataMutex != NULL) {
        xTaskCreate(vSensorReadTask, "SensorRead", 256, NULL, 2, NULL);
        xTaskCreate(vControlProcessTask, "ControlProcess", 256, NULL, 1, NULL);
        
        vTaskStartScheduler();
    }
    
    while(1);
    
    return 0;
}