# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>
#include <functional>

template<typename T>
class ResourceManager {
private:
    T* resource;
    std::function<void(T*)> deleter;

public:
    ResourceManager() : resource(nullptr), deleter(nullptr) {}

    explicit ResourceManager(T* res, std::function<void(T*)> del = [](T* ptr) { delete ptr; })
        : resource(res), deleter(del) {}

    ~ResourceManager() {
        reset();
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ResourceManager(ResourceManager&& other) noexcept
        : resource(other.resource), deleter(std::move(other.deleter)) {
        other.resource = nullptr;
        other.deleter = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            reset();
            resource = other.resource;
            deleter = std::move(other.deleter);
            other.resource = nullptr;
            other.deleter = nullptr;
        }
        return *this;
    }

    void reset() {
        if (resource && deleter) {
            deleter(resource);
        }
        resource = nullptr;
        deleter = nullptr;
    }

    void reset(T* res, std::function<void(T*)> del = [](T* ptr) { delete ptr; }) {
        reset();
        resource = res;
        deleter = del;
    }

    T* get() const {
        return resource;
    }

    T* release() {
        T* temp = resource;
        resource = nullptr;
        deleter = nullptr;
        return temp;
    }

    T& operator*() const {
        return *resource;
    }

    T* operator->() const {
        return resource;
    }

    explicit operator bool() const {
        return resource != nullptr;
    }
};

template<typename T>
class ArrayResourceManager {
private:
    T* resource;
    std::function<void(T*)> deleter;

public:
    ArrayResourceManager() : resource(nullptr), deleter(nullptr) {}

    explicit ArrayResourceManager(T* res, std::function<void(T*)> del = [](T* ptr) { delete[] ptr; })
        : resource(res), deleter(del) {}

    ~ArrayResourceManager() {
        reset();
    }

    ArrayResourceManager(const ArrayResourceManager&) = delete;
    ArrayResourceManager& operator=(const ArrayResourceManager&) = delete;

    ArrayResourceManager(ArrayResourceManager&& other) noexcept
        : resource(other.resource), deleter(std::move(other.deleter)) {
        other.resource = nullptr;
        other.deleter = nullptr;
    }

    ArrayResourceManager& operator=(ArrayResourceManager&& other) noexcept {
        if (this != &other) {
            reset();
            resource = other.resource;
            deleter = std::move(other.deleter);
            other.resource = nullptr;
            other.deleter = nullptr;
        }
        return *this;
    }

    void reset() {
        if (resource && deleter) {
            deleter(resource);
        }
        resource = nullptr;
        deleter = nullptr;
    }

    void reset(T* res, std::function<void(T*)> del = [](T* ptr) { delete[] ptr; }) {
        reset();
        resource = res;
        deleter = del;
    }

    T* get() const {
        return resource;
    }

    T* release() {
        T* temp = resource;
        resource = nullptr;
        deleter = nullptr;
        return temp;
    }

    T& operator[](size_t index) const {
        return resource[index];
    }

    explicit operator bool() const {
        return resource != nullptr;
    }
};

template<typename T, typename... Args>
ResourceManager<T> makeResource(Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...));
}

template<typename T>
ArrayResourceManager<T> makeArrayResource(size_t size) {
    return ArrayResourceManager<T>(new T[size]);
}