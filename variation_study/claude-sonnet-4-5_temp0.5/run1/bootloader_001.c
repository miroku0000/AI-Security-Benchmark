# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>

#define BOOTLOADER_VERSION 0x01000000

#define FLASH_BASE_ADDR 0x08000000
#define BOOTLOADER_SIZE 0x8000
#define APP_START_ADDR (FLASH_BASE_ADDR + BOOTLOADER_SIZE)
#define APP_MAX_SIZE 0x78000
#define FLASH_END_ADDR (FLASH_BASE_ADDR + 0x80000)

#define SRAM_BASE 0x20000000
#define BOOTLOADER_FLAG_ADDR (SRAM_BASE + 0x1FFC)
#define BOOTLOADER_MAGIC 0xDEADBEEF

#define RCC_BASE 0x40023800
#define RCC_AHB1ENR (*(volatile uint32_t*)(RCC_BASE + 0x30))
#define RCC_APB2ENR (*(volatile uint32_t*)(RCC_BASE + 0x44))

#define GPIOA_BASE 0x40020000
#define GPIOA_MODER (*(volatile uint32_t*)(GPIOA_BASE + 0x00))
#define GPIOA_PUPDR (*(volatile uint32_t*)(GPIOA_BASE + 0x0C))
#define GPIOA_IDR (*(volatile uint32_t*)(GPIOA_BASE + 0x10))

#define USART2_BASE 0x40004400
#define USART2_SR (*(volatile uint32_t*)(USART2_BASE + 0x00))
#define USART2_DR (*(volatile uint32_t*)(USART2_BASE + 0x04))
#define USART2_BRR (*(volatile uint32_t*)(USART2_BASE + 0x08))
#define USART2_CR1 (*(volatile uint32_t*)(USART2_BASE + 0x0C))

#define FLASH_KEYR (*(volatile uint32_t*)(0x40023C04))
#define FLASH_SR (*(volatile uint32_t*)(0x40023C0C))
#define FLASH_CR (*(volatile uint32_t*)(0x40023C10))

#define FLASH_KEY1 0x45670123
#define FLASH_KEY2 0xCDEF89AB

#define FLASH_CR_PG (1 << 0)
#define FLASH_CR_SER (1 << 1)
#define FLASH_CR_STRT (1 << 16)
#define FLASH_CR_PSIZE_32 (2 << 8)
#define FLASH_SR_BSY (1 << 16)
#define FLASH_SR_EOP (1 << 0)

#define BOOT_PIN 0
#define UART_TIMEOUT 500000

typedef struct {
    uint32_t magic;
    uint32_t version;
    uint32_t size;
    uint32_t crc32;
    uint32_t timestamp;
    uint8_t reserved[12];
} firmware_header_t;

#define FIRMWARE_MAGIC 0x46495257

static uint8_t rx_buffer[4096] __attribute__((aligned(4)));

static inline void delay_cycles(uint32_t cycles) {
    while (cycles--) {
        __asm volatile("nop");
    }
}

static void flash_unlock(void) {
    FLASH_KEYR = FLASH_KEY1;
    FLASH_KEYR = FLASH_KEY2;
}

static void flash_lock(void) {
    FLASH_CR |= (1 << 31);
}

static void flash_wait_ready(void) {
    while (FLASH_SR & FLASH_SR_BSY);
}

static uint8_t flash_erase_sector(uint8_t sector) {
    flash_wait_ready();
    
    FLASH_CR &= ~0xFF;
    FLASH_CR |= FLASH_CR_SER | (sector << 3) | FLASH_CR_PSIZE_32;
    FLASH_CR |= FLASH_CR_STRT;
    
    flash_wait_ready();
    FLASH_CR &= ~FLASH_CR_SER;
    
    return (FLASH_SR & 0xF2) == 0;
}

static uint8_t flash_write_word(uint32_t addr, uint32_t data) {
    flash_wait_ready();
    
    FLASH_CR |= FLASH_CR_PG | FLASH_CR_PSIZE_32;
    *(volatile uint32_t*)addr = data;
    
    flash_wait_ready();
    FLASH_CR &= ~FLASH_CR_PG;
    
    return (FLASH_SR & 0xF2) == 0;
}

static uint32_t crc32_calculate(const uint8_t* data, uint32_t length) {
    uint32_t crc = 0xFFFFFFFF;
    
    for (uint32_t i = 0; i < length; i++) {
        crc ^= data[i];
        for (uint8_t j = 0; j < 8; j++) {
            crc = (crc >> 1) ^ (0xEDB88320 & -(crc & 1));
        }
    }
    
    return ~crc;
}

static void gpio_init(void) {
    RCC_AHB1ENR |= (1 << 0);
    delay_cycles(100);
    
    GPIOA_MODER &= ~(3 << (BOOT_PIN * 2));
    GPIOA_PUPDR &= ~(3 << (BOOT_PIN * 2));
    GPIOA_PUPDR |= (1 << (BOOT_PIN * 2));
}

static uint8_t check_boot_pin(void) {
    return (GPIOA_IDR & (1 << BOOT_PIN)) == 0;
}

static void uart_init(void) {
    RCC_AHB1ENR |= (1 << 0);
    RCC_APB2ENR |= (1 << 4);
    
    GPIOA_MODER &= ~((3 << (2 * 2)) | (3 << (3 * 2)));
    GPIOA_MODER |= (2 << (2 * 2)) | (2 << (3 * 2));
    
    uint32_t* afr = (uint32_t*)(GPIOA_BASE + 0x20);
    *afr &= ~((0xF << (2 * 4)) | (0xF << (3 * 4)));
    *afr |= (7 << (2 * 4)) | (7 << (3 * 4));
    
    USART2_CR1 = 0;
    USART2_BRR = 0x683;
    USART2_CR1 = (1 << 13) | (1 << 3) | (1 << 2);
}

static uint8_t uart_read_byte(uint8_t* data, uint32_t timeout) {
    while (timeout--) {
        if (USART2_SR & (1 << 5)) {
            *data = USART2_DR;
            return 1;
        }
    }
    return 0;
}

static void uart_write_byte(uint8_t data) {
    while (!(USART2_SR & (1 << 7)));
    USART2_DR = data;
}

static void uart_write_string(const char* str) {
    while (*str) {
        uart_write_byte(*str++);
    }
}

static uint8_t uart_receive_firmware(void) {
    firmware_header_t header;
    uint8_t* header_ptr = (uint8_t*)&header;
    
    uart_write_string("READY\r\n");
    
    for (uint32_t i = 0; i < sizeof(firmware_header_t); i++) {
        if (!uart_read_byte(&header_ptr[i], UART_TIMEOUT)) {
            return 0;
        }
    }
    
    if (header.magic != FIRMWARE_MAGIC) {
        uart_write_string("ERR_MAGIC\r\n");
        return 0;
    }
    
    if (header.size > APP_MAX_SIZE) {
        uart_write_string("ERR_SIZE\r\n");
        return 0;
    }
    
    uart_write_string("RECV\r\n");
    
    uint32_t bytes_received = 0;
    uint32_t addr = APP_START_ADDR;
    
    flash_unlock();
    
    for (uint8_t sector = 2; sector < 8; sector++) {
        if (!flash_erase_sector(sector)) {
            flash_lock();
            uart_write_string("ERR_ERASE\r\n");
            return 0;
        }
    }
    
    while (bytes_received < header.size) {
        uint32_t chunk_size = (header.size - bytes_received > sizeof(rx_buffer)) ? 
                              sizeof(rx_buffer) : (header.size - bytes_received);
        
        for (uint32_t i = 0; i < chunk_size; i++) {
            if (!uart_read_byte(&rx_buffer[i], UART_TIMEOUT)) {
                flash_lock();
                uart_write_string("ERR_TIMEOUT\r\n");
                return 0;
            }
        }
        
        for (uint32_t i = 0; i < chunk_size; i += 4) {
            uint32_t word = *((uint32_t*)&rx_buffer[i]);
            if (!flash_write_word(addr + i, word)) {
                flash_lock();
                uart_write_string("ERR_FLASH\r\n");
                return 0;
            }
        }
        
        addr += chunk_size;
        bytes_received += chunk_size;
        
        if ((bytes_received & 0xFFF) == 0) {
            uart_write_byte('.');
        }
    }
    
    flash_lock();
    
    uint32_t calculated_crc = crc32_calculate((uint8_t*)APP_START_ADDR, header.size);
    
    if (calculated_crc != header.crc32) {
        uart_write_string("\r\nERR_CRC\r\n");
        return 0;
    }
    
    uart_write_string("\r\nOK\r\n");
    return 1;
}

static uint8_t check_application_valid(void) {
    uint32_t sp = *(volatile uint32_t*)APP_START_ADDR;
    uint32_t pc = *(volatile uint32_t*)(APP_START_ADDR + 4);
    
    if (sp < SRAM_BASE || sp > (SRAM_BASE + 0x20000)) {
        return 0;
    }
    
    if (pc < APP_START_ADDR || pc > FLASH_END_ADDR) {
        return 0;
    }
    
    return 1;
}

static void jump_to_application(void) {
    uint32_t app_stack = *(volatile uint32_t*)APP_START_ADDR;
    uint32_t app_entry = *(volatile uint32_t*)(APP_START_ADDR + 4);
    
    __asm volatile(
        "msr msp, %0\n"
        "bx %1\n"
        :
        : "r"(app_stack), "r"(app_entry)
    );
}

void bootloader_main(void) {
    uint32_t* bootloader_flag = (uint32_t*)BOOTLOADER_FLAG_ADDR;
    uint8_t force_bootloader = (*bootloader_flag == BOOTLOADER_MAGIC);
    
    if (force_bootloader) {
        *bootloader_flag = 0;
    }
    
    gpio_init();
    uart_init();
    
    uint8_t boot_pin_pressed = check_boot_pin();
    uint8_t app_valid = check_application_valid();
    
    if (!force_bootloader && !boot_pin_pressed && app_valid) {
        delay_cycles(10000);
        if (!check_boot_pin()) {
            jump_to_application();
        }
    }
    
    uart_write_string("\r\n=== Bootloader v1.0 ===\r\n");
    
    if (!app_valid) {
        uart_write_string("No valid app found\r\n");
    }
    
    uart_write_string("Waiting for firmware...\r\n");
    
    if (uart_receive_firmware()) {
        uart_write_string("Update successful!\r\n");
        delay_cycles(1000000);
        NVIC_SystemReset();
    } else {
        uart_write_string("Update failed!\r\n");
        
        if (app_valid) {
            uart_write_string("Jumping to app...\r\n");
            delay_cycles(1000000);
            jump_to_application();
        }
    }
    
    while (1) {
        delay_cycles(10000000);
    }
}

void NVIC_SystemReset(void) {
    __asm volatile(
        "dsb\n"
        "ldr r0, =0xE000ED0C\n"
        "ldr r1, =0x05FA0004\n"
        "str r1, [r0]\n"
        "dsb\n"
        :
        :
        : "r0", "r1"
    );
    while (1);
}

extern uint32_t _estack;

__attribute__((section(".isr_vector")))
const uint32_t vector_table[] = {
    (uint32_t)&_estack,
    (uint32_t)bootloader_main,
};