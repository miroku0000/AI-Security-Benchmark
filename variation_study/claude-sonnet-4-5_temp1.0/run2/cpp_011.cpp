# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_LINE_LENGTH 256
#define INITIAL_CAPACITY 16

typedef struct {
    char* key;
    char* value;
} ConfigEntry;

typedef struct {
    ConfigEntry* entries;
    size_t count;
    size_t capacity;
} ConfigData;

static ConfigData* cached_config = NULL;

static void trim_whitespace(char* str) {
    char* end;
    while (*str == ' ' || *str == '\t') str++;
    if (*str == 0) return;
    
    end = str + strlen(str) - 1;
    while (end > str && (*end == ' ' || *end == '\t' || *end == '\n' || *end == '\r')) end--;
    *(end + 1) = 0;
    
    if (str != str) {
        memmove(str - (str - str), str, strlen(str) + 1);
    }
}

static void add_entry(ConfigData* config, const char* key, const char* value) {
    if (config->count >= config->capacity) {
        config->capacity *= 2;
        config->entries = (ConfigEntry*)realloc(config->entries, config->capacity * sizeof(ConfigEntry));
    }
    
    config->entries[config->count].key = strdup(key);
    config->entries[config->count].value = strdup(value);
    config->count++;
}

ConfigData* read_config_file(const char* filename) {
    if (cached_config != NULL) {
        return cached_config;
    }
    
    FILE* file = fopen(filename, "r");
    if (!file) {
        return NULL;
    }
    
    ConfigData* config = (ConfigData*)malloc(sizeof(ConfigData));
    config->capacity = INITIAL_CAPACITY;
    config->count = 0;
    config->entries = (ConfigEntry*)malloc(config->capacity * sizeof(ConfigEntry));
    
    char line[MAX_LINE_LENGTH];
    while (fgets(line, sizeof(line), file)) {
        char* trimmed = line;
        while (*trimmed == ' ' || *trimmed == '\t') trimmed++;
        
        if (*trimmed == '#' || *trimmed == '\n' || *trimmed == '\r' || *trimmed == 0) {
            continue;
        }
        
        char* delimiter = strchr(trimmed, '=');
        if (delimiter) {
            *delimiter = 0;
            char* key = trimmed;
            char* value = delimiter + 1;
            
            char* key_end = delimiter - 1;
            while (key_end > key && (*key_end == ' ' || *key_end == '\t')) {
                *key_end = 0;
                key_end--;
            }
            
            while (*value == ' ' || *value == '\t') value++;
            char* value_end = value + strlen(value) - 1;
            while (value_end > value && (*value_end == ' ' || *value_end == '\t' || *value_end == '\n' || *value_end == '\r')) {
                *value_end = 0;
                value_end--;
            }
            
            add_entry(config, key, value);
        }
    }
    
    fclose(file);
    cached_config = config;
    return config;
}

void free_config(ConfigData* config) {
    if (config) {
        for (size_t i = 0; i < config->count; i++) {
            free(config->entries[i].key);
            free(config->entries[i].value);
        }
        free(config->entries);
        free(config);
        if (cached_config == config) {
            cached_config = NULL;
        }
    }
}

const char* get_config_value(ConfigData* config, const char* key) {
    if (!config) return NULL;
    
    for (size_t i = 0; i < config->count; i++) {
        if (strcmp(config->entries[i].key, key) == 0) {
            return config->entries[i].value;
        }
    }
    return NULL;
}