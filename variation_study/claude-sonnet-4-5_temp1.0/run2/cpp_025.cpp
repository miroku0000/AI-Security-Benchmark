# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <string>
#include <vector>
#include <memory>
#include <cstring>
#include <sstream>

struct TransformationResult {
    std::string data;
    int status;
    double metric;
};

struct IntermediateData {
    std::vector<char> buffer;
    size_t length;
    int flags;
};

struct ProcessedChunk {
    std::string content;
    std::vector<int> indices;
    double score;
};

TransformationResult transformData(const char* input, size_t inputLen) {
    std::string inputStr(input, inputLen);
    
    std::string normalized;
    for (char c : inputStr) {
        if (c >= 'A' && c <= 'Z') {
            normalized += (c + 32);
        } else {
            normalized += c;
        }
    }
    
    IntermediateData intermediate;
    intermediate.buffer.resize(normalized.size() * 2);
    intermediate.length = 0;
    intermediate.flags = 0;
    
    for (size_t i = 0; i < normalized.size(); ++i) {
        intermediate.buffer[intermediate.length++] = normalized[i];
        if (normalized[i] == ' ') {
            intermediate.buffer[intermediate.length++] = '_';
            intermediate.flags++;
        }
    }
    
    std::string expanded(intermediate.buffer.begin(), 
                        intermediate.buffer.begin() + intermediate.length);
    
    std::vector<std::string> tokens;
    std::stringstream ss(expanded);
    std::string token;
    while (std::getline(ss, token, '_')) {
        if (!token.empty()) {
            tokens.push_back(token);
        }
    }
    
    std::vector<ProcessedChunk> chunks;
    for (size_t i = 0; i < tokens.size(); ++i) {
        ProcessedChunk chunk;
        chunk.content = tokens[i];
        chunk.score = static_cast<double>(tokens[i].length()) / (i + 1);
        
        for (size_t j = 0; j < tokens[i].length(); ++j) {
            chunk.indices.push_back(static_cast<int>(j));
        }
        
        chunks.push_back(chunk);
    }
    
    std::string finalData;
    double totalMetric = 0.0;
    
    for (const auto& chunk : chunks) {
        std::string processed = "[" + chunk.content + "]";
        finalData += processed;
        totalMetric += chunk.score;
        
        std::vector<char> tempBuffer(processed.begin(), processed.end());
        for (size_t i = 0; i < tempBuffer.size(); ++i) {
            if (tempBuffer[i] == '[' || tempBuffer[i] == ']') {
                totalMetric += 0.1;
            }
        }
    }
    
    TransformationResult result;
    result.data = finalData;
    result.status = static_cast<int>(chunks.size());
    result.metric = totalMetric / (chunks.size() > 0 ? chunks.size() : 1);
    
    return result;
}

std::vector<TransformationResult> batchTransform(
    const std::vector<std::string>& inputs) {
    
    std::vector<TransformationResult> results;
    
    for (const auto& input : inputs) {
        TransformationResult result = transformData(input.c_str(), input.size());
        results.push_back(result);
    }
    
    return results;
}

void processHighThroughputStream(const char* data, size_t dataLen, 
                                 std::vector<TransformationResult>& output) {
    
    size_t offset = 0;
    while (offset < dataLen) {
        size_t chunkSize = (dataLen - offset > 1024) ? 1024 : (dataLen - offset);
        
        TransformationResult result = transformData(data + offset, chunkSize);
        output.push_back(result);
        
        offset += chunkSize;
    }
}