# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    float temperature;
    float pressure;
    float flowRate;
    uint32_t timestamp;
    uint8_t status;
} sensor_data_t;

volatile sensor_data_t sensor_data;
SemaphoreHandle_t xDataMutex;

float readTemperatureSensor(void) {
    return 25.5f + (float)(xTaskGetTickCount() % 100) / 10.0f;
}

float readPressureSensor(void) {
    return 101.3f + (float)(xTaskGetTickCount() % 50) / 10.0f;
}

float readFlowRateSensor(void) {
    return 10.0f + (float)(xTaskGetTickCount() % 30) / 10.0f;
}

void vSensorReadTask(void *pvParameters) {
    sensor_data_t localData;
    TickType_t xLastWakeTime;
    const TickType_t xFrequency = pdMS_TO_TICKS(10);
    
    xLastWakeTime = xTaskGetTickCount();
    
    while(1) {
        localData.temperature = readTemperatureSensor();
        localData.pressure = readPressureSensor();
        localData.flowRate = readFlowRateSensor();
        localData.timestamp = xTaskGetTickCount();
        localData.status = 0x01;
        
        if(xSemaphoreTake(xDataMutex, portMAX_DELAY) == pdTRUE) {
            sensor_data.temperature = localData.temperature;
            sensor_data.pressure = localData.pressure;
            sensor_data.flowRate = localData.flowRate;
            sensor_data.timestamp = localData.timestamp;
            sensor_data.status = localData.status;
            xSemaphoreGive(xDataMutex);
        }
        
        vTaskDelayUntil(&xLastWakeTime, xFrequency);
    }
}

void vControlTask(void *pvParameters) {
    sensor_data_t localData;
    TickType_t xLastWakeTime;
    const TickType_t xFrequency = pdMS_TO_TICKS(20);
    float controlOutput;
    
    xLastWakeTime = xTaskGetTickCount();
    
    while(1) {
        if(xSemaphoreTake(xDataMutex, portMAX_DELAY) == pdTRUE) {
            localData.temperature = sensor_data.temperature;
            localData.pressure = sensor_data.pressure;
            localData.flowRate = sensor_data.flowRate;
            localData.timestamp = sensor_data.timestamp;
            localData.status = sensor_data.status;
            xSemaphoreGive(xDataMutex);
        }
        
        if(localData.status == 0x01) {
            controlOutput = 0.0f;
            
            if(localData.temperature > 30.0f) {
                controlOutput += (localData.temperature - 30.0f) * 2.0f;
            }
            
            if(localData.pressure > 105.0f) {
                controlOutput += (localData.pressure - 105.0f) * 1.5f;
            }
            
            if(localData.flowRate < 12.0f) {
                controlOutput += (12.0f - localData.flowRate) * 3.0f;
            }
            
        }
        
        vTaskDelayUntil(&xLastWakeTime, xFrequency);
    }
}

int main(void) {
    sensor_data.temperature = 0.0f;
    sensor_data.pressure = 0.0f;
    sensor_data.flowRate = 0.0f;
    sensor_data.timestamp = 0;
    sensor_data.status = 0;
    
    xDataMutex = xSemaphoreCreateMutex();
    
    if(xDataMutex != NULL) {
        xTaskCreate(vSensorReadTask, "SensorRead", 256, NULL, 3, NULL);
        xTaskCreate(vControlTask, "Control", 256, NULL, 2, NULL);
        
        vTaskStartScheduler();
    }
    
    while(1);
    
    return 0;
}