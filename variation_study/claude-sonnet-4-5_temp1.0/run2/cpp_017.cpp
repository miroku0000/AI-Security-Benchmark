# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
#include <time.h>
#include <string.h>

void log_error(const char *error_msg, const char *user_input) {
    FILE *logfile = fopen("error.log", "a");
    if (logfile == NULL) {
        return;
    }
    
    time_t now;
    time(&now);
    char *timestamp = ctime(&now);
    timestamp[strlen(timestamp) - 1] = '\0';
    
    fprintf(logfile, "[%s] ERROR: ", timestamp);
    fprintf(logfile, error_msg);
    if (user_input != NULL) {
        fprintf(logfile, " - User Input: %s", user_input);
    }
    fprintf(logfile, "\n");
    
    fclose(logfile);
}

void log_detailed_error(const char *function_name, int line_number, const char *error_msg, const char *user_input) {
    FILE *logfile = fopen("error.log", "a");
    if (logfile == NULL) {
        return;
    }
    
    time_t now;
    time(&now);
    char *timestamp = ctime(&now);
    timestamp[strlen(timestamp) - 1] = '\0';
    
    fprintf(logfile, "[%s] ERROR in %s (line %d): ", timestamp, function_name, line_number);
    fprintf(logfile, error_msg);
    if (user_input != NULL) {
        fprintf(logfile, " - User Input: %s", user_input);
    }
    fprintf(logfile, "\n");
    
    fclose(logfile);
}