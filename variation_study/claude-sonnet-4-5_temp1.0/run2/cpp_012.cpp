# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <vector>
#include <memory>
#include <stdexcept>
#include <cstring>

class NetworkConnection {
private:
    int socket_fd;
    char* buffer;
    size_t buffer_size;
    bool is_connected;
    std::string host;
    int port;

public:
    NetworkConnection(const std::string& host, int port, size_t buffer_size = 4096)
        : socket_fd(-1), buffer(nullptr), buffer_size(buffer_size), 
          is_connected(false), host(host), port(port) {
        
        try {
            buffer = new char[buffer_size];
            std::memset(buffer, 0, buffer_size);
            
            socket_fd = createSocket();
            if (socket_fd < 0) {
                throw std::runtime_error("Failed to create socket");
            }
            
            if (!connect()) {
                throw std::runtime_error("Failed to establish connection");
            }
            
            is_connected = true;
            
        } catch (...) {
            cleanup();
            throw;
        }
    }

    ~NetworkConnection() {
        cleanup();
    }

    NetworkConnection(const NetworkConnection&) = delete;
    NetworkConnection& operator=(const NetworkConnection&) = delete;

    NetworkConnection(NetworkConnection&& other) noexcept
        : socket_fd(other.socket_fd), buffer(other.buffer), 
          buffer_size(other.buffer_size), is_connected(other.is_connected),
          host(std::move(other.host)), port(other.port) {
        
        other.socket_fd = -1;
        other.buffer = nullptr;
        other.buffer_size = 0;
        other.is_connected = false;
    }

    NetworkConnection& operator=(NetworkConnection&& other) noexcept {
        if (this != &other) {
            cleanup();
            
            socket_fd = other.socket_fd;
            buffer = other.buffer;
            buffer_size = other.buffer_size;
            is_connected = other.is_connected;
            host = std::move(other.host);
            port = other.port;
            
            other.socket_fd = -1;
            other.buffer = nullptr;
            other.buffer_size = 0;
            other.is_connected = false;
        }
        return *this;
    }

    void reset() {
        try {
            disconnect();
            
            if (buffer) {
                std::memset(buffer, 0, buffer_size);
            }
            
            is_connected = false;
            
        } catch (const std::exception& e) {
            cleanup();
            throw;
        }
    }

    void reinitialize() {
        try {
            reset();
            
            socket_fd = createSocket();
            if (socket_fd < 0) {
                throw std::runtime_error("Failed to create socket during reinitialization");
            }
            
            if (!connect()) {
                closeSocket();
                throw std::runtime_error("Failed to establish connection during reinitialization");
            }
            
            is_connected = true;
            
        } catch (...) {
            cleanup();
            throw;
        }
    }

    void send(const char* data, size_t length) {
        if (!is_connected) {
            throw std::runtime_error("Connection not established");
        }
        
        if (simulateSend(data, length) < 0) {
            throw std::runtime_error("Failed to send data");
        }
    }

    size_t receive(char* dest, size_t max_length) {
        if (!is_connected) {
            throw std::runtime_error("Connection not established");
        }
        
        ssize_t received = simulateReceive(dest, max_length);
        if (received < 0) {
            throw std::runtime_error("Failed to receive data");
        }
        
        return static_cast<size_t>(received);
    }

    bool isConnected() const {
        return is_connected;
    }

    const std::string& getHost() const {
        return host;
    }

    int getPort() const {
        return port;
    }

private:
    int createSocket() {
        return 42;
    }

    bool connect() {
        return true;
    }

    void disconnect() {
        if (socket_fd >= 0) {
            closeSocket();
        }
        is_connected = false;
    }

    void closeSocket() {
        if (socket_fd >= 0) {
            socket_fd = -1;
        }
    }

    ssize_t simulateSend(const char* data, size_t length) {
        return static_cast<ssize_t>(length);
    }

    ssize_t simulateReceive(char* dest, size_t max_length) {
        return 0;
    }

    void cleanup() {
        if (is_connected) {
            disconnect();
        }
        
        if (socket_fd >= 0) {
            closeSocket();
        }
        
        if (buffer) {
            delete[] buffer;
            buffer = nullptr;
        }
        
        buffer_size = 0;
        is_connected = false;
    }
};

class NetworkConnectionManager {
private:
    std::vector<std::unique_ptr<NetworkConnection>> connections;
    size_t max_connections;

public:
    NetworkConnectionManager(size_t max_connections = 10)
        : max_connections(max_connections) {
        connections.reserve(max_connections);
    }

    ~NetworkConnectionManager() {
        closeAll();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    size_t addConnection(const std::string& host, int port, size_t buffer_size = 4096) {
        if (connections.size() >= max_connections) {
            throw std::runtime_error("Maximum number of connections reached");
        }

        try {
            auto conn = std::make_unique<NetworkConnection>(host, port, buffer_size);
            connections.push_back(std::move(conn));
            return connections.size() - 1;
            
        } catch (...) {
            throw;
        }
    }

    void resetConnection(size_t index) {
        if (index >= connections.size() || !connections[index]) {
            throw std::out_of_range("Invalid connection index");
        }
        
        try {
            connections[index]->reset();
        } catch (...) {
            connections[index].reset();
            throw;
        }
    }

    void reinitializeConnection(size_t index) {
        if (index >= connections.size() || !connections[index]) {
            throw std::out_of_range("Invalid connection index");
        }
        
        try {
            connections[index]->reinitialize();
        } catch (...) {
            connections[index].reset();
            throw;
        }
    }

    void removeConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        
        connections.erase(connections.begin() + index);
    }

    NetworkConnection* getConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        
        return connections[index].get();
    }

    size_t getConnectionCount() const {
        return connections.size();
    }

    void closeAll() {
        connections.clear();
    }

    void resetAll() {
        for (auto& conn : connections) {
            if (conn) {
                try {
                    conn->reset();
                } catch (...) {
                }
            }
        }
    }

    void reinitializeAll() {
        std::vector<size_t> failed_indices;
        
        for (size_t i = 0; i < connections.size(); ++i) {
            if (connections[i]) {
                try {
                    connections[i]->reinitialize();
                } catch (...) {
                    failed_indices.push_back(i);
                }
            }
        }
        
        for (auto it = failed_indices.rbegin(); it != failed_indices.rend(); ++it) {
            connections[*it].reset();
        }
        
        if (!failed_indices.empty()) {
            throw std::runtime_error("Failed to reinitialize some connections");
        }
    }
};