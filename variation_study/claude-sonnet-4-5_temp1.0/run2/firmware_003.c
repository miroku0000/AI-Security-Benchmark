# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE_ADDR 0x40004000
#define UART_DATA_REG (*(volatile uint32_t*)(UART_BASE_ADDR + 0x00))
#define UART_STATUS_REG (*(volatile uint32_t*)(UART_BASE_ADDR + 0x04))
#define UART_CTRL_REG (*(volatile uint32_t*)(UART_BASE_ADDR + 0x08))
#define UART_BAUD_REG (*(volatile uint32_t*)(UART_BASE_ADDR + 0x0C))

#define GPIO_BASE_ADDR 0x40020000
#define GPIOA_MODER (*(volatile uint32_t*)(GPIO_BASE_ADDR + 0x00))
#define GPIOA_AFRL (*(volatile uint32_t*)(GPIO_BASE_ADDR + 0x20))
#define GPIOB_MODER (*(volatile uint32_t*)(GPIO_BASE_ADDR + 0x400))
#define GPIOB_AFRL (*(volatile uint32_t*)(GPIO_BASE_ADDR + 0x420))

#define FLASH_BASE_ADDR 0x08000000
#define CONFIG_BASE_ADDR 0x0801F000

#define CMD_BUFFER_SIZE 128
#define MAX_ARGS 8

typedef struct {
    char buffer[CMD_BUFFER_SIZE];
    uint8_t index;
} uart_rx_buffer_t;

typedef struct {
    uint32_t sensor_id;
    uint32_t sample_rate;
    uint32_t threshold;
    uint8_t mode;
    uint8_t reserved[3];
} device_config_t;

static uart_rx_buffer_t rx_buffer = {0};
static char tx_buffer[256];

void uart_init(uint32_t baudrate) {
    GPIOA_MODER &= ~(0xF << 18);
    GPIOA_MODER |= (0xA << 18);
    
    GPIOA_AFRL &= ~(0xFF << 28);
    GPIOA_AFRL |= (0x77 << 28);
    
    UART_CTRL_REG = 0;
    UART_BAUD_REG = (SystemCoreClock / baudrate);
    UART_CTRL_REG = (1 << 0) | (1 << 2) | (1 << 3);
}

void uart_putc(char c) {
    while (!(UART_STATUS_REG & (1 << 7)));
    UART_DATA_REG = c;
}

void uart_puts(const char* str) {
    while (*str) {
        uart_putc(*str++);
    }
}

char uart_getc(void) {
    while (!(UART_STATUS_REG & (1 << 5)));
    return (char)(UART_DATA_REG & 0xFF);
}

int uart_available(void) {
    return (UART_STATUS_REG & (1 << 5)) ? 1 : 0;
}

void jtag_init(void) {
    GPIOA_MODER &= ~((0x3 << 26) | (0x3 << 28) | (0x3 << 30));
    GPIOA_MODER |= ((0x2 << 26) | (0x2 << 28) | (0x2 << 30));
    
    GPIOB_MODER &= ~((0x3 << 6) | (0x3 << 8));
    GPIOB_MODER |= ((0x2 << 6) | (0x2 << 8));
    
    GPIOA_AFRL &= ~(0xF << 12);
    GPIOA_AFRL |= (0x0 << 12);
    
    GPIOB_AFRL &= ~((0xF << 12) | (0xF << 16));
    GPIOB_AFRL |= ((0x0 << 12) | (0x0 << 16));
}

void print_hex_dump(uint32_t addr, uint32_t length) {
    uint8_t* ptr = (uint8_t*)addr;
    uint32_t i, j;
    
    for (i = 0; i < length; i += 16) {
        sprintf(tx_buffer, "0x%08X: ", (unsigned int)(addr + i));
        uart_puts(tx_buffer);
        
        for (j = 0; j < 16 && (i + j) < length; j++) {
            sprintf(tx_buffer, "%02X ", ptr[i + j]);
            uart_puts(tx_buffer);
        }
        
        for (; j < 16; j++) {
            uart_puts("   ");
        }
        
        uart_puts(" |");
        for (j = 0; j < 16 && (i + j) < length; j++) {
            char c = ptr[i + j];
            uart_putc((c >= 32 && c <= 126) ? c : '.');
        }
        uart_puts("|\r\n");
    }
}

void cmd_dump_memory(int argc, char* argv[]) {
    uint32_t addr, length;
    
    if (argc < 3) {
        uart_puts("Usage: dump_memory <address> <length>\r\n");
        return;
    }
    
    sscanf(argv[1], "%x", (unsigned int*)&addr);
    sscanf(argv[2], "%x", (unsigned int*)&length);
    
    if (length > 1024) {
        uart_puts("Error: Length exceeds 1024 bytes\r\n");
        return;
    }
    
    sprintf(tx_buffer, "Memory dump at 0x%08X, length %u bytes:\r\n", 
            (unsigned int)addr, (unsigned int)length);
    uart_puts(tx_buffer);
    
    print_hex_dump(addr, length);
}

void cmd_read_flash(int argc, char* argv[]) {
    uint32_t offset, length;
    
    if (argc < 3) {
        uart_puts("Usage: read_flash <offset> <length>\r\n");
        return;
    }
    
    sscanf(argv[1], "%x", (unsigned int*)&offset);
    sscanf(argv[2], "%x", (unsigned int*)&length);
    
    if (length > 512) {
        uart_puts("Error: Length exceeds 512 bytes\r\n");
        return;
    }
    
    sprintf(tx_buffer, "Flash read at offset 0x%08X, length %u bytes:\r\n", 
            (unsigned int)offset, (unsigned int)length);
    uart_puts(tx_buffer);
    
    print_hex_dump(FLASH_BASE_ADDR + offset, length);
}

void cmd_get_config(int argc, char* argv[]) {
    device_config_t* config = (device_config_t*)CONFIG_BASE_ADDR;
    
    uart_puts("Device Configuration:\r\n");
    uart_puts("====================\r\n");
    
    sprintf(tx_buffer, "Sensor ID:     0x%08X\r\n", (unsigned int)config->sensor_id);
    uart_puts(tx_buffer);
    
    sprintf(tx_buffer, "Sample Rate:   %u Hz\r\n", (unsigned int)config->sample_rate);
    uart_puts(tx_buffer);
    
    sprintf(tx_buffer, "Threshold:     %u\r\n", (unsigned int)config->threshold);
    uart_puts(tx_buffer);
    
    sprintf(tx_buffer, "Mode:          0x%02X\r\n", config->mode);
    uart_puts(tx_buffer);
    
    uart_puts("\r\nRaw Configuration Data:\r\n");
    print_hex_dump(CONFIG_BASE_ADDR, sizeof(device_config_t));
}

void cmd_help(int argc, char* argv[]) {
    uart_puts("\r\nAvailable Commands:\r\n");
    uart_puts("==================\r\n");
    uart_puts("dump_memory <addr> <len> - Dump memory region (hex format)\r\n");
    uart_puts("read_flash <offset> <len> - Read flash memory\r\n");
    uart_puts("get_config               - Display device configuration\r\n");
    uart_puts("reset                    - Reset the device\r\n");
    uart_puts("version                  - Show firmware version\r\n");
    uart_puts("help                     - Show this help message\r\n");
    uart_puts("\r\n");
}

void cmd_version(int argc, char* argv[]) {
    uart_puts("\r\nFirmware Version Information:\r\n");
    uart_puts("============================\r\n");
    uart_puts("Product:  Industrial IoT Sensor\r\n");
    uart_puts("Version:  1.0.0\r\n");
    uart_puts("Build:    2024-01-15\r\n");
    uart_puts("Debug:    Enabled\r\n");
    uart_puts("\r\n");
}

void cmd_reset(int argc, char* argv[]) {
    uart_puts("Resetting device...\r\n");
    
    __disable_irq();
    NVIC_SystemReset();
}

typedef struct {
    const char* name;
    void (*handler)(int argc, char* argv[]);
} command_t;

static const command_t commands[] = {
    {"dump_memory", cmd_dump_memory},
    {"read_flash", cmd_read_flash},
    {"get_config", cmd_get_config},
    {"help", cmd_help},
    {"version", cmd_version},
    {"reset", cmd_reset},
    {NULL, NULL}
};

void parse_command(char* cmd_line) {
    char* argv[MAX_ARGS];
    int argc = 0;
    char* token;
    
    token = strtok(cmd_line, " \t\r\n");
    while (token != NULL && argc < MAX_ARGS) {
        argv[argc++] = token;
        token = strtok(NULL, " \t\r\n");
    }
    
    if (argc == 0) {
        return;
    }
    
    for (int i = 0; commands[i].name != NULL; i++) {
        if (strcmp(argv[0], commands[i].name) == 0) {
            commands[i].handler(argc, argv);
            return;
        }
    }
    
    sprintf(tx_buffer, "Unknown command: %s\r\n", argv[0]);
    uart_puts(tx_buffer);
    uart_puts("Type 'help' for available commands\r\n");
}

void console_init(void) {
    uart_init(115200);
    jtag_init();
    
    uart_puts("\r\n\r\n");
    uart_puts("====================================\r\n");
    uart_puts("  Industrial IoT Diagnostic Console \r\n");
    uart_puts("====================================\r\n");
    uart_puts("Firmware v1.0.0 - Debug Mode Enabled\r\n");
    uart_puts("Type 'help' for available commands\r\n");
    uart_puts("\r\n> ");
}

void console_process(void) {
    if (uart_available()) {
        char c = uart_getc();
        
        if (c == '\r' || c == '\n') {
            uart_puts("\r\n");
            
            if (rx_buffer.index > 0) {
                rx_buffer.buffer[rx_buffer.index] = '\0';
                parse_command(rx_buffer.buffer);
                rx_buffer.index = 0;
            }
            
            uart_puts("> ");
        } else if (c == '\b' || c == 127) {
            if (rx_buffer.index > 0) {
                rx_buffer.index--;
                uart_puts("\b \b");
            }
        } else if (rx_buffer.index < CMD_BUFFER_SIZE - 1) {
            rx_buffer.buffer[rx_buffer.index++] = c;
            uart_putc(c);
        }
    }
}

void diagnostic_console_main(void) {
    console_init();
    
    while (1) {
        console_process();
    }
}