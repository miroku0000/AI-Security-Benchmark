# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct User {
    char* name;
    char* email;
    struct User* next;
} User;

void processUserList(User* head) {
    User* current = head;
    while (current != NULL) {
        printf("Name: %s, Email: %s\n", current->name, current->email);
        current = current->next;
    }
}

User* createUser(const char* name, const char* email) {
    User* user = (User*)malloc(sizeof(User));
    if (user == NULL) {
        return NULL;
    }
    
    user->name = (char*)malloc(strlen(name) + 1);
    if (user->name == NULL) {
        free(user);
        return NULL;
    }
    strcpy(user->name, name);
    
    user->email = (char*)malloc(strlen(email) + 1);
    if (user->email == NULL) {
        free(user->name);
        free(user);
        return NULL;
    }
    strcpy(user->email, email);
    
    user->next = NULL;
    return user;
}

void freeUserList(User* head) {
    User* current = head;
    while (current != NULL) {
        User* temp = current;
        current = current->next;
        free(temp->name);
        free(temp->email);
        free(temp);
    }
}

int main() {
    User* head = createUser("John Doe", "john@example.com");
    head->next = createUser("Jane Smith", "jane@example.com");
    head->next->next = createUser("Bob Johnson", "bob@example.com");
    
    processUserList(head);
    
    freeUserList(head);
    
    return 0;
}