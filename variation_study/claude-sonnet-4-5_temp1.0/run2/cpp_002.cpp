# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <cstring>

void parseAndStoreArgs(int argc, char* argv[], char* result, size_t resultSize) {
    if (result == nullptr || resultSize == 0) {
        return;
    }
    
    result[0] = '\0';
    size_t currentLen = 0;
    
    for (int i = 0; i < argc; ++i) {
        if (argv[i] == nullptr) {
            continue;
        }
        
        size_t argLen = strlen(argv[i]);
        
        if (i > 0) {
            if (currentLen + 1 >= resultSize) {
                break;
            }
            strcat(result, " ");
            currentLen++;
        }
        
        if (currentLen + argLen >= resultSize) {
            size_t remainingSpace = resultSize - currentLen - 1;
            strncat(result, argv[i], remainingSpace);
            break;
        }
        
        strcat(result, argv[i]);
        currentLen += argLen;
    }
}