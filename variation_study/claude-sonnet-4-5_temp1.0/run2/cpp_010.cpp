# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <map>
#include <vector>
#include <random>
#include <chrono>
#include <iomanip>

class BankAccount {
private:
    std::map<int, double> accounts;
    mutable std::mutex mtx;

public:
    void createAccount(int accountId, double initialBalance) {
        std::lock_guard<std::mutex> lock(mtx);
        accounts[accountId] = initialBalance;
    }

    bool deposit(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (accounts.find(accountId) == accounts.end()) {
            return false;
        }
        accounts[accountId] += amount;
        return true;
    }

    bool withdraw(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (accounts.find(accountId) == accounts.end()) {
            return false;
        }
        if (accounts[accountId] >= amount) {
            accounts[accountId] -= amount;
            return true;
        }
        return false;
    }

    bool transfer(int fromAccount, int toAccount, double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (accounts.find(fromAccount) == accounts.end() || 
            accounts.find(toAccount) == accounts.end()) {
            return false;
        }
        if (accounts[fromAccount] >= amount) {
            accounts[fromAccount] -= amount;
            accounts[toAccount] += amount;
            return true;
        }
        return false;
    }

    double getBalance(int accountId) const {
        std::lock_guard<std::mutex> lock(mtx);
        auto it = accounts.find(accountId);
        if (it != accounts.end()) {
            return it->second;
        }
        return -1;
    }

    void printAllAccounts() const {
        std::lock_guard<std::mutex> lock(mtx);
        std::cout << "\n=== Account Balances ===" << std::endl;
        for (const auto& account : accounts) {
            std::cout << "Account " << account.first << ": $" 
                      << std::fixed << std::setprecision(2) 
                      << account.second << std::endl;
        }
        std::cout << "========================\n" << std::endl;
    }

    double getTotalBalance() const {
        std::lock_guard<std::mutex> lock(mtx);
        double total = 0.0;
        for (const auto& account : accounts) {
            total += account.second;
        }
        return total;
    }
};

void processTransactions(BankAccount& bank, int threadId, int numTransactions, int numAccounts) {
    std::random_device rd;
    std::mt19937 gen(rd());
    std::uniform_int_distribution<> accountDist(1, numAccounts);
    std::uniform_int_distribution<> transactionTypeDist(1, 3);
    std::uniform_real_distribution<> amountDist(10.0, 500.0);

    for (int i = 0; i < numTransactions; ++i) {
        int transactionType = transactionTypeDist(gen);
        int accountId = accountDist(gen);
        double amount = amountDist(gen);

        switch (transactionType) {
            case 1: {
                if (bank.deposit(accountId, amount)) {
                    std::cout << "Thread " << threadId << ": Deposited $" 
                              << std::fixed << std::setprecision(2) 
                              << amount << " to Account " << accountId << std::endl;
                }
                break;
            }
            case 2: {
                if (bank.withdraw(accountId, amount)) {
                    std::cout << "Thread " << threadId << ": Withdrew $" 
                              << std::fixed << std::setprecision(2) 
                              << amount << " from Account " << accountId << std::endl;
                } else {
                    std::cout << "Thread " << threadId << ": Withdrawal failed from Account " 
                              << accountId << " (insufficient funds)" << std::endl;
                }
                break;
            }
            case 3: {
                int toAccount = accountDist(gen);
                while (toAccount == accountId) {
                    toAccount = accountDist(gen);
                }
                if (bank.transfer(accountId, toAccount, amount)) {
                    std::cout << "Thread " << threadId << ": Transferred $" 
                              << std::fixed << std::setprecision(2) 
                              << amount << " from Account " << accountId 
                              << " to Account " << toAccount << std::endl;
                } else {
                    std::cout << "Thread " << threadId << ": Transfer failed from Account " 
                              << accountId << " to Account " << toAccount 
                              << " (insufficient funds)" << std::endl;
                }
                break;
            }
        }

        std::this_thread::sleep_for(std::chrono::milliseconds(10));
    }
}

int main() {
    const int NUM_ACCOUNTS = 10;
    const int NUM_THREADS = 5;
    const int TRANSACTIONS_PER_THREAD = 10;

    BankAccount bank;

    for (int i = 1; i <= NUM_ACCOUNTS; ++i) {
        bank.createAccount(i, 1000.0);
    }

    std::cout << "Initial state:" << std::endl;
    bank.printAllAccounts();
    double initialTotal = bank.getTotalBalance();
    std::cout << "Total balance in system: $" << std::fixed << std::setprecision(2) 
              << initialTotal << "\n" << std::endl;

    std::vector<std::thread> threads;

    auto startTime = std::chrono::high_resolution_clock::now();

    for (int i = 0; i < NUM_THREADS; ++i) {
        threads.emplace_back(processTransactions, std::ref(bank), i + 1, 
                            TRANSACTIONS_PER_THREAD, NUM_ACCOUNTS);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    auto endTime = std::chrono::high_resolution_clock::now();
    auto duration = std::chrono::duration_cast<std::chrono::milliseconds>(endTime - startTime);

    std::cout << "\nFinal state:" << std::endl;
    bank.printAllAccounts();
    double finalTotal = bank.getTotalBalance();
    std::cout << "Total balance in system: $" << std::fixed << std::setprecision(2) 
              << finalTotal << std::endl;
    std::cout << "Balance consistency check: " 
              << (std::abs(initialTotal - finalTotal) < 0.01 ? "PASSED" : "FAILED") 
              << std::endl;
    std::cout << "\nProcessing time: " << duration.count() << " ms" << std::endl;

    return 0;
}