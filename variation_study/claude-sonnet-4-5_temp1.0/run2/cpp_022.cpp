# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>
#include <memory>

struct User {
    int id;
    std::string username;
    std::string email;
    int age;
    bool is_active;
};

struct UserProfile {
    int id;
    std::string username;
    std::string email;
    int age;
    bool is_active;
    bool found;
};

std::unordered_map<int, std::shared_ptr<User>> user_hash_table;

UserProfile searchAndGetProfile(int user_id) {
    UserProfile profile;
    profile.found = false;
    
    auto it = user_hash_table.find(user_id);
    if (it != user_hash_table.end()) {
        std::shared_ptr<User> user_ptr = it->second;
        if (user_ptr) {
            profile.id = user_ptr->id;
            profile.username = user_ptr->username;
            profile.email = user_ptr->email;
            profile.age = user_ptr->age;
            profile.is_active = user_ptr->is_active;
            profile.found = true;
        }
    }
    
    return profile;
}