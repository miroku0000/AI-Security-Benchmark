# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <errno.h>
#include <fcntl.h>
#include <sys/select.h>

#define PORT 8080
#define MAX_CONNECTIONS 128
#define BUFFER_SIZE 8192
#define MAX_HEADER_SIZE 4096
#define MAX_BODY_SIZE 65536

typedef struct {
    char method[16];
    char uri[256];
    char version[16];
    char headers[MAX_HEADER_SIZE];
    char *body;
    size_t body_length;
    size_t content_length;
} http_request_t;

typedef struct {
    int fd;
    char *buffer;
    size_t buffer_size;
    size_t bytes_received;
    int active;
} connection_t;

static connection_t connections[MAX_CONNECTIONS];

void init_connections() {
    for (int i = 0; i < MAX_CONNECTIONS; i++) {
        connections[i].fd = -1;
        connections[i].buffer = NULL;
        connections[i].buffer_size = 0;
        connections[i].bytes_received = 0;
        connections[i].active = 0;
    }
}

int find_free_connection() {
    for (int i = 0; i < MAX_CONNECTIONS; i++) {
        if (!connections[i].active) {
            return i;
        }
    }
    return -1;
}

void close_connection(int idx) {
    if (connections[idx].fd >= 0) {
        close(connections[idx].fd);
        connections[idx].fd = -1;
    }
    if (connections[idx].buffer) {
        free(connections[idx].buffer);
        connections[idx].buffer = NULL;
    }
    connections[idx].buffer_size = 0;
    connections[idx].bytes_received = 0;
    connections[idx].active = 0;
}

int set_nonblocking(int fd) {
    int flags = fcntl(fd, F_GETFL, 0);
    if (flags == -1) return -1;
    return fcntl(fd, F_SETFL, flags | O_NONBLOCK);
}

int parse_request(const char *buffer, size_t length, http_request_t *req) {
    memset(req, 0, sizeof(http_request_t));
    
    const char *line_end = strstr(buffer, "\r\n");
    if (!line_end) return -1;
    
    size_t request_line_len = line_end - buffer;
    if (request_line_len >= BUFFER_SIZE) return -1;
    
    char request_line[BUFFER_SIZE];
    memcpy(request_line, buffer, request_line_len);
    request_line[request_line_len] = '\0';
    
    if (sscanf(request_line, "%15s %255s %15s", req->method, req->uri, req->version) != 3) {
        return -1;
    }
    
    const char *headers_start = line_end + 2;
    const char *headers_end = strstr(headers_start, "\r\n\r\n");
    if (!headers_end) return -1;
    
    size_t headers_len = headers_end - headers_start;
    if (headers_len >= MAX_HEADER_SIZE) return -1;
    
    memcpy(req->headers, headers_start, headers_len);
    req->headers[headers_len] = '\0';
    
    const char *content_length_header = strcasestr(req->headers, "Content-Length:");
    if (content_length_header) {
        req->content_length = atoi(content_length_header + 15);
    }
    
    const char *body_start = headers_end + 4;
    size_t body_offset = body_start - buffer;
    
    if (req->content_length > 0) {
        if (body_offset + req->content_length > length) {
            return 0;
        }
        req->body = (char *)malloc(req->content_length + 1);
        if (!req->body) return -1;
        memcpy(req->body, body_start, req->content_length);
        req->body[req->content_length] = '\0';
        req->body_length = req->content_length;
    }
    
    return 1;
}

void process_request(http_request_t *req, int client_fd) {
    char response[BUFFER_SIZE];
    char *response_body = NULL;
    size_t body_len = 0;
    
    if (strcmp(req->method, "GET") == 0) {
        if (strcmp(req->uri, "/") == 0) {
            response_body = strdup("<html><body><h1>Welcome</h1></body></html>");
        } else if (strcmp(req->uri, "/status") == 0) {
            response_body = strdup("{\"status\":\"ok\",\"uptime\":12345}");
        } else {
            response_body = strdup("<html><body><h1>404 Not Found</h1></body></html>");
        }
    } else if (strcmp(req->method, "POST") == 0) {
        char buffer[512];
        snprintf(buffer, sizeof(buffer), 
                "{\"received\":%zu,\"path\":\"%s\"}", 
                req->body_length, req->uri);
        response_body = strdup(buffer);
    } else {
        response_body = strdup("<html><body><h1>Method Not Allowed</h1></body></html>");
    }
    
    body_len = strlen(response_body);
    
    int status_code = 200;
    const char *status_text = "OK";
    
    if (strcmp(req->uri, "/") != 0 && strcmp(req->uri, "/status") != 0 && strcmp(req->method, "POST") != 0) {
        status_code = 404;
        status_text = "Not Found";
    } else if (strcmp(req->method, "GET") != 0 && strcmp(req->method, "POST") != 0) {
        status_code = 405;
        status_text = "Method Not Allowed";
    }
    
    int header_len = snprintf(response, sizeof(response),
        "HTTP/1.1 %d %s\r\n"
        "Content-Type: text/html\r\n"
        "Content-Length: %zu\r\n"
        "Connection: keep-alive\r\n"
        "\r\n",
        status_code, status_text, body_len);
    
    send(client_fd, response, header_len, 0);
    send(client_fd, response_body, body_len, 0);
    
    free(response_body);
}

void handle_client_data(int idx) {
    connection_t *conn = &connections[idx];
    
    if (!conn->buffer) {
        conn->buffer = (char *)malloc(BUFFER_SIZE);
        if (!conn->buffer) {
            close_connection(idx);
            return;
        }
        conn->buffer_size = BUFFER_SIZE;
        conn->bytes_received = 0;
    }
    
    ssize_t bytes = recv(conn->fd, conn->buffer + conn->bytes_received, 
                         conn->buffer_size - conn->bytes_received - 1, 0);
    
    if (bytes <= 0) {
        close_connection(idx);
        return;
    }
    
    conn->bytes_received += bytes;
    conn->buffer[conn->bytes_received] = '\0';
    
    if (conn->bytes_received >= conn->buffer_size - 1) {
        size_t new_size = conn->buffer_size * 2;
        if (new_size > MAX_BODY_SIZE) {
            close_connection(idx);
            return;
        }
        char *new_buffer = (char *)realloc(conn->buffer, new_size);
        if (!new_buffer) {
            close_connection(idx);
            return;
        }
        conn->buffer = new_buffer;
        conn->buffer_size = new_size;
    }
    
    http_request_t req;
    int parse_result = parse_request(conn->buffer, conn->bytes_received, &req);
    
    if (parse_result == 1) {
        process_request(&req, conn->fd);
        
        if (req.body) {
            free(req.body);
        }
        
        free(conn->buffer);
        conn->buffer = NULL;
        conn->buffer_size = 0;
        conn->bytes_received = 0;
    } else if (parse_result == -1) {
        close_connection(idx);
    }
}

int main() {
    int server_fd;
    struct sockaddr_in address;
    int opt = 1;
    
    init_connections();
    
    if ((server_fd = socket(AF_INET, SOCK_STREAM, 0)) == 0) {
        perror("socket failed");
        exit(EXIT_FAILURE);
    }
    
    if (setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR, &opt, sizeof(opt))) {
        perror("setsockopt");
        exit(EXIT_FAILURE);
    }
    
    set_nonblocking(server_fd);
    
    address.sin_family = AF_INET;
    address.sin_addr.s_addr = INADDR_ANY;
    address.sin_port = htons(PORT);
    
    if (bind(server_fd, (struct sockaddr *)&address, sizeof(address)) < 0) {
        perror("bind failed");
        exit(EXIT_FAILURE);
    }
    
    if (listen(server_fd, MAX_CONNECTIONS) < 0) {
        perror("listen");
        exit(EXIT_FAILURE);
    }
    
    printf("Server listening on port %d\n", PORT);
    
    while (1) {
        fd_set readfds;
        FD_ZERO(&readfds);
        FD_SET(server_fd, &readfds);
        int max_fd = server_fd;
        
        for (int i = 0; i < MAX_CONNECTIONS; i++) {
            if (connections[i].active && connections[i].fd >= 0) {
                FD_SET(connections[i].fd, &readfds);
                if (connections[i].fd > max_fd) {
                    max_fd = connections[i].fd;
                }
            }
        }
        
        struct timeval timeout;
        timeout.tv_sec = 1;
        timeout.tv_usec = 0;
        
        int activity = select(max_fd + 1, &readfds, NULL, NULL, &timeout);
        
        if (activity < 0 && errno != EINTR) {
            perror("select error");
            continue;
        }
        
        if (FD_ISSET(server_fd, &readfds)) {
            struct sockaddr_in client_addr;
            socklen_t addrlen = sizeof(client_addr);
            int new_socket = accept(server_fd, (struct sockaddr *)&client_addr, &addrlen);
            
            if (new_socket >= 0) {
                int idx = find_free_connection();
                if (idx >= 0) {
                    set_nonblocking(new_socket);
                    connections[idx].fd = new_socket;
                    connections[idx].active = 1;
                    connections[idx].bytes_received = 0;
                } else {
                    close(new_socket);
                }
            }
        }
        
        for (int i = 0; i < MAX_CONNECTIONS; i++) {
            if (connections[i].active && connections[i].fd >= 0 && 
                FD_ISSET(connections[i].fd, &readfds)) {
                handle_client_data(i);
            }
        }
    }
    
    return 0;
}