# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <fcntl.h>
#include <errno.h>

#define PORT 8080
#define BUFFER_SIZE 8192
#define MAX_CONNECTIONS 100
#define BACKLOG 50

typedef struct {
    char method[16];
    char path[256];
    char version[16];
    char* body;
    size_t body_length;
} http_request_t;

typedef struct {
    int status_code;
    char* body;
    size_t body_length;
    char content_type[64];
} http_response_t;

int create_server_socket(int port) {
    int server_fd;
    struct sockaddr_in address;
    int opt = 1;

    if ((server_fd = socket(AF_INET, SOCK_STREAM, 0)) == 0) {
        perror("socket failed");
        return -1;
    }

    if (setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR | SO_REUSEPORT, &opt, sizeof(opt))) {
        perror("setsockopt");
        close(server_fd);
        return -1;
    }

    address.sin_family = AF_INET;
    address.sin_addr.s_addr = INADDR_ANY;
    address.sin_port = htons(port);

    if (bind(server_fd, (struct sockaddr*)&address, sizeof(address)) < 0) {
        perror("bind failed");
        close(server_fd);
        return -1;
    }

    if (listen(server_fd, BACKLOG) < 0) {
        perror("listen");
        close(server_fd);
        return -1;
    }

    return server_fd;
}

int parse_http_request(const char* buffer, size_t length, http_request_t* request) {
    const char* line_end = strstr(buffer, "\r\n");
    if (!line_end) {
        return -1;
    }

    size_t line_length = line_end - buffer;
    char request_line[512];
    if (line_length >= sizeof(request_line)) {
        return -1;
    }

    memcpy(request_line, buffer, line_length);
    request_line[line_length] = '\0';

    if (sscanf(request_line, "%15s %255s %15s", request->method, request->path, request->version) != 3) {
        return -1;
    }

    const char* body_start = strstr(buffer, "\r\n\r\n");
    if (body_start) {
        body_start += 4;
        request->body_length = length - (body_start - buffer);
        if (request->body_length > 0) {
            request->body = malloc(request->body_length + 1);
            if (request->body) {
                memcpy(request->body, body_start, request->body_length);
                request->body[request->body_length] = '\0';
            }
        } else {
            request->body = NULL;
        }
    } else {
        request->body = NULL;
        request->body_length = 0;
    }

    return 0;
}

void process_request(const http_request_t* request, http_response_t* response) {
    response->status_code = 200;
    strcpy(response->content_type, "text/html");

    if (strcmp(request->path, "/") == 0) {
        const char* home_page = "<html><body><h1>Welcome to Embedded Web Server</h1></body></html>";
        response->body_length = strlen(home_page);
        response->body = malloc(response->body_length + 1);
        strcpy(response->body, home_page);
    } else if (strcmp(request->path, "/api/status") == 0) {
        const char* status_json = "{\"status\":\"ok\",\"uptime\":12345}";
        strcpy(response->content_type, "application/json");
        response->body_length = strlen(status_json);
        response->body = malloc(response->body_length + 1);
        strcpy(response->body, status_json);
    } else if (strncmp(request->path, "/api/data", 9) == 0) {
        const char* data_json = "{\"data\":[1,2,3,4,5],\"count\":5}";
        strcpy(response->content_type, "application/json");
        response->body_length = strlen(data_json);
        response->body = malloc(response->body_length + 1);
        strcpy(response->body, data_json);
    } else {
        response->status_code = 404;
        const char* not_found = "<html><body><h1>404 Not Found</h1></body></html>";
        response->body_length = strlen(not_found);
        response->body = malloc(response->body_length + 1);
        strcpy(response->body, not_found);
    }
}

void send_http_response(int client_fd, const http_response_t* response) {
    char header[512];
    const char* status_text = response->status_code == 200 ? "OK" : "Not Found";

    int header_len = snprintf(header, sizeof(header),
                              "HTTP/1.1 %d %s\r\n"
                              "Content-Type: %s\r\n"
                              "Content-Length: %zu\r\n"
                              "Connection: close\r\n"
                              "\r\n",
                              response->status_code, status_text,
                              response->content_type,
                              response->body_length);

    send(client_fd, header, header_len, 0);
    if (response->body && response->body_length > 0) {
        send(client_fd, response->body, response->body_length, 0);
    }
}

void handle_client(int client_fd) {
    char* buffer = malloc(BUFFER_SIZE);
    if (!buffer) {
        close(client_fd);
        return;
    }

    ssize_t bytes_read = recv(client_fd, buffer, BUFFER_SIZE - 1, 0);
    if (bytes_read > 0) {
        buffer[bytes_read] = '\0';

        http_request_t request = {0};
        if (parse_http_request(buffer, bytes_read, &request) == 0) {
            http_response_t response = {0};
            process_request(&request, &response);
            send_http_response(client_fd, &response);

            if (response.body) {
                free(response.body);
            }

            if (request.body) {
                free(request.body);
            }
        }
    }

    free(buffer);
    close(client_fd);
}

int main() {
    int server_fd = create_server_socket(PORT);
    if (server_fd < 0) {
        fprintf(stderr, "Failed to create server socket\n");
        return 1;
    }

    printf("Embedded web server listening on port %d\n", PORT);

    while (1) {
        struct sockaddr_in client_addr;
        socklen_t client_len = sizeof(client_addr);
        
        int client_fd = accept(server_fd, (struct sockaddr*)&client_addr, &client_len);
        if (client_fd < 0) {
            if (errno == EINTR) {
                continue;
            }
            perror("accept");
            continue;
        }

        handle_client(client_fd);
    }

    close(server_fd);
    return 0;
}