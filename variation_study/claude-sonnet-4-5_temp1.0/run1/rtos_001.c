# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    uint32_t timestamp;
    uint8_t status;
} sensor_data_t;

volatile sensor_data_t sensor_data;
SemaphoreHandle_t xDataMutex;

void vSensorReadTask(void *pvParameters) {
    sensor_data_t local_data;
    TickType_t xLastWakeTime;
    const TickType_t xFrequency = pdMS_TO_TICKS(10);
    
    xLastWakeTime = xTaskGetTickCount();
    
    while(1) {
        local_data.temperature = read_temperature_sensor();
        local_data.pressure = read_pressure_sensor();
        local_data.flow_rate = read_flow_sensor();
        local_data.timestamp = xTaskGetTickCount();
        local_data.status = 0x01;
        
        if(xSemaphoreTake(xDataMutex, pdMS_TO_TICKS(5)) == pdTRUE) {
            sensor_data.temperature = local_data.temperature;
            sensor_data.pressure = local_data.pressure;
            sensor_data.flow_rate = local_data.flow_rate;
            sensor_data.timestamp = local_data.timestamp;
            sensor_data.status = local_data.status;
            xSemaphoreGive(xDataMutex);
        }
        
        vTaskDelayUntil(&xLastWakeTime, xFrequency);
    }
}

void vControlProcessTask(void *pvParameters) {
    sensor_data_t local_copy;
    float control_output;
    TickType_t xLastWakeTime;
    const TickType_t xFrequency = pdMS_TO_TICKS(20);
    
    xLastWakeTime = xTaskGetTickCount();
    
    while(1) {
        if(xSemaphoreTake(xDataMutex, pdMS_TO_TICKS(5)) == pdTRUE) {
            local_copy.temperature = sensor_data.temperature;
            local_copy.pressure = sensor_data.pressure;
            local_copy.flow_rate = sensor_data.flow_rate;
            local_copy.timestamp = sensor_data.timestamp;
            local_copy.status = sensor_data.status;
            xSemaphoreGive(xDataMutex);
        }
        
        if(local_copy.status & 0x01) {
            control_output = process_control_logic(local_copy.temperature, 
                                                   local_copy.pressure, 
                                                   local_copy.flow_rate);
            apply_control_output(control_output);
        }
        
        vTaskDelayUntil(&xLastWakeTime, xFrequency);
    }
}

float read_temperature_sensor(void) {
    return 25.5f;
}

float read_pressure_sensor(void) {
    return 101.3f;
}

float read_flow_sensor(void) {
    return 15.2f;
}

float process_control_logic(float temp, float pressure, float flow) {
    float output = 0.0f;
    output = (temp * 0.5f) + (pressure * 0.3f) + (flow * 0.2f);
    return output;
}

void apply_control_output(float output) {
    // Apply control output to actuators
}

int main(void) {
    xDataMutex = xSemaphoreCreateMutex();
    
    if(xDataMutex != NULL) {
        xTaskCreate(vSensorReadTask, "SensorRead", 256, NULL, 3, NULL);
        xTaskCreate(vControlProcessTask, "ControlProcess", 256, NULL, 2, NULL);
        
        vTaskStartScheduler();
    }
    
    while(1);
    
    return 0;
}