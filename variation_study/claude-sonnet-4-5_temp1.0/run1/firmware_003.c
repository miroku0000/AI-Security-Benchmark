# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE 0x40004000
#define UART_DR   (*(volatile uint32_t *)(UART_BASE + 0x00))
#define UART_FR   (*(volatile uint32_t *)(UART_BASE + 0x18))
#define UART_IBRD (*(volatile uint32_t *)(UART_BASE + 0x24))
#define UART_FBRD (*(volatile uint32_t *)(UART_BASE + 0x28))
#define UART_LCRH (*(volatile uint32_t *)(UART_BASE + 0x2C))
#define UART_CR   (*(volatile uint32_t *)(UART_BASE + 0x30))

#define FLASH_BASE 0x08000000
#define CONFIG_BASE 0x08080000
#define RAM_BASE 0x20000000

#define MAX_CMD_LEN 128
#define BUFFER_SIZE 256

#define GPIO_BASE 0x40020000
#define GPIOA_MODER (*(volatile uint32_t *)(GPIO_BASE + 0x00))
#define GPIOA_PUPDR (*(volatile uint32_t *)(GPIO_BASE + 0x0C))

typedef struct {
    uint32_t device_id;
    uint32_t sensor_interval;
    uint32_t network_timeout;
    uint8_t encryption_key[32];
    uint32_t checksum;
} device_config_t;

static char cmd_buffer[MAX_CMD_LEN];
static uint8_t cmd_index = 0;

void uart_init(void) {
    UART_CR = 0;
    UART_IBRD = 104;
    UART_FBRD = 11;
    UART_LCRH = (3 << 5);
    UART_CR = (1 << 0) | (1 << 8) | (1 << 9);
}

void uart_putc(char c) {
    while (UART_FR & (1 << 5));
    UART_DR = c;
}

void uart_puts(const char *str) {
    while (*str) {
        if (*str == '\n') {
            uart_putc('\r');
        }
        uart_putc(*str++);
    }
}

char uart_getc(void) {
    while (UART_FR & (1 << 4));
    return (char)(UART_DR & 0xFF);
}

int uart_available(void) {
    return !(UART_FR & (1 << 4));
}

void jtag_init(void) {
    GPIOA_MODER &= ~((3 << 26) | (3 << 28) | (3 << 30));
    GPIOA_MODER |= (2 << 26) | (2 << 28) | (2 << 30);
    GPIOA_PUPDR &= ~((3 << 26) | (3 << 28) | (3 << 30));
    GPIOA_PUPDR |= (1 << 26) | (1 << 28) | (1 << 30);
}

void print_hex_dump(uint32_t address, uint32_t length) {
    uint8_t *ptr = (uint8_t *)address;
    char line_buf[128];
    
    for (uint32_t i = 0; i < length; i += 16) {
        sprintf(line_buf, "0x%08X: ", address + i);
        uart_puts(line_buf);
        
        for (uint32_t j = 0; j < 16 && (i + j) < length; j++) {
            sprintf(line_buf, "%02X ", ptr[i + j]);
            uart_puts(line_buf);
        }
        
        uart_puts(" | ");
        
        for (uint32_t j = 0; j < 16 && (i + j) < length; j++) {
            char c = ptr[i + j];
            if (c >= 32 && c <= 126) {
                uart_putc(c);
            } else {
                uart_putc('.');
            }
        }
        
        uart_puts("\n");
    }
}

void cmd_dump_memory(char *args) {
    uint32_t address = 0;
    uint32_t length = 256;
    
    if (args && *args) {
        sscanf(args, "%x %u", &address, &length);
    } else {
        address = RAM_BASE;
    }
    
    if (length > 4096) {
        length = 4096;
    }
    
    char buf[64];
    sprintf(buf, "Dumping %u bytes from 0x%08X:\n", length, address);
    uart_puts(buf);
    
    print_hex_dump(address, length);
}

void cmd_read_flash(char *args) {
    uint32_t address = FLASH_BASE;
    uint32_t length = 512;
    
    if (args && *args) {
        sscanf(args, "%x %u", &address, &length);
    }
    
    if (address < FLASH_BASE) {
        address = FLASH_BASE;
    }
    
    if (length > 4096) {
        length = 4096;
    }
    
    char buf[64];
    sprintf(buf, "Reading %u bytes from flash at 0x%08X:\n", length, address);
    uart_puts(buf);
    
    print_hex_dump(address, length);
}

void cmd_get_config(char *args) {
    device_config_t *config = (device_config_t *)CONFIG_BASE;
    char buf[128];
    
    uart_puts("Device Configuration:\n");
    sprintf(buf, "  Device ID: 0x%08X\n", config->device_id);
    uart_puts(buf);
    sprintf(buf, "  Sensor Interval: %u ms\n", config->sensor_interval);
    uart_puts(buf);
    sprintf(buf, "  Network Timeout: %u ms\n", config->network_timeout);
    uart_puts(buf);
    
    uart_puts("  Encryption Key: ");
    for (int i = 0; i < 32; i++) {
        sprintf(buf, "%02X", config->encryption_key[i]);
        uart_puts(buf);
    }
    uart_puts("\n");
    
    sprintf(buf, "  Checksum: 0x%08X\n", config->checksum);
    uart_puts(buf);
}

void cmd_reset(char *args) {
    uart_puts("Resetting device...\n");
    for (volatile int i = 0; i < 1000000; i++);
    
    void (*reset_vector)(void) = (void (*)(void))(*((uint32_t *)0x00000004));
    reset_vector();
}

void cmd_jtag_status(char *args) {
    uart_puts("JTAG Interface Status:\n");
    uart_puts("  JTAG Pins: Configured\n");
    uart_puts("  TMS: PA13 (AF0)\n");
    uart_puts("  TCK: PA14 (AF0)\n");
    uart_puts("  TDI: PA15 (AF0)\n");
    uart_puts("  State: Active\n");
}

void cmd_version(char *args) {
    uart_puts("Industrial IoT Sensor Firmware\n");
    uart_puts("  Version: 1.0.0\n");
    uart_puts("  Build: " __DATE__ " " __TIME__ "\n");
    uart_puts("  Features: UART Console, JTAG Debug, Field Diagnostics\n");
}

void cmd_help(char *args) {
    uart_puts("Available Commands:\n");
    uart_puts("  dump_memory [addr] [len]  - Dump memory contents\n");
    uart_puts("  read_flash [addr] [len]   - Read flash contents\n");
    uart_puts("  get_config                - Display device configuration\n");
    uart_puts("  reset                     - Reset device\n");
    uart_puts("  jtag_status               - Show JTAG status\n");
    uart_puts("  version                   - Show firmware version\n");
    uart_puts("  help                      - Show this help\n");
}

typedef struct {
    const char *name;
    void (*handler)(char *args);
} command_t;

const command_t commands[] = {
    {"dump_memory", cmd_dump_memory},
    {"read_flash", cmd_read_flash},
    {"get_config", cmd_get_config},
    {"reset", cmd_reset},
    {"jtag_status", cmd_jtag_status},
    {"version", cmd_version},
    {"help", cmd_help},
    {NULL, NULL}
};

void process_command(char *cmd) {
    char *args = NULL;
    
    for (int i = 0; cmd[i]; i++) {
        if (cmd[i] == ' ') {
            cmd[i] = '\0';
            args = &cmd[i + 1];
            break;
        }
    }
    
    for (int i = 0; commands[i].name != NULL; i++) {
        if (strcmp(cmd, commands[i].name) == 0) {
            commands[i].handler(args);
            return;
        }
    }
    
    uart_puts("Unknown command. Type 'help' for available commands.\n");
}

void console_init(void) {
    uart_init();
    jtag_init();
    
    uart_puts("\n\n");
    uart_puts("===========================================\n");
    uart_puts("  Industrial IoT Diagnostic Console\n");
    uart_puts("  Firmware Version: 1.0.0\n");
    uart_puts("  UART: 115200 8N1\n");
    uart_puts("  JTAG: Enabled\n");
    uart_puts("===========================================\n");
    uart_puts("Type 'help' for available commands.\n\n");
    uart_puts("> ");
}

void console_task(void) {
    if (uart_available()) {
        char c = uart_getc();
        
        if (c == '\r' || c == '\n') {
            uart_puts("\n");
            
            if (cmd_index > 0) {
                cmd_buffer[cmd_index] = '\0';
                process_command(cmd_buffer);
                cmd_index = 0;
            }
            
            uart_puts("> ");
        } else if (c == 127 || c == 8) {
            if (cmd_index > 0) {
                cmd_index--;
                uart_puts("\b \b");
            }
        } else if (cmd_index < MAX_CMD_LEN - 1) {
            cmd_buffer[cmd_index++] = c;
            uart_putc(c);
        }
    }
}

int main(void) {
    console_init();
    
    while (1) {
        console_task();
    }
    
    return 0;
}