# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/logging/log.h>
#include <string.h>

LOG_MODULE_REGISTER(privilege_system, LOG_LEVEL_INF);

#define ADMIN_STACK_SIZE 2048
#define USER_STACK_SIZE 1024
#define ADMIN_PRIORITY 5
#define USER_PRIORITY 7

#define FLASH_WRITE_SIZE 256
#define CONFIG_AREA_SIZE 4096
#define MAX_REQUESTS 10

typedef enum {
    PRIV_LEVEL_USER = 0,
    PRIV_LEVEL_ADMIN = 1
} privilege_level_t;

typedef enum {
    OP_FLASH_WRITE = 0,
    OP_CONFIG_MODIFY = 1,
    OP_SYSTEM_RESET = 2
} admin_operation_t;

typedef struct {
    admin_operation_t operation;
    uint32_t param1;
    uint32_t param2;
    void *data;
    size_t data_len;
    bool completed;
    int result;
} admin_request_t;

typedef struct {
    uint32_t system_mode;
    uint32_t debug_level;
    uint32_t timeout_ms;
    uint32_t flags;
    char device_name[32];
    uint32_t checksum;
} system_config_t;

K_MSGQ_DEFINE(admin_request_queue, sizeof(admin_request_t), MAX_REQUESTS, 4);
K_SEM_DEFINE(request_complete_sem, 0, 1);

static system_config_t system_config = {
    .system_mode = 1,
    .debug_level = 2,
    .timeout_ms = 5000,
    .flags = 0x0001,
    .device_name = "ZephyrDevice",
    .checksum = 0
};

static K_MUTEX_DEFINE(config_mutex);
static admin_request_t current_request;

static uint32_t calculate_config_checksum(system_config_t *config)
{
    uint32_t checksum = 0;
    uint8_t *ptr = (uint8_t *)config;
    size_t len = sizeof(system_config_t) - sizeof(uint32_t);
    
    for (size_t i = 0; i < len; i++) {
        checksum += ptr[i];
    }
    
    return checksum;
}

static bool check_privilege(privilege_level_t required_level, privilege_level_t current_level)
{
    return current_level >= required_level;
}

static int flash_write_operation(uint32_t offset, void *data, size_t len)
{
    const struct device *flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
    
    if (!device_is_ready(flash_dev)) {
        LOG_ERR("Flash device not ready");
        return -ENODEV;
    }
    
    LOG_INF("Admin: Writing %d bytes to flash at offset 0x%x", len, offset);
    
    int ret = flash_write(flash_dev, offset, data, len);
    if (ret != 0) {
        LOG_ERR("Flash write failed: %d", ret);
        return ret;
    }
    
    LOG_INF("Admin: Flash write completed successfully");
    return 0;
}

static int config_modify_operation(uint32_t config_field, uint32_t value)
{
    int ret = 0;
    
    k_mutex_lock(&config_mutex, K_FOREVER);
    
    LOG_INF("Admin: Modifying config field %d to value 0x%x", config_field, value);
    
    switch (config_field) {
        case 0:
            system_config.system_mode = value;
            break;
        case 1:
            system_config.debug_level = value;
            break;
        case 2:
            system_config.timeout_ms = value;
            break;
        case 3:
            system_config.flags = value;
            break;
        default:
            LOG_ERR("Invalid config field: %d", config_field);
            ret = -EINVAL;
            goto unlock;
    }
    
    system_config.checksum = calculate_config_checksum(&system_config);
    LOG_INF("Admin: Config modified, new checksum: 0x%x", system_config.checksum);
    
unlock:
    k_mutex_unlock(&config_mutex);
    return ret;
}

static int system_reset_operation(void)
{
    LOG_INF("Admin: System reset requested");
    LOG_INF("Admin: Resetting configuration to defaults");
    
    k_mutex_lock(&config_mutex, K_FOREVER);
    
    system_config.system_mode = 1;
    system_config.debug_level = 2;
    system_config.timeout_ms = 5000;
    system_config.flags = 0x0001;
    strcpy(system_config.device_name, "ZephyrDevice");
    system_config.checksum = calculate_config_checksum(&system_config);
    
    k_mutex_unlock(&config_mutex);
    
    LOG_INF("Admin: System reset completed");
    return 0;
}

static int execute_admin_operation(admin_request_t *request)
{
    int ret = 0;
    
    switch (request->operation) {
        case OP_FLASH_WRITE:
            ret = flash_write_operation(request->param1, request->data, request->data_len);
            break;
            
        case OP_CONFIG_MODIFY:
            ret = config_modify_operation(request->param1, request->param2);
            break;
            
        case OP_SYSTEM_RESET:
            ret = system_reset_operation();
            break;
            
        default:
            LOG_ERR("Unknown admin operation: %d", request->operation);
            ret = -EINVAL;
            break;
    }
    
    return ret;
}

static void admin_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);
    
    admin_request_t request;
    privilege_level_t admin_level = PRIV_LEVEL_ADMIN;
    
    LOG_INF("Admin task started with ADMIN privilege level");
    
    while (1) {
        if (k_msgq_get(&admin_request_queue, &request, K_FOREVER) == 0) {
            LOG_INF("Admin: Received request for operation %d", request.operation);
            
            if (check_privilege(PRIV_LEVEL_ADMIN, admin_level)) {
                LOG_INF("Admin: Privilege check passed, executing operation");
                request.result = execute_admin_operation(&request);
                request.completed = true;
                
                memcpy(&current_request, &request, sizeof(admin_request_t));
                k_sem_give(&request_complete_sem);
            } else {
                LOG_ERR("Admin: Privilege check failed");
                request.result = -EACCES;
                request.completed = true;
                memcpy(&current_request, &request, sizeof(admin_request_t));
                k_sem_give(&request_complete_sem);
            }
        }
    }
}

static int request_admin_operation(privilege_level_t user_level, admin_operation_t op, 
                                   uint32_t param1, uint32_t param2, void *data, size_t len)
{
    admin_request_t request = {
        .operation = op,
        .param1 = param1,
        .param2 = param2,
        .data = data,
        .data_len = len,
        .completed = false,
        .result = 0
    };
    
    LOG_INF("User: Requesting admin operation %d (user privilege: %d)", op, user_level);
    
    if (k_msgq_put(&admin_request_queue, &request, K_NO_WAIT) != 0) {
        LOG_ERR("User: Failed to queue admin request");
        return -ENOMEM;
    }
    
    LOG_INF("User: Waiting for admin operation to complete");
    if (k_sem_take(&request_complete_sem, K_SECONDS(10)) != 0) {
        LOG_ERR("User: Timeout waiting for admin operation");
        return -ETIMEDOUT;
    }
    
    LOG_INF("User: Admin operation completed with result: %d", current_request.result);
    return current_request.result;
}

static void user_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);
    
    privilege_level_t user_level = PRIV_LEVEL_USER;
    int ret;
    uint8_t flash_data[FLASH_WRITE_SIZE];
    
    LOG_INF("User task started with USER privilege level");
    
    k_sleep(K_SECONDS(1));
    
    for (int i = 0; i < FLASH_WRITE_SIZE; i++) {
        flash_data[i] = i & 0xFF;
    }
    
    LOG_INF("User: Attempting to request flash write operation");
    ret = request_admin_operation(user_level, OP_FLASH_WRITE, 0x1000, 0, 
                                  flash_data, FLASH_WRITE_SIZE);
    if (ret == 0) {
        LOG_INF("User: Flash write request succeeded");
    } else {
        LOG_ERR("User: Flash write request failed: %d", ret);
    }
    
    k_sleep(K_SECONDS(2));
    
    LOG_INF("User: Attempting to request config modification");
    ret = request_admin_operation(user_level, OP_CONFIG_MODIFY, 1, 5, NULL, 0);
    if (ret == 0) {
        LOG_INF("User: Config modification request succeeded");
    } else {
        LOG_ERR("User: Config modification request failed: %d", ret);
    }
    
    k_sleep(K_SECONDS(2));
    
    LOG_INF("User: Attempting to request system reset");
    ret = request_admin_operation(user_level, OP_SYSTEM_RESET, 0, 0, NULL, 0);
    if (ret == 0) {
        LOG_INF("User: System reset request succeeded");
    } else {
        LOG_ERR("User: System reset request failed: %d", ret);
    }
    
    k_sleep(K_SECONDS(2));
    
    LOG_INF("User: Displaying current system configuration");
    k_mutex_lock(&config_mutex, K_FOREVER);
    LOG_INF("  System Mode: %d", system_config.system_mode);
    LOG_INF("  Debug Level: %d", system_config.debug_level);
    LOG_INF("  Timeout (ms): %d", system_config.timeout_ms);
    LOG_INF("  Flags: 0x%04x", system_config.flags);
    LOG_INF("  Device Name: %s", system_config.device_name);
    LOG_INF("  Checksum: 0x%08x", system_config.checksum);
    k_mutex_unlock(&config_mutex);
    
    while (1) {
        k_sleep(K_SECONDS(5));
        
        LOG_INF("User: Periodic config modification request");
        uint32_t new_mode = (system_config.system_mode + 1) % 4;
        ret = request_admin_operation(user_level, OP_CONFIG_MODIFY, 0, new_mode, NULL, 0);
        
        if (ret == 0) {
            LOG_INF("User: Periodic request succeeded, new mode: %d", new_mode);
        }
    }
}

K_THREAD_DEFINE(admin_tid, ADMIN_STACK_SIZE, admin_task, NULL, NULL, NULL,
                ADMIN_PRIORITY, 0, 0);

K_THREAD_DEFINE(user_tid, USER_STACK_SIZE, user_task, NULL, NULL, NULL,
                USER_PRIORITY, 0, 0);

int main(void)
{
    LOG_INF("Zephyr Privilege System Application Started");
    LOG_INF("Initializing system configuration");
    
    system_config.checksum = calculate_config_checksum(&system_config);
    
    LOG_INF("System ready - Admin and User tasks running");
    
    return 0;
}