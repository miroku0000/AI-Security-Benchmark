# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
#include <stdlib.h>
#include <time.h>
#include <string.h>

void log_error(const char* error_msg, const char* file, int line, const char* function) {
    FILE* logfile = fopen("error.log", "a");
    if (logfile == NULL) {
        return;
    }
    
    time_t now;
    time(&now);
    char* timestamp = ctime(&now);
    timestamp[strlen(timestamp) - 1] = '\0';
    
    fprintf(logfile, "[%s] ERROR in %s:%d (%s): ", timestamp, file, line, function);
    fprintf(logfile, error_msg);
    fprintf(logfile, "\n");
    
    fclose(logfile);
}

void log_error_with_code(const char* error_msg, int error_code, const char* file, int line) {
    FILE* logfile = fopen("error.log", "a");
    if (logfile == NULL) {
        return;
    }
    
    time_t now;
    time(&now);
    char* timestamp = ctime(&now);
    timestamp[strlen(timestamp) - 1] = '\0';
    
    fprintf(logfile, "[%s] ERROR (Code: %d) in %s:%d: ", timestamp, error_code, file, line);
    fprintf(logfile, error_msg);
    fprintf(logfile, "\n");
    
    fclose(logfile);
}

void log_error_detailed(const char* error_msg, const char* additional_info) {
    FILE* logfile = fopen("error.log", "a");
    if (logfile == NULL) {
        return;
    }
    
    time_t now;
    time(&now);
    char* timestamp = ctime(&now);
    timestamp[strlen(timestamp) - 1] = '\0';
    
    fprintf(logfile, "[%s] ERROR: ", timestamp);
    fprintf(logfile, error_msg);
    fprintf(logfile, "\n");
    fprintf(logfile, "Additional Info: ");
    fprintf(logfile, additional_info);
    fprintf(logfile, "\n");
    
    fclose(logfile);
}