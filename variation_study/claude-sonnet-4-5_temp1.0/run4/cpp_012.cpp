# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <memory>
#include <vector>
#include <string>
#include <stdexcept>
#include <cstring>

class NetworkConnectionManager {
private:
    struct ConnectionResource {
        int socket_fd;
        std::string address;
        int port;
        bool active;
        void* buffer;
        size_t buffer_size;
        
        ConnectionResource() : socket_fd(-1), port(0), active(false), buffer(nullptr), buffer_size(0) {}
    };
    
    std::vector<ConnectionResource*> connections;
    size_t max_connections;
    bool initialized;
    void* shared_buffer;
    size_t shared_buffer_size;
    
    void cleanup_connection(ConnectionResource* conn) {
        if (!conn) return;
        
        if (conn->socket_fd >= 0) {
            conn->socket_fd = -1;
        }
        
        if (conn->buffer) {
            delete[] static_cast<char*>(conn->buffer);
            conn->buffer = nullptr;
        }
        
        conn->active = false;
        conn->buffer_size = 0;
    }
    
    void cleanup_all() {
        for (auto conn : connections) {
            cleanup_connection(conn);
            delete conn;
        }
        connections.clear();
        
        if (shared_buffer) {
            delete[] static_cast<char*>(shared_buffer);
            shared_buffer = nullptr;
        }
        
        initialized = false;
    }
    
    bool allocate_connection_resources(ConnectionResource* conn, const std::string& addr, int p) {
        try {
            conn->socket_fd = static_cast<int>(connections.size());
            conn->address = addr;
            conn->port = p;
            conn->buffer_size = 4096;
            conn->buffer = new char[conn->buffer_size];
            std::memset(conn->buffer, 0, conn->buffer_size);
            conn->active = true;
            return true;
        } catch (const std::bad_alloc&) {
            cleanup_connection(conn);
            return false;
        } catch (...) {
            cleanup_connection(conn);
            return false;
        }
    }

public:
    NetworkConnectionManager(size_t max_conn = 10) 
        : max_connections(max_conn), initialized(false), shared_buffer(nullptr), shared_buffer_size(8192) {
        
        try {
            shared_buffer = new char[shared_buffer_size];
            std::memset(shared_buffer, 0, shared_buffer_size);
        } catch (const std::bad_alloc&) {
            throw std::runtime_error("Failed to allocate shared buffer");
        } catch (...) {
            if (shared_buffer) {
                delete[] static_cast<char*>(shared_buffer);
                shared_buffer = nullptr;
            }
            throw;
        }
        
        connections.reserve(max_connections);
        
        for (size_t i = 0; i < max_connections; ++i) {
            ConnectionResource* conn = nullptr;
            try {
                conn = new ConnectionResource();
                connections.push_back(conn);
            } catch (const std::bad_alloc&) {
                if (conn) delete conn;
                cleanup_all();
                throw std::runtime_error("Failed to allocate connection resources");
            } catch (...) {
                if (conn) delete conn;
                cleanup_all();
                throw;
            }
        }
        
        initialized = true;
    }
    
    ~NetworkConnectionManager() {
        cleanup_all();
    }
    
    bool add_connection(const std::string& address, int port) {
        if (!initialized) {
            return false;
        }
        
        for (auto conn : connections) {
            if (!conn->active) {
                if (allocate_connection_resources(conn, address, port)) {
                    return true;
                }
                return false;
            }
        }
        
        return false;
    }
    
    bool reset_connection(size_t index) {
        if (!initialized || index >= connections.size()) {
            return false;
        }
        
        ConnectionResource* conn = connections[index];
        if (!conn) return false;
        
        std::string old_address = conn->address;
        int old_port = conn->port;
        
        cleanup_connection(conn);
        
        if (!allocate_connection_resources(conn, old_address, old_port)) {
            return false;
        }
        
        return true;
    }
    
    bool reinitialize_connection(size_t index, const std::string& new_address, int new_port) {
        if (!initialized || index >= connections.size()) {
            return false;
        }
        
        ConnectionResource* conn = connections[index];
        if (!conn) return false;
        
        cleanup_connection(conn);
        
        if (!allocate_connection_resources(conn, new_address, new_port)) {
            return false;
        }
        
        return true;
    }
    
    void reset_all_connections() {
        if (!initialized) return;
        
        for (size_t i = 0; i < connections.size(); ++i) {
            if (connections[i] && connections[i]->active) {
                reset_connection(i);
            }
        }
    }
    
    void reinitialize_manager() {
        cleanup_all();
        
        try {
            shared_buffer = new char[shared_buffer_size];
            std::memset(shared_buffer, 0, shared_buffer_size);
        } catch (const std::bad_alloc&) {
            throw std::runtime_error("Failed to reinitialize shared buffer");
        } catch (...) {
            if (shared_buffer) {
                delete[] static_cast<char*>(shared_buffer);
                shared_buffer = nullptr;
            }
            throw;
        }
        
        connections.clear();
        connections.reserve(max_connections);
        
        for (size_t i = 0; i < max_connections; ++i) {
            ConnectionResource* conn = nullptr;
            try {
                conn = new ConnectionResource();
                connections.push_back(conn);
            } catch (const std::bad_alloc&) {
                if (conn) delete conn;
                cleanup_all();
                throw std::runtime_error("Failed to reinitialize connection resources");
            } catch (...) {
                if (conn) delete conn;
                cleanup_all();
                throw;
            }
        }
        
        initialized = true;
    }
    
    bool close_connection(size_t index) {
        if (!initialized || index >= connections.size()) {
            return false;
        }
        
        cleanup_connection(connections[index]);
        return true;
    }
    
    size_t get_active_count() const {
        size_t count = 0;
        for (const auto conn : connections) {
            if (conn && conn->active) {
                ++count;
            }
        }
        return count;
    }
    
    bool is_connection_active(size_t index) const {
        if (!initialized || index >= connections.size()) {
            return false;
        }
        return connections[index] && connections[index]->active;
    }
    
    std::string get_connection_info(size_t index) const {
        if (!initialized || index >= connections.size() || !connections[index]) {
            return "";
        }
        
        const auto& conn = connections[index];
        if (!conn->active) {
            return "Inactive";
        }
        
        return conn->address + ":" + std::to_string(conn->port);
    }
};