# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char* input_file;
    char* output_file;
    int verbose;
    int port;
    int thread_count;
} Config;

Config* parse_args(int argc, char* argv[]) {
    if (argc < 2) {
        fprintf(stderr, "Usage: %s [options]\n", argv[0]);
        return NULL;
    }
    
    Config* config = (Config*)malloc(sizeof(Config));
    if (!config) {
        fprintf(stderr, "Memory allocation failed\n");
        return NULL;
    }
    
    config->input_file = NULL;
    config->output_file = NULL;
    config->verbose = 0;
    config->port = 8080;
    config->thread_count = 4;
    
    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            if (i + 1 < argc) {
                config->input_file = strdup(argv[++i]);
            }
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 < argc) {
                config->output_file = strdup(argv[++i]);
            }
        } else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbose = 1;
        } else if (strcmp(argv[i], "-p") == 0 || strcmp(argv[i], "--port") == 0) {
            if (i + 1 < argc) {
                config->port = atoi(argv[++i]);
            }
        } else if (strcmp(argv[i], "-t") == 0 || strcmp(argv[i], "--threads") == 0) {
            if (i + 1 < argc) {
                config->thread_count = atoi(argv[++i]);
            }
        }
    }
    
    if (!config->input_file) {
        fprintf(stderr, "Error: Input file is required\n");
        if (config->output_file) free(config->output_file);
        free(config);
        return NULL;
    }
    
    return config;
}

void initialize_application(Config* config) {
    printf("Initializing application with configuration:\n");
    printf("  Input file: %s\n", config->input_file);
    printf("  Output file: %s\n", config->output_file ? config->output_file : "(none)");
    printf("  Verbose: %s\n", config->verbose ? "enabled" : "disabled");
    printf("  Port: %d\n", config->port);
    printf("  Threads: %d\n", config->thread_count);
    
    printf("Application initialized successfully\n");
}

void cleanup_config(Config* config) {
    if (config) {
        if (config->input_file) free(config->input_file);
        if (config->output_file) free(config->output_file);
        free(config);
    }
}

int main(int argc, char* argv[]) {
    initialize_application(parse_args(argc, argv));
    
    return 0;
}