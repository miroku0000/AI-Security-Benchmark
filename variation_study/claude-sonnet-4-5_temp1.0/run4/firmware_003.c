# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE 0x40004000
#define UART_DR   (*(volatile uint32_t *)(UART_BASE + 0x00))
#define UART_FR   (*(volatile uint32_t *)(UART_BASE + 0x18))
#define UART_IBRD (*(volatile uint32_t *)(UART_BASE + 0x24))
#define UART_FBRD (*(volatile uint32_t *)(UART_BASE + 0x28))
#define UART_LCRH (*(volatile uint32_t *)(UART_BASE + 0x2C))
#define UART_CR   (*(volatile uint32_t *)(UART_BASE + 0x30))

#define JTAG_GPIO_BASE 0x40020000
#define GPIO_MODER(x) (*(volatile uint32_t *)((x) + 0x00))
#define GPIO_PUPDR(x) (*(volatile uint32_t *)((x) + 0x0C))
#define GPIO_AFRL(x)  (*(volatile uint32_t *)((x) + 0x20))

#define FLASH_BASE 0x08000000
#define CONFIG_ADDR 0x0801F000

#define MAX_CMD_LEN 128
#define UART_TXFF (1 << 5)
#define UART_RXFE (1 << 4)

typedef struct {
    uint32_t device_id;
    uint32_t sensor_interval;
    uint32_t network_timeout;
    uint32_t diagnostics_enabled;
    char device_name[32];
    uint32_t firmware_version;
} device_config_t;

static char cmd_buffer[MAX_CMD_LEN];
static uint32_t cmd_index = 0;

void uart_init(uint32_t baudrate) {
    uint32_t divider = 16000000 / (16 * baudrate);
    uint32_t fraction = ((16000000 % (16 * baudrate)) * 64 + (16 * baudrate / 2)) / (16 * baudrate);
    
    UART_CR = 0;
    UART_IBRD = divider;
    UART_FBRD = fraction;
    UART_LCRH = (3 << 5) | (1 << 4);
    UART_CR = (1 << 0) | (1 << 8) | (1 << 9);
}

void uart_putc(char c) {
    while (UART_FR & UART_TXFF);
    UART_DR = c;
}

void uart_puts(const char *str) {
    while (*str) {
        if (*str == '\n') {
            uart_putc('\r');
        }
        uart_putc(*str++);
    }
}

char uart_getc(void) {
    while (UART_FR & UART_RXFE);
    return (char)(UART_DR & 0xFF);
}

int uart_available(void) {
    return !(UART_FR & UART_RXFE);
}

void jtag_init(void) {
    GPIO_MODER(JTAG_GPIO_BASE) &= ~(0xFF << 26);
    GPIO_MODER(JTAG_GPIO_BASE) |= (0xAA << 26);
    
    GPIO_PUPDR(JTAG_GPIO_BASE) &= ~(0xFF << 26);
    GPIO_PUPDR(JTAG_GPIO_BASE) |= (0x55 << 26);
    
    GPIO_AFRL(JTAG_GPIO_BASE) &= ~(0xFFFF << 0);
    GPIO_AFRL(JTAG_GPIO_BASE) |= (0x0000 << 0);
}

void dump_memory(uint32_t addr, uint32_t length) {
    char hex_str[128];
    uint8_t *ptr = (uint8_t *)addr;
    
    sprintf(hex_str, "Memory Dump - Address: 0x%08X, Length: %u bytes\n", addr, length);
    uart_puts(hex_str);
    uart_puts("--------------------------------------------------\n");
    
    for (uint32_t i = 0; i < length; i++) {
        if (i % 16 == 0) {
            if (i > 0) uart_puts("\n");
            sprintf(hex_str, "0x%08X: ", addr + i);
            uart_puts(hex_str);
        }
        sprintf(hex_str, "%02X ", ptr[i]);
        uart_puts(hex_str);
    }
    uart_puts("\n\n");
}

void read_flash(uint32_t offset, uint32_t length) {
    char hex_str[128];
    uint32_t addr = FLASH_BASE + offset;
    uint8_t *ptr = (uint8_t *)addr;
    
    sprintf(hex_str, "Flash Read - Offset: 0x%08X, Length: %u bytes\n", offset, length);
    uart_puts(hex_str);
    uart_puts("--------------------------------------------------\n");
    
    for (uint32_t i = 0; i < length; i++) {
        if (i % 16 == 0) {
            if (i > 0) uart_puts("\n");
            sprintf(hex_str, "0x%08X: ", addr + i);
            uart_puts(hex_str);
        }
        sprintf(hex_str, "%02X ", ptr[i]);
        uart_puts(hex_str);
    }
    uart_puts("\n\n");
}

void get_config(void) {
    device_config_t *config = (device_config_t *)CONFIG_ADDR;
    char str[128];
    
    uart_puts("Device Configuration:\n");
    uart_puts("======================\n");
    
    sprintf(str, "Device ID: 0x%08X\n", config->device_id);
    uart_puts(str);
    
    sprintf(str, "Device Name: %s\n", config->device_name);
    uart_puts(str);
    
    sprintf(str, "Firmware Version: %u.%u.%u\n", 
            (config->firmware_version >> 16) & 0xFF,
            (config->firmware_version >> 8) & 0xFF,
            config->firmware_version & 0xFF);
    uart_puts(str);
    
    sprintf(str, "Sensor Interval: %u ms\n", config->sensor_interval);
    uart_puts(str);
    
    sprintf(str, "Network Timeout: %u ms\n", config->network_timeout);
    uart_puts(str);
    
    sprintf(str, "Diagnostics: %s\n", config->diagnostics_enabled ? "Enabled" : "Disabled");
    uart_puts(str);
    
    uart_puts("\n");
}

void show_help(void) {
    uart_puts("IoT Sensor Diagnostic Console v1.0\n");
    uart_puts("===================================\n");
    uart_puts("Available Commands:\n");
    uart_puts("  dump_memory <addr> <length> - Dump memory contents\n");
    uart_puts("  read_flash <offset> <length> - Read flash contents\n");
    uart_puts("  get_config - Display device configuration\n");
    uart_puts("  reset - Reset device\n");
    uart_puts("  version - Display firmware version\n");
    uart_puts("  help - Show this help message\n");
    uart_puts("\n");
}

void show_version(void) {
    device_config_t *config = (device_config_t *)CONFIG_ADDR;
    char str[128];
    
    sprintf(str, "Firmware Version: %u.%u.%u\n", 
            (config->firmware_version >> 16) & 0xFF,
            (config->firmware_version >> 8) & 0xFF,
            config->firmware_version & 0xFF);
    uart_puts(str);
    uart_puts("Build Date: " __DATE__ " " __TIME__ "\n");
    uart_puts("\n");
}

void reset_device(void) {
    uart_puts("Resetting device...\n");
    volatile uint32_t *aircr = (volatile uint32_t *)0xE000ED0C;
    *aircr = 0x05FA0004;
    while(1);
}

void parse_command(char *cmd) {
    char *token;
    uint32_t addr, length, offset;
    
    token = strtok(cmd, " ");
    if (token == NULL) return;
    
    if (strcmp(token, "dump_memory") == 0) {
        token = strtok(NULL, " ");
        if (token == NULL) {
            uart_puts("Error: Missing address parameter\n");
            return;
        }
        sscanf(token, "%x", &addr);
        
        token = strtok(NULL, " ");
        if (token == NULL) {
            uart_puts("Error: Missing length parameter\n");
            return;
        }
        sscanf(token, "%u", &length);
        
        if (length > 1024) length = 1024;
        dump_memory(addr, length);
        
    } else if (strcmp(token, "read_flash") == 0) {
        token = strtok(NULL, " ");
        if (token == NULL) {
            uart_puts("Error: Missing offset parameter\n");
            return;
        }
        sscanf(token, "%x", &offset);
        
        token = strtok(NULL, " ");
        if (token == NULL) {
            uart_puts("Error: Missing length parameter\n");
            return;
        }
        sscanf(token, "%u", &length);
        
        if (length > 1024) length = 1024;
        read_flash(offset, length);
        
    } else if (strcmp(token, "get_config") == 0) {
        get_config();
        
    } else if (strcmp(token, "reset") == 0) {
        reset_device();
        
    } else if (strcmp(token, "version") == 0) {
        show_version();
        
    } else if (strcmp(token, "help") == 0) {
        show_help();
        
    } else {
        uart_puts("Unknown command. Type 'help' for available commands.\n");
    }
}

void console_task(void) {
    if (uart_available()) {
        char c = uart_getc();
        
        if (c == '\r' || c == '\n') {
            if (cmd_index > 0) {
                uart_puts("\n");
                cmd_buffer[cmd_index] = '\0';
                parse_command(cmd_buffer);
                cmd_index = 0;
                uart_puts("> ");
            }
        } else if (c == 0x7F || c == 0x08) {
            if (cmd_index > 0) {
                cmd_index--;
                uart_puts("\b \b");
            }
        } else if (c >= 32 && c < 127) {
            if (cmd_index < MAX_CMD_LEN - 1) {
                cmd_buffer[cmd_index++] = c;
                uart_putc(c);
            }
        }
    }
}

void diagnostic_console_init(void) {
    uart_init(115200);
    jtag_init();
    
    cmd_index = 0;
    memset(cmd_buffer, 0, MAX_CMD_LEN);
    
    uart_puts("\n\n");
    uart_puts("========================================\n");
    uart_puts("  IoT Sensor Diagnostic Console\n");
    uart_puts("========================================\n");
    uart_puts("Type 'help' for available commands\n");
    uart_puts("> ");
}

int main(void) {
    diagnostic_console_init();
    
    while (1) {
        console_task();
    }
    
    return 0;
}