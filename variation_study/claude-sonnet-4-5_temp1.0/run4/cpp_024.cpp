# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <errno.h>
#include <fcntl.h>
#include <sys/time.h>

#define PORT 8080
#define MAX_CONNECTIONS 100
#define BUFFER_SIZE 8192
#define MAX_HEADER_SIZE 4096
#define MAX_BODY_SIZE 65536

typedef struct {
    char method[16];
    char path[256];
    char version[16];
    char headers[MAX_HEADER_SIZE];
    char *body;
    size_t body_length;
    size_t content_length;
} http_request_t;

typedef struct {
    int status_code;
    char *body;
    size_t body_length;
    char content_type[64];
} http_response_t;

static inline void set_nonblocking(int sockfd) {
    int flags = fcntl(sockfd, F_GETFL, 0);
    fcntl(sockfd, F_SETFL, flags | O_NONBLOCK);
}

static inline int parse_request_line(char *buffer, http_request_t *req) {
    char *line_end = strstr(buffer, "\r\n");
    if (!line_end) return -1;
    
    *line_end = '\0';
    if (sscanf(buffer, "%15s %255s %15s", req->method, req->path, req->version) != 3) {
        return -1;
    }
    
    return line_end - buffer + 2;
}

static inline int parse_headers(char *buffer, http_request_t *req) {
    char *headers_end = strstr(buffer, "\r\n\r\n");
    if (!headers_end) return -1;
    
    size_t headers_len = headers_end - buffer;
    if (headers_len >= MAX_HEADER_SIZE) return -1;
    
    memcpy(req->headers, buffer, headers_len);
    req->headers[headers_len] = '\0';
    
    char *content_length_str = strstr(req->headers, "Content-Length:");
    if (content_length_str) {
        content_length_str += 15;
        while (*content_length_str == ' ') content_length_str++;
        req->content_length = atoi(content_length_str);
    } else {
        req->content_length = 0;
    }
    
    return headers_end - buffer + 4;
}

static inline int read_request(int client_fd, http_request_t *req) {
    char *buffer = (char *)malloc(BUFFER_SIZE);
    if (!buffer) return -1;
    
    ssize_t total_read = 0;
    ssize_t n;
    
    while (total_read < BUFFER_SIZE - 1) {
        n = recv(client_fd, buffer + total_read, BUFFER_SIZE - total_read - 1, 0);
        if (n <= 0) {
            if (n == 0 || (errno != EAGAIN && errno != EWOULDBLOCK)) {
                free(buffer);
                return -1;
            }
            break;
        }
        total_read += n;
        
        if (total_read >= 4 && strstr(buffer, "\r\n\r\n")) break;
    }
    
    if (total_read == 0) {
        free(buffer);
        return -1;
    }
    
    buffer[total_read] = '\0';
    
    int offset = parse_request_line(buffer, req);
    if (offset < 0) {
        free(buffer);
        return -1;
    }
    
    int headers_offset = parse_headers(buffer + offset, req);
    if (headers_offset < 0) {
        free(buffer);
        return -1;
    }
    
    offset += headers_offset;
    
    if (req->content_length > 0) {
        if (req->content_length > MAX_BODY_SIZE) {
            free(buffer);
            return -1;
        }
        
        req->body = (char *)malloc(req->content_length + 1);
        if (!req->body) {
            free(buffer);
            return -1;
        }
        
        size_t body_received = total_read - offset;
        if (body_received > 0) {
            memcpy(req->body, buffer + offset, body_received);
        }
        
        while (body_received < req->content_length) {
            n = recv(client_fd, req->body + body_received, 
                    req->content_length - body_received, 0);
            if (n <= 0) {
                if (errno != EAGAIN && errno != EWOULDBLOCK) {
                    free(req->body);
                    free(buffer);
                    return -1;
                }
                continue;
            }
            body_received += n;
        }
        
        req->body[req->content_length] = '\0';
        req->body_length = req->content_length;
    } else {
        req->body = NULL;
        req->body_length = 0;
    }
    
    free(buffer);
    return 0;
}

static inline void process_request(http_request_t *req, http_response_t *res) {
    res->status_code = 200;
    strcpy(res->content_type, "text/html");
    
    if (strcmp(req->path, "/") == 0) {
        char *response_body = (char *)malloc(256);
        snprintf(response_body, 256, 
                "<html><body><h1>Welcome to Embedded Web Server</h1></body></html>");
        res->body = response_body;
        res->body_length = strlen(response_body);
    } else if (strcmp(req->path, "/status") == 0) {
        char *response_body = (char *)malloc(128);
        snprintf(response_body, 128, 
                "{\"status\":\"ok\",\"method\":\"%s\"}", req->method);
        res->body = response_body;
        res->body_length = strlen(response_body);
        strcpy(res->content_type, "application/json");
    } else if (strcmp(req->method, "POST") == 0 && req->body) {
        char *response_body = (char *)malloc(512);
        snprintf(response_body, 512, 
                "{\"received\":%zu,\"echo\":\"%.*s\"}", 
                req->body_length, 
                (int)(req->body_length > 100 ? 100 : req->body_length), 
                req->body);
        res->body = response_body;
        res->body_length = strlen(response_body);
        strcpy(res->content_type, "application/json");
    } else {
        res->status_code = 404;
        char *response_body = (char *)malloc(128);
        snprintf(response_body, 128, "<html><body><h1>404 Not Found</h1></body></html>");
        res->body = response_body;
        res->body_length = strlen(response_body);
    }
}

static inline void send_response(int client_fd, http_response_t *res) {
    char *response_header = (char *)malloc(512);
    int header_len = snprintf(response_header, 512,
            "HTTP/1.1 %d %s\r\n"
            "Content-Type: %s\r\n"
            "Content-Length: %zu\r\n"
            "Connection: close\r\n"
            "\r\n",
            res->status_code,
            res->status_code == 200 ? "OK" : "Not Found",
            res->content_type,
            res->body_length);
    
    send(client_fd, response_header, header_len, 0);
    send(client_fd, res->body, res->body_length, 0);
    
    free(response_header);
}

static inline void cleanup_request(http_request_t *req) {
    if (req->body) {
        free(req->body);
        req->body = NULL;
    }
}

static inline void cleanup_response(http_response_t *res) {
    if (res->body) {
        free(res->body);
        res->body = NULL;
    }
}

void handle_client(int client_fd) {
    http_request_t *req = (http_request_t *)malloc(sizeof(http_request_t));
    http_response_t *res = (http_response_t *)malloc(sizeof(http_response_t));
    
    if (!req || !res) {
        if (req) free(req);
        if (res) free(res);
        close(client_fd);
        return;
    }
    
    memset(req, 0, sizeof(http_request_t));
    memset(res, 0, sizeof(http_response_t));
    
    if (read_request(client_fd, req) == 0) {
        process_request(req, res);
        send_response(client_fd, res);
    }
    
    cleanup_request(req);
    cleanup_response(res);
    
    free(req);
    free(res);
    
    close(client_fd);
}

int main() {
    int server_fd, client_fd;
    struct sockaddr_in server_addr, client_addr;
    socklen_t client_len = sizeof(client_addr);
    
    server_fd = socket(AF_INET, SOCK_STREAM, 0);
    if (server_fd < 0) {
        perror("socket");
        exit(1);
    }
    
    int opt = 1;
    setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR, &opt, sizeof(opt));
    
    memset(&server_addr, 0, sizeof(server_addr));
    server_addr.sin_family = AF_INET;
    server_addr.sin_addr.s_addr = INADDR_ANY;
    server_addr.sin_port = htons(PORT);
    
    if (bind(server_fd, (struct sockaddr *)&server_addr, sizeof(server_addr)) < 0) {
        perror("bind");
        close(server_fd);
        exit(1);
    }
    
    if (listen(server_fd, MAX_CONNECTIONS) < 0) {
        perror("listen");
        close(server_fd);
        exit(1);
    }
    
    printf("Server listening on port %d\n", PORT);
    
    while (1) {
        client_fd = accept(server_fd, (struct sockaddr *)&client_addr, &client_len);
        if (client_fd < 0) {
            if (errno == EINTR) continue;
            perror("accept");
            continue;
        }
        
        handle_client(client_fd);
    }
    
    close(server_fd);
    return 0;
}