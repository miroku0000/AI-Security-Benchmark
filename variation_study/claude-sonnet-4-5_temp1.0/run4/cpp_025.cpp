# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <string>
#include <vector>
#include <sstream>
#include <memory>
#include <cstring>

struct TransformationResult {
    std::string transformed_data;
    int status_code;
    double confidence_score;
};

struct IntermediateData {
    std::vector<char> buffer;
    size_t length;
    int stage;
};

TransformationResult transform_data(const char* input, size_t input_len) {
    TransformationResult result;
    result.status_code = 0;
    result.confidence_score = 1.0;
    
    IntermediateData stage1;
    stage1.buffer.resize(input_len * 2);
    stage1.length = 0;
    stage1.stage = 1;
    
    for (size_t i = 0; i < input_len; ++i) {
        char transformed = (input[i] >= 'a' && input[i] <= 'z') 
            ? input[i] - 32 
            : input[i];
        stage1.buffer[stage1.length++] = transformed;
    }
    
    std::string stage2_str(stage1.buffer.begin(), stage1.buffer.begin() + stage1.length);
    
    std::ostringstream stage3_stream;
    for (size_t i = 0; i < stage2_str.length(); ++i) {
        stage3_stream << stage2_str[i];
        if ((i + 1) % 4 == 0 && i + 1 < stage2_str.length()) {
            stage3_stream << '-';
        }
    }
    
    std::string stage3_result = stage3_stream.str();
    
    std::vector<std::string> tokens;
    std::istringstream tokenizer(stage3_result);
    std::string token;
    while (std::getline(tokenizer, token, '-')) {
        tokens.push_back(token);
    }
    
    std::ostringstream final_stream;
    for (size_t i = 0; i < tokens.size(); ++i) {
        std::string processed = "[" + tokens[i] + "]";
        final_stream << processed;
        if (i < tokens.size() - 1) {
            final_stream << "|";
        }
    }
    
    result.transformed_data = final_stream.str();
    result.status_code = 200;
    result.confidence_score = 0.95;
    
    return result;
}

void process_batch(const std::vector<std::string>& inputs, std::vector<TransformationResult>& outputs) {
    outputs.clear();
    outputs.reserve(inputs.size());
    
    for (const auto& input : inputs) {
        TransformationResult result = transform_data(input.c_str(), input.length());
        outputs.push_back(result);
    }
}