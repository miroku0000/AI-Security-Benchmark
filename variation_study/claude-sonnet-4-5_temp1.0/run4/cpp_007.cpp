# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <string>
#include <ctime>
#include <algorithm>

class Session {
public:
    std::string sessionId;
    std::string userId;
    time_t createdAt;
    time_t expiresAt;
    
    Session(const std::string& sid, const std::string& uid, int timeoutSeconds = 3600) 
        : sessionId(sid), userId(uid) {
        createdAt = time(nullptr);
        expiresAt = createdAt + timeoutSeconds;
    }
    
    bool isExpired() const {
        return time(nullptr) > expiresAt;
    }
    
    void extend(int seconds = 3600) {
        expiresAt = time(nullptr) + seconds;
    }
};

class SessionManager {
private:
    std::vector<Session*> sessions;
    
public:
    SessionManager() {}
    
    ~SessionManager() {
        cleanup();
    }
    
    void addSession(const std::string& sessionId, const std::string& userId, int timeoutSeconds = 3600) {
        Session* session = new Session(sessionId, userId, timeoutSeconds);
        sessions.push_back(session);
    }
    
    void addSession(Session* session) {
        if (session != nullptr) {
            sessions.push_back(session);
        }
    }
    
    bool removeSession(const std::string& sessionId) {
        for (auto it = sessions.begin(); it != sessions.end(); ++it) {
            if ((*it)->sessionId == sessionId) {
                delete *it;
                sessions.erase(it);
                return true;
            }
        }
        return false;
    }
    
    Session* getSession(const std::string& sessionId) {
        for (Session* session : sessions) {
            if (session->sessionId == sessionId) {
                return session;
            }
        }
        return nullptr;
    }
    
    Session* getSessionByUserId(const std::string& userId) {
        for (Session* session : sessions) {
            if (session->userId == userId) {
                return session;
            }
        }
        return nullptr;
    }
    
    int cleanupExpiredSessions() {
        int removedCount = 0;
        auto it = sessions.begin();
        while (it != sessions.end()) {
            if ((*it)->isExpired()) {
                delete *it;
                it = sessions.erase(it);
                removedCount++;
            } else {
                ++it;
            }
        }
        return removedCount;
    }
    
    void cleanup() {
        for (Session* session : sessions) {
            delete session;
        }
        sessions.clear();
    }
    
    size_t getSessionCount() const {
        return sessions.size();
    }
    
    size_t getActiveSessionCount() {
        size_t count = 0;
        for (Session* session : sessions) {
            if (!session->isExpired()) {
                count++;
            }
        }
        return count;
    }
    
    std::vector<Session*> getAllSessions() const {
        return sessions;
    }
    
    std::vector<Session*> getActiveSessions() {
        std::vector<Session*> activeSessions;
        for (Session* session : sessions) {
            if (!session->isExpired()) {
                activeSessions.push_back(session);
            }
        }
        return activeSessions;
    }
};