# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct FileHandleNode {
    FILE *file;
    char *filename;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct {
    FileHandleNode *head;
    int count;
} FileHandleList;

FileHandleList* create_file_handle_list() {
    FileHandleList *list = (FileHandleList*)malloc(sizeof(FileHandleList));
    if (list) {
        list->head = NULL;
        list->count = 0;
    }
    return list;
}

int add_file_handle(FileHandleList *list, FILE *file, const char *filename) {
    if (!list || !file || !filename) {
        return -1;
    }

    FileHandleNode *node = (FileHandleNode*)malloc(sizeof(FileHandleNode));
    if (!node) {
        return -1;
    }

    node->file = file;
    node->filename = (char*)malloc(strlen(filename) + 1);
    if (!node->filename) {
        free(node);
        return -1;
    }
    strcpy(node->filename, filename);

    node->next = list->head;
    list->head = node;
    list->count++;

    return 0;
}

int remove_file_handle(FileHandleList *list, FILE *file) {
    if (!list || !file) {
        return -1;
    }

    FileHandleNode *current = list->head;
    FileHandleNode *prev = NULL;

    while (current) {
        if (current->file == file) {
            if (prev) {
                prev->next = current->next;
            } else {
                list->head = current->next;
            }

            if (current->file) {
                fclose(current->file);
            }
            free(current->filename);
            free(current);
            list->count--;
            return 0;
        }
        prev = current;
        current = current->next;
    }

    return -1;
}

int remove_file_handle_by_name(FileHandleList *list, const char *filename) {
    if (!list || !filename) {
        return -1;
    }

    FileHandleNode *current = list->head;
    FileHandleNode *prev = NULL;

    while (current) {
        if (strcmp(current->filename, filename) == 0) {
            if (prev) {
                prev->next = current->next;
            } else {
                list->head = current->next;
            }

            if (current->file) {
                fclose(current->file);
            }
            free(current->filename);
            free(current);
            list->count--;
            return 0;
        }
        prev = current;
        current = current->next;
    }

    return -1;
}

void cleanup_file_handles(FileHandleList *list) {
    if (!list) {
        return;
    }

    FileHandleNode *current = list->head;
    FileHandleNode *next;

    while (current) {
        next = current->next;
        
        if (current->file) {
            fclose(current->file);
            current->file = NULL;
        }
        
        if (current->filename) {
            free(current->filename);
            current->filename = NULL;
        }
        
        free(current);
        current = next;
    }

    list->head = NULL;
    list->count = 0;
}

void destroy_file_handle_list(FileHandleList *list) {
    if (!list) {
        return;
    }
    
    cleanup_file_handles(list);
    free(list);
}

int get_file_handle_count(FileHandleList *list) {
    if (!list) {
        return 0;
    }
    return list->count;
}

FILE* find_file_handle(FileHandleList *list, const char *filename) {
    if (!list || !filename) {
        return NULL;
    }

    FileHandleNode *current = list->head;
    while (current) {
        if (strcmp(current->filename, filename) == 0) {
            return current->file;
        }
        current = current->next;
    }

    return NULL;
}

void print_file_handles(FileHandleList *list) {
    if (!list) {
        printf("List is NULL\n");
        return;
    }

    printf("File Handle List (count: %d):\n", list->count);
    FileHandleNode *current = list->head;
    int index = 0;
    while (current) {
        printf("  [%d] %s (file: %p)\n", index++, current->filename, (void*)current->file);
        current = current->next;
    }
}

int main() {
    FileHandleList *list = create_file_handle_list();
    
    FILE *f1 = fopen("test1.txt", "w");
    FILE *f2 = fopen("test2.txt", "w");
    FILE *f3 = fopen("test3.txt", "w");
    
    if (f1) add_file_handle(list, f1, "test1.txt");
    if (f2) add_file_handle(list, f2, "test2.txt");
    if (f3) add_file_handle(list, f3, "test3.txt");
    
    printf("After adding 3 files:\n");
    print_file_handles(list);
    
    remove_file_handle_by_name(list, "test2.txt");
    
    printf("\nAfter removing test2.txt:\n");
    print_file_handles(list);
    
    printf("\nCalling cleanup (first time):\n");
    cleanup_file_handles(list);
    print_file_handles(list);
    
    printf("\nCalling cleanup (second time - should be safe):\n");
    cleanup_file_handles(list);
    print_file_handles(list);
    
    destroy_file_handle_list(list);
    
    return 0;
}