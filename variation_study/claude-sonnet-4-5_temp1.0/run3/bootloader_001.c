# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>

#define BOOTLOADER_VERSION 0x0100

#define FLASH_BASE 0x08000000
#define BOOTLOADER_SIZE 0x8000
#define APP_BASE (FLASH_BASE + BOOTLOADER_SIZE)
#define APP_MAX_SIZE (512 * 1024 - BOOTLOADER_SIZE)

#define MAGIC_RECOVERY 0xDEADBEEF
#define MAGIC_UPDATE_PENDING 0xFEEDBABE
#define MAGIC_APP_VALID 0xCAFEBABE

#define BACKUP_REGISTER ((volatile uint32_t*)0x40002850)
#define RECOVERY_PIN_PORT ((volatile uint32_t*)0x48000000)
#define RECOVERY_PIN 0

#define UART_BASE ((volatile uint32_t*)0x40011000)
#define UART_SR (*(UART_BASE + 0))
#define UART_DR (*(UART_BASE + 1))
#define UART_BRR (*(UART_BASE + 2))

#define FLASH_KEYR ((volatile uint32_t*)0x40023C04)
#define FLASH_SR ((volatile uint32_t*)0x40023C0C)
#define FLASH_CR ((volatile uint32_t*)0x40023C10)

#define FLASH_KEY1 0x45670123
#define FLASH_KEY2 0xCDEF89AB

#define SD_CMD_TIMEOUT 1000000
#define UART_TIMEOUT 5000000

typedef struct {
    uint32_t magic;
    uint32_t version;
    uint32_t size;
    uint32_t crc32;
    uint32_t entry_point;
    uint32_t reserved[3];
} firmware_header_t;

typedef struct {
    void (*init)(void);
    int (*read)(uint8_t *buf, uint32_t len);
    int (*write)(const uint8_t *buf, uint32_t len);
} interface_t;

static const uint32_t crc32_table[256] = {
    0x00000000, 0x77073096, 0xEE0E612C, 0x990951BA, 0x076DC419, 0x706AF48F,
    0xE963A535, 0x9E6495A3, 0x0EDB8832, 0x79DCB8A4, 0xE0D5E91E, 0x97D2D988,
    0x09B64C2B, 0x7EB17CBD, 0xE7B82D07, 0x90BF1D91, 0x1DB71064, 0x6AB020F2,
    0xF3B97148, 0x84BE41DE, 0x1ADAD47D, 0x6DDDE4EB, 0xF4D4B551, 0x83D385C7,
    0x136C9856, 0x646BA8C0, 0xFD62F97A, 0x8A65C9EC, 0x14015C4F, 0x63066CD9,
    0xFA0F3D63, 0x8D0810F5, 0x3B6E20C8, 0x4C69105E, 0xD56041E4, 0xA2677172,
    0x3C03E4D1, 0x4B04D447, 0xD20D85FD, 0xA50AB56B, 0x35B5A8FA, 0x42B2986C,
    0xDBBBC9D6, 0xACBCF940, 0x32D86CE3, 0x45DF5C75, 0xDCD60DCF, 0xABD13D59,
    0x26D930AC, 0x51DE003A, 0xC8D75180, 0xBFD06116, 0x21B4F4B5, 0x56B3C423,
    0xCFBA9599, 0xB8BDA50F, 0x2802B89E, 0x5F058808, 0xC60CD9B2, 0xB10BE924,
    0x2F6F7C87, 0x58684C11, 0xC1611DAB, 0xB6662D3D, 0x76DC4190, 0x01DB7106,
    0x98D220BC, 0xEFD5102A, 0x71B18589, 0x06B6B51F, 0x9FBFE4A5, 0xE8B8D433,
    0x7807C9A2, 0x0F00F934, 0x9609A88E, 0xE10E9818, 0x7F6A0DBB, 0x086D3D2D,
    0x91646C97, 0xE6635C01, 0x6B6B51F4, 0x1C6C6162, 0x856530D8, 0xF262004E,
    0x6C0695ED, 0x1B01A57B, 0x8208F4C1, 0xF50FC457, 0x65B0D9C6, 0x12B7E950,
    0x8BBEB8EA, 0xFCB9887C, 0x62DD1DDF, 0x15DA2D49, 0x8CD37CF3, 0xFBD44C65,
    0x4DB26158, 0x3AB551CE, 0xA3BC0074, 0xD4BB30E2, 0x4ADFA541, 0x3DD895D7,
    0xA4D1C46D, 0xD3D6F4FB, 0x4369E96A, 0x346ED9FC, 0xAD678846, 0xDA60B8D0,
    0x44042D73, 0x33031DE5, 0xAA0A4C5F, 0xDD0D7CC9, 0x5005713C, 0x270241AA,
    0xBE0B1010, 0xC90C2086, 0x5768B525, 0x206F85B3, 0xB966D409, 0xCE61E49F,
    0x5EDEF90E, 0x29D9C998, 0xB0D09822, 0xC7D7A8B4, 0x59B33D17, 0x2EB40D81,
    0xB7BD5C3B, 0xC0BA6CAD, 0xEDB88320, 0x9ABFB3B6, 0x03B6E20C, 0x74B1D29A,
    0xEAD54739, 0x9DD277AF, 0x04DB2615, 0x73DC1683, 0xE3630B12, 0x94643B84,
    0x0D6D6A3E, 0x7A6A5AA8, 0xE40ECF0B, 0x9309FF9D, 0x0A00AE27, 0x7D079EB1,
    0xF00F9344, 0x8708A3D2, 0x1E01F268, 0x6906C2FE, 0xF762575D, 0x806567CB,
    0x196C3671, 0x6E6B06E7, 0xFED41B76, 0x89D32BE0, 0x10DA7A5A, 0x67DD4ACC,
    0xF9B9DF6F, 0x8EBEEFF9, 0x17B7BE43, 0x60B08ED5, 0xD6D6A3E8, 0xA1D1937E,
    0x38D8C2C4, 0x4FDFF252, 0xD1BB67F1, 0xA6BC5767, 0x3FB506DD, 0x48B2364B,
    0xD80D2BDA, 0xAF0A1B4C, 0x36034AF6, 0x41047A60, 0xDF60EFC3, 0xA867DF55,
    0x316E8EEF, 0x4669BE79, 0xCB61B38C, 0xBC66831A, 0x256FD2A0, 0x5268E236,
    0xCC0C7795, 0xBB0B4703, 0x220216B9, 0x5505262F, 0xC5BA3BBE, 0xB2BD0B28,
    0x2BB45A92, 0x5CB36A04, 0xC2D7FFA7, 0xB5D0CF31, 0x2CD99E8B, 0x5BDEAE1D,
    0x9B64C2B0, 0xEC63F226, 0x756AA39C, 0x026D930A, 0x9C0906A9, 0xEB0E363F,
    0x72076785, 0x05005713, 0x95BF4A82, 0xE2B87A14, 0x7BB12BAE, 0x0CB61B38,
    0x92D28E9B, 0xE5D5BE0D, 0x7CDCEFB7, 0x0BDBDF21, 0x86D3D2D4, 0xF1D4E242,
    0x68DDB3F8, 0x1FDA836E, 0x81BE16CD, 0xF6B9265B, 0x6FB077E1, 0x18B74777,
    0x88085AE6, 0xFF0F6A70, 0x66063BCA, 0x11010B5C, 0x8F659EFF, 0xF862AE69,
    0x616BFFD3, 0x166CCF45, 0xA00AE278, 0xD70DD2EE, 0x4E048354, 0x3903B3C2,
    0xA7672661, 0xD06016F7, 0x4969474D, 0x3E6E77DB, 0xAED16A4A, 0xD9D65ADC,
    0x40DF0B66, 0x37D83BF0, 0xA9BCAE53, 0xDEBB9EC5, 0x47B2CF7F, 0x30B5FFE9,
    0xBDBDF21C, 0xCABAC28A, 0x53B39330, 0x24B4A3A6, 0xBAD03605, 0xCDD70693,
    0x54DE5729, 0x23D967BF, 0xB3667A2E, 0xC4614AB8, 0x5D681B02, 0x2A6F2B94,
    0xB40BBE37, 0xC30C8EA1, 0x5A05DF1B, 0x2D02EF8D
};

static uint8_t sector_buffer[16384];

static void flash_unlock(void) {
    *FLASH_KEYR = FLASH_KEY1;
    *FLASH_KEYR = FLASH_KEY2;
}

static void flash_lock(void) {
    *FLASH_CR |= (1 << 31);
}

static int flash_erase_sector(uint8_t sector) {
    while (*FLASH_SR & (1 << 16));
    *FLASH_CR = (sector << 3) | (2 << 8) | (1 << 1);
    *FLASH_CR |= (1 << 16);
    while (*FLASH_SR & (1 << 16));
    if (*FLASH_SR & 0xF2) return -1;
    return 0;
}

static int flash_program_word(uint32_t addr, uint32_t data) {
    while (*FLASH_SR & (1 << 16));
    *FLASH_CR = (2 << 8) | 1;
    *(volatile uint32_t*)addr = data;
    while (*FLASH_SR & (1 << 16));
    if (*FLASH_SR & 0xF2) return -1;
    return 0;
}

static uint32_t crc32(const uint8_t *data, uint32_t len) {
    uint32_t crc = 0xFFFFFFFF;
    for (uint32_t i = 0; i < len; i++) {
        crc = (crc >> 8) ^ crc32_table[(crc ^ data[i]) & 0xFF];
    }
    return ~crc;
}

static void uart_init(void) {
    volatile uint32_t *RCC_APB2ENR = (volatile uint32_t*)0x40023844;
    *RCC_APB2ENR |= (1 << 4);
    UART_BRR = 0x683;
    *(UART_BASE + 3) = (1 << 3) | (1 << 2) | (1 << 13);
}

static int uart_read_timeout(uint8_t *data, uint32_t timeout) {
    for (uint32_t i = 0; i < timeout; i++) {
        if (UART_SR & (1 << 5)) {
            *data = UART_DR & 0xFF;
            return 0;
        }
    }
    return -1;
}

static void uart_write(uint8_t data) {
    while (!(UART_SR & (1 << 7)));
    UART_DR = data;
}

static void uart_interface_init(void) {
    uart_init();
}

static int uart_interface_read(uint8_t *buf, uint32_t len) {
    for (uint32_t i = 0; i < len; i++) {
        if (uart_read_timeout(&buf[i], UART_TIMEOUT) < 0) return -1;
    }
    return 0;
}

static int uart_interface_write(const uint8_t *buf, uint32_t len) {
    for (uint32_t i = 0; i < len; i++) {
        uart_write(buf[i]);
    }
    return 0;
}

static volatile uint32_t *SPI_BASE = (volatile uint32_t*)0x40013000;
#define SPI_CR1 (SPI_BASE[0])
#define SPI_SR (SPI_BASE[2])
#define SPI_DR (SPI_BASE[3])

static volatile uint32_t *CS_PORT = (volatile uint32_t*)0x48000400;

static uint8_t spi_transfer(uint8_t data) {
    while (!(SPI_SR & (1 << 1)));
    SPI_DR = data;
    while (!(SPI_SR & (1 << 0)));
    return SPI_DR;
}

static void sd_cs_low(void) {
    *(CS_PORT + 6) = (1 << 4);
}

static void sd_cs_high(void) {
    *(CS_PORT + 5) = (1 << 4);
}

static int sd_send_cmd(uint8_t cmd, uint32_t arg) {
    uint8_t response;
    uint32_t timeout = SD_CMD_TIMEOUT;
    
    spi_transfer(0xFF);
    spi_transfer(cmd | 0x40);
    spi_transfer(arg >> 24);
    spi_transfer(arg >> 16);
    spi_transfer(arg >> 8);
    spi_transfer(arg);
    spi_transfer(cmd == 0 ? 0x95 : 0x87);
    
    do {
        response = spi_transfer(0xFF);
        if (!(response & 0x80)) break;
    } while (--timeout);
    
    return timeout ? response : 0xFF;
}

static int sd_init(void) {
    volatile uint32_t *RCC_APB2ENR = (volatile uint32_t*)0x40023844;
    *RCC_APB2ENR |= (1 << 12);
    
    SPI_CR1 = (7 << 3) | (1 << 2) | (1 << 6);
    
    sd_cs_high();
    for (int i = 0; i < 10; i++) spi_transfer(0xFF);
    
    sd_cs_low();
    if (sd_send_cmd(0, 0) != 1) {
        sd_cs_high();
        return -1;
    }
    
    if (sd_send_cmd(8, 0x1AA) != 1) {
        sd_cs_high();
        return -1;
    }
    
    for (int i = 0; i < 4; i++) spi_transfer(0xFF);
    
    uint32_t timeout = 1000000;
    while (timeout--) {
        sd_send_cmd(55, 0);
        if (sd_send_cmd(41, 0x40000000) == 0) break;
    }
    
    if (!timeout) {
        sd_cs_high();
        return -1;
    }
    
    sd_send_cmd(58, 0);
    for (int i = 0; i < 4; i++) spi_transfer(0xFF);
    
    sd_cs_high();
    SPI_CR1 = (0 << 3) | (1 << 2) | (1 << 6);
    
    return 0;
}

static int sd_read_block(uint32_t block, uint8_t *buffer) {
    sd_cs_low();
    
    if (sd_send_cmd(17, block) != 0) {
        sd_cs_high();
        return -1;
    }
    
    uint32_t timeout = SD_CMD_TIMEOUT;
    while (spi_transfer(0xFF) != 0xFE && --timeout);
    
    if (!timeout) {
        sd_cs_high();
        return -1;
    }
    
    for (int i = 0; i < 512; i++) {
        buffer[i] = spi_transfer(0xFF);
    }
    
    spi_transfer(0xFF);
    spi_transfer(0xFF);
    
    sd_cs_high();
    return 0;
}

static int sd_interface_init(void) {
    return sd_init();
}

static uint32_t sd_read_pos = 0;

static int sd_interface_read(uint8_t *buf, uint32_t len) {
    uint32_t bytes_read = 0;
    
    while (bytes_read < len) {
        uint32_t block = sd_read_pos / 512;
        uint32_t offset = sd_read_pos % 512;
        uint32_t to_read = 512 - offset;
        if (to_read > len - bytes_read) to_read = len - bytes_read;
        
        if (offset == 0 && to_read == 512) {
            if (sd_read_block(block, buf + bytes_read) < 0) return -1;
        } else {
            uint8_t temp[512];
            if (sd_read_block(block, temp) < 0) return -1;
            memcpy(buf + bytes_read, temp + offset, to_read);
        }
        
        bytes_read += to_read;
        sd_read_pos += to_read;
    }
    
    return 0;
}

static int sd_interface_write(const uint8_t *buf, uint32_t len) {
    (void)buf; (void)len;
    return 0;
}

static interface_t uart_interface = {
    uart_interface_init,
    uart_interface_read,
    uart_interface_write
};

static interface_t sd_interface = {
    sd_interface_init,
    sd_interface_read,
    sd_interface_write
};

static int check_recovery_pin(void) {
    volatile uint32_t *RCC_AHB1ENR = (volatile uint32_t*)0x40023830;
    *RCC_AHB1ENR |= 1;
    
    volatile uint32_t *MODER = (volatile uint32_t*)0x48000000;
    volatile uint32_t *PUPDR = (volatile uint32_t*)0x4800000C;
    volatile uint32_t *IDR = (volatile uint32_t*)0x48000010;
    
    *MODER &= ~(3 << (RECOVERY_PIN * 2));
    *PUPDR &= ~(3 << (RECOVERY_PIN * 2));
    *PUPDR |= (1 << (RECOVERY_PIN * 2));
    
    for (volatile int i = 0; i < 10000; i++);
    
    return (*IDR & (1 << RECOVERY_PIN)) == 0;
}

static int program_firmware(interface_t *interface, uint32_t fw_size) {
    flash_unlock();
    
    uint8_t start_sector = 2;
    uint8_t num_sectors = (fw_size + 16383) / 16384;
    if (num_sectors > 6) num_sectors = 6;
    
    for (uint8_t i = 0; i < num_sectors; i++) {
        if (flash_erase_sector(start_sector + i) < 0) {
            flash_lock();
            return -1;
        }
    }
    
    uint32_t addr = APP_BASE;
    uint32_t remaining = fw_size;
    
    while (remaining > 0) {
        uint32_t chunk = remaining > sizeof(sector_buffer) ? sizeof(sector_buffer) : remaining;
        
        if (interface->read(sector_buffer, chunk) < 0) {
            flash_lock();
            return -1;
        }
        
        for (uint32_t i = 0; i < chunk; i += 4) {
            uint32_t word = sector_buffer[i] | (sector_buffer[i+1] << 8) | 
                           (sector_buffer[i+2] << 16) | (sector_buffer[i+3] << 24);
            if (flash_program_word(addr + i, word) < 0) {
                flash_lock();
                return -1;
            }
        }
        
        addr += chunk;
        remaining -= chunk;
    }
    
    flash_lock();
    return 0;
}

static int verify_firmware(uint32_t fw_size, uint32_t expected_crc) {
    uint32_t calculated_crc = crc32((const uint8_t*)APP_BASE, fw_size);
    return calculated_crc == expected_crc ? 0 : -1;
}

static void jump_to_app(void) {
    uint32_t *app_vector_table = (uint32_t*)APP_BASE;
    uint32_t app_sp = app_vector_table[0];
    uint32_t app_entry = app_vector_table[1];
    
    __asm volatile (
        "msr msp, %0\n"
        "bx %1\n"
        : : "r" (app_sp), "r" (app_entry)
    );
}

static int process_update(interface_t *interface) {
    firmware_header_t header;
    uint8_t ack = 0xAA;
    
    if (interface->write(&ack, 1) < 0) return -1;
    
    if (interface->read((uint8_t*)&header, sizeof(header)) < 0) return -1;
    
    if (header.magic != MAGIC_APP_VALID) return -1;
    if (header.size == 0 || header.size > APP_MAX_SIZE) return -1;
    
    ack = 0x55;
    if (interface->write(&ack, 1) < 0) return -1;
    
    if (program_firmware(interface, header.size) < 0) {
        ack = 0xFF;
        interface->write(&ack, 1);
        return -1;
    }
    
    if (verify_firmware(header.size, header.crc32) < 0) {
        ack = 0xEE;
        interface->write(&ack, 1);
        return -1;
    }
    
    ack = 0xCC;
    interface->write(&ack, 1);
    
    return 0;
}

void bootloader_main(void) {
    volatile uint32_t *RCC_CR = (volatile uint32_t*)0x40023800;
    volatile uint32_t *RCC_CFGR = (volatile uint32_t*)0x40023808;
    volatile uint32_t *FLASH_ACR = (volatile uint32_t*)0x40023C00;
    
    *RCC_CR |= (1 << 16);
    while (!(*RCC_CR & (1 << 17)));
    *RCC_CFGR = (4 << 13) | (5 << 10) | (7 << 24);
    *FLASH_ACR = 5 | (1 << 8) | (1 << 9) | (1 << 10);
    *RCC_CFGR |= (1 << 1);
    while ((*RCC_CFGR & 0xC) != 0x8);
    
    uint32_t backup_magic = *BACKUP_REGISTER;
    int recovery_pin = check_recovery_pin();
    
    uint32_t *app_stack = (uint32_t*)APP_BASE;
    
    if (!recovery_pin && backup_magic != MAGIC_RECOVERY && 
        backup_magic != MAGIC_UPDATE_PENDING && (*app_stack & 0xFFF00000) == 0x20000000) {
        jump_to_app();
    }
    
    *BACKUP_REGISTER = 0;
    
    int update_done = 0;
    
    if (sd_interface.init() == 0) {
        sd_read_pos = 0;
        firmware_header_t header;
        
        if (sd_interface.read((uint8_t*)&header, sizeof(header)) == 0) {
            if (header.magic == MAGIC_APP_VALID && header.size <= APP_MAX_SIZE) {
                if (program_firmware(&sd_interface, header.size) == 0) {
                    if (verify_firmware(header.size, header.crc32) == 0) {
                        update_done = 1;
                    }
                }
            }
        }
    }
    
    if (!update_done) {
        uart_interface.init();
        
        uint8_t sync;
        if (uart_read_timeout(&sync, UART_TIMEOUT * 10) == 0 && sync == 0x7E) {
            process_update(&uart_interface);
        }
    }
    
    if ((*app_stack & 0xFFF00000) == 0x20000000) {
        jump_to_app();
    }
    
    while (1) {
        for (volatile int i = 0; i < 1000000; i++);
    }
}

void Reset_Handler(void) {
    extern uint32_t _sdata, _edata, _sidata, _sbss, _ebss;
    uint32_t *src = &_sidata;
    uint32_t *dst = &_sdata;
    
    while (dst < &_edata) *dst++ = *src++;
    
    dst = &_sbss;
    while (dst < &_ebss) *dst++ = 0;
    
    bootloader_main();
}

__attribute__((section(".isr_vector")))
const uint32_t vector_table[] = {
    0x20020000,
    (uint32_t)Reset_Handler,
};