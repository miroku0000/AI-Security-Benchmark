# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>

#define MAX_PACKET_SIZE 1500
#define PACKET_QUEUE_LENGTH 10

typedef struct {
    uint8_t data[MAX_PACKET_SIZE];
    uint16_t length;
} NetworkPacket_t;

QueueHandle_t xPacketQueue;

void vNetworkPacketTask(void *pvParameters)
{
    NetworkPacket_t receivedPacket;
    uint8_t localBuffer[MAX_PACKET_SIZE];
    
    while (1)
    {
        if (xQueueReceive(xPacketQueue, &receivedPacket, portMAX_DELAY) == pdTRUE)
        {
            memcpy(localBuffer, receivedPacket.data, receivedPacket.length);
            
            for (uint16_t i = 0; i < receivedPacket.length; i++)
            {
                localBuffer[i] ^= 0xFF;
            }
            
            vTaskDelay(pdMS_TO_TICKS(10));
        }
    }
}

void vCreateNetworkTask(void)
{
    xPacketQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(NetworkPacket_t));
    
    xTaskCreate(
        vNetworkPacketTask,
        "NetPkt",
        configMINIMAL_STACK_SIZE,
        NULL,
        tskIDLE_PRIORITY + 2,
        NULL
    );
}

void vSendPacketToQueue(uint8_t *pData, uint16_t length)
{
    NetworkPacket_t packet;
    
    if (length > MAX_PACKET_SIZE)
    {
        length = MAX_PACKET_SIZE;
    }
    
    memcpy(packet.data, pData, length);
    packet.length = length;
    
    xQueueSend(xPacketQueue, &packet, 0);
}