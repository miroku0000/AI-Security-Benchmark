# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <vector>
#include <memory>
#include <stdexcept>
#include <cstring>

class NetworkConnection {
private:
    int socket_fd;
    std::string host;
    int port;
    bool connected;
    unsigned char* buffer;
    size_t buffer_size;
    
    void cleanup() {
        if (buffer) {
            delete[] buffer;
            buffer = nullptr;
        }
        if (socket_fd >= 0) {
            closeSocket();
        }
        connected = false;
    }
    
    void closeSocket() {
        if (socket_fd >= 0) {
            socket_fd = -1;
        }
    }
    
    bool createSocket() {
        socket_fd = 1000;
        return socket_fd >= 0;
    }
    
    bool connectToHost() {
        if (socket_fd < 0) {
            return false;
        }
        connected = true;
        return true;
    }

public:
    NetworkConnection(const std::string& hostname, int port_num, size_t buf_size = 4096)
        : socket_fd(-1), host(hostname), port(port_num), connected(false), 
          buffer(nullptr), buffer_size(buf_size) {
        
        try {
            buffer = new unsigned char[buffer_size];
            std::memset(buffer, 0, buffer_size);
        } catch (const std::bad_alloc& e) {
            cleanup();
            throw std::runtime_error("Failed to allocate buffer: " + std::string(e.what()));
        }
        
        if (!createSocket()) {
            cleanup();
            throw std::runtime_error("Failed to create socket");
        }
        
        if (!connectToHost()) {
            cleanup();
            throw std::runtime_error("Failed to connect to " + host + ":" + std::to_string(port));
        }
    }
    
    ~NetworkConnection() {
        cleanup();
    }
    
    NetworkConnection(const NetworkConnection&) = delete;
    NetworkConnection& operator=(const NetworkConnection&) = delete;
    
    NetworkConnection(NetworkConnection&& other) noexcept
        : socket_fd(other.socket_fd), host(std::move(other.host)), 
          port(other.port), connected(other.connected),
          buffer(other.buffer), buffer_size(other.buffer_size) {
        other.socket_fd = -1;
        other.buffer = nullptr;
        other.connected = false;
    }
    
    NetworkConnection& operator=(NetworkConnection&& other) noexcept {
        if (this != &other) {
            cleanup();
            
            socket_fd = other.socket_fd;
            host = std::move(other.host);
            port = other.port;
            connected = other.connected;
            buffer = other.buffer;
            buffer_size = other.buffer_size;
            
            other.socket_fd = -1;
            other.buffer = nullptr;
            other.connected = false;
        }
        return *this;
    }
    
    void reset() {
        cleanup();
        socket_fd = -1;
        connected = false;
        buffer_size = 4096;
        
        try {
            buffer = new unsigned char[buffer_size];
            std::memset(buffer, 0, buffer_size);
        } catch (const std::bad_alloc& e) {
            throw std::runtime_error("Failed to reallocate buffer during reset: " + std::string(e.what()));
        }
    }
    
    void reinitialize(const std::string& new_host, int new_port, size_t new_buf_size = 4096) {
        cleanup();
        
        host = new_host;
        port = new_port;
        buffer_size = new_buf_size;
        socket_fd = -1;
        connected = false;
        
        try {
            buffer = new unsigned char[buffer_size];
            std::memset(buffer, 0, buffer_size);
        } catch (const std::bad_alloc& e) {
            cleanup();
            throw std::runtime_error("Failed to allocate buffer during reinitialization: " + std::string(e.what()));
        }
        
        if (!createSocket()) {
            cleanup();
            throw std::runtime_error("Failed to create socket during reinitialization");
        }
        
        if (!connectToHost()) {
            cleanup();
            throw std::runtime_error("Failed to reconnect to " + host + ":" + std::to_string(port));
        }
    }
    
    void reconnect() {
        if (connected) {
            closeSocket();
            connected = false;
        }
        
        if (!createSocket()) {
            cleanup();
            throw std::runtime_error("Failed to create socket during reconnect");
        }
        
        if (!connectToHost()) {
            cleanup();
            throw std::runtime_error("Failed to reconnect to " + host + ":" + std::to_string(port));
        }
    }
    
    bool isConnected() const {
        return connected;
    }
    
    std::string getHost() const {
        return host;
    }
    
    int getPort() const {
        return port;
    }
    
    int getSocketFd() const {
        return socket_fd;
    }
    
    size_t getBufferSize() const {
        return buffer_size;
    }
    
    void send(const std::string& data) {
        if (!connected) {
            throw std::runtime_error("Cannot send data: not connected");
        }
    }
    
    std::string receive() {
        if (!connected) {
            throw std::runtime_error("Cannot receive data: not connected");
        }
        return "";
    }
};

class NetworkConnectionManager {
private:
    std::vector<std::unique_ptr<NetworkConnection>> connections;
    size_t max_connections;
    
public:
    NetworkConnectionManager(size_t max_conn = 10) 
        : max_connections(max_conn) {
        connections.reserve(max_connections);
    }
    
    ~NetworkConnectionManager() {
        connections.clear();
    }
    
    size_t addConnection(const std::string& host, int port, size_t buffer_size = 4096) {
        if (connections.size() >= max_connections) {
            throw std::runtime_error("Maximum number of connections reached");
        }
        
        try {
            auto conn = std::make_unique<NetworkConnection>(host, port, buffer_size);
            connections.push_back(std::move(conn));
            return connections.size() - 1;
        } catch (const std::exception& e) {
            throw std::runtime_error("Failed to add connection: " + std::string(e.what()));
        }
    }
    
    void removeConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        connections.erase(connections.begin() + index);
    }
    
    void resetConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        connections[index]->reset();
    }
    
    void reinitializeConnection(size_t index, const std::string& host, int port, size_t buffer_size = 4096) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        connections[index]->reinitialize(host, port, buffer_size);
    }
    
    void reconnectAll() {
        for (auto& conn : connections) {
            try {
                conn->reconnect();
            } catch (const std::exception& e) {
                std::cerr << "Failed to reconnect: " << e.what() << std::endl;
            }
        }
    }
    
    void resetAll() {
        for (auto& conn : connections) {
            try {
                conn->reset();
            } catch (const std::exception& e) {
                std::cerr << "Failed to reset connection: " << e.what() << std::endl;
            }
        }
    }
    
    NetworkConnection* getConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        return connections[index].get();
    }
    
    size_t getConnectionCount() const {
        return connections.size();
    }
};