# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    float temperature;
    float pressure;
    float humidity;
    uint32_t timestamp;
} sensor_data_t;

volatile sensor_data_t sensor_data;
SemaphoreHandle_t xDataMutex;

void vSensorReadTask(void *pvParameters)
{
    TickType_t xLastWakeTime;
    const TickType_t xFrequency = pdMS_TO_TICKS(10);
    
    xLastWakeTime = xTaskGetTickCount();
    
    while(1)
    {
        float temp_reading = read_temperature_sensor();
        float pressure_reading = read_pressure_sensor();
        float humidity_reading = read_humidity_sensor();
        uint32_t timestamp = xTaskGetTickCount();
        
        if(xSemaphoreTake(xDataMutex, portMAX_DELAY) == pdTRUE)
        {
            sensor_data.temperature = temp_reading;
            sensor_data.pressure = pressure_reading;
            sensor_data.humidity = humidity_reading;
            sensor_data.timestamp = timestamp;
            
            xSemaphoreGive(xDataMutex);
        }
        
        vTaskDelayUntil(&xLastWakeTime, xFrequency);
    }
}

void vControlTask(void *pvParameters)
{
    TickType_t xLastWakeTime;
    const TickType_t xFrequency = pdMS_TO_TICKS(20);
    sensor_data_t local_data;
    
    xLastWakeTime = xTaskGetTickCount();
    
    while(1)
    {
        if(xSemaphoreTake(xDataMutex, portMAX_DELAY) == pdTRUE)
        {
            local_data.temperature = sensor_data.temperature;
            local_data.pressure = sensor_data.pressure;
            local_data.humidity = sensor_data.humidity;
            local_data.timestamp = sensor_data.timestamp;
            
            xSemaphoreGive(xDataMutex);
        }
        
        if(local_data.temperature > 80.0f)
        {
            activate_cooling_system();
        }
        else if(local_data.temperature < 60.0f)
        {
            activate_heating_system();
        }
        
        if(local_data.pressure > 150.0f)
        {
            activate_pressure_relief();
        }
        
        if(local_data.humidity < 30.0f)
        {
            activate_humidifier();
        }
        else if(local_data.humidity > 70.0f)
        {
            activate_dehumidifier();
        }
        
        vTaskDelayUntil(&xLastWakeTime, xFrequency);
    }
}

int main(void)
{
    hardware_init();
    
    xDataMutex = xSemaphoreCreateMutex();
    
    if(xDataMutex != NULL)
    {
        sensor_data.temperature = 0.0f;
        sensor_data.pressure = 0.0f;
        sensor_data.humidity = 0.0f;
        sensor_data.timestamp = 0;
        
        xTaskCreate(vSensorReadTask, "SensorRead", 256, NULL, 3, NULL);
        xTaskCreate(vControlTask, "Control", 256, NULL, 2, NULL);
        
        vTaskStartScheduler();
    }
    
    while(1);
    
    return 0;
}

float read_temperature_sensor(void)
{
    return 25.0f + (float)(rand() % 100) / 10.0f;
}

float read_pressure_sensor(void)
{
    return 100.0f + (float)(rand() % 100) / 2.0f;
}

float read_humidity_sensor(void)
{
    return 40.0f + (float)(rand() % 60) / 2.0f;
}

void activate_cooling_system(void)
{
}

void activate_heating_system(void)
{
}

void activate_pressure_relief(void)
{
}

void activate_humidifier(void)
{
}

void activate_dehumidifier(void)
{
}

void hardware_init(void)
{
}