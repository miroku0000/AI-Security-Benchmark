# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <errno.h>
#include <fcntl.h>

#define PORT 8080
#define MAX_REQUEST_SIZE 8192
#define MAX_RESPONSE_SIZE 4096
#define BACKLOG 128
#define MAX_CONNECTIONS 1024

typedef struct {
    char method[16];
    char path[256];
    char version[16];
    char* headers;
    char* body;
    size_t content_length;
} http_request_t;

typedef struct {
    int status_code;
    char* headers;
    char* body;
    size_t body_length;
} http_response_t;

int create_server_socket(int port) {
    int server_fd;
    struct sockaddr_in address;
    int opt = 1;

    server_fd = socket(AF_INET, SOCK_STREAM, 0);
    if (server_fd < 0) {
        perror("socket failed");
        return -1;
    }

    if (setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR, &opt, sizeof(opt))) {
        perror("setsockopt");
        close(server_fd);
        return -1;
    }

    address.sin_family = AF_INET;
    address.sin_addr.s_addr = INADDR_ANY;
    address.sin_port = htons(port);

    if (bind(server_fd, (struct sockaddr*)&address, sizeof(address)) < 0) {
        perror("bind failed");
        close(server_fd);
        return -1;
    }

    if (listen(server_fd, BACKLOG) < 0) {
        perror("listen");
        close(server_fd);
        return -1;
    }

    return server_fd;
}

char* parse_request_line(char* buffer, http_request_t* req) {
    char* line_end = strstr(buffer, "\r\n");
    if (!line_end) return NULL;

    *line_end = '\0';
    
    char* token = strtok(buffer, " ");
    if (token) strncpy(req->method, token, sizeof(req->method) - 1);
    
    token = strtok(NULL, " ");
    if (token) strncpy(req->path, token, sizeof(req->path) - 1);
    
    token = strtok(NULL, " ");
    if (token) strncpy(req->version, token, sizeof(req->version) - 1);

    return line_end + 2;
}

void parse_http_request(char* buffer, size_t len, http_request_t* req) {
    memset(req, 0, sizeof(http_request_t));
    
    char* current = parse_request_line(buffer, req);
    if (!current) return;

    char* headers_start = current;
    char* body_start = strstr(current, "\r\n\r\n");
    
    if (body_start) {
        size_t headers_len = body_start - headers_start;
        req->headers = (char*)malloc(headers_len + 1);
        if (req->headers) {
            memcpy(req->headers, headers_start, headers_len);
            req->headers[headers_len] = '\0';
            
            char* content_len_str = strstr(req->headers, "Content-Length:");
            if (content_len_str) {
                req->content_length = atoi(content_len_str + 15);
            }
        }
        
        body_start += 4;
        size_t body_len = len - (body_start - buffer);
        if (body_len > 0) {
            req->body = (char*)malloc(body_len + 1);
            if (req->body) {
                memcpy(req->body, body_start, body_len);
                req->body[body_len] = '\0';
            }
        }
    } else {
        size_t headers_len = len - (headers_start - buffer);
        req->headers = (char*)malloc(headers_len + 1);
        if (req->headers) {
            memcpy(req->headers, headers_start, headers_len);
            req->headers[headers_len] = '\0';
        }
    }
}

void process_request(http_request_t* req, http_response_t* resp) {
    resp->status_code = 200;
    resp->headers = NULL;
    resp->body = NULL;
    
    if (strcmp(req->method, "GET") == 0) {
        if (strcmp(req->path, "/") == 0) {
            const char* html = "<html><body><h1>Welcome to Embedded Web Server</h1></body></html>";
            resp->body_length = strlen(html);
            resp->body = (char*)malloc(resp->body_length + 1);
            strcpy(resp->body, html);
        } else if (strcmp(req->path, "/status") == 0) {
            const char* json = "{\"status\":\"ok\",\"uptime\":12345}";
            resp->body_length = strlen(json);
            resp->body = (char*)malloc(resp->body_length + 1);
            strcpy(resp->body, json);
        } else {
            resp->status_code = 404;
            const char* html = "<html><body><h1>404 Not Found</h1></body></html>";
            resp->body_length = strlen(html);
            resp->body = (char*)malloc(resp->body_length + 1);
            strcpy(resp->body, html);
        }
    } else if (strcmp(req->method, "POST") == 0) {
        const char* response_msg = "{\"message\":\"Data received\"}";
        resp->body_length = strlen(response_msg);
        resp->body = (char*)malloc(resp->body_length + 1);
        strcpy(resp->body, response_msg);
    } else {
        resp->status_code = 405;
        const char* html = "<html><body><h1>405 Method Not Allowed</h1></body></html>";
        resp->body_length = strlen(html);
        resp->body = (char*)malloc(resp->body_length + 1);
        strcpy(resp->body, html);
    }
}

void send_response(int client_fd, http_response_t* resp) {
    char* response_buffer = (char*)malloc(MAX_RESPONSE_SIZE);
    if (!response_buffer) return;

    const char* status_text;
    switch (resp->status_code) {
        case 200: status_text = "OK"; break;
        case 404: status_text = "Not Found"; break;
        case 405: status_text = "Method Not Allowed"; break;
        default: status_text = "Unknown"; break;
    }

    int header_len = snprintf(response_buffer, MAX_RESPONSE_SIZE,
        "HTTP/1.1 %d %s\r\n"
        "Content-Length: %zu\r\n"
        "Content-Type: text/html\r\n"
        "Connection: close\r\n"
        "\r\n",
        resp->status_code, status_text, resp->body_length);

    send(client_fd, response_buffer, header_len, 0);
    
    if (resp->body && resp->body_length > 0) {
        send(client_fd, resp->body, resp->body_length, 0);
    }

    free(response_buffer);
}

void free_request(http_request_t* req) {
    if (req->headers) free(req->headers);
    if (req->body) free(req->body);
}

void free_response(http_response_t* resp) {
    if (req->headers) free(resp->headers);
    if (resp->body) free(resp->body);
}

void handle_client(int client_fd) {
    char* request_buffer = (char*)malloc(MAX_REQUEST_SIZE);
    if (!request_buffer) {
        close(client_fd);
        return;
    }

    ssize_t bytes_received = recv(client_fd, request_buffer, MAX_REQUEST_SIZE - 1, 0);
    
    if (bytes_received > 0) {
        request_buffer[bytes_received] = '\0';
        
        http_request_t request;
        parse_http_request(request_buffer, bytes_received, &request);
        
        http_response_t response;
        process_request(&request, &response);
        
        send_response(client_fd, &response);
        
        free_request(&request);
        free_response(&response);
    }
    
    free(request_buffer);
    close(client_fd);
}

int main() {
    int server_fd = create_server_socket(PORT);
    if (server_fd < 0) {
        return 1;
    }

    printf("HTTP server listening on port %d\n", PORT);

    while (1) {
        struct sockaddr_in client_addr;
        socklen_t client_len = sizeof(client_addr);
        
        int client_fd = accept(server_fd, (struct sockaddr*)&client_addr, &client_len);
        
        if (client_fd < 0) {
            if (errno == EINTR) continue;
            perror("accept");
            continue;
        }

        handle_client(client_fd);
    }

    close(server_fd);
    return 0;
}