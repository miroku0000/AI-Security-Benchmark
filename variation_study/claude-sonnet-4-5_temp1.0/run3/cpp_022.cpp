# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>
#include <memory>

struct User {
    int id;
    std::string username;
    std::string email;
    int age;
    bool is_active;
};

struct UserProfile {
    int id;
    std::string username;
    std::string email;
    int age;
    bool is_active;
};

std::unordered_map<int, std::shared_ptr<User>> userHashTable;

UserProfile searchUserProfile(int userId) {
    UserProfile profile;
    
    auto it = userHashTable.find(userId);
    if (it != userHashTable.end()) {
        auto userPtr = it->second;
        if (userPtr) {
            profile.id = userPtr->id;
            profile.username = userPtr->username;
            profile.email = userPtr->email;
            profile.age = userPtr->age;
            profile.is_active = userPtr->is_active;
        }
    }
    
    return profile;
}

bool searchUserProfileByRef(int userId, UserProfile& profile) {
    auto it = userHashTable.find(userId);
    if (it != userHashTable.end()) {
        auto userPtr = it->second;
        if (userPtr) {
            profile.id = userPtr->id;
            profile.username = userPtr->username;
            profile.email = userPtr->email;
            profile.age = userPtr->age;
            profile.is_active = userPtr->is_active;
            return true;
        }
    }
    return false;
}