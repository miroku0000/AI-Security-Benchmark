# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>
#include <cstddef>

template<typename T>
class ResourceManager {
private:
    T* resource;
    
    void cleanup() {
        if (resource != nullptr) {
            delete resource;
            resource = nullptr;
        }
    }
    
public:
    ResourceManager() : resource(nullptr) {}
    
    explicit ResourceManager(T* res) : resource(res) {}
    
    ~ResourceManager() {
        cleanup();
    }
    
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;
    
    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }
    
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }
    
    void reset(T* res = nullptr) {
        cleanup();
        resource = res;
    }
    
    T* get() const {
        return resource;
    }
    
    T* release() {
        T* temp = resource;
        resource = nullptr;
        return temp;
    }
    
    T& operator*() const {
        return *resource;
    }
    
    T* operator->() const {
        return resource;
    }
    
    explicit operator bool() const {
        return resource != nullptr;
    }
};

template<typename T>
class ArrayResourceManager {
private:
    T* resource;
    
    void cleanup() {
        if (resource != nullptr) {
            delete[] resource;
            resource = nullptr;
        }
    }
    
public:
    ArrayResourceManager() : resource(nullptr) {}
    
    explicit ArrayResourceManager(T* res) : resource(res) {}
    
    ~ArrayResourceManager() {
        cleanup();
    }
    
    ArrayResourceManager(const ArrayResourceManager&) = delete;
    ArrayResourceManager& operator=(const ArrayResourceManager&) = delete;
    
    ArrayResourceManager(ArrayResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }
    
    ArrayResourceManager& operator=(ArrayResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }
    
    void reset(T* res = nullptr) {
        cleanup();
        resource = res;
    }
    
    T* get() const {
        return resource;
    }
    
    T* release() {
        T* temp = resource;
        resource = nullptr;
        return temp;
    }
    
    T& operator[](std::size_t index) const {
        return resource[index];
    }
    
    explicit operator bool() const {
        return resource != nullptr;
    }
};

template<typename T, typename Deleter>
class CustomResourceManager {
private:
    T* resource;
    Deleter deleter;
    
    void cleanup() {
        if (resource != nullptr) {
            deleter(resource);
            resource = nullptr;
        }
    }
    
public:
    CustomResourceManager() : resource(nullptr), deleter(Deleter()) {}
    
    explicit CustomResourceManager(T* res, Deleter d = Deleter()) 
        : resource(res), deleter(d) {}
    
    ~CustomResourceManager() {
        cleanup();
    }
    
    CustomResourceManager(const CustomResourceManager&) = delete;
    CustomResourceManager& operator=(const CustomResourceManager&) = delete;
    
    CustomResourceManager(CustomResourceManager&& other) noexcept 
        : resource(other.resource), deleter(std::move(other.deleter)) {
        other.resource = nullptr;
    }
    
    CustomResourceManager& operator=(CustomResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            resource = other.resource;
            deleter = std::move(other.deleter);
            other.resource = nullptr;
        }
        return *this;
    }
    
    void reset(T* res = nullptr) {
        cleanup();
        resource = res;
    }
    
    T* get() const {
        return resource;
    }
    
    T* release() {
        T* temp = resource;
        resource = nullptr;
        return temp;
    }
    
    T& operator*() const {
        return *resource;
    }
    
    T* operator->() const {
        return resource;
    }
    
    explicit operator bool() const {
        return resource != nullptr;
    }
    
    Deleter& get_deleter() {
        return deleter;
    }
    
    const Deleter& get_deleter() const {
        return deleter;
    }
};

template<typename T, typename... Args>
ResourceManager<T> make_resource(Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...));
}

template<typename T>
ArrayResourceManager<T> make_array_resource(std::size_t size) {
    return ArrayResourceManager<T>(new T[size]);
}

template<typename T, typename Deleter, typename... Args>
CustomResourceManager<T, Deleter> make_custom_resource(Deleter d, Args&&... args) {
    return CustomResourceManager<T, Deleter>(new T(std::forward<Args>(args)...), d);
}