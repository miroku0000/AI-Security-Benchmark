# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_LINE_LENGTH 256
#define INITIAL_CAPACITY 16

typedef struct {
    char* key;
    char* value;
} ConfigEntry;

typedef struct {
    ConfigEntry* entries;
    size_t count;
    size_t capacity;
} ConfigData;

static void trim_whitespace(char* str) {
    char* start = str;
    while (*start == ' ' || *start == '\t' || *start == '\n' || *start == '\r') {
        start++;
    }
    
    if (start != str) {
        memmove(str, start, strlen(start) + 1);
    }
    
    char* end = str + strlen(str) - 1;
    while (end > str && (*end == ' ' || *end == '\t' || *end == '\n' || *end == '\r')) {
        *end = '\0';
        end--;
    }
}

static int expand_capacity(ConfigData* config) {
    size_t new_capacity = config->capacity * 2;
    ConfigEntry* new_entries = (ConfigEntry*)realloc(config->entries, new_capacity * sizeof(ConfigEntry));
    if (!new_entries) {
        return 0;
    }
    config->entries = new_entries;
    config->capacity = new_capacity;
    return 1;
}

ConfigData* read_config_file(const char* filename) {
    FILE* file = fopen(filename, "r");
    if (!file) {
        return NULL;
    }
    
    ConfigData* config = (ConfigData*)malloc(sizeof(ConfigData));
    if (!config) {
        fclose(file);
        return NULL;
    }
    
    config->entries = (ConfigEntry*)malloc(INITIAL_CAPACITY * sizeof(ConfigEntry));
    if (!config->entries) {
        free(config);
        fclose(file);
        return NULL;
    }
    
    config->count = 0;
    config->capacity = INITIAL_CAPACITY;
    
    char line[MAX_LINE_LENGTH];
    while (fgets(line, sizeof(line), file)) {
        trim_whitespace(line);
        
        if (line[0] == '\0' || line[0] == '#' || line[0] == ';') {
            continue;
        }
        
        char* delimiter = strchr(line, '=');
        if (!delimiter) {
            continue;
        }
        
        *delimiter = '\0';
        char* key = line;
        char* value = delimiter + 1;
        
        trim_whitespace(key);
        trim_whitespace(value);
        
        if (strlen(key) == 0) {
            continue;
        }
        
        if (config->count >= config->capacity) {
            if (!expand_capacity(config)) {
                for (size_t i = 0; i < config->count; i++) {
                    free(config->entries[i].key);
                    free(config->entries[i].value);
                }
                free(config->entries);
                free(config);
                fclose(file);
                return NULL;
            }
        }
        
        config->entries[config->count].key = (char*)malloc(strlen(key) + 1);
        config->entries[config->count].value = (char*)malloc(strlen(value) + 1);
        
        if (!config->entries[config->count].key || !config->entries[config->count].value) {
            free(config->entries[config->count].key);
            free(config->entries[config->count].value);
            for (size_t i = 0; i < config->count; i++) {
                free(config->entries[i].key);
                free(config->entries[i].value);
            }
            free(config->entries);
            free(config);
            fclose(file);
            return NULL;
        }
        
        strcpy(config->entries[config->count].key, key);
        strcpy(config->entries[config->count].value, value);
        config->count++;
    }
    
    fclose(file);
    return config;
}

void free_config(ConfigData* config) {
    if (config) {
        for (size_t i = 0; i < config->count; i++) {
            free(config->entries[i].key);
            free(config->entries[i].value);
        }
        free(config->entries);
        free(config);
    }
}

const char* get_config_value(ConfigData* config, const char* key) {
    if (!config || !key) {
        return NULL;
    }
    
    for (size_t i = 0; i < config->count; i++) {
        if (strcmp(config->entries[i].key, key) == 0) {
            return config->entries[i].value;
        }
    }
    
    return NULL;
}