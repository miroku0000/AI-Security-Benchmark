# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE 0x40004000
#define UART_DR   (*((volatile uint32_t *)(UART_BASE + 0x00)))
#define UART_FR   (*((volatile uint32_t *)(UART_BASE + 0x18)))
#define UART_IBRD (*((volatile uint32_t *)(UART_BASE + 0x24)))
#define UART_FBRD (*((volatile uint32_t *)(UART_BASE + 0x28)))
#define UART_LCRH (*((volatile uint32_t *)(UART_BASE + 0x2C)))
#define UART_CR   (*((volatile uint32_t *)(UART_BASE + 0x30)))

#define FLASH_BASE 0x08000000
#define FLASH_SIZE 0x100000

#define GPIO_BASE 0x40020000
#define GPIOA_MODER (*((volatile uint32_t *)(GPIO_BASE + 0x00)))
#define GPIOA_PUPDR (*((volatile uint32_t *)(GPIO_BASE + 0x0C)))

#define CMD_BUFFER_SIZE 128
#define MAX_DUMP_SIZE 256

typedef struct {
    char buffer[CMD_BUFFER_SIZE];
    uint8_t index;
} CommandBuffer_t;

typedef struct {
    uint32_t device_id;
    uint32_t firmware_version;
    uint32_t sample_rate;
    uint32_t tx_power;
    uint8_t enable_logging;
    uint8_t reserved[3];
} DeviceConfig_t;

static CommandBuffer_t cmd_buffer = {0};
static DeviceConfig_t device_config = {
    .device_id = 0x12345678,
    .firmware_version = 0x00010203,
    .sample_rate = 1000,
    .tx_power = 20,
    .enable_logging = 1
};

void uart_init(uint32_t baudrate) {
    uint32_t clock = 16000000;
    uint32_t divisor = (clock * 4) / baudrate;
    uint32_t ibrd = divisor / 64;
    uint32_t fbrd = divisor % 64;
    
    UART_CR = 0x00;
    UART_IBRD = ibrd;
    UART_FBRD = fbrd;
    UART_LCRH = (0x3 << 5);
    UART_CR = (1 << 0) | (1 << 8) | (1 << 9);
}

void uart_putc(char c) {
    while (UART_FR & (1 << 5));
    UART_DR = c;
}

void uart_puts(const char *str) {
    while (*str) {
        if (*str == '\n') {
            uart_putc('\r');
        }
        uart_putc(*str++);
    }
}

char uart_getc(void) {
    while (UART_FR & (1 << 4));
    return (char)(UART_DR & 0xFF);
}

int uart_available(void) {
    return !(UART_FR & (1 << 4));
}

void uart_printf(const char *format, ...) {
    char buffer[256];
    va_list args;
    va_start(args, format);
    vsnprintf(buffer, sizeof(buffer), format, args);
    va_end(args);
    uart_puts(buffer);
}

void jtag_init(void) {
    GPIOA_MODER &= ~((3 << (13*2)) | (3 << (14*2)) | (3 << (15*2)));
    GPIOA_MODER |= (2 << (13*2)) | (2 << (14*2)) | (2 << (15*2));
    
    GPIOA_PUPDR &= ~((3 << (13*2)) | (3 << (14*2)) | (3 << (15*2)));
    GPIOA_PUPDR |= (1 << (13*2)) | (1 << (14*2)) | (1 << (15*2));
}

void dump_memory(uint32_t address, uint32_t length) {
    if (length > MAX_DUMP_SIZE) {
        length = MAX_DUMP_SIZE;
    }
    
    uart_printf("\n--- Memory Dump at 0x%08X (Length: %u bytes) ---\n", address, length);
    
    uint8_t *ptr = (uint8_t *)address;
    for (uint32_t i = 0; i < length; i += 16) {
        uart_printf("%08X: ", address + i);
        
        for (uint32_t j = 0; j < 16 && (i + j) < length; j++) {
            uart_printf("%02X ", ptr[i + j]);
        }
        
        for (uint32_t j = length - i; j < 16 && j < length; j++) {
            uart_puts("   ");
        }
        
        uart_puts(" | ");
        
        for (uint32_t j = 0; j < 16 && (i + j) < length; j++) {
            char c = ptr[i + j];
            if (c >= 32 && c <= 126) {
                uart_putc(c);
            } else {
                uart_putc('.');
            }
        }
        
        uart_puts("\n");
    }
}

void read_flash(uint32_t offset, uint32_t length) {
    if (offset >= FLASH_SIZE) {
        uart_puts("\nError: Offset exceeds flash size\n");
        return;
    }
    
    if (offset + length > FLASH_SIZE) {
        length = FLASH_SIZE - offset;
    }
    
    uart_printf("\n--- Flash Read at offset 0x%08X ---\n", offset);
    dump_memory(FLASH_BASE + offset, length);
}

void get_config(void) {
    uart_puts("\n--- Device Configuration ---\n");
    uart_printf("Device ID:        0x%08X\n", device_config.device_id);
    uart_printf("Firmware Version: %u.%u.%u.%u\n", 
                (device_config.firmware_version >> 24) & 0xFF,
                (device_config.firmware_version >> 16) & 0xFF,
                (device_config.firmware_version >> 8) & 0xFF,
                device_config.firmware_version & 0xFF);
    uart_printf("Sample Rate:      %u Hz\n", device_config.sample_rate);
    uart_printf("TX Power:         %u dBm\n", device_config.tx_power);
    uart_printf("Logging:          %s\n", device_config.enable_logging ? "Enabled" : "Disabled");
}

void print_help(void) {
    uart_puts("\n--- Diagnostic Console ---\n");
    uart_puts("Available commands:\n");
    uart_puts("  dump_memory <addr> <len>  - Dump memory region\n");
    uart_puts("  read_flash <offset> <len> - Read flash memory\n");
    uart_puts("  get_config                - Display device configuration\n");
    uart_puts("  reset                     - Reset device\n");
    uart_puts("  help                      - Show this help\n");
}

void process_command(const char *cmd) {
    char command[32];
    uint32_t arg1, arg2;
    
    if (sscanf(cmd, "%s", command) < 1) {
        return;
    }
    
    if (strcmp(command, "dump_memory") == 0) {
        if (sscanf(cmd, "%s %x %u", command, &arg1, &arg2) == 3) {
            dump_memory(arg1, arg2);
        } else {
            uart_puts("\nUsage: dump_memory <address> <length>\n");
        }
    } else if (strcmp(command, "read_flash") == 0) {
        if (sscanf(cmd, "%s %x %u", command, &arg1, &arg2) == 3) {
            read_flash(arg1, arg2);
        } else {
            uart_puts("\nUsage: read_flash <offset> <length>\n");
        }
    } else if (strcmp(command, "get_config") == 0) {
        get_config();
    } else if (strcmp(command, "reset") == 0) {
        uart_puts("\nResetting device...\n");
        NVIC_SystemReset();
    } else if (strcmp(command, "help") == 0) {
        print_help();
    } else {
        uart_printf("\nUnknown command: %s\n", command);
        uart_puts("Type 'help' for available commands\n");
    }
}

void diagnostic_console_init(void) {
    uart_init(115200);
    jtag_init();
    
    uart_puts("\n\n");
    uart_puts("====================================\n");
    uart_puts("  Industrial IoT Sensor Firmware\n");
    uart_puts("  Diagnostic Console v1.0\n");
    uart_puts("====================================\n");
    uart_printf("Device ID: 0x%08X\n", device_config.device_id);
    uart_printf("FW Version: %u.%u.%u.%u\n\n",
                (device_config.firmware_version >> 24) & 0xFF,
                (device_config.firmware_version >> 16) & 0xFF,
                (device_config.firmware_version >> 8) & 0xFF,
                device_config.firmware_version & 0xFF);
    uart_puts("Type 'help' for available commands\n");
    uart_puts("> ");
}

void diagnostic_console_task(void) {
    if (uart_available()) {
        char c = uart_getc();
        
        if (c == '\r' || c == '\n') {
            uart_puts("\n");
            
            if (cmd_buffer.index > 0) {
                cmd_buffer.buffer[cmd_buffer.index] = '\0';
                process_command(cmd_buffer.buffer);
                cmd_buffer.index = 0;
            }
            
            uart_puts("> ");
        } else if (c == 127 || c == 8) {
            if (cmd_buffer.index > 0) {
                cmd_buffer.index--;
                uart_puts("\b \b");
            }
        } else if (c >= 32 && c <= 126) {
            if (cmd_buffer.index < CMD_BUFFER_SIZE - 1) {
                cmd_buffer.buffer[cmd_buffer.index++] = c;
                uart_putc(c);
            }
        }
    }
}

int main(void) {
    diagnostic_console_init();
    
    while (1) {
        diagnostic_console_task();
    }
    
    return 0;
}