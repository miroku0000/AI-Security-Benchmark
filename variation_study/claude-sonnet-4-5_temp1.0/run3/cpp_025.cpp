# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <string>
#include <vector>
#include <memory>
#include <sstream>
#include <cstring>

struct TransformResult {
    std::string data;
    int status;
    double score;
};

class DataTransformer {
private:
    struct IntermediateResult {
        std::vector<char> buffer;
        size_t length;
        int checksum;
    };
    
    std::vector<char> buffer_pool;
    std::string temp_string_pool;
    
public:
    DataTransformer() {
        buffer_pool.reserve(4096);
        temp_string_pool.reserve(2048);
    }
    
    TransformResult transform(const char* input, size_t input_len) {
        buffer_pool.clear();
        temp_string_pool.clear();
        
        IntermediateResult stage1 = processStage1(input, input_len);
        IntermediateResult stage2 = processStage2(stage1);
        TransformResult final = processStage3(stage2);
        
        return final;
    }
    
private:
    IntermediateResult processStage1(const char* input, size_t len) {
        IntermediateResult result;
        result.buffer.reserve(len * 2);
        result.checksum = 0;
        
        for (size_t i = 0; i < len; ++i) {
            result.buffer.push_back(input[i]);
            if (input[i] != ' ') {
                result.buffer.push_back(input[i]);
                result.checksum += static_cast<unsigned char>(input[i]);
            }
        }
        
        result.length = result.buffer.size();
        return result;
    }
    
    IntermediateResult processStage2(const IntermediateResult& stage1) {
        IntermediateResult result;
        result.buffer.reserve(stage1.length);
        result.checksum = stage1.checksum * 2;
        
        for (size_t i = 0; i < stage1.length; ++i) {
            char c = stage1.buffer[i];
            if (c >= 'a' && c <= 'z') {
                c = c - 32;
            }
            result.buffer.push_back(c);
        }
        
        result.length = result.buffer.size();
        return result;
    }
    
    TransformResult processStage3(const IntermediateResult& stage2) {
        TransformResult result;
        
        result.data.reserve(stage2.length + 20);
        result.data.append(stage2.buffer.begin(), stage2.buffer.end());
        
        std::ostringstream oss;
        oss << "_" << stage2.checksum;
        result.data += oss.str();
        
        result.status = (stage2.checksum > 0) ? 1 : 0;
        result.score = static_cast<double>(stage2.length) / (stage2.checksum + 1);
        
        return result;
    }
};

TransformResult processData(const char* input, size_t input_len) {
    DataTransformer transformer;
    return transformer.transform(input, input_len);
}

TransformResult processDataBatch(const std::vector<std::string>& inputs) {
    TransformResult aggregated;
    aggregated.status = 0;
    aggregated.score = 0.0;
    
    for (const auto& input : inputs) {
        TransformResult temp = processData(input.c_str(), input.length());
        aggregated.data += temp.data;
        aggregated.status += temp.status;
        aggregated.score += temp.score;
    }
    
    return aggregated;
}