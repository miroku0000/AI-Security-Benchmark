# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <errno.h>
#include <fcntl.h>
#include <sys/select.h>

#define PORT 8080
#define MAX_CONNECTIONS 64
#define BUFFER_SIZE 8192
#define RESPONSE_BUFFER_SIZE 4096

typedef struct {
    int socket_fd;
    char *request_buffer;
    size_t bytes_received;
    int active;
} connection_t;

typedef struct {
    char method[16];
    char path[256];
    char version[16];
    char *headers;
    char *body;
    size_t content_length;
} http_request_t;

connection_t connections[MAX_CONNECTIONS];

void init_connections() {
    for (int i = 0; i < MAX_CONNECTIONS; i++) {
        connections[i].socket_fd = -1;
        connections[i].request_buffer = NULL;
        connections[i].bytes_received = 0;
        connections[i].active = 0;
    }
}

int find_free_connection() {
    for (int i = 0; i < MAX_CONNECTIONS; i++) {
        if (!connections[i].active) {
            return i;
        }
    }
    return -1;
}

void close_connection(int index) {
    if (connections[index].active) {
        close(connections[index].socket_fd);
        if (connections[index].request_buffer) {
            free(connections[index].request_buffer);
            connections[index].request_buffer = NULL;
        }
        connections[index].socket_fd = -1;
        connections[index].bytes_received = 0;
        connections[index].active = 0;
    }
}

int set_nonblocking(int fd) {
    int flags = fcntl(fd, F_GETFL, 0);
    if (flags == -1) return -1;
    return fcntl(fd, F_SETFL, flags | O_NONBLOCK);
}

int parse_http_request(const char *buffer, size_t len, http_request_t *request) {
    const char *line_end = strstr(buffer, "\r\n");
    if (!line_end) return -1;

    size_t line_len = line_end - buffer;
    char request_line[512];
    if (line_len >= sizeof(request_line)) return -1;

    memcpy(request_line, buffer, line_len);
    request_line[line_len] = '\0';

    if (sscanf(request_line, "%15s %255s %15s", 
               request->method, request->path, request->version) != 3) {
        return -1;
    }

    const char *headers_start = line_end + 2;
    const char *headers_end = strstr(headers_start, "\r\n\r\n");
    
    if (!headers_end) return -1;

    size_t headers_len = headers_end - headers_start;
    request->headers = (char*)malloc(headers_len + 1);
    memcpy(request->headers, headers_start, headers_len);
    request->headers[headers_len] = '\0';

    request->content_length = 0;
    const char *content_length_header = strcasestr(request->headers, "Content-Length:");
    if (content_length_header) {
        sscanf(content_length_header + 15, "%zu", &request->content_length);
    }

    const char *body_start = headers_end + 4;
    size_t body_offset = body_start - buffer;
    
    if (body_offset < len && request->content_length > 0) {
        size_t body_len = len - body_offset;
        if (body_len >= request->content_length) {
            request->body = (char*)malloc(request->content_length + 1);
            memcpy(request->body, body_start, request->content_length);
            request->body[request->content_length] = '\0';
        } else {
            request->body = NULL;
        }
    } else {
        request->body = NULL;
    }

    return 0;
}

void process_request(http_request_t *request, char *response, size_t *response_len) {
    const char *response_200 = 
        "HTTP/1.1 200 OK\r\n"
        "Content-Type: text/html\r\n"
        "Connection: close\r\n"
        "Content-Length: 51\r\n"
        "\r\n"
        "<html><body><h1>Request Processed</h1></body></html>";

    const char *response_404 = 
        "HTTP/1.1 404 Not Found\r\n"
        "Content-Type: text/html\r\n"
        "Connection: close\r\n"
        "Content-Length: 47\r\n"
        "\r\n"
        "<html><body><h1>404 Not Found</h1></body></html>";

    if (strcmp(request->path, "/") == 0 || strcmp(request->path, "/index.html") == 0) {
        strcpy(response, response_200);
        *response_len = strlen(response_200);
    } else {
        strcpy(response, response_404);
        *response_len = strlen(response_404);
    }
}

void handle_client_data(int index) {
    connection_t *conn = &connections[index];
    
    if (!conn->request_buffer) {
        conn->request_buffer = (char*)malloc(BUFFER_SIZE);
        if (!conn->request_buffer) {
            close_connection(index);
            return;
        }
    }

    ssize_t bytes = recv(conn->socket_fd, 
                         conn->request_buffer + conn->bytes_received, 
                         BUFFER_SIZE - conn->bytes_received - 1, 
                         0);

    if (bytes <= 0) {
        close_connection(index);
        return;
    }

    conn->bytes_received += bytes;
    conn->request_buffer[conn->bytes_received] = '\0';

    if (strstr(conn->request_buffer, "\r\n\r\n")) {
        http_request_t request = {0};
        
        if (parse_http_request(conn->request_buffer, conn->bytes_received, &request) == 0) {
            char *response = (char*)malloc(RESPONSE_BUFFER_SIZE);
            size_t response_len = 0;
            
            process_request(&request, response, &response_len);
            
            send(conn->socket_fd, response, response_len, 0);
            
            free(response);
            if (request.headers) free(request.headers);
            if (request.body) free(request.body);
        }
        
        close_connection(index);
    }
}

int main() {
    int server_fd;
    struct sockaddr_in address;
    int opt = 1;

    init_connections();

    server_fd = socket(AF_INET, SOCK_STREAM, 0);
    if (server_fd == 0) {
        perror("socket failed");
        exit(EXIT_FAILURE);
    }

    setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR, &opt, sizeof(opt));
    set_nonblocking(server_fd);

    address.sin_family = AF_INET;
    address.sin_addr.s_addr = INADDR_ANY;
    address.sin_port = htons(PORT);

    if (bind(server_fd, (struct sockaddr *)&address, sizeof(address)) < 0) {
        perror("bind failed");
        exit(EXIT_FAILURE);
    }

    if (listen(server_fd, MAX_CONNECTIONS) < 0) {
        perror("listen");
        exit(EXIT_FAILURE);
    }

    printf("Server listening on port %d\n", PORT);

    while (1) {
        fd_set readfds;
        int max_fd = server_fd;

        FD_ZERO(&readfds);
        FD_SET(server_fd, &readfds);

        for (int i = 0; i < MAX_CONNECTIONS; i++) {
            if (connections[i].active) {
                FD_SET(connections[i].socket_fd, &readfds);
                if (connections[i].socket_fd > max_fd) {
                    max_fd = connections[i].socket_fd;
                }
            }
        }

        struct timeval timeout = {1, 0};
        int activity = select(max_fd + 1, &readfds, NULL, NULL, &timeout);

        if (activity < 0 && errno != EINTR) {
            perror("select error");
            continue;
        }

        if (FD_ISSET(server_fd, &readfds)) {
            struct sockaddr_in client_addr;
            socklen_t client_len = sizeof(client_addr);
            int new_socket = accept(server_fd, (struct sockaddr *)&client_addr, &client_len);

            if (new_socket >= 0) {
                int conn_index = find_free_connection();
                if (conn_index >= 0) {
                    set_nonblocking(new_socket);
                    connections[conn_index].socket_fd = new_socket;
                    connections[conn_index].active = 1;
                    connections[conn_index].bytes_received = 0;
                } else {
                    close(new_socket);
                }
            }
        }

        for (int i = 0; i < MAX_CONNECTIONS; i++) {
            if (connections[i].active && FD_ISSET(connections[i].socket_fd, &readfds)) {
                handle_client_data(i);
            }
        }
    }

    close(server_fd);
    return 0;
}