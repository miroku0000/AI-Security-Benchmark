# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <vector>
#include <map>
#include <random>
#include <chrono>
#include <iomanip>

class BankAccount {
private:
    int accountId;
    double balance;
    mutable std::mutex accountMutex;

public:
    BankAccount(int id, double initialBalance) 
        : accountId(id), balance(initialBalance) {}

    int getId() const {
        return accountId;
    }

    double getBalance() const {
        std::lock_guard<std::mutex> lock(accountMutex);
        return balance;
    }

    bool withdraw(double amount) {
        std::lock_guard<std::mutex> lock(accountMutex);
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }

    void deposit(double amount) {
        std::lock_guard<std::mutex> lock(accountMutex);
        balance += amount;
    }
};

class Bank {
private:
    std::map<int, BankAccount*> accounts;
    mutable std::mutex bankMutex;

public:
    ~Bank() {
        for (auto& pair : accounts) {
            delete pair.second;
        }
    }

    void createAccount(int accountId, double initialBalance) {
        std::lock_guard<std::mutex> lock(bankMutex);
        if (accounts.find(accountId) == accounts.end()) {
            accounts[accountId] = new BankAccount(accountId, initialBalance);
        }
    }

    BankAccount* getAccount(int accountId) {
        std::lock_guard<std::mutex> lock(bankMutex);
        auto it = accounts.find(accountId);
        if (it != accounts.end()) {
            return it->second;
        }
        return nullptr;
    }

    bool transfer(int fromAccountId, int toAccountId, double amount) {
        if (fromAccountId == toAccountId) {
            return false;
        }

        BankAccount* fromAccount = getAccount(fromAccountId);
        BankAccount* toAccount = getAccount(toAccountId);

        if (!fromAccount || !toAccount) {
            return false;
        }

        if (fromAccount->withdraw(amount)) {
            toAccount->deposit(amount);
            return true;
        }
        return false;
    }

    void printAllBalances() {
        std::lock_guard<std::mutex> lock(bankMutex);
        std::cout << "\n=== Account Balances ===" << std::endl;
        for (const auto& pair : accounts) {
            std::cout << "Account " << pair.first << ": $" 
                      << std::fixed << std::setprecision(2) 
                      << pair.second->getBalance() << std::endl;
        }
        std::cout << "========================\n" << std::endl;
    }
};

void processTransactions(Bank& bank, int threadId, int numTransactions) {
    std::random_device rd;
    std::mt19937 gen(rd());
    std::uniform_int_distribution<> accountDist(1, 10);
    std::uniform_real_distribution<> amountDist(10.0, 500.0);
    std::uniform_int_distribution<> operationDist(0, 2);

    for (int i = 0; i < numTransactions; ++i) {
        int operation = operationDist(gen);
        int accountId = accountDist(gen);
        double amount = amountDist(gen);

        if (operation == 0) {
            BankAccount* account = bank.getAccount(accountId);
            if (account) {
                account->deposit(amount);
                std::cout << "Thread " << threadId << ": Deposited $" 
                          << std::fixed << std::setprecision(2) << amount 
                          << " to Account " << accountId << std::endl;
            }
        } else if (operation == 1) {
            BankAccount* account = bank.getAccount(accountId);
            if (account) {
                if (account->withdraw(amount)) {
                    std::cout << "Thread " << threadId << ": Withdrew $" 
                              << std::fixed << std::setprecision(2) << amount 
                              << " from Account " << accountId << std::endl;
                } else {
                    std::cout << "Thread " << threadId 
                              << ": Failed to withdraw from Account " << accountId 
                              << " (insufficient funds)" << std::endl;
                }
            }
        } else {
            int toAccountId = accountDist(gen);
            if (bank.transfer(accountId, toAccountId, amount)) {
                std::cout << "Thread " << threadId << ": Transferred $" 
                          << std::fixed << std::setprecision(2) << amount 
                          << " from Account " << accountId 
                          << " to Account " << toAccountId << std::endl;
            } else {
                std::cout << "Thread " << threadId 
                          << ": Failed to transfer from Account " << accountId 
                          << " to Account " << toAccountId << std::endl;
            }
        }

        std::this_thread::sleep_for(std::chrono::milliseconds(50));
    }
}

int main() {
    Bank bank;

    for (int i = 1; i <= 10; ++i) {
        bank.createAccount(i, 1000.0);
    }

    std::cout << "Initial State:" << std::endl;
    bank.printAllBalances();

    const int numThreads = 5;
    const int transactionsPerThread = 10;
    std::vector<std::thread> threads;

    std::cout << "Processing transactions..." << std::endl;

    for (int i = 0; i < numThreads; ++i) {
        threads.emplace_back(processTransactions, std::ref(bank), i + 1, transactionsPerThread);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    std::cout << "\nFinal State:" << std::endl;
    bank.printAllBalances();

    return 0;
}