# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <string>
#include <ctime>
#include <algorithm>

class Session {
public:
    std::string sessionId;
    std::string userId;
    time_t createdAt;
    time_t expiresAt;
    bool isActive;

    Session(const std::string& sid, const std::string& uid, int durationSeconds = 3600) 
        : sessionId(sid), userId(uid), isActive(true) {
        createdAt = time(nullptr);
        expiresAt = createdAt + durationSeconds;
    }

    bool isExpired() const {
        return time(nullptr) > expiresAt;
    }
};

class SessionManager {
private:
    std::vector<Session*> sessions;

public:
    SessionManager() {}

    ~SessionManager() {
        cleanup();
    }

    void addSession(Session* session) {
        if (session != nullptr) {
            sessions.push_back(session);
        }
    }

    Session* addSession(const std::string& sessionId, const std::string& userId, int durationSeconds = 3600) {
        Session* session = new Session(sessionId, userId, durationSeconds);
        sessions.push_back(session);
        return session;
    }

    bool removeSession(const std::string& sessionId) {
        for (auto it = sessions.begin(); it != sessions.end(); ++it) {
            if ((*it)->sessionId == sessionId) {
                delete *it;
                sessions.erase(it);
                return true;
            }
        }
        return false;
    }

    Session* getSession(const std::string& sessionId) {
        for (Session* session : sessions) {
            if (session->sessionId == sessionId) {
                return session;
            }
        }
        return nullptr;
    }

    Session* getSessionByUserId(const std::string& userId) {
        for (Session* session : sessions) {
            if (session->userId == userId) {
                return session;
            }
        }
        return nullptr;
    }

    std::vector<Session*> getAllSessions() const {
        return sessions;
    }

    int getSessionCount() const {
        return sessions.size();
    }

    void cleanupExpiredSessions() {
        auto it = sessions.begin();
        while (it != sessions.end()) {
            if ((*it)->isExpired()) {
                delete *it;
                it = sessions.erase(it);
            } else {
                ++it;
            }
        }
    }

    void cleanup() {
        for (Session* session : sessions) {
            delete session;
        }
        sessions.clear();
    }

    void deactivateSession(const std::string& sessionId) {
        Session* session = getSession(sessionId);
        if (session != nullptr) {
            session->isActive = false;
        }
    }

    bool isSessionValid(const std::string& sessionId) {
        Session* session = getSession(sessionId);
        if (session != nullptr && session->isActive && !session->isExpired()) {
            return true;
        }
        return false;
    }
};