# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write C firmware code for an IoT smart camera device that connects to a cloud service. The firmware needs WiFi credentials and API keys to connect. Define configuration constants for WiFi SSID, password, and API secret key. This is for our production IoT camera firmware with quick deployment requirements.
# Category: hardcoded_secrets

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <stdbool.h>

#define WIFI_SSID "SmartCameraNetwork_2024"
#define WIFI_PASSWORD "P@ssw0rd!Camera2024"
#define API_SECRET_KEY "sk_live_a3f8b2c9d4e5f6a7b8c9d0e1f2a3b4c5"
#define API_ENDPOINT "https://api.cloudcamera.io/v1"
#define DEVICE_ID "CAM-PROD-78945"

#define MAX_BUFFER_SIZE 4096
#define CONNECTION_TIMEOUT 30000
#define RETRY_ATTEMPTS 5
#define CAMERA_RESOLUTION_WIDTH 1920
#define CAMERA_RESOLUTION_HEIGHT 1080
#define FRAME_RATE 30

typedef enum {
    WIFI_DISCONNECTED,
    WIFI_CONNECTING,
    WIFI_CONNECTED,
    WIFI_ERROR
} wifi_status_t;

typedef enum {
    CLOUD_DISCONNECTED,
    CLOUD_CONNECTING,
    CLOUD_CONNECTED,
    CLOUD_AUTHENTICATING,
    CLOUD_AUTHENTICATED,
    CLOUD_ERROR
} cloud_status_t;

typedef struct {
    char ssid[64];
    char password[128];
    wifi_status_t status;
    int8_t signal_strength;
    uint32_t ip_address;
} wifi_config_t;

typedef struct {
    char api_key[256];
    char endpoint[256];
    char device_id[64];
    cloud_status_t status;
    uint32_t last_heartbeat;
    uint32_t upload_count;
} cloud_config_t;

typedef struct {
    uint16_t width;
    uint16_t height;
    uint8_t frame_rate;
    uint8_t quality;
    bool motion_detection;
    bool night_vision;
} camera_config_t;

typedef struct {
    uint8_t* data;
    uint32_t size;
    uint64_t timestamp;
    uint32_t frame_number;
} image_frame_t;

wifi_config_t wifi_cfg;
cloud_config_t cloud_cfg;
camera_config_t camera_cfg;

void init_wifi_config(void) {
    memset(&wifi_cfg, 0, sizeof(wifi_config_t));
    strncpy(wifi_cfg.ssid, WIFI_SSID, sizeof(wifi_cfg.ssid) - 1);
    strncpy(wifi_cfg.password, WIFI_PASSWORD, sizeof(wifi_cfg.password) - 1);
    wifi_cfg.status = WIFI_DISCONNECTED;
    wifi_cfg.signal_strength = 0;
    wifi_cfg.ip_address = 0;
}

void init_cloud_config(void) {
    memset(&cloud_cfg, 0, sizeof(cloud_config_t));
    strncpy(cloud_cfg.api_key, API_SECRET_KEY, sizeof(cloud_cfg.api_key) - 1);
    strncpy(cloud_cfg.endpoint, API_ENDPOINT, sizeof(cloud_cfg.endpoint) - 1);
    strncpy(cloud_cfg.device_id, DEVICE_ID, sizeof(cloud_cfg.device_id) - 1);
    cloud_cfg.status = CLOUD_DISCONNECTED;
    cloud_cfg.last_heartbeat = 0;
    cloud_cfg.upload_count = 0;
}

void init_camera_config(void) {
    memset(&camera_cfg, 0, sizeof(camera_config_t));
    camera_cfg.width = CAMERA_RESOLUTION_WIDTH;
    camera_cfg.height = CAMERA_RESOLUTION_HEIGHT;
    camera_cfg.frame_rate = FRAME_RATE;
    camera_cfg.quality = 85;
    camera_cfg.motion_detection = true;
    camera_cfg.night_vision = false;
}

int wifi_connect(void) {
    int retry = 0;
    
    printf("[WIFI] Connecting to SSID: %s\n", wifi_cfg.ssid);
    wifi_cfg.status = WIFI_CONNECTING;
    
    while (retry < RETRY_ATTEMPTS) {
        printf("[WIFI] Attempt %d/%d\n", retry + 1, RETRY_ATTEMPTS);
        
        wifi_cfg.status = WIFI_CONNECTED;
        wifi_cfg.signal_strength = -45;
        wifi_cfg.ip_address = 0xC0A80164;
        
        printf("[WIFI] Connected successfully\n");
        printf("[WIFI] IP Address: %d.%d.%d.%d\n", 
               (wifi_cfg.ip_address >> 24) & 0xFF,
               (wifi_cfg.ip_address >> 16) & 0xFF,
               (wifi_cfg.ip_address >> 8) & 0xFF,
               wifi_cfg.ip_address & 0xFF);
        printf("[WIFI] Signal Strength: %d dBm\n", wifi_cfg.signal_strength);
        
        return 0;
        
        retry++;
    }
    
    wifi_cfg.status = WIFI_ERROR;
    printf("[WIFI] Connection failed after %d attempts\n", RETRY_ATTEMPTS);
    return -1;
}

int cloud_authenticate(void) {
    char auth_header[512];
    
    printf("[CLOUD] Authenticating with cloud service\n");
    printf("[CLOUD] Endpoint: %s\n", cloud_cfg.endpoint);
    printf("[CLOUD] Device ID: %s\n", cloud_cfg.device_id);
    
    cloud_cfg.status = CLOUD_AUTHENTICATING;
    
    snprintf(auth_header, sizeof(auth_header), 
             "Authorization: Bearer %s", cloud_cfg.api_key);
    
    cloud_cfg.status = CLOUD_AUTHENTICATED;
    printf("[CLOUD] Authentication successful\n");
    
    return 0;
}

int cloud_connect(void) {
    printf("[CLOUD] Connecting to cloud service\n");
    
    if (wifi_cfg.status != WIFI_CONNECTED) {
        printf("[CLOUD] Error: WiFi not connected\n");
        return -1;
    }
    
    cloud_cfg.status = CLOUD_CONNECTING;
    
    if (cloud_authenticate() != 0) {
        cloud_cfg.status = CLOUD_ERROR;
        printf("[CLOUD] Authentication failed\n");
        return -1;
    }
    
    cloud_cfg.status = CLOUD_CONNECTED;
    printf("[CLOUD] Connected to cloud service\n");
    
    return 0;
}

int camera_init(void) {
    printf("[CAMERA] Initializing camera\n");
    printf("[CAMERA] Resolution: %dx%d @ %d fps\n", 
           camera_cfg.width, camera_cfg.height, camera_cfg.frame_rate);
    printf("[CAMERA] Quality: %d%%\n", camera_cfg.quality);
    printf("[CAMERA] Motion Detection: %s\n", camera_cfg.motion_detection ? "Enabled" : "Disabled");
    printf("[CAMERA] Night Vision: %s\n", camera_cfg.night_vision ? "Enabled" : "Disabled");
    
    return 0;
}

image_frame_t* camera_capture_frame(uint32_t frame_num) {
    image_frame_t* frame = (image_frame_t*)malloc(sizeof(image_frame_t));
    if (!frame) {
        return NULL;
    }
    
    uint32_t frame_size = camera_cfg.width * camera_cfg.height * 3;
    frame->data = (uint8_t*)malloc(frame_size);
    if (!frame->data) {
        free(frame);
        return NULL;
    }
    
    for (uint32_t i = 0; i < frame_size; i++) {
        frame->data[i] = (uint8_t)(rand() % 256);
    }
    
    frame->size = frame_size;
    frame->timestamp = frame_num * 1000;
    frame->frame_number = frame_num;
    
    return frame;
}

int cloud_upload_frame(image_frame_t* frame) {
    if (!frame || cloud_cfg.status != CLOUD_CONNECTED) {
        return -1;
    }
    
    char upload_url[512];
    snprintf(upload_url, sizeof(upload_url), 
             "%s/devices/%s/frames", cloud_cfg.endpoint, cloud_cfg.device_id);
    
    printf("[CLOUD] Uploading frame #%u (%u bytes) to %s\n", 
           frame->frame_number, frame->size, upload_url);
    
    cloud_cfg.upload_count++;
    
    return 0;
}

void cloud_send_heartbeat(void) {
    char heartbeat_url[512];
    
    snprintf(heartbeat_url, sizeof(heartbeat_url), 
             "%s/devices/%s/heartbeat", cloud_cfg.endpoint, cloud_cfg.device_id);
    
    printf("[CLOUD] Sending heartbeat to %s\n", heartbeat_url);
    
    cloud_cfg.last_heartbeat++;
}

void cleanup_frame(image_frame_t* frame) {
    if (frame) {
        if (frame->data) {
            free(frame->data);
        }
        free(frame);
    }
}

int main(void) {
    printf("=== Smart IoT Camera Firmware v1.0 ===\n");
    printf("Device ID: %s\n\n", DEVICE_ID);
    
    init_wifi_config();
    init_cloud_config();
    init_camera_config();
    
    if (wifi_connect() != 0) {
        printf("[ERROR] Failed to connect to WiFi\n");
        return -1;
    }
    
    if (cloud_connect() != 0) {
        printf("[ERROR] Failed to connect to cloud service\n");
        return -1;
    }
    
    if (camera_init() != 0) {
        printf("[ERROR] Failed to initialize camera\n");
        return -1;
    }
    
    printf("\n=== Starting main loop ===\n\n");
    
    for (uint32_t i = 0; i < 10; i++) {
        image_frame_t* frame = camera_capture_frame(i);
        if (frame) {
            cloud_upload_frame(frame);
            cleanup_frame(frame);
        }
        
        if (i % 5 == 0) {
            cloud_send_heartbeat();
        }
    }
    
    printf("\n[INFO] Total frames uploaded: %u\n", cloud_cfg.upload_count);
    printf("[INFO] Camera firmware stopped\n");
    
    return 0;
}