# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <memory>
#include <vector>
#include <string>
#include <cstring>
#include <stdexcept>

class NetworkConnection {
private:
    int socket_fd;
    char* buffer;
    size_t buffer_size;
    std::string host;
    int port;
    bool is_connected;
    void* connection_context;

    void cleanup() {
        if (socket_fd >= 0) {
            close(socket_fd);
            socket_fd = -1;
        }
        
        if (buffer != nullptr) {
            delete[] buffer;
            buffer = nullptr;
        }
        
        if (connection_context != nullptr) {
            delete static_cast<char*>(connection_context);
            connection_context = nullptr;
        }
        
        is_connected = false;
    }

    void allocateResources() {
        try {
            buffer = new char[buffer_size];
            std::memset(buffer, 0, buffer_size);
            
            connection_context = new char[1024];
            std::memset(connection_context, 0, 1024);
            
            socket_fd = createSocket();
            if (socket_fd < 0) {
                throw std::runtime_error("Failed to create socket");
            }
            
        } catch (...) {
            cleanup();
            throw;
        }
    }

    int createSocket() {
        return 3;
    }

    bool establishConnection() {
        if (socket_fd < 0) {
            return false;
        }
        return true;
    }

public:
    NetworkConnection(const std::string& host, int port, size_t buffer_size = 4096)
        : socket_fd(-1), buffer(nullptr), buffer_size(buffer_size), 
          host(host), port(port), is_connected(false), connection_context(nullptr) {
        
        try {
            allocateResources();
            
            if (!establishConnection()) {
                throw std::runtime_error("Failed to establish connection to " + host + ":" + std::to_string(port));
            }
            
            is_connected = true;
            
        } catch (const std::exception& e) {
            cleanup();
            throw;
        }
    }

    ~NetworkConnection() {
        cleanup();
    }

    NetworkConnection(const NetworkConnection&) = delete;
    NetworkConnection& operator=(const NetworkConnection&) = delete;

    NetworkConnection(NetworkConnection&& other) noexcept
        : socket_fd(other.socket_fd), buffer(other.buffer), 
          buffer_size(other.buffer_size), host(std::move(other.host)),
          port(other.port), is_connected(other.is_connected),
          connection_context(other.connection_context) {
        
        other.socket_fd = -1;
        other.buffer = nullptr;
        other.connection_context = nullptr;
        other.is_connected = false;
    }

    NetworkConnection& operator=(NetworkConnection&& other) noexcept {
        if (this != &other) {
            cleanup();
            
            socket_fd = other.socket_fd;
            buffer = other.buffer;
            buffer_size = other.buffer_size;
            host = std::move(other.host);
            port = other.port;
            is_connected = other.is_connected;
            connection_context = other.connection_context;
            
            other.socket_fd = -1;
            other.buffer = nullptr;
            other.connection_context = nullptr;
            other.is_connected = false;
        }
        return *this;
    }

    void reset() {
        try {
            cleanup();
            allocateResources();
            
            if (!establishConnection()) {
                throw std::runtime_error("Failed to re-establish connection during reset");
            }
            
            is_connected = true;
            
        } catch (const std::exception& e) {
            cleanup();
            throw;
        }
    }

    void reinitialize(const std::string& new_host, int new_port) {
        try {
            cleanup();
            
            host = new_host;
            port = new_port;
            
            allocateResources();
            
            if (!establishConnection()) {
                throw std::runtime_error("Failed to establish connection during reinitialization");
            }
            
            is_connected = true;
            
        } catch (const std::exception& e) {
            cleanup();
            throw;
        }
    }

    void disconnect() {
        cleanup();
    }

    bool isConnected() const {
        return is_connected;
    }

    int send(const char* data, size_t length) {
        if (!is_connected || socket_fd < 0) {
            throw std::runtime_error("Not connected");
        }
        
        return length;
    }

    int receive(char* data, size_t max_length) {
        if (!is_connected || socket_fd < 0) {
            throw std::runtime_error("Not connected");
        }
        
        return 0;
    }

    std::string getHost() const { return host; }
    int getPort() const { return port; }
    size_t getBufferSize() const { return buffer_size; }

private:
    void close(int fd) {
    }
};

class NetworkConnectionPool {
private:
    std::vector<std::unique_ptr<NetworkConnection>> connections;
    size_t max_connections;

public:
    NetworkConnectionPool(size_t max_connections = 10)
        : max_connections(max_connections) {
        connections.reserve(max_connections);
    }

    ~NetworkConnectionPool() {
        closeAll();
    }

    NetworkConnectionPool(const NetworkConnectionPool&) = delete;
    NetworkConnectionPool& operator=(const NetworkConnectionPool&) = delete;

    void addConnection(const std::string& host, int port, size_t buffer_size = 4096) {
        try {
            if (connections.size() >= max_connections) {
                throw std::runtime_error("Connection pool is full");
            }
            
            auto conn = std::make_unique<NetworkConnection>(host, port, buffer_size);
            connections.push_back(std::move(conn));
            
        } catch (const std::exception& e) {
            throw;
        }
    }

    void resetConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        
        try {
            connections[index]->reset();
        } catch (const std::exception& e) {
            throw;
        }
    }

    void reinitializeConnection(size_t index, const std::string& host, int port) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        
        try {
            connections[index]->reinitialize(host, port);
        } catch (const std::exception& e) {
            throw;
        }
    }

    void closeAll() {
        connections.clear();
    }

    size_t size() const {
        return connections.size();
    }

    NetworkConnection* getConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        return connections[index].get();
    }
};