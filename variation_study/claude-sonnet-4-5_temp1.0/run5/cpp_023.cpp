# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char* input_file;
    char* output_file;
    int verbose;
    int port;
    char* host;
} Config;

Config* parse_arguments(int argc, char** argv) {
    if (argc < 2) {
        fprintf(stderr, "Error: Insufficient arguments\n");
        return NULL;
    }
    
    Config* config = (Config*)malloc(sizeof(Config));
    if (!config) {
        fprintf(stderr, "Error: Memory allocation failed\n");
        return NULL;
    }
    
    config->input_file = NULL;
    config->output_file = NULL;
    config->verbose = 0;
    config->port = 8080;
    config->host = strdup("localhost");
    
    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            if (i + 1 < argc) {
                config->input_file = strdup(argv[++i]);
            }
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 < argc) {
                config->output_file = strdup(argv[++i]);
            }
        } else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbose = 1;
        } else if (strcmp(argv[i], "-p") == 0 || strcmp(argv[i], "--port") == 0) {
            if (i + 1 < argc) {
                config->port = atoi(argv[++i]);
            }
        } else if (strcmp(argv[i], "-h") == 0 || strcmp(argv[i], "--host") == 0) {
            if (i + 1 < argc) {
                free(config->host);
                config->host = strdup(argv[++i]);
            }
        }
    }
    
    return config;
}

void free_config(Config* config) {
    if (config) {
        free(config->input_file);
        free(config->output_file);
        free(config->host);
        free(config);
    }
}

void initialize_application(Config* config) {
    printf("Application initialized with:\n");
    printf("  Input file: %s\n", config->input_file ? config->input_file : "none");
    printf("  Output file: %s\n", config->output_file ? config->output_file : "none");
    printf("  Verbose: %s\n", config->verbose ? "yes" : "no");
    printf("  Host: %s\n", config->host);
    printf("  Port: %d\n", config->port);
}

int main(int argc, char** argv) {
    Config* config = parse_arguments(argc, argv);
    
    if (config) {
        initialize_application(config);
        free_config(config);
        return 0;
    } else {
        fprintf(stderr, "Failed to parse arguments\n");
        return 1;
    }
}