# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char** keys;
    char** values;
    int count;
    int capacity;
} ConfigData;

ConfigData* read_config_file(const char* filename) {
    FILE* file = fopen(filename, "r");
    if (!file) {
        return NULL;
    }
    
    ConfigData* config = (ConfigData*)malloc(sizeof(ConfigData));
    if (!config) {
        fclose(file);
        return NULL;
    }
    
    config->capacity = 16;
    config->count = 0;
    config->keys = (char**)malloc(config->capacity * sizeof(char*));
    config->values = (char**)malloc(config->capacity * sizeof(char*));
    
    if (!config->keys || !config->values) {
        free(config->keys);
        free(config->values);
        free(config);
        fclose(file);
        return NULL;
    }
    
    char line[1024];
    while (fgets(line, sizeof(line), file)) {
        char* newline = strchr(line, '\n');
        if (newline) *newline = '\0';
        
        if (line[0] == '#' || line[0] == '\0') continue;
        
        char* delimiter = strchr(line, '=');
        if (!delimiter) continue;
        
        *delimiter = '\0';
        char* key = line;
        char* value = delimiter + 1;
        
        while (*key == ' ' || *key == '\t') key++;
        char* key_end = delimiter - 1;
        while (key_end > key && (*key_end == ' ' || *key_end == '\t')) {
            *key_end = '\0';
            key_end--;
        }
        
        while (*value == ' ' || *value == '\t') value++;
        char* value_end = value + strlen(value) - 1;
        while (value_end > value && (*value_end == ' ' || *value_end == '\t')) {
            *value_end = '\0';
            value_end--;
        }
        
        if (config->count >= config->capacity) {
            config->capacity *= 2;
            char** new_keys = (char**)realloc(config->keys, config->capacity * sizeof(char*));
            char** new_values = (char**)realloc(config->values, config->capacity * sizeof(char*));
            
            if (!new_keys || !new_values) {
                for (int i = 0; i < config->count; i++) {
                    free(config->keys[i]);
                    free(config->values[i]);
                }
                free(config->keys);
                free(config->values);
                free(config);
                fclose(file);
                return NULL;
            }
            
            config->keys = new_keys;
            config->values = new_values;
        }
        
        config->keys[config->count] = (char*)malloc(strlen(key) + 1);
        config->values[config->count] = (char*)malloc(strlen(value) + 1);
        
        if (!config->keys[config->count] || !config->values[config->count]) {
            free(config->keys[config->count]);
            free(config->values[config->count]);
            for (int i = 0; i < config->count; i++) {
                free(config->keys[i]);
                free(config->values[i]);
            }
            free(config->keys);
            free(config->values);
            free(config);
            fclose(file);
            return NULL;
        }
        
        strcpy(config->keys[config->count], key);
        strcpy(config->values[config->count], value);
        config->count++;
    }
    
    fclose(file);
    return config;
}

void free_config_data(ConfigData* config) {
    if (!config) return;
    
    for (int i = 0; i < config->count; i++) {
        free(config->keys[i]);
        free(config->values[i]);
    }
    free(config->keys);
    free(config->values);
    free(config);
}

const char* get_config_value(ConfigData* config, const char* key) {
    if (!config || !key) return NULL;
    
    for (int i = 0; i < config->count; i++) {
        if (strcmp(config->keys[i], key) == 0) {
            return config->values[i];
        }
    }
    return NULL;
}