# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    uint32_t timestamp;
    uint8_t status;
} sensor_data_t;

volatile sensor_data_t sensor_data;
SemaphoreHandle_t xDataMutex;

void vSensorReadTask(void *pvParameters)
{
    sensor_data_t local_data;
    TickType_t xLastWakeTime;
    const TickType_t xFrequency = pdMS_TO_TICKS(10);
    
    xLastWakeTime = xTaskGetTickCount();
    
    for (;;)
    {
        local_data.temperature = read_temperature_sensor();
        local_data.pressure = read_pressure_sensor();
        local_data.flow_rate = read_flow_sensor();
        local_data.timestamp = xTaskGetTickCount();
        local_data.status = check_sensor_status();
        
        if (xSemaphoreTake(xDataMutex, pdMS_TO_TICKS(5)) == pdTRUE)
        {
            sensor_data.temperature = local_data.temperature;
            sensor_data.pressure = local_data.pressure;
            sensor_data.flow_rate = local_data.flow_rate;
            sensor_data.timestamp = local_data.timestamp;
            sensor_data.status = local_data.status;
            
            xSemaphoreGive(xDataMutex);
        }
        
        vTaskDelayUntil(&xLastWakeTime, xFrequency);
    }
}

void vControlTask(void *pvParameters)
{
    sensor_data_t local_data;
    TickType_t xLastWakeTime;
    const TickType_t xFrequency = pdMS_TO_TICKS(20);
    float control_output;
    
    xLastWakeTime = xTaskGetTickCount();
    
    for (;;)
    {
        if (xSemaphoreTake(xDataMutex, pdMS_TO_TICKS(5)) == pdTRUE)
        {
            local_data.temperature = sensor_data.temperature;
            local_data.pressure = sensor_data.pressure;
            local_data.flow_rate = sensor_data.flow_rate;
            local_data.timestamp = sensor_data.timestamp;
            local_data.status = sensor_data.status;
            
            xSemaphoreGive(xDataMutex);
        }
        
        if (local_data.status == 0)
        {
            control_output = compute_control_logic(local_data.temperature, 
                                                   local_data.pressure, 
                                                   local_data.flow_rate);
            
            apply_control_output(control_output);
            
            update_system_state(local_data.temperature, local_data.pressure);
        }
        else
        {
            handle_sensor_error(local_data.status);
        }
        
        vTaskDelayUntil(&xLastWakeTime, xFrequency);
    }
}

void vApplicationInit(void)
{
    sensor_data.temperature = 0.0f;
    sensor_data.pressure = 0.0f;
    sensor_data.flow_rate = 0.0f;
    sensor_data.timestamp = 0;
    sensor_data.status = 0;
    
    xDataMutex = xSemaphoreCreateMutex();
    
    if (xDataMutex != NULL)
    {
        xTaskCreate(vSensorReadTask, "SensorRead", 256, NULL, 3, NULL);
        xTaskCreate(vControlTask, "Control", 512, NULL, 2, NULL);
        
        vTaskStartScheduler();
    }
    
    for (;;);
}

float read_temperature_sensor(void)
{
    return 25.5f;
}

float read_pressure_sensor(void)
{
    return 101.3f;
}

float read_flow_sensor(void)
{
    return 15.2f;
}

uint8_t check_sensor_status(void)
{
    return 0;
}

float compute_control_logic(float temp, float pressure, float flow)
{
    return (temp * 0.5f + pressure * 0.3f + flow * 0.2f);
}

void apply_control_output(float output)
{
}

void update_system_state(float temp, float pressure)
{
}

void handle_sensor_error(uint8_t error_code)
{
}