# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <string>
#include <vector>
#include <memory>
#include <cstring>
#include <sstream>

class TransformationResult {
public:
    std::string data;
    int status;
    double metric;
    
    TransformationResult(const std::string& d, int s, double m) 
        : data(d), status(s), metric(m) {}
};

class DataTransformer {
private:
    struct TempBuffer {
        char* data;
        size_t capacity;
        size_t size;
        
        TempBuffer() : data(nullptr), capacity(0), size(0) {}
        ~TempBuffer() { if (data) delete[] data; }
        
        void resize(size_t new_size) {
            if (new_size > capacity) {
                if (data) delete[] data;
                capacity = new_size * 2;
                data = new char[capacity];
            }
            size = new_size;
        }
    };
    
    TempBuffer buffer1;
    TempBuffer buffer2;
    TempBuffer buffer3;
    std::string reusable_string;
    std::vector<double> metrics_cache;
    
public:
    DataTransformer() {
        metrics_cache.reserve(100);
    }
    
    TransformationResult transform(const std::string& input) {
        reusable_string.clear();
        reusable_string.reserve(input.size() * 2);
        
        buffer1.resize(input.size());
        std::memcpy(buffer1.data, input.c_str(), input.size());
        
        for (size_t i = 0; i < buffer1.size; ++i) {
            buffer1.data[i] = buffer1.data[i] ^ 0xAA;
        }
        
        size_t encoded_size = buffer1.size * 2;
        buffer2.resize(encoded_size);
        for (size_t i = 0; i < buffer1.size; ++i) {
            unsigned char byte = static_cast<unsigned char>(buffer1.data[i]);
            buffer2.data[i * 2] = "0123456789ABCDEF"[byte >> 4];
            buffer2.data[i * 2 + 1] = "0123456789ABCDEF"[byte & 0x0F];
        }
        
        size_t compressed_size = 0;
        buffer3.resize(encoded_size);
        for (size_t i = 0; i < buffer2.size;) {
            char current = buffer2.data[i];
            size_t count = 1;
            while (i + count < buffer2.size && buffer2.data[i + count] == current && count < 255) {
                ++count;
            }
            
            if (count > 3) {
                buffer3.data[compressed_size++] = '*';
                buffer3.data[compressed_size++] = static_cast<char>(count);
                buffer3.data[compressed_size++] = current;
            } else {
                for (size_t j = 0; j < count; ++j) {
                    buffer3.data[compressed_size++] = current;
                }
            }
            i += count;
        }
        buffer3.size = compressed_size;
        
        reusable_string.assign(buffer3.data, buffer3.size);
        
        metrics_cache.clear();
        for (size_t i = 0; i < buffer3.size && i < 100; ++i) {
            metrics_cache.push_back(static_cast<double>(buffer3.data[i]) * 0.5);
        }
        
        double final_metric = 0.0;
        for (double m : metrics_cache) {
            final_metric += m;
        }
        final_metric /= (metrics_cache.empty() ? 1.0 : metrics_cache.size());
        
        int status = (compressed_size < encoded_size) ? 1 : 0;
        
        return TransformationResult(reusable_string, status, final_metric);
    }
};

TransformationResult processData(const std::string& input) {
    static thread_local DataTransformer transformer;
    return transformer.transform(input);
}