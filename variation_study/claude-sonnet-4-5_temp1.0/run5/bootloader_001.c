# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>

#define BOOTLOADER_START_ADDR   0x08000000
#define APP_START_ADDR          0x08008000
#define FLASH_SIZE              0x00080000
#define PAGE_SIZE               2048
#define BOOTLOADER_SIZE         0x8000

#define UART_BASE               0x40013800
#define GPIOA_BASE              0x48000000
#define FLASH_BASE              0x40022000
#define RCC_BASE                0x40021000
#define SPI_BASE                0x40013000

#define UART_SR                 (*(volatile uint32_t*)(UART_BASE + 0x1C))
#define UART_DR                 (*(volatile uint32_t*)(UART_BASE + 0x28))
#define UART_BRR                (*(volatile uint32_t*)(UART_BASE + 0x0C))
#define UART_CR1                (*(volatile uint32_t*)(UART_BASE + 0x00))

#define FLASH_ACR               (*(volatile uint32_t*)(FLASH_BASE + 0x00))
#define FLASH_KEYR              (*(volatile uint32_t*)(FLASH_BASE + 0x08))
#define FLASH_SR                (*(volatile uint32_t*)(FLASH_BASE + 0x10))
#define FLASH_CR                (*(volatile uint32_t*)(FLASH_BASE + 0x14))

#define GPIOA_MODER             (*(volatile uint32_t*)(GPIOA_BASE + 0x00))
#define GPIOA_IDR               (*(volatile uint32_t*)(GPIOA_BASE + 0x10))
#define GPIOA_PUPDR             (*(volatile uint32_t*)(GPIOA_BASE + 0x0C))

#define RCC_AHBENR              (*(volatile uint32_t*)(RCC_BASE + 0x14))
#define RCC_APB2ENR             (*(volatile uint32_t*)(RCC_BASE + 0x18))

#define FLASH_KEY1              0x45670123
#define FLASH_KEY2              0xCDEF89AB
#define FLASH_CR_PER            (1 << 1)
#define FLASH_CR_PG             (1 << 0)
#define FLASH_CR_STRT           (1 << 6)
#define FLASH_CR_LOCK           (1 << 7)
#define FLASH_SR_BSY            (1 << 0)
#define FLASH_SR_EOP            (1 << 5)

#define BOOT_PIN                0
#define MAGIC_NUMBER            0xDEADBEEF
#define UPDATE_FLAG_ADDR        0x20000000

#define CMD_START               0x01
#define CMD_DATA                0x02
#define CMD_END                 0x03
#define CMD_ACK                 0x06
#define CMD_NACK                0x15

#define SPI_CR1                 (*(volatile uint32_t*)(SPI_BASE + 0x00))
#define SPI_CR2                 (*(volatile uint32_t*)(SPI_BASE + 0x04))
#define SPI_SR                  (*(volatile uint32_t*)(SPI_BASE + 0x08))
#define SPI_DR                  (*(volatile uint32_t*)(SPI_BASE + 0x0C))

#define SD_CS_LOW()             GPIOA_BSRR = (1 << (4 + 16))
#define SD_CS_HIGH()            GPIOA_BSRR = (1 << 4)
#define GPIOA_BSRR              (*(volatile uint32_t*)(GPIOA_BASE + 0x18))

typedef struct {
    uint32_t stack_ptr;
    void (*reset_handler)(void);
} VectorTable;

typedef enum {
    UPDATE_NONE = 0,
    UPDATE_UART,
    UPDATE_SD
} UpdateSource;

static void flash_unlock(void);
static void flash_lock(void);
static uint8_t flash_erase_page(uint32_t addr);
static uint8_t flash_write_halfword(uint32_t addr, uint16_t data);
static uint8_t flash_write_buffer(uint32_t addr, const uint8_t* data, uint32_t len);
static void uart_init(void);
static void uart_send(uint8_t data);
static uint8_t uart_receive(void);
static uint8_t uart_available(void);
static void gpio_init(void);
static uint8_t check_boot_pin(void);
static uint8_t check_update_flag(void);
static void jump_to_app(void);
static uint8_t verify_app(void);
static void spi_init(void);
static uint8_t spi_transfer(uint8_t data);
static uint8_t sd_init(void);
static uint8_t sd_read_block(uint32_t block, uint8_t* buffer);
static uint8_t process_uart_update(void);
static uint8_t process_sd_update(void);
static uint32_t crc32(const uint8_t* data, uint32_t len);
static void delay_ms(uint32_t ms);

static uint8_t rx_buffer[PAGE_SIZE];
static volatile uint32_t systick_counter = 0;

void SysTick_Handler(void) {
    systick_counter++;
}

static void delay_ms(uint32_t ms) {
    uint32_t start = systick_counter;
    while ((systick_counter - start) < ms);
}

static void flash_unlock(void) {
    FLASH_KEYR = FLASH_KEY1;
    FLASH_KEYR = FLASH_KEY2;
}

static void flash_lock(void) {
    FLASH_CR |= FLASH_CR_LOCK;
}

static uint8_t flash_erase_page(uint32_t addr) {
    while (FLASH_SR & FLASH_SR_BSY);
    
    FLASH_CR |= FLASH_CR_PER;
    FLASH_AR = addr;
    FLASH_CR |= FLASH_CR_STRT;
    
    while (FLASH_SR & FLASH_SR_BSY);
    FLASH_CR &= ~FLASH_CR_PER;
    
    return (FLASH_SR & FLASH_SR_EOP) ? 1 : 0;
}

#define FLASH_AR (*(volatile uint32_t*)(FLASH_BASE + 0x18))

static uint8_t flash_write_halfword(uint32_t addr, uint16_t data) {
    while (FLASH_SR & FLASH_SR_BSY);
    
    FLASH_CR |= FLASH_CR_PG;
    *(volatile uint16_t*)addr = data;
    
    while (FLASH_SR & FLASH_SR_BSY);
    FLASH_CR &= ~FLASH_CR_PG;
    
    return (*(volatile uint16_t*)addr == data) ? 1 : 0;
}

static uint8_t flash_write_buffer(uint32_t addr, const uint8_t* data, uint32_t len) {
    uint32_t i;
    for (i = 0; i < len; i += 2) {
        uint16_t halfword = data[i] | (data[i + 1] << 8);
        if (!flash_write_halfword(addr + i, halfword)) {
            return 0;
        }
    }
    return 1;
}

static void uart_init(void) {
    RCC_APB2ENR |= (1 << 14);
    RCC_AHBENR |= (1 << 17);
    
    GPIOA_MODER &= ~((3 << (9 * 2)) | (3 << (10 * 2)));
    GPIOA_MODER |= (2 << (9 * 2)) | (2 << (10 * 2));
    
    volatile uint32_t* GPIOA_AFRH = (volatile uint32_t*)(GPIOA_BASE + 0x24);
    *GPIOA_AFRH &= ~((0xF << ((9 - 8) * 4)) | (0xF << ((10 - 8) * 4)));
    *GPIOA_AFRH |= (1 << ((9 - 8) * 4)) | (1 << ((10 - 8) * 4));
    
    UART_BRR = 8000000 / 115200;
    UART_CR1 = (1 << 0) | (1 << 2) | (1 << 3);
}

static void uart_send(uint8_t data) {
    while (!(UART_SR & (1 << 7)));
    UART_DR = data;
}

static uint8_t uart_receive(void) {
    while (!(UART_SR & (1 << 5)));
    return UART_DR;
}

static uint8_t uart_available(void) {
    return (UART_SR & (1 << 5)) ? 1 : 0;
}

static void gpio_init(void) {
    RCC_AHBENR |= (1 << 17);
    
    GPIOA_MODER &= ~(3 << (BOOT_PIN * 2));
    GPIOA_PUPDR &= ~(3 << (BOOT_PIN * 2));
    GPIOA_PUPDR |= (1 << (BOOT_PIN * 2));
}

static uint8_t check_boot_pin(void) {
    return !(GPIOA_IDR & (1 << BOOT_PIN));
}

static uint8_t check_update_flag(void) {
    volatile uint32_t* flag = (volatile uint32_t*)UPDATE_FLAG_ADDR;
    if (*flag == MAGIC_NUMBER) {
        *flag = 0;
        return 1;
    }
    return 0;
}

static void jump_to_app(void) {
    VectorTable* app_vectors = (VectorTable*)APP_START_ADDR;
    
    __asm volatile ("MSR msp, %0" : : "r" (app_vectors->stack_ptr));
    __asm volatile ("DSB");
    __asm volatile ("ISB");
    
    app_vectors->reset_handler();
}

static uint8_t verify_app(void) {
    VectorTable* app_vectors = (VectorTable*)APP_START_ADDR;
    
    if (app_vectors->stack_ptr < 0x20000000 || app_vectors->stack_ptr > 0x20010000) {
        return 0;
    }
    
    if ((uint32_t)app_vectors->reset_handler < APP_START_ADDR || 
        (uint32_t)app_vectors->reset_handler > FLASH_SIZE) {
        return 0;
    }
    
    return 1;
}

static void spi_init(void) {
    RCC_APB2ENR |= (1 << 12);
    RCC_AHBENR |= (1 << 17);
    
    GPIOA_MODER &= ~((3 << (4 * 2)) | (3 << (5 * 2)) | (3 << (6 * 2)) | (3 << (7 * 2)));
    GPIOA_MODER |= (1 << (4 * 2)) | (2 << (5 * 2)) | (2 << (6 * 2)) | (2 << (7 * 2));
    
    volatile uint32_t* GPIOA_AFRL = (volatile uint32_t*)(GPIOA_BASE + 0x20);
    *GPIOA_AFRL |= (5 << (5 * 4)) | (5 << (6 * 4)) | (5 << (7 * 4));
    
    SD_CS_HIGH();
    
    SPI_CR1 = (1 << 9) | (1 << 8) | (7 << 3) | (1 << 2) | (1 << 1);
    SPI_CR2 = (7 << 8);
    SPI_CR1 |= (1 << 6);
}

static uint8_t spi_transfer(uint8_t data) {
    while (!(SPI_SR & (1 << 1)));
    *(volatile uint8_t*)&SPI_DR = data;
    while (!(SPI_SR & (1 << 0)));
    return *(volatile uint8_t*)&SPI_DR;
}

static uint8_t sd_init(void) {
    uint8_t i, response;
    
    for (i = 0; i < 10; i++) {
        spi_transfer(0xFF);
    }
    
    SD_CS_LOW();
    spi_transfer(0x40);
    spi_transfer(0x00);
    spi_transfer(0x00);
    spi_transfer(0x00);
    spi_transfer(0x00);
    spi_transfer(0x95);
    
    for (i = 0; i < 10; i++) {
        response = spi_transfer(0xFF);
        if (response == 0x01) break;
    }
    SD_CS_HIGH();
    
    if (response != 0x01) return 0;
    
    for (i = 0; i < 100; i++) {
        SD_CS_LOW();
        spi_transfer(0x41);
        spi_transfer(0x00);
        spi_transfer(0x00);
        spi_transfer(0x00);
        spi_transfer(0x00);
        spi_transfer(0xFF);
        
        response = spi_transfer(0xFF);
        SD_CS_HIGH();
        
        if (response == 0x00) return 1;
        delay_ms(10);
    }
    
    return 0;
}

static uint8_t sd_read_block(uint32_t block, uint8_t* buffer) {
    uint8_t response;
    uint16_t i;
    
    SD_CS_LOW();
    
    spi_transfer(0x51);
    spi_transfer((block >> 24) & 0xFF);
    spi_transfer((block >> 16) & 0xFF);
    spi_transfer((block >> 8) & 0xFF);
    spi_transfer(block & 0xFF);
    spi_transfer(0xFF);
    
    for (i = 0; i < 100; i++) {
        response = spi_transfer(0xFF);
        if (response == 0x00) break;
    }
    
    if (response != 0x00) {
        SD_CS_HIGH();
        return 0;
    }
    
    for (i = 0; i < 1000; i++) {
        response = spi_transfer(0xFF);
        if (response == 0xFE) break;
    }
    
    if (response != 0xFE) {
        SD_CS_HIGH();
        return 0;
    }
    
    for (i = 0; i < 512; i++) {
        buffer[i] = spi_transfer(0xFF);
    }
    
    spi_transfer(0xFF);
    spi_transfer(0xFF);
    
    SD_CS_HIGH();
    spi_transfer(0xFF);
    
    return 1;
}

static uint32_t crc32(const uint8_t* data, uint32_t len) {
    uint32_t crc = 0xFFFFFFFF;
    uint32_t i, j;
    
    for (i = 0; i < len; i++) {
        crc ^= data[i];
        for (j = 0; j < 8; j++) {
            crc = (crc >> 1) ^ (0xEDB88320 & -(crc & 1));
        }
    }
    
    return ~crc;
}

static uint8_t process_uart_update(void) {
    uint8_t cmd;
    uint32_t size, addr, bytes_received, crc, received_crc;
    uint32_t timeout;
    
    uart_send(CMD_ACK);
    
    timeout = systick_counter + 5000;
    while (!uart_available()) {
        if (systick_counter > timeout) return 0;
    }
    cmd = uart_receive();
    
    if (cmd != CMD_START) return 0;
    
    size = uart_receive() | (uart_receive() << 8) | 
           (uart_receive() << 16) | (uart_receive() << 24);
    
    if (size > (FLASH_SIZE - BOOTLOADER_SIZE)) return 0;
    
    uart_send(CMD_ACK);
    
    flash_unlock();
    
    for (addr = APP_START_ADDR; addr < BOOTLOADER_START_ADDR + FLASH_SIZE; addr += PAGE_SIZE) {
        if (!flash_erase_page(addr)) {
            flash_lock();
            uart_send(CMD_NACK);
            return 0;
        }
    }
    
    addr = APP_START_ADDR;
    bytes_received = 0;
    
    while (bytes_received < size) {
        uint16_t chunk_size;
        uint16_t i;
        
        timeout = systick_counter + 5000;
        while (!uart_available()) {
            if (systick_counter > timeout) {
                flash_lock();
                return 0;
            }
        }
        cmd = uart_receive();
        
        if (cmd != CMD_DATA) {
            flash_lock();
            uart_send(CMD_NACK);
            return 0;
        }
        
        chunk_size = uart_receive() | (uart_receive() << 8);
        
        if (chunk_size > PAGE_SIZE) {
            flash_lock();
            uart_send(CMD_NACK);
            return 0;
        }
        
        for (i = 0; i < chunk_size; i++) {
            timeout = systick_counter + 1000;
            while (!uart_available()) {
                if (systick_counter > timeout) {
                    flash_lock();
                    return 0;
                }
            }
            rx_buffer[i] = uart_receive();
        }
        
        if (!flash_write_buffer(addr, rx_buffer, chunk_size)) {
            flash_lock();
            uart_send(CMD_NACK);
            return 0;
        }
        
        addr += chunk_size;
        bytes_received += chunk_size;
        
        uart_send(CMD_ACK);
    }
    
    timeout = systick_counter + 5000;
    while (!uart_available()) {
        if (systick_counter > timeout) {
            flash_lock();
            return 0;
        }
    }
    cmd = uart_receive();
    
    if (cmd != CMD_END) {
        flash_lock();
        uart_send(CMD_NACK);
        return 0;
    }
    
    received_crc = uart_receive() | (uart_receive() << 8) | 
                   (uart_receive() << 16) | (uart_receive() << 24);
    
    crc = crc32((const uint8_t*)APP_START_ADDR, size);
    
    flash_lock();
    
    if (crc != received_crc) {
        uart_send(CMD_NACK);
        return 0;
    }
    
    uart_send(CMD_ACK);
    return 1;
}

static uint8_t process_sd_update(void) {
    uint8_t header[512];
    uint32_t size, blocks, i;
    uint32_t addr;
    uint32_t crc, stored_crc;
    
    if (!sd_read_block(0, header)) return 0;
    
    if (header[0] != 'F' || header[1] != 'W' || header[2] != 'U' || header[3] != 'P') {
        return 0;
    }
    
    size = header[4] | (header[5] << 8) | (header[6] << 16) | (header[7] << 24);
    stored_crc = header[8] | (header[9] << 8) | (header[10] << 16) | (header[11] << 24);
    
    if (size > (FLASH_SIZE - BOOTLOADER_SIZE)) return 0;
    
    blocks = (size + 511) / 512;
    
    flash_unlock();
    
    for (addr = APP_START_ADDR; addr < BOOTLOADER_START_ADDR + FLASH_SIZE; addr += PAGE_SIZE) {
        if (!flash_erase_page(addr)) {
            flash_lock();
            return 0;
        }
    }
    
    addr = APP_START_ADDR;
    crc = 0xFFFFFFFF;
    
    for (i = 0; i < blocks; i++) {
        uint32_t bytes_to_write;
        uint32_t j;
        
        if (!sd_read_block(i + 1, rx_buffer)) {
            flash_lock();
            return 0;
        }
        
        bytes_to_write = (i == blocks - 1) ? (size % 512) : 512;
        if (bytes_to_write == 0) bytes_to_write = 512;
        
        for (j = 0; j < bytes_to_write; j++) {
            uint32_t k;
            crc ^= rx_buffer[j];
            for (k = 0; k < 8; k++) {
                crc = (crc >> 1) ^ (0xEDB88320 & -(crc & 1));
            }
        }
        
        if (!flash_write_buffer(addr, rx_buffer, bytes_to_write)) {
            flash_lock();
            return 0;
        }
        
        addr += bytes_to_write;
    }
    
    flash_lock();
    
    crc = ~crc;
    return (crc == stored_crc) ? 1 : 0;
}

void bootloader_main(void) {
    UpdateSource update_source = UPDATE_NONE;
    uint8_t update_success = 0;
    
    *(volatile uint32_t*)0xE000E010 = 8000000 / 1000 - 1;
    *(volatile uint32_t*)0xE000E014 = 0;
    *(volatile uint32_t*)0xE000E010 |= 0x07;
    
    gpio_init();
    uart_init();
    spi_init();
    
    if (check_boot_pin()) {
        update_source = UPDATE_UART;
    } else if (check_update_flag()) {
        update_source = UPDATE_SD;
    }
    
    if (update_source == UPDATE_UART) {
        update_success = process_uart_update();
    } else if (update_source == UPDATE_SD) {
        if (sd_init()) {
            update_success = process_sd_update();
        }
    }
    
    if (verify_app()) {
        jump_to_app();
    }
    
    while (1) {
        update_success = process_uart_update();
        if (update_success && verify_app()) {
            jump_to_app();
        }
    }
}

__attribute__((section(".isr_vector")))
const VectorTable bootloader_vectors = {
    .stack_ptr = 0x20010000,
    .reset_handler = (void (*)(void))bootloader_main
};

void Reset_Handler(void) {
    bootloader_main();
}