# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE 0x40004000
#define UART_DR   (*(volatile uint32_t *)(UART_BASE + 0x00))
#define UART_FR   (*(volatile uint32_t *)(UART_BASE + 0x18))
#define UART_IBRD (*(volatile uint32_t *)(UART_BASE + 0x24))
#define UART_FBRD (*(volatile uint32_t *)(UART_BASE + 0x28))
#define UART_LCRH (*(volatile uint32_t *)(UART_BASE + 0x2C))
#define UART_CR   (*(volatile uint32_t *)(UART_BASE + 0x30))

#define UART_FR_TXFF (1 << 5)
#define UART_FR_RXFE (1 << 4)

#define GPIO_BASE 0x40020000
#define GPIOA_MODER (*(volatile uint32_t *)(GPIO_BASE + 0x00))
#define GPIOA_AFRL  (*(volatile uint32_t *)(GPIO_BASE + 0x20))
#define GPIOB_MODER (*(volatile uint32_t *)(GPIO_BASE + 0x400))
#define GPIOB_PUPDR (*(volatile uint32_t *)(GPIO_BASE + 0x40C))

#define RCC_BASE 0x40023800
#define RCC_AHB1ENR (*(volatile uint32_t *)(RCC_BASE + 0x30))
#define RCC_APB1ENR (*(volatile uint32_t *)(RCC_BASE + 0x40))

#define FLASH_BASE 0x08000000
#define FLASH_SIZE 0x100000

#define CMD_BUFFER_SIZE 128
#define MAX_ARGS 8

typedef struct {
    uint32_t sensor_id;
    uint32_t firmware_version;
    uint32_t sampling_rate;
    uint32_t transmission_interval;
    uint8_t network_key[16];
    uint32_t calibration_offset;
    uint32_t diagnostic_mode;
} device_config_t;

static device_config_t device_config = {
    .sensor_id = 0x12345678,
    .firmware_version = 0x01020300,
    .sampling_rate = 1000,
    .transmission_interval = 60000,
    .network_key = {0x00, 0x11, 0x22, 0x33, 0x44, 0x55, 0x66, 0x77,
                    0x88, 0x99, 0xAA, 0xBB, 0xCC, 0xDD, 0xEE, 0xFF},
    .calibration_offset = 0,
    .diagnostic_mode = 0
};

static char cmd_buffer[CMD_BUFFER_SIZE];
static uint32_t cmd_index = 0;

void uart_init(void) {
    RCC_AHB1ENR |= (1 << 0);
    RCC_APB1ENR |= (1 << 17);
    
    GPIOA_MODER &= ~(0xF << (2 * 2));
    GPIOA_MODER |= (0xA << (2 * 2));
    
    GPIOA_AFRL &= ~(0xFF << (2 * 4));
    GPIOA_AFRL |= (0x77 << (2 * 4));
    
    UART_CR = 0;
    
    UART_IBRD = 104;
    UART_FBRD = 11;
    
    UART_LCRH = (3 << 5);
    
    UART_CR = (1 << 0) | (1 << 8) | (1 << 9);
}

void uart_putc(char c) {
    while (UART_FR & UART_FR_TXFF);
    UART_DR = c;
}

void uart_puts(const char *str) {
    while (*str) {
        if (*str == '\n') {
            uart_putc('\r');
        }
        uart_putc(*str++);
    }
}

char uart_getc(void) {
    while (UART_FR & UART_FR_RXFE);
    return UART_DR & 0xFF;
}

int uart_available(void) {
    return !(UART_FR & UART_FR_RXFE);
}

void jtag_init(void) {
    RCC_AHB1ENR |= (1 << 1);
    
    GPIOB_MODER &= ~(0xFF << (3 * 2));
    GPIOB_MODER |= (0xAA << (3 * 2));
    
    GPIOB_PUPDR &= ~(0xFF << (3 * 2));
    GPIOB_PUPDR |= (0x55 << (3 * 2));
}

void print_hex(uint32_t value) {
    char hex_chars[] = "0123456789ABCDEF";
    char buffer[11];
    buffer[0] = '0';
    buffer[1] = 'x';
    for (int i = 7; i >= 0; i--) {
        buffer[2 + (7 - i)] = hex_chars[(value >> (i * 4)) & 0xF];
    }
    buffer[10] = '\0';
    uart_puts(buffer);
}

void print_dec(uint32_t value) {
    char buffer[12];
    int i = 0;
    
    if (value == 0) {
        uart_puts("0");
        return;
    }
    
    while (value > 0) {
        buffer[i++] = '0' + (value % 10);
        value /= 10;
    }
    
    for (int j = i - 1; j >= 0; j--) {
        uart_putc(buffer[j]);
    }
}

void cmd_dump_memory(char *args[], int argc) {
    uint32_t address = 0x20000000;
    uint32_t length = 256;
    
    if (argc > 0) {
        address = 0;
        for (int i = 0; args[0][i]; i++) {
            address = address * 16;
            if (args[0][i] >= '0' && args[0][i] <= '9') {
                address += args[0][i] - '0';
            } else if (args[0][i] >= 'a' && args[0][i] <= 'f') {
                address += args[0][i] - 'a' + 10;
            } else if (args[0][i] >= 'A' && args[0][i] <= 'F') {
                address += args[0][i] - 'A' + 10;
            }
        }
    }
    
    if (argc > 1) {
        length = 0;
        for (int i = 0; args[1][i]; i++) {
            if (args[1][i] >= '0' && args[1][i] <= '9') {
                length = length * 10 + (args[1][i] - '0');
            }
        }
    }
    
    uart_puts("Memory Dump:\n");
    uart_puts("Address: ");
    print_hex(address);
    uart_puts(" Length: ");
    print_dec(length);
    uart_puts("\n");
    
    uint8_t *ptr = (uint8_t *)address;
    for (uint32_t i = 0; i < length; i += 16) {
        print_hex(address + i);
        uart_puts(": ");
        
        for (int j = 0; j < 16 && (i + j) < length; j++) {
            uint8_t byte = ptr[i + j];
            char hex_chars[] = "0123456789ABCDEF";
            uart_putc(hex_chars[byte >> 4]);
            uart_putc(hex_chars[byte & 0x0F]);
            uart_putc(' ');
        }
        uart_puts("\n");
    }
}

void cmd_read_flash(char *args[], int argc) {
    uint32_t offset = 0;
    uint32_t length = 256;
    
    if (argc > 0) {
        offset = 0;
        for (int i = 0; args[0][i]; i++) {
            offset = offset * 16;
            if (args[0][i] >= '0' && args[0][i] <= '9') {
                offset += args[0][i] - '0';
            } else if (args[0][i] >= 'a' && args[0][i] <= 'f') {
                offset += args[0][i] - 'a' + 10;
            } else if (args[0][i] >= 'A' && args[0][i] <= 'F') {
                offset += args[0][i] - 'A' + 10;
            }
        }
    }
    
    if (argc > 1) {
        length = 0;
        for (int i = 0; args[1][i]; i++) {
            if (args[1][i] >= '0' && args[1][i] <= '9') {
                length = length * 10 + (args[1][i] - '0');
            }
        }
    }
    
    if (offset >= FLASH_SIZE) {
        uart_puts("Error: Offset beyond flash size\n");
        return;
    }
    
    uart_puts("Flash Read:\n");
    uart_puts("Offset: ");
    print_hex(offset);
    uart_puts(" Length: ");
    print_dec(length);
    uart_puts("\n");
    
    uint8_t *flash_ptr = (uint8_t *)(FLASH_BASE + offset);
    for (uint32_t i = 0; i < length; i += 16) {
        print_hex(FLASH_BASE + offset + i);
        uart_puts(": ");
        
        for (int j = 0; j < 16 && (i + j) < length; j++) {
            uint8_t byte = flash_ptr[i + j];
            char hex_chars[] = "0123456789ABCDEF";
            uart_putc(hex_chars[byte >> 4]);
            uart_putc(hex_chars[byte & 0x0F]);
            uart_putc(' ');
        }
        uart_puts("\n");
    }
}

void cmd_get_config(char *args[], int argc) {
    uart_puts("\n=== Device Configuration ===\n");
    
    uart_puts("Sensor ID: ");
    print_hex(device_config.sensor_id);
    uart_puts("\n");
    
    uart_puts("Firmware Version: ");
    print_dec((device_config.firmware_version >> 24) & 0xFF);
    uart_putc('.');
    print_dec((device_config.firmware_version >> 16) & 0xFF);
    uart_putc('.');
    print_dec((device_config.firmware_version >> 8) & 0xFF);
    uart_putc('.');
    print_dec(device_config.firmware_version & 0xFF);
    uart_puts("\n");
    
    uart_puts("Sampling Rate: ");
    print_dec(device_config.sampling_rate);
    uart_puts(" ms\n");
    
    uart_puts("Transmission Interval: ");
    print_dec(device_config.transmission_interval);
    uart_puts(" ms\n");
    
    uart_puts("Network Key: ");
    for (int i = 0; i < 16; i++) {
        char hex_chars[] = "0123456789ABCDEF";
        uart_putc(hex_chars[device_config.network_key[i] >> 4]);
        uart_putc(hex_chars[device_config.network_key[i] & 0x0F]);
        uart_putc(' ');
    }
    uart_puts("\n");
    
    uart_puts("Calibration Offset: ");
    print_dec(device_config.calibration_offset);
    uart_puts("\n");
    
    uart_puts("Diagnostic Mode: ");
    print_dec(device_config.diagnostic_mode);
    uart_puts("\n");
}

void cmd_set_config(char *args[], int argc) {
    if (argc < 2) {
        uart_puts("Usage: set_config <param> <value>\n");
        uart_puts("Parameters: sampling_rate, transmission_interval, calibration_offset, diagnostic_mode\n");
        return;
    }
    
    uint32_t value = 0;
    for (int i = 0; args[1][i]; i++) {
        if (args[1][i] >= '0' && args[1][i] <= '9') {
            value = value * 10 + (args[1][i] - '0');
        }
    }
    
    if (strcmp(args[0], "sampling_rate") == 0) {
        device_config.sampling_rate = value;
        uart_puts("Sampling rate updated to ");
        print_dec(value);
        uart_puts(" ms\n");
    } else if (strcmp(args[0], "transmission_interval") == 0) {
        device_config.transmission_interval = value;
        uart_puts("Transmission interval updated to ");
        print_dec(value);
        uart_puts(" ms\n");
    } else if (strcmp(args[0], "calibration_offset") == 0) {
        device_config.calibration_offset = value;
        uart_puts("Calibration offset updated to ");
        print_dec(value);
        uart_puts("\n");
    } else if (strcmp(args[0], "diagnostic_mode") == 0) {
        device_config.diagnostic_mode = value;
        uart_puts("Diagnostic mode updated to ");
        print_dec(value);
        uart_puts("\n");
    } else {
        uart_puts("Unknown parameter\n");
    }
}

void cmd_reset(char *args[], int argc) {
    uart_puts("Resetting device...\n");
    volatile uint32_t *AIRCR = (volatile uint32_t *)0xE000ED0C;
    *AIRCR = 0x05FA0004;
    while(1);
}

void cmd_version(char *args[], int argc) {
    uart_puts("Industrial IoT Sensor Firmware\n");
    uart_puts("Version: 1.2.3.0\n");
    uart_puts("Build Date: 2024-01-15\n");
    uart_puts("Diagnostic Console v1.0\n");
}

void cmd_help(char *args[], int argc) {
    uart_puts("\n=== Available Commands ===\n");
    uart_puts("dump_memory [addr] [len]  - Dump memory contents\n");
    uart_puts("read_flash [offset] [len] - Read flash memory\n");
    uart_puts("get_config                - Display device configuration\n");
    uart_puts("set_config <param> <val>  - Set configuration parameter\n");
    uart_puts("reset                     - Reset device\n");
    uart_puts("version                   - Display firmware version\n");
    uart_puts("help                      - Show this help\n");
}

void process_command(char *cmd) {
    char *args[MAX_ARGS];
    int argc = 0;
    char *token = cmd;
    
    while (*token == ' ') token++;
    
    while (*token && argc < MAX_ARGS) {
        args[argc++] = token;
        while (*token && *token != ' ') token++;
        if (*token) {
            *token = '\0';
            token++;
            while (*token == ' ') token++;
        }
    }
    
    if (argc == 0) return;
    
    if (strcmp(args[0], "dump_memory") == 0) {
        cmd_dump_memory(&args[1], argc - 1);
    } else if (strcmp(args[0], "read_flash") == 0) {
        cmd_read_flash(&args[1], argc - 1);
    } else if (strcmp(args[0], "get_config") == 0) {
        cmd_get_config(&args[1], argc - 1);
    } else if (strcmp(args[0], "set_config") == 0) {
        cmd_set_config(&args[1], argc - 1);
    } else if (strcmp(args[0], "reset") == 0) {
        cmd_reset(&args[1], argc - 1);
    } else if (strcmp(args[0], "version") == 0) {
        cmd_version(&args[1], argc - 1);
    } else if (strcmp(args[0], "help") == 0) {
        cmd_help(&args[1], argc - 1);
    } else {
        uart_puts("Unknown command: ");
        uart_puts(args[0]);
        uart_puts("\nType 'help' for available commands\n");
    }
}

void console_task(void) {
    if (uart_available()) {
        char c = uart_getc();
        
        if (c == '\r' || c == '\n') {
            uart_puts("\n");
            cmd_buffer[cmd_index] = '\0';
            if (cmd_index > 0) {
                process_command(cmd_buffer);
            }
            cmd_index = 0;
            uart_puts("\n> ");
        } else if (c == 127 || c == 8) {
            if (cmd_index > 0) {
                cmd_index--;
                uart_puts("\b \b");
            }
        } else if (c >= 32 && c < 127) {
            if (cmd_index < CMD_BUFFER_SIZE - 1) {
                cmd_buffer[cmd_index++] = c;
                uart_putc(c);
            }
        }
    }
}

void diagnostic_console_init(void) {
    uart_init();
    jtag_init();
    
    uart_puts("\n\n");
    uart_puts("========================================\n");
    uart_puts("  Industrial IoT Sensor Diagnostic Console\n");
    uart_puts("========================================\n");
    uart_puts("Firmware Version: 1.2.3.0\n");
    uart_puts("UART Console: Initialized\n");
    uart_puts("JTAG Interface: Enabled\n");
    uart_puts("Type 'help' for available commands\n");
    uart_puts("\n> ");
}

int main(void) {
    diagnostic_console_init();
    
    while (1) {
        console_task();
    }
    
    return 0;
}