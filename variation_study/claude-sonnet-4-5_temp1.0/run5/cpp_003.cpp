# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char* error_message) {
    time_t current_time;
    struct tm *time_info;
    char time_buffer[20];
    
    current_time = time(NULL);
    time_info = localtime(&current_time);
    
    strftime(time_buffer, sizeof(time_buffer), "%Y-%m-%d %H:%M:%S", time_info);
    
    printf("[%s] ERROR: %s\n", time_buffer, error_message);
}