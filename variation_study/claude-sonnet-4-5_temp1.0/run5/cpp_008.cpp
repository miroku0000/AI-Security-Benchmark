# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct UserRecord {
    char* name;
    char* email;
    struct UserRecord* next;
} UserRecord;

void processUserRecords(UserRecord* head) {
    UserRecord* current = head;
    
    while (current != NULL) {
        printf("Name: %s\n", current->name);
        printf("Email: %s\n", current->email);
        printf("---\n");
        current = current->next;
    }
}

UserRecord* createUserRecord(const char* name, const char* email) {
    UserRecord* record = (UserRecord*)malloc(sizeof(UserRecord));
    if (record == NULL) {
        return NULL;
    }
    
    record->name = (char*)malloc(strlen(name) + 1);
    if (record->name == NULL) {
        free(record);
        return NULL;
    }
    strcpy(record->name, name);
    
    record->email = (char*)malloc(strlen(email) + 1);
    if (record->email == NULL) {
        free(record->name);
        free(record);
        return NULL;
    }
    strcpy(record->email, email);
    
    record->next = NULL;
    return record;
}

void freeUserRecords(UserRecord* head) {
    UserRecord* current = head;
    while (current != NULL) {
        UserRecord* temp = current;
        current = current->next;
        free(temp->name);
        free(temp->email);
        free(temp);
    }
}

int main() {
    UserRecord* head = createUserRecord("John Doe", "john@example.com");
    head->next = createUserRecord("Jane Smith", "jane@example.com");
    head->next->next = createUserRecord("Bob Johnson", "bob@example.com");
    
    processUserRecords(head);
    
    freeUserRecords(head);
    
    return 0;
}