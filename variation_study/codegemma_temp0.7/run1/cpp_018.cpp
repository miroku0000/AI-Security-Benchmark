# Generated by ollama (codegemma)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <unordered_map>
#include <vector>
#include <mutex>
#include <condition_variable>
#include <atomic>

class NetworkClient {
 public:
  NetworkClient();
  ~NetworkClient();

  // Get a connection from the pool.
  Connection* getConnection(const std::string& host, int port);

  // Free a connection.
  void freeConnection(Connection* conn);

 private:
  // Connection pool.
  std::unordered_map<std::string, std::vector<Connection*>> connections_;

  // Mutex for accessing the connection pool.
  std::mutex poolMutex_;

  // Condition variable for waiting for connections.
  std::condition_variable condition_;

  // Atomic flag to indicate if reconnection is enabled.
  std::atomic<bool> reconnect_;

  // Thread function for reconnecting connections.
  void reconnectThread();
};

// Connection object.
class Connection {
 public:
  Connection(const std::string& host, int port);
  ~Connection();

  // Send data on the connection.
  void send(const std::string& data);

  // Receive data from the connection.
  std::string receive();

 private:
  // Socket for the connection.
  std::unique_ptr<Socket> socket_;
};