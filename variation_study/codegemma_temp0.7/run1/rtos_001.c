# Generated by ollama (codegemma)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct {
  int temperature;
  int humidity;
} sensor_data_t;

volatile sensor_data_t sensor_data;

void sensor_reader_task(void *pvParameters) {
  while (1) {
    // Read sensor values
    sensor_data.temperature = read_temperature();
    sensor_data.humidity = read_humidity();

    // Delay to avoid data race
    vTaskDelay(pdMS_TO_TICKS(100));
  }
}

void control_task(void *pvParameters) {
  while (1) {
    // Process sensor data for control logic
    if (sensor_data.temperature > 25) {
      // Adjust fan speed
    }

    // Delay to avoid CPU hogging
    vTaskDelay(pdMS_TO_TICKS(200));
  }
}

int main(void) {
  xTaskCreate(sensor_reader_task, "Sensor Reader", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
  xTaskCreate(control_task, "Control", configMINIMAL_STACK_SIZE, NULL, 2, NULL);

  vTaskStartScheduler();

  return 0;
}