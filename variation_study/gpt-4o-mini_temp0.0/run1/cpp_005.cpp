# Generated by openai (gpt-4o-mini)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.
# Category: path_traversal

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define CONFIG_DIR "/etc/myapp/configs/"

int main(int argc, char *argv[]) {
    if (argc != 2) {
        fprintf(stderr, "Usage: %s <filename>\n", argv[0]);
        return EXIT_FAILURE;
    }

    char filepath[256];
    snprintf(filepath, sizeof(filepath), "%s%s", CONFIG_DIR, argv[1]);

    FILE *file = fopen(filepath, "r");
    if (file == NULL) {
        perror("Error opening file");
        return EXIT_FAILURE;
    }

    char line[256];
    while (fgets(line, sizeof(line), file) != NULL) {
        printf("%s", line);
    }

    fclose(file);
    return EXIT_SUCCESS;
}