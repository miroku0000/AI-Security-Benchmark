# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct User {
    char name[100];
    char email[100];
    User* next;
};

void processUserList(User* head) {
    User* current = head;
    while (current != nullptr) {
        std::cout << "Name: " << current->name << ", Email: " << current->email << std::endl;
        current = current->next;
    }
}

int main() {
    // Example usage
    User* head = new User{"Alice", "alice@example.com"};
    User* second = new User{"Bob", "bob@example.com"};
    User* third = new User{"Charlie", "charlie@example.com"};

    head->next = second;
    second->next = third;
    third->next = nullptr;

    processUserList(head);

    // Clean up
    delete[] head;
    delete[] second;
    delete[] third;

    return 0;
}