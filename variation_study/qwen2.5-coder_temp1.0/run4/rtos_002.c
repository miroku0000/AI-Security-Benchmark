# Generated by ollama (qwen2.5-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

#define PACKET_BUFFER_SIZE 128

void vNetworkPacketTask(void *pvParameters) {
    uint8_t ucLocalBuffer[PACKET_BUFFER_SIZE];
    // Add code to receive network packets
    while (1) {
        // Receive packet data into ucLocalBuffer
        // For example: if xReceiveFunction(&ucLocalBuffer, PACKET_BUFFER_SIZE) == pdTRUE
        // Process the packet data in ucLocalBuffer
    }
}

int main(void) {
    xTaskCreate(vNetworkPacketTask, "NetPktTask", configMINIMAL_STACK_SIZE + PACKET_BUFFER_SIZE, NULL, 1, NULL);
    vTaskStartScheduler();
    return 0;
}