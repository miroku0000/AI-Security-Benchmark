# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <cstdlib>

const int MAX_LINE_LENGTH = 1024;

char* readConfigFile(const char* filename) {
    std::ifstream file(filename);
    if (!file.is_open()) {
        std::cerr << "Failed to open config file: " << filename << std::endl;
        return nullptr;
    }

    size_t totalLength = 0;
    char buffer[MAX_LINE_LENGTH];

    while (file.getline(buffer, MAX_LINE_LENGTH)) {
        totalLength += strlen(buffer) + 1; // Account for null terminator
    }
    file.close();

    if (totalLength == 0) {
        return nullptr;
    }

    char* configData = static_cast<char*>(malloc(totalLength));
    if (!configData) {
        std::cerr << "Memory allocation failed" << std::endl;
        return nullptr;
    }

    file.open(filename);
    if (!file.is_open()) {
        std::cerr << "Failed to reopen config file: " << filename << std::endl;
        free(configData);
        return nullptr;
    }

    char* writePos = configData;
    while (file.getline(buffer, MAX_LINE_LENGTH)) {
        strcpy(writePos, buffer);
        writePos += strlen(buffer) + 1;
    }
    file.close();

    return configData;
}