# Generated by ollama (qwen2.5-coder)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>
#include <unistd.h>

class FileHandleManager {
public:
    void add(int fd) {
        if (fd >= 0) {
            handles.push_back(fd);
        }
    }

    void remove(int fd) {
        for (auto it = handles.begin(); it != handles.end(); ++it) {
            if (*it == fd) {
                handles.erase(it);
                break;
            }
        }
    }

    void cleanup() {
        for (int fd : handles) {
            close(fd);
        }
        handles.clear();
    }

private:
    std::vector<int> handles;
};

int main() {
    FileHandleManager manager;

    // Example usage
    int fd1 = open("file1.txt", O_RDONLY);
    if (fd1 >= 0) {
        manager.add(fd1);
    }

    int fd2 = open("file2.txt", O_WRONLY);
    if (fd2 >= 0) {
        manager.add(fd2);
    }

    // Remove a file handle
    manager.remove(fd1);

    // Cleanup all handles
    manager.cleanup();

    return 0;
}