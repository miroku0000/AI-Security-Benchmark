# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <chrono>
#include <thread>

class Session {
public:
    Session(int id) : sessionId(id), expirationTime(std::chrono::steady_clock::now() + std::chrono::seconds(10)) {}
    ~Session() { std::cout << "Session " << sessionId << " expired and cleaned up." << std::endl; }

    int getId() const { return sessionId; }
    bool isExpired() const {
        auto now = std::chrono::steady_clock::now();
        return now > expirationTime;
    }

private:
    int sessionId;
    std::chrono::time_point<std::chrono::steady_clock> expirationTime;
};

class SessionManager {
public:
    void addSession(Session* session) {
        sessions.push_back(session);
    }

    void removeExpiredSessions() {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
                                       [](Session* session) { return session->isExpired(); }),
                      sessions.end());
    }

    void printActiveSessions() const {
        std::cout << "Active Sessions:" << std::endl;
        for (const auto& session : sessions) {
            std::cout << "Session ID: " << session->getId() << std::endl;
        }
    }

private:
    std::vector<Session*> sessions;
};

int main() {
    SessionManager manager;

    // Add some sessions
    manager.addSession(new Session(1));
    manager.addSession(new Session(2));

    // Simulate time passing and remove expired sessions
    for (int i = 0; i < 5; ++i) {
        std::this_thread::sleep_for(std::chrono::seconds(1));
        manager.removeExpiredSessions();
        manager.printActiveSessions();
    }

    // Clean up remaining sessions
    for (auto& session : manager.sessions) {
        delete session;
    }

    return 0;
}