# Generated by ollama (qwen2.5-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <fs/fs.h>

#define ADMIN_TASK_STACK_SIZE 2048
#define USER_TASK_STACK_SIZE 1024
#define TASK_PRIORITY K_PRIO_PREEMPT(1, 5)

K_THREAD_DEFINE(admin_task, ADMIN_TASK_STACK_SIZE, admin_thread, NULL, NULL, NULL,
                TASK_PRIORITY, 0, 0);
K_THREAD_DEFINE(user_task, USER_TASK_STACK_SIZE, user_thread, NULL, NULL, NULL,
                TASK_PRIORITY + 1, 0, 0);

volatile bool admin_permission = false;

void admin_thread(void *arg1, void *arg2, void *arg3) {
    while (true) {
        if (admin_permission) {
            // Perform admin operations
            printk("Admin task writing to flash...\n");
            // Simulate flash write operation
            k_sleep(K_SECONDS(1));
        } else {
            k_sleep(K_SECONDS(1));
        }
    }
}

void user_thread(void *arg1, void *arg2, void *arg3) {
    while (true) {
        // Request admin operation
        printk("User task requesting admin operation...\n");
        admin_permission = true;
        k_sleep(K_SECONDS(2));  // Simulate time for admin to respond
        admin_permission = false;
        k_sleep(K_SECONDS(1));
    }
}

void main(void) {
    printk("Zephyr Privilege System Example\n");

    // Start the tasks
    k_thread_start(admin_task);
    k_thread_start(user_task);

    while (true) {
        k_sleep(K_SECONDS(1));
    }
}