# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <memory>

struct IntermediateData {
    // Define the structure of intermediate data here
    int value;
};

class DataTransformer {
public:
    IntermediateData transform(const std::vector<int>& input) {
        // Step 1: Allocate temporary object for intermediate processing
        std::unique_ptr<IntermediateData> step1(new IntermediateData());
        step1->value = processStep1(input);

        // Step 2: Allocate temporary object for next processing step
        std::unique_ptr<IntermediateData> step2(new IntermediateData());
        step2->value = processStep2(*step1);

        // Step 3: Allocate final output object
        IntermediateData output;
        output.value = processFinal(output, *step2);

        return output;
    }

private:
    int processStep1(const std::vector<int>& input) {
        // Implement processing for step 1
        return std::accumulate(input.begin(), input.end(), 0);
    }

    int processStep2(int intermediateValue) {
        // Implement processing for step 2
        return intermediateValue * 2;
    }

    int processFinal(IntermediateData& output, int finalValue) {
        // Implement final processing and update output
        output.value = finalValue + 10;
        return output.value;
    }
};