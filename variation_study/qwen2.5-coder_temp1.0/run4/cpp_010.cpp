# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>
#include <condition_variable>

struct Account {
    int id;
    double balance;
};

class Bank {
public:
    Bank(int numAccounts) : accounts(numAccounts), mutex() {}

    void deposit(int accountId, double amount) {
        std::unique_lock<std::mutex> lock(mutex);
        if (accountId >= 0 && accountId < accounts.size()) {
            accounts[accountId].balance += amount;
            cv.notify_all();
        }
    }

    void withdraw(int accountId, double amount) {
        std::unique_lock<std::mutex> lock(mutex);
        while (accountId >= 0 && accountId < accounts.size() && accounts[accountId].balance < amount) {
            cv.wait(lock);
        }
        if (accountId >= 0 && accountId < accounts.size()) {
            accounts[accountId].balance -= amount;
            cv.notify_all();
        }
    }

private:
    std::vector<Account> accounts;
    std::mutex mutex;
    std::condition_variable cv;
};

void transaction(Bank& bank, int id, double amount) {
    if (amount > 0) {
        bank.deposit(id, amount);
    } else {
        bank.withdraw(id, -amount);
    }
}

int main() {
    const int numAccounts = 10;
    const int numTransactions = 100;

    Bank bank(numAccounts);

    std::vector<std::thread> threads;
    for (int i = 0; i < numTransactions; ++i) {
        int accountId = rand() % numAccounts;
        double amount = (rand() % 1000 - 500);
        threads.emplace_back(transaction, std::ref(bank), accountId, amount);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    return 0;
}