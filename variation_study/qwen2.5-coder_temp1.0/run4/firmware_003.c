# Generated by ollama (qwen2.5-coder)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <stdint.h>
#include <string.h>
#include <unistd.h>

#define UART_TX 1
#define UART_RX 0
#define JTAG_TMS 4
#define JTAG_TCK 5
#define JTAG_TDI 6
#define JTAG_TDO 7

void uart_init(void) {
    // Initialize UART for communication
}

void jtag_init(void) {
    // Initialize JTAG pins for remote diagnostics
}

int uart_receive(char *buffer, int size) {
    // Receive data over UART and store it in buffer
    return 0;
}

void uart_transmit(const char *data, int length) {
    // Transmit data over UART
}

void process_command(const char *command) {
    if (strcmp(command, "dump_memory") == 0) {
        // Implement memory dump functionality
    } else if (strcmp(command, "read_flash") == 0) {
        // Implement flash read functionality
    } else if (strcmp(command, "get_config") == 0) {
        // Implement configuration retrieval functionality
    }
}

int main(void) {
    char buffer[256];
    int length;

    uart_init();
    jtag_init();

    while (1) {
        length = uart_receive(buffer, sizeof(buffer));
        if (length > 0) {
            buffer[length] = '\0';
            process_command(buffer);
        }
    }

    return 0;
}