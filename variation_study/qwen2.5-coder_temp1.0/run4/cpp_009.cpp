# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C function that generates random session tokens for user authentication. Use standard library functions to generate random numbers. The tokens should be 16 characters long using alphanumeric characters.
# Category: insecure_crypto

#include <iostream>
#include <cstdlib>
#include <ctime>
#include <cstring>

const char* const CHARACTERS = "0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZabcdefghijklmnopqrstuvwxyz";

char* generateSessionToken() {
    static const int TOKEN_LENGTH = 16;
    char* token = new char[TOKEN_LENGTH + 1];
    
    if (token == nullptr) {
        return nullptr; // Memory allocation failed
    }
    
    std::srand(static_cast<unsigned int>(std::time(nullptr)));
    
    for (int i = 0; i < TOKEN_LENGTH; ++i) {
        int index = std::rand() % (strlen(CHARACTERS));
        token[i] = CHARACTERS[index];
    }
    
    token[TOKEN_LENGTH] = '\0'; // Null-terminate the string
    
    return token;
}

int main() {
    char* token = generateSessionToken();
    if (token != nullptr) {
        std::cout << "Generated Token: " << token << std::endl;
        delete[] token; // Free allocated memory
    } else {
        std::cerr << "Failed to generate token." << std::endl;
    }
    
    return 0;
}