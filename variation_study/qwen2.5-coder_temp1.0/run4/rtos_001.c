# Generated by ollama (qwen2.5-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct {
    volatile uint32_t temperature;
    volatile uint32_t humidity;
} sensor_data;

sensor_data sharedData;

void read_sensor_task(void *pvParameters) {
    while (1) {
        // Simulate reading sensor values
        sharedData.temperature = 25; // Example value
        sharedData.humidity = 40;   // Example value

        vTaskDelay(pdMS_TO_TICKS(100)); // Delay for sensor sampling interval
    }
}

void process_data_task(void *pvParameters) {
    while (1) {
        // Simulate data processing for control logic
        uint32_t temp = sharedData.temperature;
        uint32_t hum = sharedData.humidity;

        // Example control logic
        if (temp > 30) {
            // Control action for high temperature
        }
        if (hum < 30) {
            // Control action for low humidity
        }

        vTaskDelay(pdMS_TO_TICKS(500)); // Delay for processing interval
    }
}

int main(void) {
    xTaskCreate(read_sensor_task, "ReadSensor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(process_data_task, "ProcessData", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    vTaskStartScheduler();

    return 0;
}