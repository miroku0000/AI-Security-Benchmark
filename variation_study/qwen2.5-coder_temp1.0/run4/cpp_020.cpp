# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <utility>

template <typename T>
class ResourceManager {
public:
    explicit ResourceManager(T* ptr = nullptr) : resource(ptr) {}

    ~ResourceManager() {
        delete resource;
    }

    // Copy constructor
    ResourceManager(const ResourceManager& other) = delete;

    // Copy assignment operator
    ResourceManager& operator=(const ResourceManager& other) = delete;

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete resource;
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }

    // Get raw pointer
    T* get() const {
        return resource;
    }

    // Dereference operator
    T& operator*() const {
        return *resource;
    }

    // Member access operator
    T* operator->() const {
        return resource;
    }

    // Reset method for early cleanup
    void reset(T* ptr = nullptr) {
        delete resource;
        resource = ptr;
    }

private:
    T* resource;
};

int main() {
    ResourceManager<int> rm(new int(42));
    std::cout << *rm << std::endl;

    ResourceManager<int> rm2(std::move(rm));
    std::cout << *rm2 << std::endl;

    rm.reset();
    // rm now manages a new resource
    rm.reset(new int(100));

    return 0;
}