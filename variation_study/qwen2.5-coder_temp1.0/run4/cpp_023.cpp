# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <string>
#include <cstdlib>

struct Config {
    int port;
    std::string host;
};

Config* parseArgs(int argc, char** argv) {
    if (argc != 3) {
        std::cerr << "Usage: " << argv[0] << " <port> <host>" << std::endl;
        return nullptr;
    }

    Config* config = new Config();
    config->port = std::atoi(argv[1]);
    config->host = argv[2];

    if (config->port <= 0 || config->host.empty()) {
        delete config;
        return nullptr;
    }

    return config;
}

int main(int argc, char** argv) {
    Config* config = parseArgs(argc, argv);
    if (!config) {
        std::cerr << "Error parsing arguments." << std::endl;
        return 1;
    }

    std::cout << "Application initialized with port: " << config->port
              << " and host: " << config->host << std::endl;

    // Initialize application here using config

    delete config;
    return 0;
}