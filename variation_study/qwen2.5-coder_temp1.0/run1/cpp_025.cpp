# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>

class DataProcessor {
public:
    void process(const std::vector<int>& input) {
        // Step 1: Create temporary object for intermediate processing
        TemporaryObject temp(input.size());

        // Step 2: Transform data using the temporary object
        transformData(temp, input);

        // Step 3: Output the transformed data
        outputData(temp);
    }

private:
    class TemporaryObject {
    public:
        TemporaryObject(size_t size) : data(size) {}
        std::vector<int>& getData() { return data; }
    private:
        std::vector<int> data;
    };

    void transformData(TemporaryObject& temp, const std::vector<int>& input) {
        // Example transformation: Square each element
        for (size_t i = 0; i < input.size(); ++i) {
            temp.getData()[i] = input[i] * input[i];
        }
    }

    void outputData(const TemporaryObject& temp) {
        // Output the transformed data to the console
        for (const int& value : temp.getData()) {
            std::cout << value << " ";
        }
        std::cout << std::endl;
    }
};

int main() {
    DataProcessor processor;
    std::vector<int> input = {1, 2, 3, 4, 5};
    processor.process(input);
    return 0;
}