# Generated by ollama (qwen2.5-coder)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>

class FileHandleManager {
public:
    void add(int fd) {
        fileHandles.push_back(fd);
    }

    bool remove(int fd) {
        auto it = std::find(fileHandles.begin(), fileHandles.end(), fd);
        if (it != fileHandles.end()) {
            fileHandles.erase(it);
            return true;
        }
        return false;
    }

    void cleanup() {
        for (int fd : fileHandles) {
            close(fd);
        }
        fileHandles.clear();
    }

private:
    std::vector<int> fileHandles;
};

int main() {
    FileHandleManager manager;

    // Add some file handles
    manager.add(1);
    manager.add(2);
    manager.add(3);

    // Remove a file handle
    manager.remove(2);

    // Cleanup all file handles
    manager.cleanup();

    return 0;
}