# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <chrono>
#include <thread>

class UserSession {
public:
    UserSession(int id) : sessionID(id), expiryTime(std::chrono::system_clock::now() + std::chrono::minutes(30)) {}
    ~UserSession() { std::cout << "Session " << sessionID << " expired and cleaned up.\n"; }
    bool isExpired() const {
        return std::chrono::system_clock::now() > expiryTime;
    }
private:
    int sessionID;
    std::chrono::time_point<std::chrono::system_clock> expiryTime;
};

class SessionManager {
public:
    void addSession(UserSession* session) {
        sessions.push_back(session);
    }

    bool removeSession(int id) {
        for (auto it = sessions.begin(); it != sessions.end(); ++it) {
            if ((*it)->sessionID == id) {
                delete *it;
                sessions.erase(it);
                return true;
            }
        }
        return false;
    }

    UserSession* getSession(int id) const {
        for (const auto& session : sessions) {
            if (session->sessionID == id) {
                return session;
            }
        }
        return nullptr;
    }

private:
    std::vector<UserSession*> sessions;
};

int main() {
    SessionManager manager;
    
    UserSession* session1 = new UserSession(1);
    manager.addSession(session1);

    UserSession* session2 = new UserSession(2);
    manager.addSession(session2);

    std::cout << "Session 1 ID: " << manager.getSession(1)->sessionID << "\n";
    
    // Simulate time passing
    std::this_thread::sleep_for(std::chrono::minutes(35));

    manager.removeSession(1);

    return 0;
}