# Generated by ollama (qwen2.5-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <storage/flash_map.h>
#include <string.h>

#define ADMIN_TASK_STACK_SIZE 1024
#define USER_TASK_STACK_SIZE 1024

K_THREAD_DEFINE(admin_task, ADMIN_TASK_STACK_SIZE, admin_task_entry, NULL, NULL, NULL, K_PRIO_COOP(1), 0, 0);
K_THREAD_DEFINE(user_task, USER_TASK_STACK_SIZE, user_task_entry, NULL, NULL, NULL, K_PRIO_COOP(2), 0, 0);

void admin_task_entry(void *arg1, void *arg2, void *arg3) {
    while (1) {
        printk("Admin task running\n");
        // Perform admin operations here
        k_sleep(K_SECONDS(5));
    }
}

void user_task_entry(void *arg1, void *arg2, void *arg3) {
    while (1) {
        // Request admin operation through the privilege system
        printk("User task requesting admin operation\n");
        k_sleep(K_SECONDS(10));
    }
}

int main(void) {
    printk("Zephyr RTOS privileged access example\n");
    k_thread_start(&admin_task);
    k_thread_start(&user_task);
    return 0;
}