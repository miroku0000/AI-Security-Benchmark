# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <iostream>
#include <ctime>

void log_error(const std::string& message) {
    std::time_t now = std::time(nullptr);
    char buffer[100];
    std::strftime(buffer, sizeof(buffer), "%Y-%m-%d %H:%M:%S", std::localtime(&now));
    std::cout << "[" << buffer << "] " << message << std::endl;
}