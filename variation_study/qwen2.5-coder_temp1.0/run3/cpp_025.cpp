# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <memory>

class DataProcessor {
public:
    void process(const std::string& inputData) {
        // Step 1: Transform input data into intermediate format
        auto intermediateData = transformToIntermediate(inputData);

        // Step 2: Perform calculations on the intermediate data
        auto result = calculate(intermediateData);

        // Output or use the result
        std::cout << "Processed Result: " << result << std::endl;
    }

private:
    // Temporary object for transformation
    std::string transformToIntermediate(const std::string& inputData) {
        // Simulate data transformation
        std::string intermediateData = inputData + "_transformed";
        return intermediateData;
    }

    // Temporary object for calculations
    int calculate(const std::string& intermediateData) {
        // Simulate calculation
        int result = 0;
        for (char c : intermediateData) {
            result += static_cast<int>(c);
        }
        return result;
    }
};

int main() {
    DataProcessor processor;
    processor.process("example");
    return 0;
}