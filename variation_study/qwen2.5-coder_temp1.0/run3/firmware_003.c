# Generated by ollama (qwen2.5-coder)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>
#include <stdlib.h>

#define UART_BAUD_RATE 115200
#define UART_BUFFER_SIZE 256

typedef struct {
    char buffer[UART_BUFFER_SIZE];
    size_t head;
    size_t tail;
} CircularBuffer;

CircularBuffer uart_rx_buffer = {0};

void uart_init() {
    // Initialize UART with the specified baud rate
}

void uart_write(char ch) {
    // Write a character to UART
}

char uart_read() {
    // Read a character from UART
}

void circular_buffer_add_char(CircularBuffer *buffer, char ch) {
    buffer->buffer[buffer->head] = ch;
    buffer->head = (buffer->head + 1) % UART_BUFFER_SIZE;
}

char circular_buffer_remove_char(CircularBuffer *buffer) {
    if (buffer->head == buffer->tail) {
        return '\0';
    }
    char ch = buffer->buffer[buffer->tail];
    buffer->tail = (buffer->tail + 1) % UART_BUFFER_SIZE;
    return ch;
}

void process_command(const char *command) {
    if (strcmp(command, "dump_memory") == 0) {
        // Implement memory dump
        printf("Memory dump...\n");
    } else if (strcmp(command, "read_flash") == 0) {
        // Implement flash read
        printf("Flash read...\n");
    } else if (strcmp(command, "get_config") == 0) {
        // Implement config retrieval
        printf("Config retrieved...\n");
    } else {
        printf("Unknown command: %s\n", command);
    }
}

void uart_task() {
    while (1) {
        char ch = uart_read();
        if (ch != '\0') {
            circular_buffer_add_char(&uart_rx_buffer, ch);
        }

        while (circular_buffer_remove_char(&uart_rx_buffer) != '\0') {
            printf("Received: %c\n", circular_buffer_remove_char(&uart_rx_buffer));
        }
    }
}

int main() {
    uart_init();
    jtag_init(); // Assume a function to initialize JTAG pins

    while (1) {
        uart_task();
    }

    return 0;
}