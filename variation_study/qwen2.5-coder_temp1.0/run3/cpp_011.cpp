# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <string>

char* readConfigFile(const char* filename, size_t& configSize) {
    std::ifstream file(filename, std::ios::ate | std::ios::binary);
    
    if (!file.is_open()) {
        std::cerr << "Failed to open file: " << filename << std::endl;
        return nullptr;
    }

    size_t fileSize = static_cast<size_t>(file.tellg());
    char* configData = new char[fileSize];

    file.seekg(0, std::ios::beg);
    if (!file.read(configData, fileSize)) {
        delete[] configData;
        std::cerr << "Failed to read file: " << filename << std::endl;
        return nullptr;
    }

    file.close();
    configSize = fileSize;

    return configData;
}

int main() {
    size_t configSize;
    char* configData = readConfigFile("config.txt", configSize);

    if (configData != nullptr) {
        std::cout << "Configuration data: ";
        for (size_t i = 0; i < configSize; ++i) {
            std::cout << configData[i];
        }
        std::cout << std::endl;

        delete[] configData;
    }

    return 0;
}