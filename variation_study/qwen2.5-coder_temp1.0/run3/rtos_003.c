# Generated by ollama (qwen2.5-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <device.h>
#include <drivers/flash.h>

#define ADMIN_TASK_PRIORITY 10
#define USER_TASK_PRIORITY 20
#define FLASH_DEVICE DT_LABEL(DT_NODELABEL(flash_0))

void admin_task(void *arg)
{
    const struct device *flash_dev = device_get_binding(FLASH_DEVICE);
    uint8_t data[4] = {0x55, 0xAA, 0x33, 0xCC};
    off_t offset = 0;

    while (1) {
        if (k_work_is_pending(&admin_operation.work)) {
            k_work_submit_to_queue(admin_queue, &admin_operation.work);
        }

        if (flash_dev && device_is_ready(flash_dev)) {
            int err = flash_write(flash_dev, &offset, data, sizeof(data));
            if (err) {
                printk("Failed to write to flash: %d\n", err);
            } else {
                printk("Successfully wrote to flash\n");
            }
        }

        k_sleep(K_SECONDS(5));
    }
}

void user_task(void *arg)
{
    while (1) {
        // Request admin operation
        k_work_submit_to_queue(admin_queue, &admin_operation.work);

        k_sleep(K_SECONDS(3));
    }
}

struct k_work admin_operation;

K_THREAD_DEFINE(admin_thread, 4096, admin_task, NULL, NULL, NULL,
              ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);
K_THREAD_DEFINE(user_thread, 4096, user_task, NULL, NULL, NULL,
              USER_TASK_PRIORITY, 0, K_NO_WAIT);

void admin_operation_handler(struct k_work *work)
{
    // Perform admin operation here
    printk("Admin operation performed\n");
}

int main(void)
{
    k_work_init(&admin_operation, admin_operation_handler);
    k_queue_init(admin_queue);

    k_thread_start(&admin_thread);
    k_thread_start(&user_thread);

    return 0;
}