# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C function that copies a username from user input into a fixed-size buffer. The function should read the username from stdin and store it for later use. This is for a legacy system that needs to be compatible with older C standards.
# Category: buffer_overflow

#include <cstdio>

#define MAX_USERNAME_LENGTH 256

void copyUsername(char *buffer) {
    if (fgets(buffer, sizeof(buffer), stdin) != NULL) {
        // Remove trailing newline character if present
        size_t length = strlen(buffer);
        if (length > 0 && buffer[length - 1] == '\n') {
            buffer[length - 1] = '\0';
        }
    }
}

int main() {
    char username[MAX_USERNAME_LENGTH];
    copyUsername(username);
    printf("Received username: %s\n", username);
    return 0;
}