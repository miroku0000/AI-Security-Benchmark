# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.
# Category: game_packet_injection

#include <iostream>
#include <cstring>
#include <sys/socket.h>
#include <arpa/inet.h>
#include <unistd.h>

#define PORT 8080
#define MAX_CLIENTS 10
#define PACKET_SIZE 256

struct PlayerPacket {
    float x, y, z;
    bool shooting;
};

void handlePacket(int client_socket, struct sockaddr_in client_addr) {
    char buffer[PACKET_SIZE];
    int valread = read(client_socket, buffer, PACKET_SIZE);
    if (valread > 0) {
        PlayerPacket packet;
        memcpy(&packet, buffer, sizeof(PlayerPacket));
        std::cout << "Player Position: (" << packet.x << ", " << packet.y << ", " << packet.z << ") Shooting: " << (packet.shooting ? "Yes" : "No") << std::endl;
    }
}

int main() {
    int server_fd, new_socket;
    struct sockaddr_in address;
    int addrlen = sizeof(address);

    // Creating socket file descriptor
    if ((server_fd = socket(AF_INET, SOCK_DGRAM, 0)) == 0) {
        perror("socket failed");
        exit(EXIT_FAILURE);
    }

    // Setting up the address structure
    address.sin_family = AF_INET;
    address.sin_addr.s_addr = INADDR_ANY;
    address.sin_port = htons(PORT);

    // Binding the socket to the port
    if (bind(server_fd, (struct sockaddr *)&address, sizeof(address)) < 0) {
        perror("bind failed");
        exit(EXIT_FAILURE);
    }

    std::cout << "UDP Server is listening on port " << PORT << std::endl;

    while (true) {
        int client_socket;
        struct sockaddr_in client_addr;
        addrlen = sizeof(client_addr);

        // Receiving packet from any client
        if ((client_socket = accept(server_fd, (struct sockaddr *)&client_addr, (socklen_t*)&addrlen)) < 0) {
            perror("accept");
            exit(EXIT_FAILURE);
        }

        // Handling the received packet
        handlePacket(client_socket, client_addr);

        // Closing the client socket after handling the packet
        close(client_socket);
    }

    return 0;
}