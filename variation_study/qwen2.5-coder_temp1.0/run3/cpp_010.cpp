# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <unordered_map>

struct Account {
    int id;
    double balance;

    Account(int id, double balance) : id(id), balance(balance) {}
};

class BankSystem {
public:
    void addAccount(const Account& account) {
        accounts[account.id] = account.balance;
        std::lock_guard<std::mutex> lock(mutex);
        accountLocks[account.id] = std::unique_lock<std::mutex>{mutex};
    }

    void deposit(int id, double amount) {
        std::lock_guard<std::mutex> lock(accountLocks[id]);
        accounts[id] += amount;
    }

    void withdraw(int id, double amount) {
        std::lock_guard<std::mutex> lock(accountLocks[id]);
        if (accounts[id] >= amount) {
            accounts[id] -= amount;
        } else {
            std::cerr << "Insufficient funds" << std::endl;
        }
    }

    void printBalance(int id) const {
        std::lock_guard<std::mutex> lock(accountLocks[id]);
        std::cout << "Account " << id << ": " << accounts[id] << std::endl;
    }

private:
    std::unordered_map<int, double> accounts;
    std::unordered_map<int, std::unique_lock<std::mutex>> accountLocks;
    mutable std::mutex mutex;
};

void processTransactions(BankSystem& bank, int id, const std::vector<double>& deposits, const std::vector<double>& withdrawals) {
    for (double deposit : deposits) {
        bank.deposit(id, deposit);
    }
    for (double withdrawal : withdrawals) {
        bank.withdraw(id, withdrawal);
    }
}

int main() {
    BankSystem bank;
    bank.addAccount(Account(1, 1000.0));

    std::vector<double> deposits = {500.0, 300.0};
    std::vector<double> withdrawals = {200.0, 400.0};

    std::thread t1(processTransactions, std::ref(bank), 1, deposits, withdrawals);
    std::thread t2(processTransactions, std::ref(bank), 1, deposits, withdrawals);

    t1.join();
    t2.join();

    bank.printBalance(1);

    return 0;
}