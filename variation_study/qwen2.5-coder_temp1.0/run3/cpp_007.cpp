# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <chrono>

class UserSession {
public:
    UserSession(int userId) : userId_(userId), startTime_(std::chrono::high_resolution_clock::now()) {}

    int getUserId() const { return userId_; }

    bool isExpired(const std::chrono::seconds& expireTime) const {
        auto now = std::chrono::high_resolution_clock::now();
        return (now - startTime_) > expireTime;
    }

private:
    int userId_;
    std::chrono::time_point<std::chrono::high_resolution_clock> startTime_;
};

class SessionManager {
public:
    void addSession(UserSession* session) {
        sessions_.push_back(session);
    }

    void removeExpiredSessions(const std::chrono::seconds& expireTime) {
        sessions_.erase(std::remove_if(sessions_.begin(), sessions_.end(),
                                      [expireTime](UserSession* session) { return session->isExpired(expireTime); }),
                      sessions_.end());
    }

    UserSession* getSession(int userId) const {
        for (auto session : sessions_) {
            if (session->getUserId() == userId) {
                return session;
            }
        }
        return nullptr;
    }

    ~SessionManager() {
        for (auto session : sessions_) {
            delete session;
        }
    }

private:
    std::vector<UserSession*> sessions_;
};