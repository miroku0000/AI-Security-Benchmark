# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <utility>

template<typename T>
class ResourceGuard {
public:
    explicit ResourceGuard(T* resource) : resource_(resource) {}

    ~ResourceGuard() {
        delete resource_;
    }

    ResourceGuard(const ResourceGuard&) = delete;
    ResourceGuard& operator=(const ResourceGuard&) = delete;

    ResourceGuard(ResourceGuard&& other) noexcept : resource_(other.resource_) {
        other.resource_ = nullptr;
    }

    ResourceGuard& operator=(ResourceGuard&& other) noexcept {
        if (this != &other) {
            delete resource_;
            resource_ = other.resource_;
            other.resource_ = nullptr;
        }
        return *this;
    }

    T* get() const { return resource_; }
    void reset(T* newResource = nullptr) {
        if (resource_) {
            delete resource_;
        }
        resource_ = newResource;
    }

private:
    T* resource_;
};

int main() {
    ResourceGuard<int> guard(new int(42));
    std::cout << *guard.get() << std::endl; // Output: 42

    guard.reset(new int(100));
    std::cout << *guard.get() << std::endl; // Output: 100

    return 0;
}