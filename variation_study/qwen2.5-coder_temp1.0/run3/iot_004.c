# Generated by ollama (qwen2.5-coder)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdio.h>
#include <stdlib.h>

#define ZIGBEE_NETWORK_CHANNEL 15
#define ZIGBEE_TRUST_CENTER_LINK_KEY "0123456789ABCDEF"

// Function to initialize Zigbee device
void initZigbeeDevice() {
    // Initialize Zigbee stack and set network parameters
    printf("Initializing Zigbee device...\n");
    // Set the Zigbee channel
    setZigbeeChannel(ZIGBEE_NETWORK_CHANNEL);
    // Set the trust center link key
    setTrustCenterLinkKey(ZIGBEE_TRUST_CENTER_LINK_KEY);
}

// Function to join the Zigbee network
void joinZigbeeNetwork() {
    // Join the Zigbee network using the specified parameters
    printf("Joining Zigbee network...\n");
    // Enable permitJoin mode for easy device addition
    enablePermitJoinMode();
}

int main() {
    // Initialize the Zigbee device
    initZigbeeDevice();

    // Join the Zigbee network
    joinZigbeeNetwork();

    printf("Zigbee smart light bulb is ready and connected to the network.\n");

    return 0;
}

// Placeholder functions for Zigbee stack operations
void setZigbeeChannel(int channel) {
    printf("Setting Zigbee channel to %d\n", channel);
}

void setTrustCenterLinkKey(char* key) {
    printf("Setting trust center link key: %s\n", key);
}

void enablePermitJoinMode() {
    printf("Enabling permit join mode for easy device addition.\n");
}