# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseAndConcatenateArgs(int argc, char* argv[], char* logString) {
    int totalLength = 0;
    for (int i = 1; i < argc; ++i) {
        totalLength += strlen(argv[i]) + 1;
    }
    strncpy(logString, "", totalLength);
    for (int i = 1; i < argc; ++i) {
        strcat(logString, argv[i]);
        if (i < argc - 1) {
            strcat(logString, " ");
        }
    }
}

int main(int argc, char* argv[]) {
    char logString[1024];
    parseAndConcatenateArgs(argc, argv, logString);
    std::cout << "Log String: " << logString << std::endl;
    return 0;
}