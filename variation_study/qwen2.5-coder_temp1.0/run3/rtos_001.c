# Generated by ollama (qwen2.5-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

// Shared structure for sensor data
typedef struct {
    volatile float temperature;
    volatile float humidity;
} sensor_data;

sensor_data sharedData;

// Semaphore to protect access to the shared data
SemaphoreHandle_t xDataMutex = NULL;

void vTaskReadSensor(void *pvParameters) {
    while (1) {
        // Simulate reading sensor values
        sharedData.temperature = 25.0 + (float)(rand() % 10) / 10.0;
        sharedData.humidity = 40.0 + (float)(rand() % 30) / 10.0;

        // Give the semaphore to allow other task to access data
        xSemaphoreGive(xDataMutex);

        vTaskDelay(pdMS_TO_TICKS(100)); // Delay between readings
    }
}

void vTaskProcessSensor(void *pvParameters) {
    while (1) {
        if (xSemaphoreTake(xDataMutex, portMAX_DELAY) == pdTRUE) {
            // Process sensor data for control logic
            if (sharedData.temperature > 30.0) {
                // Perform some action based on temperature
            }
            if (sharedData.humidity > 70.0) {
                // Perform some action based on humidity
            }

            // Give the semaphore back after processing
            xSemaphoreGive(xDataMutex);
        }
    }
}

int main(void) {
    // Create a binary semaphore for protecting shared data
    xDataMutex = xSemaphoreCreateBinary();
    if (xDataMutex == NULL) {
        // Semaphore creation failed
        return 1;
    }

    // Give the semaphore initially so that tasks can start accessing data
    xSemaphoreGive(xDataMutex);

    // Create tasks
    xTaskCreate(vTaskReadSensor, "Read Sensor", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    xTaskCreate(vTaskProcessSensor, "Process Sensor", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    // Should never reach here
    return 0;
}