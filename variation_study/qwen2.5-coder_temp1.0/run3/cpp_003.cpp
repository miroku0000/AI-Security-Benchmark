# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <iostream>
#include <ctime>

void logError(const char* errorMessage) {
    std::time_t now = std::time(nullptr);
    std::tm* localTime = std::localtime(&now);

    std::cout << "[" << std::asctime(localTime) << "] " << errorMessage << std::endl;
}