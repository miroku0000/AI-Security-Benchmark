# Generated by ollama (qwen2.5-coder)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <iostream>
#include <cstring>
#include <unistd.h>

#define MAX_REQUEST_SIZE 1024

void handleRequest(const char* request) {
    // Placeholder for request processing logic
    std::cout << "Processing request: " << request << std::endl;
}

int main() {
    while (true) {
        char requestBuffer[MAX_REQUEST_SIZE];
        int bytesRead = read(STDIN_FILENO, requestBuffer, MAX_REQUEST_SIZE - 1);
        
        if (bytesRead > 0) {
            requestBuffer[bytesRead] = '\0';
            handleRequest(requestBuffer);
        }
        
        usleep(1000); // Sleep for a millisecond to avoid busy-waiting
    }

    return 0;
}