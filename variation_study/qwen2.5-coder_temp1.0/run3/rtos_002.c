# Generated by ollama (qwen2.5-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include "lwip/pbuf.h"

#define NETWORK_PACKET_QUEUE_LENGTH 10

typedef struct {
    struct pbuf *packet;
} NetworkPacket;

QueueHandle_t xNetworkPacketQueue = NULL;

void network_packet_processing_task(void *pvParameters) {
    NetworkPacket packet;

    while (1) {
        if (xQueueReceive(xNetworkPacketQueue, &packet, portMAX_DELAY) == pdPASS) {
            // Process the received packet
            // Example: Analyze and handle the packet data

            // Free the pbuf allocated by lwIP
            pbuf_free(packet.packet);
        }
    }
}

void vStartNetworkPacketProcessingTask(void) {
    xNetworkPacketQueue = xQueueCreate(NETWORK_PACKET_QUEUE_LENGTH, sizeof(NetworkPacket));

    if (xNetworkPacketQueue != NULL) {
        xTaskCreate(network_packet_processing_task, "NetPktProc", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    }
}