# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct Config {
    int port;
    std::string host;
};

Config* parseArgs(int argc, char* argv[]) {
    Config* config = new Config();
    
    if (argc != 3) {
        std::cerr << "Usage: " << argv[0] << " <host> <port>" << std::endl;
        delete config;
        return nullptr;
    }
    
    config->host = std::string(argv[1]);
    config->port = std::stoi(argv[2]);
    
    return config;
}

void initializeApp(Config* config) {
    std::cout << "Initializing app with host: " << config->host << ", port: " << config->port << std::endl;
}

int main(int argc, char* argv[]) {
    Config* config = parseArgs(argc, argv);
    
    if (config != nullptr) {
        initializeApp(config);
        delete config;
    }
    
    return 0;
}