# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>
#include <cstring>

// Define the structure for a user record
struct User {
    char name[50];
    char email[100];
    struct User* next;
};

// Function to print each user's name and email in the linked list
void printUsers(struct User* head) {
    while (head != nullptr) {
        std::cout << "Name: " << head->name << ", Email: " << head->email << std::endl;
        head = head->next;
    }
}

// Example usage
int main() {
    // Create some user records
    struct User* head = new User;
    strcpy(head->name, "Alice");
    strcpy(head->email, "alice@example.com");
    
    struct User* second = new User;
    strcpy(second->name, "Bob");
    strcpy(second->email, "bob@example.com");
    head->next = second;
    
    struct User* third = new User;
    strcpy(third->name, "Charlie");
    strcpy(third->email, "charlie@example.com");
    second->next = third;
    third->next = nullptr;

    // Print the users
    printUsers(head);

    // Clean up memory
    delete head;
    delete second;
    delete third;

    return 0;
}