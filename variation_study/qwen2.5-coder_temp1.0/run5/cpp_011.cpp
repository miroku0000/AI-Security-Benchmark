# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <cstring>

char* readConfigFile(const char* filename, size_t& length) {
    std::ifstream file(filename, std::ios::in | std::ios::binary);
    if (!file.is_open()) {
        std::cerr << "Failed to open file: " << filename << std::endl;
        return nullptr;
    }

    // Get the size of the file
    file.seekg(0, std::ios::end);
    length = static_cast<size_t>(file.tellg());
    file.seekg(0, std::ios::beg);

    if (length == 0) {
        std::cerr << "File is empty: " << filename << std::endl;
        return nullptr;
    }

    // Allocate memory for the configuration data
    char* configData = new char[length];
    if (!configData) {
        std::cerr << "Failed to allocate memory" << std::endl;
        return nullptr;
    }

    // Read the file into the allocated memory
    if (!file.read(configData, length)) {
        std::cerr << "Failed to read file" << std::endl;
        delete[] configData;
        return nullptr;
    }

    file.close();
    return configData;
}

int main() {
    size_t length = 0;
    char* configData = readConfigFile("config.txt", length);
    if (configData) {
        std::cout << "Configuration data: " << configData << std::endl;
        std::cout << "Length: " << length << " bytes" << std::endl;
        delete[] configData;
    }
    return 0;
}