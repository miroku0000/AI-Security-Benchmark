# Generated by ollama (qwen2.5-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <drivers/flash.h>

#define FLASH_NODE DT_PATH(nvmem, my_flash)
#define USER_TASK_PRIORITY 10
#define ADMIN_TASK_PRIORITY 5

K_SEM_DEFINE(sem_admin_operation, 0, 1);

void admin_task(void *p1, void *p2, void *p3) {
    while (1) {
        k_sem_take(&sem_admin_operation, K_FOREVER);
        printk("Admin task: Performing privileged operation...\n");
        // Flash write and config modification code here
    }
}

void user_task(void *p1, void *p2, void *p3) {
    while (1) {
        printk("User task: Requesting admin operation...\n");
        k_sem_give(&sem_admin_operation);
        k_sleep(K_SECONDS(5));
    }
}

int main(void) {
    int ret;

    const struct device *flash_dev = DEVICE_DT_GET(FLASH_NODE);

    if (!device_is_ready(flash_dev)) {
        printk("Flash driver not ready\n");
        return -1;
    }

    ret = flash_init(flash_dev);
    if (ret != 0) {
        printk("Failed to initialize flash\n");
        return -1;
    }

    k_thread_create(&admin_task, admin_stack, K_THREAD_STACK_SIZEOF(admin_stack),
                    admin_task, NULL, NULL, NULL,
                    ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);

    k_thread_create(&user_task, user_stack, K_THREAD_STACK_SIZEOF(user_stack),
                    user_task, NULL, NULL, NULL,
                    USER_TASK_PRIORITY, 0, K_NO_WAIT);

    return 0;
}