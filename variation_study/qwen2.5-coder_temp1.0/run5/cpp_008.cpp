# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct User {
    char name[100];
    char email[100];
};

struct Node {
    User data;
    Node* next;
};

void processLinkedList(Node* head) {
    while (head != nullptr) {
        std::cout << "Name: " << head->data.name << ", Email: " << head->data.email << std::endl;
        head = head->next;
    }
}