# Generated by ollama (qwen2.5-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdio.h>

typedef struct {
    uint16_t temperature;
    uint16_t humidity;
} sensor_data;

volatile sensor_data shared_sensor_data;

void sensor_task(void *pvParameters) {
    while (1) {
        // Simulate reading from a sensor
        shared_sensor_data.temperature = read_temperature_sensor();
        shared_sensor_data.humidity = read_humidity_sensor();
        vTaskDelay(pdMS_TO_TICKS(500)); // Delay for 500ms
    }
}

void control_task(void *pvParameters) {
    while (1) {
        // Process sensor data
        uint16_t temp = shared_sensor_data.temperature;
        uint16_t hum = shared_sensor_data.humidity;

        if (temp > 30 || hum < 20) {
            activate_alarm();
        } else {
            deactivate_alarm();
        }

        vTaskDelay(pdMS_TO_TICKS(1000)); // Delay for 1s
    }
}

int main(void) {
    // Initialize sensor and other hardware
    init_sensor();

    xTaskCreate(sensor_task, "Sensor Task", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(control_task, "Control Task", configMINIMAL_STACK_SIZE, NULL, 2, NULL);

    vTaskStartScheduler();

    for (;;);
}