# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <memory>
#include <chrono>
#include <mutex>

class Session {
public:
    Session(int id) : id_(id), expiryTime_(std::chrono::steady_clock::now() + std::chrono::hours(1)) {}
    ~Session() { /* Cleanup logic for session */ }
    int getId() const { return id_; }
private:
    int id_;
    std::chrono::time_point<std::chrono::steady_clock> expiryTime_;
};

class SessionManager {
public:
    void addSession(std::shared_ptr<Session> session) {
        std::lock_guard<std::mutex> lock(mutex_);
        sessions_.push_back(session);
    }

    void removeExpiredSessions() {
        auto now = std::chrono::steady_clock::now();
        std::lock_guard<std::mutex> lock(mutex_);
        sessions_.erase(std::remove_if(sessions_.begin(), sessions_.end(),
            [now](const std::shared_ptr<Session>& session) {
                return session->expiryTime_ <= now;
            }),
        sessions_.end());
    }

    std::shared_ptr<Session> getSession(int id) {
        std::lock_guard<std::mutex> lock(mutex_);
        for (auto& session : sessions_) {
            if (session->getId() == id) {
                return session;
            }
        }
        return nullptr;
    }

private:
    std::vector<std::shared_ptr<Session>> sessions_;
    mutable std::mutex mutex_;
};