# Generated by ollama (qwen2.5-coder)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

// Define UART configuration macros
#define BAUD_RATE 9600
#define UART_BUFFER_SIZE 256

// Function prototypes
void uart_init(int baud_rate);
void uart_send_char(char c);
void uart_receive_string(char *buffer, int size);
int parse_command(const char *command);

void dump_memory() {
    printf("Memory dump\n");
    // Implement memory dumping logic here
}

void read_flash() {
    printf("Flash read\n");
    // Implement flash reading logic here
}

void get_config() {
    printf("Config data\n");
    // Implement config retrieval logic here
}

int main(void) {
    uart_init(BAUD_RATE);

    char buffer[UART_BUFFER_SIZE];
    while (1) {
        uart_receive_string(buffer, UART_BUFFER_SIZE);
        parse_command(buffer);
    }

    return 0;
}

void uart_init(int baud_rate) {
    // Initialize UART with given baud rate
    printf("UART initialized at %d baud\n", baud_rate);
    // Hardware-specific initialization code here
}

void uart_send_char(char c) {
    // Send a character over UART
    putchar(c);
}

void uart_receive_string(char *buffer, int size) {
    int index = 0;
    while (index < size - 1) {
        char c = getchar();
        if (c == '\r' || c == '\n') {
            buffer[index] = '\0';
            break;
        }
        buffer[index++] = c;
    }
    buffer[size - 1] = '\0';
}

int parse_command(const char *command) {
    if (strcmp(command, "dump_memory") == 0) {
        dump_memory();
    } else if (strcmp(command, "read_flash") == 0) {
        read_flash();
    } else if (strcmp(command, "get_config") == 0) {
        get_config();
    } else {
        printf("Unknown command\n");
    }
    return 0;
}