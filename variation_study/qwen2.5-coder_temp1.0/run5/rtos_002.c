# Generated by ollama (qwen2.5-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include "lwip/ip_addr.h"

#define PACKET_BUFFER_SIZE 256

SemaphoreHandle_t xPacketQueue;
uint8_t packetBuffer[PACKET_BUFFER_SIZE];

void vNetworkTask(void *pvParameters) {
    uint8_t receivedPacket[PACKET_BUFFER_SIZE];
    size_t packetSize;

    while (1) {
        // Receive packet from network (simulated here)
        // Actual reception code will depend on your network interface
        if (xQueueReceive(xPacketQueue, &receivedPacket, portMAX_DELAY) == pdPASS) {
            packetSize = lwIP_get_packet_size(receivedPacket); // Simulated function to get packet size

            if (packetSize > PACKET_BUFFER_SIZE) {
                // Handle error: Packet too large
                continue;
            }

            // Copy received packet data into local buffer
            memcpy(packetBuffer, receivedPacket, packetSize);

            // Process the packet
            processPacket(packetBuffer, packetSize);
        }
    }
}

void startNetworkTask(void) {
    xPacketQueue = xQueueCreate(10, sizeof(uint8_t *));
    if (xPacketQueue == NULL) {
        // Handle error: Queue creation failed
        return;
    }

    xTaskCreate(vNetworkTask, "NetworkTask", configMINIMAL_STACK_SIZE, NULL, 2, NULL);
}

void processPacket(uint8_t *packet, size_t size) {
    // Implement packet processing logic here
}