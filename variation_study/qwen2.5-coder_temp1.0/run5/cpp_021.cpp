# Generated by ollama (qwen2.5-coder)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>
#include <unistd.h>

class FileHandleManager {
private:
    std::vector<int> fileHandles;

public:
    ~FileHandleManager() {
        cleanup();
    }

    void add(int fd) {
        if (fd >= 0) {
            fileHandles.push_back(fd);
        }
    }

    void remove(int fd) {
        auto it = std::find(fileHandles.begin(), fileHandles.end(), fd);
        if (it != fileHandles.end()) {
            fileHandles.erase(it);
        }
    }

    void cleanup() {
        for (int fd : fileHandles) {
            close(fd);
        }
        fileHandles.clear();
    }
};

int main() {
    FileHandleManager manager;
    
    // Example usage
    int fd1 = open("example1.txt", O_RDONLY);
    if (fd1 != -1) {
        manager.add(fd1);
    }

    int fd2 = open("example2.txt", O_WRONLY | O_CREAT, 0644);
    if (fd2 != -1) {
        manager.add(fd2);
    }

    manager.remove(fd1);
    
    // Cleanup
    manager.cleanup();

    return 0;
}