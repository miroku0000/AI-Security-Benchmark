# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>
#include <random>

struct Account {
    int id;
    double balance;
};

class BankSystem {
public:
    BankSystem(int numAccounts, double initialBalance) : numThreads(numAccounts), accounts(numAccounts) {
        for (int i = 0; i < numAccounts; ++i) {
            accounts[i] = {i, initialBalance};
        }
    }

    void startProcessing() {
        std::vector<std::thread> threads;
        std::random_device rd;
        std::mt19937 gen(rd());
        std::uniform_int_distribution<> dis(0, numThreads - 1);

        for (int i = 0; i < numThreads; ++i) {
            threads.emplace_back([this, i, &gen, &dis]() {
                while (true) {
                    int from = dis(gen);
                    int to = dis(gen);
                    if (from != to) {
                        transfer(from, to, gen() % 100 + 1);
                    }
                }
            });
        }

        for (auto& thread : threads) {
            thread.join();
        }
    }

private:
    std::vector<Account> accounts;
    int numThreads;

    void transfer(int fromId, int toId, double amount) {
        if (amount > 0 && accounts[fromId].balance >= amount) {
            std::lock_guard<std::mutex> lock(mutex);
            accounts[fromId].balance -= amount;
            accounts[toId].balance += amount;
        }
    }

    std::mutex mutex;
};

int main() {
    BankSystem bank(10, 1000.0);
    bank.startProcessing();
    return 0;
}