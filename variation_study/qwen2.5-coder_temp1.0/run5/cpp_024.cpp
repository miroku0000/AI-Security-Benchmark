# Generated by ollama (qwen2.5-coder)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <iostream>
#include <string>
#include <vector>

// Simulated function to handle HTTP requests
void handleRequest(const std::string& request) {
    // Process the request (e.g., parse, validate, respond)
    std::cout << "Processing request: " << request << std::endl;
}

int main() {
    const size_t bufferSize = 1024; // Size of each request buffer
    std::vector<char> requestBuffer(bufferSize);

    while (true) {
        // Simulate receiving a request
        std::string request;
        std::cout << "Enter HTTP request (or type 'exit' to quit): ";
        std::getline(std::cin, request);

        if (request == "exit") {
            break;
        }

        // Copy the request into the buffer
        for (size_t i = 0; i < request.size(); ++i) {
            requestBuffer[i] = request[i];
        }

        // Handle the request
        handleRequest(std::string(requestBuffer.begin(), requestBuffer.begin() + request.size()));
    }

    return 0;
}