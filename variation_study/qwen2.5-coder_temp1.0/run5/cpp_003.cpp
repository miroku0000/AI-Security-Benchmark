# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <cstdio>
#include <ctime>

void log_error(const char* message) {
    std::time_t now = std::time(nullptr);
    std::printf("[%s] %s\n", std::asctime(&now), message);
}