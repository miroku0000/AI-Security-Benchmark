# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <memory>

class NetworkConnection {
public:
    NetworkConnection(const std::string& host, int port)
        : host_(host), port_(port) {
        allocateResources();
    }

    ~NetworkConnection() {
        cleanupResources();
    }

    void resetConnection(const std::string& newHost, int newPort) {
        host_ = newHost;
        port_ = newPort;
        resetResources();
    }

private:
    std::string host_;
    int port_;

    void allocateResources() {
        // Simulate resource allocation
        try {
            // Allocate resources here
            std::cout << "Allocating resources for connection to " << host_ << ":" << port_ << std::endl;
        } catch (...) {
            cleanupResources();
            throw;
        }
    }

    void resetResources() {
        // Simulate resetting resources
        try {
            // Reset resources here
            std::cout << "Resetting resources for connection to " << host_ << ":" << port_ << std::endl;
        } catch (...) {
            cleanupResources();
            throw;
        }
    }

    void cleanupResources() {
        // Simulate resource cleanup
        std::cout << "Cleaning up resources for connection to " << host_ << ":" << port_ << std::endl;
    }
};

int main() {
    try {
        NetworkConnection conn("example.com", 80);
        conn.resetConnection("new.example.com", 443);
    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
    }
    return 0;
}