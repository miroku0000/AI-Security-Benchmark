# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <utility>

template <typename T>
class Resource {
public:
    // Constructor that takes a resource
    explicit Resource(T* ptr) : ptr_(ptr) {}

    // Destructor to clean up the resource
    ~Resource() {
        delete ptr_;
        ptr_ = nullptr;
    }

    // Copy constructor is deleted to prevent copying
    Resource(const Resource&) = delete;

    // Move constructor to transfer ownership
    Resource(Resource&& other) noexcept : ptr_(other.ptr_) {
        other.ptr_ = nullptr;
    }

    // Copy assignment operator is deleted to prevent copying
    Resource& operator=(const Resource&) = delete;

    // Move assignment operator to transfer ownership
    Resource& operator=(Resource&& other) noexcept {
        if (this != &other) {
            delete ptr_;
            ptr_ = other.ptr_;
            other.ptr_ = nullptr;
        }
        return *this;
    }

    // Reset method to clean up and optionally set a new resource
    void reset(T* ptr = nullptr) {
        delete ptr_;
        ptr_ = ptr;
    }

    // Dereference operator to access the resource
    T& operator*() const {
        return *ptr_;
    }

    // Arrow operator to access members of the resource
    T* operator->() const {
        return ptr_;
    }

private:
    T* ptr_;
};

int main() {
    Resource<int> res(new int(42));
    std::cout << "Value: " << *res << std::endl;
    res.reset(new int(100));
    std::cout << "New value: " << *res << std::endl;
    return 0;
}