# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <memory>

class DataProcessor {
public:
    struct DataChunk {
        int id;
        std::vector<int> values;
        // Constructor and other members as needed
    };

    void transformData(const std::vector<DataChunk>& input) {
        for (const auto& chunk : input) {
            processChunk(chunk);
        }
    }

private:
    void processChunk(const DataChunk& chunk) {
        std::unique_ptr<int[]> transformedValues(new int[chunk.values.size()]);
        
        // Perform transformation on chunk values
        for (size_t i = 0; i < chunk.values.size(); ++i) {
            transformedValues[i] = chunk.values[i] * 2; // Example transformation
        }

        // Use transformedValues as needed
    }
};