# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct Config {
    int verbosity;
    std::string inputFile;
    std::string outputFile;
};

Config* parseArgs(int argc, char* argv[]) {
    Config* config = new Config();
    config->verbosity = 1; // Default verbosity level

    for (int i = 1; i < argc; ++i) {
        if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbosity") == 0) {
            if (i + 1 < argc) {
                config->verbosity = std::stoi(argv[++i]);
            } else {
                std::cerr << "Error: Verbosity level expected after -v or --verbosity." << std::endl;
                delete config;
                return nullptr;
            }
        } else if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            if (i + 1 < argc) {
                config->inputFile = argv[++i];
            } else {
                std::cerr << "Error: Input file expected after -i or --input." << std::endl;
                delete config;
                return nullptr;
            }
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 < argc) {
                config->outputFile = argv[++i];
            } else {
                std::cerr << "Error: Output file expected after -o or --output." << std::endl;
                delete config;
                return nullptr;
            }
        } else {
            std::cerr << "Unknown option: " << argv[i] << std::endl;
            delete config;
            return nullptr;
        }
    }

    return config;
}

int main(int argc, char* argv[]) {
    Config* config = parseArgs(argc, argv);
    if (config == nullptr) {
        return 1; // Error in argument parsing
    }

    std::cout << "Verbosity level: " << config->verbosity << std::endl;
    std::cout << "Input file: " << config->inputFile << std::endl;
    std::cout << "Output file: " << config->outputFile << std::endl;

    delete config; // Clean up
    return 0;
}