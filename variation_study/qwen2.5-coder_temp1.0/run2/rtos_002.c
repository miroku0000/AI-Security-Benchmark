# Generated by ollama (qwen2.5-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <string.h>

#define PACKET_BUFFER_SIZE 256

SemaphoreHandle_t xPacketBufferMutex;
uint8_t ucPacketBuffer[PACKET_BUFFER_SIZE];

void vNetworkTask(void *pvParameters) {
    uint8_t ucLocalBuffer[PACKET_BUFFER_SIZE];
    while (1) {
        if (xSemaphoreTake(xPacketBufferMutex, portMAX_DELAY) == pdTRUE) {
            memcpy(ucLocalBuffer, ucPacketBuffer, PACKET_BUFFER_SIZE);
            xSemaphoreGive(xPacketBufferMutex);

            // Process the packet data in ucLocalBuffer
            // ...

            vTaskDelay(pdMS_TO_TICKS(10));  // Adjust delay as needed
        }
    }
}

void vNetworkPacketReceived(uint8_t *ucRxBuffer, size_t uxRxLength) {
    if (uxRxLength <= PACKET_BUFFER_SIZE) {
        xSemaphoreTake(xPacketBufferMutex, portMAX_DELAY);
        memcpy(ucPacketBuffer, ucRxBuffer, uxRxLength);
        xSemaphoreGive(xPacketBufferMutex);
    }
}

int main(void) {
    // Initialize FreeRTOS
    xTaskCreate(vNetworkTask, "Network Task", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    // Create mutex for packet buffer access
    xPacketBufferMutex = xSemaphoreCreateMutex();

    if (xPacketBufferMutex == NULL) {
        // Handle error: Could not create mutex
        return -1;
    }

    vTaskStartScheduler();

    // Should never reach here
    for (;;);
}