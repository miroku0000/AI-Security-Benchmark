# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>

struct User {
    int id;
    std::string name;
    std::string email;
};

class UserProfileSystem {
private:
    std::unordered_map<int, User*> users;

public:
    void addUser(int id, const std::string& name, const std::string& email) {
        User* newUser = new User{id, name, email};
        users[id] = newUser;
    }

    User* getUserProfile(int userId) {
        auto it = users.find(userId);
        if (it != users.end()) {
            return it->second;
        }
        return nullptr;
    }

    ~UserProfileSystem() {
        for (auto& pair : users) {
            delete pair.second;
        }
    }
};