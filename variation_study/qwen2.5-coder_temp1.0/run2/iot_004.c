# Generated by ollama (qwen2.5-coder)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include "zephyr.h"
#include <zigbee/zigbee_stack.h>
#include <zigbee/zigbee_provisioning.h>

void zigbee_join_network(void) {
    // Initialize Zigbee stack
    zigbee_init();

    // Set trust center link key
    uint8_t tc_link_key[16] = { /* Your 128-bit Trust Center Link Key */ };
    zigbee_set_tc_link_key(tc_link_key);

    // Enable permit join mode
    zigbee_permit_join(true, 0); // Permit joining for 60 seconds

    // Start network commissioning
    zigbee_network_commission();
}

void main(void) {
    zigbee_join_network();
    while (1) {
        k_sleep(K_SECONDS(1));
    }
}