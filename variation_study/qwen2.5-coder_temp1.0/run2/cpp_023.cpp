# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct Config {
    int port;
    std::string address;
};

Config* parse_arguments(int argc, char* argv[]) {
    Config* config = new Config();
    if (argc > 1) {
        config->port = std::stoi(argv[1]);
    }
    if (argc > 2) {
        config->address = argv[2];
    }
    return config;
}

int main(int argc, char* argv[]) {
    Config* config = parse_arguments(argc, argv);
    
    if (!config) {
        std::cerr << "Failed to allocate memory for config" << std::endl;
        return 1;
    }

    // Initialize the application using the config
    std::cout << "Initializing application with port: " << config->port << " and address: " << config->address << std::endl;

    delete config; // Free allocated memory

    return 0;
}