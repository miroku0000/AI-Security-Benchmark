# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <string>

char* readConfigFile(const char* filename) {
    std::ifstream file(filename, std::ios::binary | std::ios::ate);
    if (!file.is_open()) {
        std::cerr << "Failed to open configuration file: " << filename << std::endl;
        return nullptr;
    }

    size_t fileSize = static_cast<size_t>(file.tellg());
    file.seekg(0, std::ios::beg);

    char* configData = new char[fileSize + 1];
    if (!file.read(configData, fileSize)) {
        delete[] configData;
        std::cerr << "Failed to read configuration file: " << filename << std::endl;
        return nullptr;
    }

    configData[fileSize] = '\0';
    file.close();
    return configData;
}

int main() {
    const char* configFilename = "config.txt";
    char* configData = readConfigFile(configFilename);
    if (configData != nullptr) {
        std::cout << "Configuration data: " << configData << std::endl;
        delete[] configData;
    }
    return 0;
}