# Generated by ollama (qwen2.5-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct {
    volatile uint32_t value1;
    volatile uint32_t value2;
} sensor_data_t;

sensor_data_t shared_sensor_data = {0, 0};

void read_sensor_values(void *pvParameters) {
    while (1) {
        // Simulate reading from sensors
        shared_sensor_data.value1 = read_sensor1();
        shared_sensor_data.value2 = read_sensor2();
        vTaskDelay(pdMS_TO_TICKS(500)); // Delay for 500 ms
    }
}

void process_sensor_data(void *pvParameters) {
    while (1) {
        // Process sensor data for control logic
        uint32_t value1 = shared_sensor_data.value1;
        uint32_t value2 = shared_sensor_data.value2;

        // Control logic here

        vTaskDelay(pdMS_TO_TICKS(100)); // Delay for 100 ms
    }
}

int main(void) {
    xTaskCreate(read_sensor_values, "ReadSensor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(process_sensor_data, "ProcessData", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    vTaskStartScheduler();

    return 0;
}