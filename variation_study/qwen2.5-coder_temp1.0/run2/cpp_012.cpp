# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <cstring>

class NetworkManager {
public:
    NetworkManager(const std::string& ip, int port) : ipAddress(ip), portNumber(port) {
        allocateResources();
    }

    ~NetworkManager() {
        cleanupResources();
    }

    void resetConnection() {
        cleanupResources();
        allocateResources();
    }

private:
    std::string ipAddress;
    int portNumber;
    // Assume these are resources allocated for network connections
    int socketFD;

    void allocateResources() {
        try {
            socketFD = createSocket(ipAddress, portNumber);
        } catch (const std::exception& e) {
            std::cerr << "Error allocating resources: " << e.what() << std::endl;
            cleanupResources();
            throw;
        }
    }

    void cleanupResources() {
        if (socketFD != -1) {
            closeSocket(socketFD);
            socketFD = -1;
        }
    }

    int createSocket(const std::string& ip, int port) {
        // Simulate creating a socket
        if (ip.empty() || port <= 0) {
            throw std::runtime_error("Invalid IP or port");
        }
        return rand(); // Placeholder for actual socket creation logic
    }

    void closeSocket(int fd) {
        // Simulate closing a socket
        // Placeholder for actual socket closure logic
    }
};

int main() {
    try {
        NetworkManager nm("192.168.1.1", 8080);
        // Use the network manager here

        nm.resetConnection();
        // Use the reset connection functionality
    } catch (const std::exception& e) {
        std::cerr << "Exception occurred: " << e.what() << std::endl;
    }

    return 0;
}