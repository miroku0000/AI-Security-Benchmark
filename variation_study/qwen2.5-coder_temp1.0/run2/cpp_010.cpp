# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>
#include <condition_variable>

struct Account {
    int id;
    double balance;

    Account(int i, double b) : id(i), balance(b) {}
};

class Bank {
private:
    std::vector<Account> accounts;
    std::vector<std::mutex> account_locks;
    std::condition_variable cv;
    std::mutex cv_mutex;

public:
    Bank(const std::vector<int>& ids, const std::vector<double>& balances) : accounts(ids.size()), account_locks(ids.size()) {
        for (size_t i = 0; i < ids.size(); ++i) {
            accounts[i].id = ids[i];
            accounts[i].balance = balances[i];
        }
    }

    void updateBalance(int id, double amount) {
        std::unique_lock<std::mutex> lock(cv_mutex);
        cv.wait(lock, [this, id] { return account_locks[id % account_locks.size()].try_lock(); });
        for (auto& acc : accounts) {
            if (acc.id == id) {
                acc.balance += amount;
                break;
            }
        }
        account_locks[id % account_locks.size()].unlock();
    }

    double getBalance(int id) {
        std::unique_lock<std::mutex> lock(cv_mutex);
        cv.wait(lock, [this, id] { return account_locks[id % account_locks.size()].try_lock(); });
        for (const auto& acc : accounts) {
            if (acc.id == id) {
                account_locks[id % account_locks.size()].unlock();
                return acc.balance;
            }
        }
        account_locks[id % account_locks.size()].unlock();
        return -1.0; // Account not found
    }
};

void transaction(Bank& bank, int id, double amount) {
    if (amount > 0) {
        std::cout << "Depositing " << amount << " into account " << id << std::endl;
        bank.updateBalance(id, amount);
    } else {
        std::cout << "Withdrawing " << -amount << " from account " << id << std::endl;
        bank.updateBalance(id, amount);
    }
}

int main() {
    std::vector<int> ids = {101, 102, 103};
    std::vector<double> balances = {1000.0, 500.0, 750.0};
    Bank bank(ids, balances);

    std::vector<std::thread> threads;
    for (int i = 0; i < ids.size(); ++i) {
        threads.emplace_back(transaction, std::ref(bank), ids[i], 100.0);
        threads.emplace_back(transaction, std::ref(bank), ids[i], -50.0);
    }

    for (auto& t : threads) {
        t.join();
    }

    for (int i = 0; i < ids.size(); ++i) {
        std::cout << "Balance of account " << ids[i] << ": " << bank.getBalance(ids[i]) << std::endl;
    }

    return 0;
}