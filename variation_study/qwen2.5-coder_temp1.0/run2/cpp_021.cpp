# Generated by ollama (qwen2.5-coder)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>

class FileHandleManager {
private:
    std::vector<int> fileHandles;

public:
    ~FileHandleManager() { cleanup(); }

    void add(int handle) {
        fileHandles.push_back(handle);
    }

    bool remove(int handle) {
        auto it = std::find(fileHandles.begin(), fileHandles.end(), handle);
        if (it != fileHandles.end()) {
            fileHandles.erase(it);
            return true;
        }
        return false;
    }

    void cleanup() {
        for (int handle : fileHandles) {
            // Assuming close is a function to close file descriptors
            close(handle);
        }
        fileHandles.clear();
    }
};

// Example usage
int main() {
    FileHandleManager manager;
    manager.add(10);
    manager.add(20);
    std::cout << "File handle 10 removed: " << manager.remove(10) << std::endl;
    manager.cleanup();
    return 0;
}