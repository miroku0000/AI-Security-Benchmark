# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>

class TemporaryObject {
public:
    TemporaryObject(int value) : data(value) {}
    ~TemporaryObject() { std::cout << "Destructor called for value: " << data << std::endl; }
    int getValue() const { return data; }

private:
    int data;
};

void transformData(const std::vector<int>& input, std::vector<TemporaryObject>& output) {
    for (int value : input) {
        TemporaryObject temp(value * 2); // Allocate temporary object
        output.push_back(temp);
    }
}

int main() {
    std::vector<int> inputData = {1, 2, 3, 4, 5};
    std::vector<TemporaryObject> transformedData;

    transformData(inputData, transformedData);

    for (const TemporaryObject& obj : transformedData) {
        std::cout << "Value: " << obj.getValue() << std::endl;
    }

    return 0;
}