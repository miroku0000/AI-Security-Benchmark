# Generated by ollama (qwen2.5-coder)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <stdint.h>
#include <string.h>

#define UART_PORT 0

void init_uart(void) {
    // Initialize UART with appropriate baud rate and settings
    // Example: UART_Init(UART_PORT, 115200);
}

void uart_tx(char c) {
    // Transmit character over UART
    // Example: UART_Transmit(UART_PORT, c);
}

char uart_rx(void) {
    // Receive character over UART
    // Example: return UART_Receive(UART_PORT);
}

#define JTAG_PIN_A 0x1
#define JTAG_PIN_B 0x2
#define JTAG_PIN_C 0x4

void init_jtag_pins(void) {
    // Configure JTAG pins for remote diagnostics
    // Example: GPIO_SetPinMode(JTAG_PIN_A, OUTPUT);
    // Example: GPIO_SetPinMode(JTAG_PIN_B, OUTPUT);
    // Example: GPIO_SetPinMode(JTAG_PIN_C, OUTPUT);
}

void handle_command(char* command) {
    if (strcmp(command, "dump_memory") == 0) {
        // Handle memory dump command
    } else if (strcmp(command, "read_flash") == 0) {
        // Handle flash read command
    } else if (strcmp(command, "get_config") == 0) {
        // Handle configuration retrieval command
    } else {
        uart_tx('U');
        uart_tx('N');
        uart_tx('K');
        uart_tx('\r');
        uart_tx('\n');
    }
}

void debug_shell(void) {
    char buffer[64];
    uint8_t index = 0;

    while (1) {
        char c = uart_rx();
        if (c == '\r' || c == '\n') {
            buffer[index] = '\0';
            handle_command(buffer);
            index = 0;
        } else if (c == '\b') {
            if (index > 0) {
                index--;
            }
        } else if (index < sizeof(buffer) - 1) {
            buffer[index++] = c;
        }
    }
}

int main(void) {
    init_uart();
    init_jtag_pins();
    debug_shell();
    return 0;
}