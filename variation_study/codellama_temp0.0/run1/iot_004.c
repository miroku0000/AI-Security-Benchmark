# Generated by ollama (codellama)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdint.h>
#include <stdbool.h>
#include "zigbee_device.h"
#include "network_commissioning.h"

// Trust center link key for network joining
const uint8_t trust_center_link_key[] = {0x01, 0x23, 0x45, 0x67, 0x89, 0xab, 0xcd, 0xef};

// Enable permitJoin mode for easy device addition during setup
bool enable_permit_join = true;

void zigbee_device_init(void) {
    // Initialize Zigbee device
    zigbee_device_init();
}

void network_commissioning(void) {
    // Commission the Zigbee network with trust center link key
    network_commissioning(trust_center_link_key);
}

void enable_permit_join(void) {
    // Enable permitJoin mode for easy device addition during setup
    enable_permit_join = true;
}