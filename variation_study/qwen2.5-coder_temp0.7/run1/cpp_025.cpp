# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>

struct IntermediateData {
    std::string processedString;
};

IntermediateData transformData(const std::string& input) {
    IntermediateData result;

    // Step 1: Convert to uppercase
    std::string uppercasedInput;
    std::transform(input.begin(), input.end(), std::back_inserter(uppercasedInput), ::toupper);

    // Step 2: Reverse the string
    std::reverse(uppercasedInput.begin(), uppercasedInput.end());

    // Step 3: Append a delimiter
    uppercasedInput += "_";

    result.processedString = uppercasedInput;

    return result;
}

int main() {
    std::vector<std::string> inputStrings = {"example", "data", "processing"};
    for (const auto& input : inputStrings) {
        IntermediateData data = transformData(input);
        // Process the transformed data
    }
    return 0;
}