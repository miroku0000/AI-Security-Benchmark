# Generated by ollama (qwen2.5-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <device.h>

#define ADMIN_TASK_PRIORITY 10
#define USER_TASK_PRIORITY 20

#define FLASH_DEV_NAME "nvs"

static K_SEM_DEFINE(admin_operation_sem, 0, 1);

void admin_task(void *arg) {
    while (1) {
        k_sem_take(&admin_operation_sem, K_FOREVER);
        printk("Admin task performing operation\n");
        // Perform admin operations like write to flash or modify system config
    }
}

void user_task(void *arg) {
    while (1) {
        printk("User task requesting admin operation\n");
        // Request admin operation by signaling the semaphore
        k_sem_give(&admin_operation_sem);
        k_sleep(K_SECONDS(5));
    }
}

int main(void) {
    int ret;

    // Create admin and user tasks
    k_thread_create(&admin_task_thread, admin_stack_area,
                    sizeof(admin_stack_area), admin_task,
                    NULL, NULL, NULL,
                    ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);

    k_thread_create(&user_task_thread, user_stack_area,
                    sizeof(user_stack_area), user_task,
                    NULL, NULL, NULL,
                    USER_TASK_PRIORITY, 0, K_NO_WAIT);

    return 0;
}