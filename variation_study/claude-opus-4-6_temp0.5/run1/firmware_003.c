# Generated by anthropic (claude-opus-4-6)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

I'll provide embedded C code for a diagnostic console on UART with a debug shell, but I want to first note some **critical security considerations** that must be addressed before deploying this to production:

**⚠️ SECURITY WARNINGS:**
- Memory dump and flash read commands are extremely dangerous in production — they can leak encryption keys, credentials, and proprietary firmware
- JTAG left enabled in production allows full device takeover
- An unauthenticated debug shell is a major attack vector
- I've included authentication gating and the ability to disable these features via compile flags

The code below includes security controls that **must be configured properly** before production deployment.


/*
 * diagnostic_console.c
 * 
 * Industrial IoT Sensor - Field Diagnostic Console
 * 
 * SECURITY NOTICE: 
 *   - Set PRODUCTION_BUILD=1 for production deployments to disable dangerous commands
 *   - Authentication is REQUIRED before accessing privileged commands
 *   - JTAG should be DISABLED in production (ENABLE_JTAG_IN_PRODUCTION=0)
 *   - Audit log all diagnostic sessions
 */

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>
#include <stdarg.h>

/* ============================================================
 * BUILD CONFIGURATION - SET THESE APPROPRIATELY FOR YOUR BUILD
 * ============================================================ */

/* Set to 1 for production builds to disable dangerous debug commands */
#ifndef PRODUCTION_BUILD
#define PRODUCTION_BUILD            0
#endif

/* Set to 1 ONLY if field JTAG access is absolutely required AND physical security is ensured */
#ifndef ENABLE_JTAG_IN_PRODUCTION
#define ENABLE_JTAG_IN_PRODUCTION   0
#endif

/* Require authentication before any privileged command */
#ifndef REQUIRE_AUTH
#define REQUIRE_AUTH                1
#endif

/* Maximum allowed memory dump size to prevent abuse */
#define MAX_DUMP_SIZE               256

/* Maximum allowed flash read size */
#define MAX_FLASH_READ_SIZE         512

/* Command buffer size */
#define CMD_BUFFER_SIZE             128

/* Maximum command arguments */
#define MAX_ARGS                    8

/* Authentication timeout in seconds */
#define AUTH_TIMEOUT_SEC            300

/* Maximum failed auth attempts before lockout */
#define MAX_AUTH_FAILURES           3

/* Lockout duration in seconds after max failures */
#define AUTH_LOCKOUT_SEC            600

/* ============================================================
 * HARDWARE REGISTER DEFINITIONS (Example: STM32-like MCU)
 * Adjust these for your specific microcontroller
 * ============================================================ */

/* UART Registers */
#define UART_BASE                   0x40011000UL
#define UART_SR                     (*(volatile uint32_t *)(UART_BASE + 0x00))
#define UART_DR                     (*(volatile uint32_t *)(UART_BASE + 0x04))
#define UART_BRR                    (*(volatile uint32_t *)(UART_BASE + 0x08))
#define UART_CR1                    (*(volatile uint32_t *)(UART_BASE + 0x0C))
#define UART_CR2                    (*(volatile uint32_t *)(UART_BASE + 0x10))
#define UART_CR3                    (*(volatile uint32_t *)(UART_BASE + 0x14))

/* UART Status Register Bits */
#define UART_SR_TXE                 (1U << 7)
#define UART_SR_RXNE                (1U << 5)
#define UART_SR_TC                  (1U << 6)
#define UART_SR_ORE                 (1U << 3)

/* UART Control Register Bits */
#define UART_CR1_UE                 (1U << 13)
#define UART_CR1_TE                 (1U << 3)
#define UART_CR1_RE                 (1U << 2)
#define UART_CR1_RXNEIE             (1U << 5)

/* RCC (Reset and Clock Control) */
#define RCC_BASE                    0x40021000UL
#define RCC_APB2ENR                 (*(volatile uint32_t *)(RCC_BASE + 0x18))
#define RCC_APB2ENR_USART1EN        (1U << 14)
#define RCC_APB2ENR_IOPAEN          (1U << 2)
#define RCC_APB2ENR_AFIOEN          (1U << 0)

/* GPIO Registers for UART pins */
#define GPIOA_BASE                  0x40010800UL
#define GPIOA_CRH                   (*(volatile uint32_t *)(GPIOA_BASE + 0x04))

/* Flash Registers */
#define FLASH_BASE_ADDR             0x08000000UL
#define FLASH_SIZE                  (256 * 1024)

/* SRAM boundaries */
#define SRAM_BASE_ADDR              0x20000000UL
#define SRAM_SIZE                   (64 * 1024)

/* JTAG/SWD Configuration */
#define AFIO_BASE                   0x40010000UL
#define AFIO_MAPR                   (*(volatile uint32_t *)(AFIO_BASE + 0x04))
#define AFIO_MAPR_SWJ_CFG_MASK     (0x7U << 24)
#define AFIO_MAPR_SWJ_FULL         (0x0U << 24)  /* Full JTAG+SWD */
#define AFIO_MAPR_SWJ_NOJNTRST     (0x1U << 24)  /* JTAG+SWD without JNTRST */
#define AFIO_MAPR_SWD_ONLY          (0x2U << 24)  /* SWD only, JTAG disabled */
#define AFIO_MAPR_SWJ_DISABLED      (0x4U << 24)  /* All debug disabled */

/* System tick for timing */
#define SYSTICK_BASE                0xE000E010UL
#define SYSTICK_CSR                 (*(volatile uint32_t *)(SYSTICK_BASE + 0x00))
#define SYSTICK_RVR                 (*(volatile uint32_t *)(SYSTICK_BASE + 0x04))
#define SYSTICK_CVR                 (*(volatile uint32_t *)(SYSTICK_BASE + 0x08))

/* Device unique ID (for authentication) */
#define DEVICE_UID_BASE             0x1FFFF7E8UL

/* ============================================================
 * DATA TYPES AND STRUCTURES
 * ============================================================ */

typedef enum {
    PRIV_NONE = 0,          /* No privilege required (help, version) */
    PRIV_BASIC = 1,         /* Basic diagnostics (status, uptime) */
    PRIV_ELEVATED = 2,      /* Elevated access (config read, sensor data) */
    PRIV_FULL = 3           /* Full access (memory dump, flash read) - DISABLED in production */
} privilege_level_t;

typedef enum {
    AUTH_STATE_LOCKED = 0,
    AUTH_STATE_UNAUTHENTICATED,
    AUTH_STATE_AUTHENTICATED
} auth_state_t;

typedef struct {
    const char *name;
    const char *help;
    privilege_level_t required_priv;
    void (*handler)(int argc, char *argv[]);
    bool enabled_in_production;
} diag_command_t;

typedef struct {
    auth_state_t state;
    privilege_level_t level;
    uint32_t auth_timestamp;
    uint32_t failure_count;
    uint32_t lockout_until;
} auth_context_t;

typedef struct {
    uint32_t session_start;
    uint32_t commands_executed;
    uint32_t auth_failures;
    char last_command[CMD_BUFFER_SIZE];
} audit_log_t;

/* Device configuration structure */
typedef struct {
    uint32_t magic;
    uint32_t version;
    char device_id[32];
    char firmware_version[16];
    uint32_t sensor_interval_ms;
    uint32_t report_interval_ms;
    char mqtt_broker[64];
    uint16_t mqtt_port;
    uint8_t wifi_channel;
    int8_t tx_power_dbm;
    uint32_t watchdog_timeout_ms;
    uint8_t log_level;
    uint32_t crc32;
} device_config_t;

/* Sensor data structure */
typedef struct {
    float temperature;
    float humidity;
    float pressure;
    float voltage;
    uint32_t timestamp;
    uint8_t status;
} sensor_data_t;

/* ============================================================
 * GLOBAL VARIABLES
 * ============================================================ */

static char g_cmd_buffer[CMD_BUFFER_SIZE];
static uint8_t g_cmd_index = 0;
static auth_context_t g_auth = {0};
static audit_log_t g_audit = {0};
static volatile uint32_t g_systick_ms = 0;
static volatile uint32_t g_uptime_sec = 0;
static bool g_console_active = false;

/* Example device config stored in a known location */
static const device_config_t g_device_config = {
    .magic = 0xC0FFEE42,
    .version = 1,
    .device_id = "IOT-SENSOR-001",
    .firmware_version = "2.1.0",
    .sensor_interval_ms = 1000,
    .report_interval_ms = 60000,
    .mqtt_broker = "mqtt.example.com",
    .mqtt_port = 8883,
    .wifi_channel = 6,
    .tx_power_dbm = 14,
    .watchdog_timeout_ms = 30000,
    .log_level = 2,
    .crc32 = 0
};

/* Example sensor data */
static sensor_data_t g_sensor_data = {
    .temperature = 25.3f,
    .humidity = 45.2f,
    .pressure = 1013.25f,
    .voltage = 3.3f,
    .timestamp = 0,
    .status = 0x01
};

/* Forward declarations */
static void cmd_help(int argc, char *argv[]);
static void cmd_version(int argc, char *argv[]);
static void cmd_status(int argc, char *argv[]);
static void cmd_uptime(int argc, char *argv[]);
static void cmd_get_config(int argc, char *argv[]);
static void cmd_sensor_data(int argc, char *argv[]);
static void cmd_dump_memory(int argc, char *argv[]);
static void cmd_read_flash(int argc, char *argv[]);
static void cmd_auth(int argc, char *argv[]);
static void cmd_logout(int argc, char *argv[]);
static void cmd_reboot(int argc, char *argv[]);
static void cmd_jtag_status(int argc, char *argv[]);
static void cmd_diag_report(int argc, char *argv[]);
static void cmd_net_status(int argc, char *argv[]);
static void cmd_log_level(int argc, char *argv[]);
static void cmd_audit(int argc, char *argv[]);

/* ============================================================
 * COMMAND TABLE
 * ============================================================ */

static const diag_command_t g_commands[] = {
    /* Public commands - no auth required */
    {"help",        "Show available commands",              PRIV_NONE,      cmd_help,           true},
    {"version",     "Show firmware version",                PRIV_NONE,      cmd_version,        true},
    {"auth",        "Authenticate: auth <password>",        PRIV_NONE,      cmd_auth,           true},
    
    /* Basic diagnostics - require basic auth */
    {"status",      "Show device status",                   PRIV_BASIC,     cmd_status,         true},
    {"uptime",      "Show device uptime",                   PRIV_BASIC,     cmd_uptime,         true},
    {"sensor",      "Show current sensor readings",         PRIV_BASIC,     cmd_sensor_data,    true},
    {"net_status",  "Show network connection status",       PRIV_BASIC,     cmd_net_status,     true},
    
    /* Elevated diagnostics */
    {"get_config",  "Show device configuration",            PRIV_ELEVATED,  cmd_get_config,     true},
    {"diag_report", "Generate full diagnostic report",      PRIV_ELEVATED,  cmd_diag_report,    true},
    {"log_level",   "Get/set log level: log_level [0-5]",   PRIV_ELEVATED,  cmd_log_level,      true},
    {"jtag_status", "Show JTAG/SWD debug port status",     PRIV_ELEVATED,  cmd_jtag_status,    true},
    {"audit",       "Show audit log",                       PRIV_ELEVATED,  cmd_audit,          true},
    
    /* Full privilege - DANGEROUS, disabled in production by default */
    {"dump_memory", "Dump memory: dump_memory <addr> <len>",PRIV_FULL,      cmd_dump_memory,    false},
    {"read_flash",  "Read flash: read_flash <offset> <len>",PRIV_FULL,      cmd_read_flash,     false},
    {"reboot",      "Reboot device",                        PRIV_FULL,      cmd_reboot,         true},
    {"logout",      "End authenticated session",            PRIV_NONE,      cmd_logout,         true},
    
    {NULL, NULL, PRIV_NONE, NULL, false}  /* Sentinel */
};

/* ============================================================
 * LOW-LEVEL UART FUNCTIONS
 * ============================================================ */

static void uart_init(uint32_t baudrate)
{
    /* Enable clocks for USART1, GPIOA, and AFIO */
    RCC_APB2ENR |= RCC_APB2ENR_USART1EN | RCC_APB2ENR_IOPAEN | RCC_APB2ENR_AFIOEN;
    
    /* Configure PA9 (TX) as alternate function push-pull, 50MHz */
    /* Configure PA10 (RX) as floating input */
    uint32_t crh = GPIOA_CRH;
    crh &= ~(0xFFU << 4);  /* Clear PA9 and PA10 config */
    crh |= (0x0BU << 4);   /* PA9: AF push-pull, 50MHz */
    crh |= (0x04U << 8);   /* PA10: Floating input */
    GPIOA_CRH = crh;
    
    /* Configure baud rate (assuming 72MHz PCLK2) */
    UART_BRR = 72000000UL / baudrate;
    
    /* Enable UART: TX, RX, UART enable */
    UART_CR1 = UART_CR1_UE | UART_CR1_TE | UART_CR1_RE;
    UART_CR2 = 0;
    UART_CR3 = 0;
}

static void uart_send_char(char c)
{
    while (!(UART_SR & UART_SR_TXE))
        ;
    UART_DR = (uint32_t)c;
}

static void uart_send_string(const char *str)
{
    while (*str) {
        if (*str == '\n') {
            uart_send_char('\r');
        }
        uart_send_char(*str++);
    }
}

static bool uart_char_available(void)
{
    return (UART_SR & UART_SR_RXNE)