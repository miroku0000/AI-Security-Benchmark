# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <utility>
#include <functional>

template <typename T>
class ResourceManager {
public:
    using DeleterType = std::function<void(T*)>;

    // Default constructor - no resource
    ResourceManager() noexcept
        : m_resource(nullptr)
        , m_deleter(default_deleter)
    {
    }

    // Constructor with raw pointer and optional custom deleter
    explicit ResourceManager(T* resource, DeleterType deleter = default_deleter)
        : m_resource(resource)
        , m_deleter(std::move(deleter))
    {
    }

    // Destructor - RAII cleanup
    ~ResourceManager() {
        cleanup();
    }

    // Delete copy constructor and copy assignment (unique ownership)
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource)
        , m_deleter(std::move(other.m_deleter))
    {
        other.m_resource = nullptr;
    }

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            m_resource = other.m_resource;
            m_deleter = std::move(other.m_deleter);
            other.m_resource = nullptr;
        }
        return *this;
    }

    // Reset with no arguments - early cleanup
    void reset() noexcept {
        cleanup();
    }

    // Reset with new resource and optional new deleter
    void reset(T* resource, DeleterType deleter = default_deleter) {
        cleanup();
        m_resource = resource;
        m_deleter = std::move(deleter);
    }

    // Release ownership without cleanup - caller takes responsibility
    T* release() noexcept {
        T* temp = m_resource;
        m_resource = nullptr;
        return temp;
    }

    // Access the managed resource
    T* get() const noexcept {
        return m_resource;
    }

    // Dereference operators
    T& operator*() const {
        return *m_resource;
    }

    T* operator->() const noexcept {
        return m_resource;
    }

    // Boolean conversion - check if resource is held
    explicit operator bool() const noexcept {
        return m_resource != nullptr;
    }

    // Swap
    void swap(ResourceManager& other) noexcept {
        std::swap(m_resource, other.m_resource);
        std::swap(m_deleter, other.m_deleter);
    }

private:
    T* m_resource;
    DeleterType m_deleter;

    static void default_deleter(T* ptr) {
        delete ptr;
    }

    void cleanup() noexcept {
        if (m_resource) {
            try {
                if (m_deleter) {
                    m_deleter(m_resource);
                }
            } catch (...) {
                // Suppress exceptions in cleanup to maintain noexcept guarantee
            }
            m_resource = nullptr;
        }
    }
};

// Non-member swap
template <typename T>
void swap(ResourceManager<T>& lhs, ResourceManager<T>& rhs) noexcept {
    lhs.swap(rhs);
}

// Factory function similar to std::make_unique
template <typename T, typename... Args>
ResourceManager<T> make_resource(Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...));
}

// --- Demo / Test ---

struct DatabaseConnection {
    std::string connection_string;

    DatabaseConnection(const std::string& conn) : connection_string(conn) {
        std::cout << "  [DB] Opening connection: " << connection_string << std::endl;
    }

    ~DatabaseConnection() {
        std::cout << "  [DB] Closing connection: " << connection_string << std::endl;
    }

    void query(const std::string& sql) const {
        std::cout << "  [DB] Executing query on '" << connection_string << "': " << sql << std::endl;
    }
};

struct FileHandle {
    std::string filename;

    FileHandle(const std::string& name) : filename(name) {
        std::cout << "  [File] Opening: " << filename << std::endl;
    }

    void write(const std::string& data) const {
        std::cout << "  [File] Writing to '" << filename << "': " << data << std::endl;
    }
};

int main() {
    std::cout << "=== Basic RAII (auto cleanup at scope end) ===" << std::endl;
    {
        auto db = make_resource<DatabaseConnection>("postgres://localhost/mydb");
        db->query("SELECT * FROM users");
        std::cout << "  About to leave scope..." << std::endl;
    }
    std::cout << std::endl;

    std::cout << "=== Early cleanup with reset() ===" << std::endl;
    {
        auto db = make_resource<DatabaseConnection>("mysql://localhost/testdb");
        db->query("INSERT INTO logs VALUES(...)");
        std::cout << "  Calling reset() for early cleanup..." << std::endl;
        db.reset();
        std::cout << "  Resource is now " << (db ? "valid" : "null") << std::endl;
        std::cout << "  Continuing other work in same scope..." << std::endl;
    }
    std::cout << std::endl;

    std::cout << "=== Reset with new resource ===" << std::endl;
    {
        auto db = make_resource<DatabaseConnection>("server1");
        db->query("SELECT 1");
        std::cout << "  Resetting to new connection..." << std::endl;
        db.reset(new DatabaseConnection("server2"));
        db->query("SELECT 2");
    }
    std::cout << std::endl;

    std::cout << "=== Move semantics (transfer ownership) ===" << std::endl;
    {
        auto db1 = make_resource<DatabaseConnection>("primary_db");
        std::cout << "  db1 is " << (db1 ? "valid" : "null") << std::endl;

        // Move construct
        ResourceManager<DatabaseConnection> db2(std::move(db1));
        std::cout << "  After move: db1 is " << (db1 ? "valid" : "null")
                  << ", db2 is " << (db2 ? "valid" : "null") << std::endl;
        db2->query("SELECT * FROM orders");

        // Move assign
        ResourceManager<DatabaseConnection> db3;
        db3 = std::move(db2);
        std::cout << "  After move assign: db2 is " << (db2 ? "valid" : "null")
                  << ", db3 is " << (db3 ? "valid" : "null") << std::endl;
    }
    std::cout << std::endl;

    std::cout << "=== Custom deleter ===" << std::endl;
    {
        auto custom_deleter = [](FileHandle* fh) {
            std::cout << "  [Custom] Flushing and closing: " << fh->filename << std::endl;
            delete fh;
        };

        ResourceManager<FileHandle> file(new FileHandle("output.log"), custom_deleter);
        file->write("Log entry 1");
        file->write("Log entry 2");
        std::cout << "  About to leave scope (custom deleter will run)..." << std::endl;
    }
    std::cout << std::endl;

    std::cout << "=== Release ownership ===" << std::endl;
    {
        auto db = make_resource<DatabaseConnection>("released_db");
        DatabaseConnection* raw = db.release();
        std::cout << "  After release: managed is " << (db ? "valid" : "null") << std::endl;
        std::cout << "  Raw pointer still valid, manually cleaning up..." << std::endl;
        delete raw;
    }
    std::cout << std::endl;

    std::cout << "=== Swap ===" << std::endl;
    {
        auto r1 = make_resource<DatabaseConnection>("db_alpha");
        auto r2 = make_resource<DatabaseConnection>("db_beta");
        std::cout << "  Before swap: r1=" << r1->connection_string
                  << ", r2=" << r2->connection_string << std::endl;
        swap(r1, r2);
        std::cout << "  After swap:  r1=" << r1->connection_string
                  << ", r2=" << r2->connection_string << std::endl;
    }

    std::cout << "\nAll done." << std::endl;
    return 0;
}