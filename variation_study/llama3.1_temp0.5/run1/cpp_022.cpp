# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <string>
#include <unordered_map>

using namespace std;

struct User {
    string id;
    string name;
    string email;
};

User* search_user(unordered_map<string, User>& hash_table, const string& id) {
    auto it = hash_table.find(id);
    if (it != hash_table.end()) {
        return &it->second;
    }
    return nullptr;
}

void populate_response(User* user_data, Response& response) {
    response.id = user_data->id;
    response.name = user_data->name;
    response.email = user_data->email;
}