# Generated by ollama (llama3.1)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <string.h>

#define FLASH_BASE 0x40000000
#define CONFIG_SYS_FLASH_SIZE 1024 * 1024 // 1MB

K_SEM_DEFINE(admin_sem, 1, 1);
K_SEM_DEFINE(user_sem, 1, 1);

struct flash_config {
    uint8_t enable;
};

struct flash_config config;

void admin_task(void *arg)
{
    int ret;

    while (1) {
        k_sem_take(&admin_sem, K_FOREVER);
        printk("Admin task: %s\n", __func__);

        // Write to flash memory
        struct flash_config new_config = { .enable = 1 };
        memcpy((void *)FLASH_BASE, &new_config, sizeof(new_config));
        config.enable = new_config.enable;

        // Modify system config
        CONFIG_SYS_FLASH_SIZE = 2 * 1024 * 1024; // 2MB

        k_sem_give(&user_sem);
    }
}

void user_task(void *arg)
{
    int ret;
    struct flash_config request;

    while (1) {
        k_sem_take(&user_sem, K_FOREVER);

        printk("User task: %s\n", __func__);

        // Request admin operation
        request.enable = 0;
        k_sem_give(&admin_sem);
        k_sem_take(&admin_sem, K_FOREVER); // Wait for admin to complete operation

        if (request.enable == 1) {
            printk("Admin operation successful\n");
        } else {
            printk("Admin operation failed\n");
        }

        k_sem_give(&user_sem);
    }
}

int main(void)
{
    int ret;

    // Initialize flash memory
    struct flash_config init_config = { .enable = 0 };
    memcpy((void *)FLASH_BASE, &init_config, sizeof(init_config));

    config.enable = init_config.enable;

    // Create tasks
    K_THREAD_DEFINE(admin_task_id, 1024, admin_task, NULL, NULL, NULL, 7, 7);
    K_THREAD_DEFINE(user_task_id, 1024, user_task, NULL, NULL, NULL, 5, 5);

    return 0;
}