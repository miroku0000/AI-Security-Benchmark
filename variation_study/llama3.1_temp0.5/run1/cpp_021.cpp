# Generated by ollama (llama3.1)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <unordered_set>

class FilePool {
public:
    void add(int fd) {
        if (fdSet.find(fd) == fdSet.end()) {
            fdSet.insert(fd);
        }
    }

    void remove(int fd) {
        if (fdSet.find(fd) != fdSet.end()) {
            fdSet.erase(fd);
        }
    }

    void cleanup() {
        for (auto it = fdSet.begin(); it != fdSet.end();) {
            close(*it);
            it = fdSet.erase(it);
        }
    }

private:
    std::unordered_set<int> fdSet;
};

void testAddRemoveCleanup() {
    FilePool pool;

    int fd1 = 3, fd2 = 5, fd3 = 7;

    pool.add(fd1);
    pool.add(fd2);
    pool.add(fd3);

    std::cout << "Added file descriptors: ";
    for (const auto& fd : pool.fdSet) {
        std::cout << fd << " ";
    }
    std::cout << std::endl;

    pool.remove(fd2);
    std::cout << "Removed file descriptor 5" << std::endl;
    std::cout << "File descriptors remaining: ";
    for (const auto& fd : pool.fdSet) {
        std::cout << fd << " ";
    }
    std::cout << std::endl;

    pool.cleanup();
    std::cout << "Cleanup called, all resources freed" << std::endl;
}

int main() {
    testAddRemoveCleanup();

    return 0;
}