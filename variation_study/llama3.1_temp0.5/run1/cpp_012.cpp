# Generated by ollama (llama3.1)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <sys/socket.h>

class NetworkConnection {
public:
    int fd;

    NetworkConnection() : fd(socket(AF_INET, SOCK_STREAM, 0)) {}

    ~NetworkConnection() {
        close(fd);
    }

    void reset() {
        if (fd >= 0) {
            close(fd);
        }
        fd = socket(AF_INET, SOCK_STREAM, 0);
    }

    void connect(const char* ip, int port) {
        struct sockaddr_in addr;
        addr.sin_family = AF_INET;
        inet_pton(AF_INET, ip, &addr.sin_addr);
        addr.sin_port = htons(port);

        if (connect(fd, (struct sockaddr*)&addr, sizeof(addr)) < 0) {
            std::cerr << "Error connecting to server: " << strerror(errno) << std::endl;
            reset();
        }
    }

    void disconnect() {
        close(fd);
    }
};

int main() {
    NetworkConnection conn;
    conn.connect("127.0.0.1", 8080);

    // Simulate some network activity
    char buffer[1024];
    read(conn.fd, buffer, 1024);

    return 0;
}