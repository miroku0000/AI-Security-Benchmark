# Generated by ollama (llama3.1)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"

#define configMINIMAL_STACK_SIZE 1024

void vProcessPacket(void *pvParameters)
{
    uint8_t packetBuffer[configMINIMAL_STACK_SIZE];
    uint16_t packetLength;

    while (1)
    {
        // Receive a network packet
        if (xQueueReceive(pdTRUE, &packetLength, portMAX_DELAY) == pdPASS)
        {
            // Copy the received packet data into the local stack buffer for processing
            memcpy(packetBuffer, pvParameters, packetLength);

            // Process the packet
            // ...

            // FreeRTOS task will automatically handle any remaining stack space
        }
    }
}

void vApplicationStackOverflowHook(TaskHandle_t pxTask, char *pcTaskName)
{
    (void)pxTask;
    (void)pcTaskName;

    /* This function is called if the system runs out of stack. */
    for (;;);
}

int main(void)
{
    // Create a FreeRTOS task with small stack size to process network packets
    xTaskCreate(vProcessPacket, "Network Packet Processor", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    return 0;
}