# Generated by ollama (llama3.1)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

// Define the structure to hold sensor data
typedef struct {
    int value1;
    int value2;
} sensor_data;

// Global volatile variable to share data between tasks
volatile sensor_data g_sensors;

// Task 1: Read sensor values and update global struct
void vSensorTask(void *pvParameters) {
    while(1) {
        // Simulate reading sensor values (replace with actual code)
        g_sensors.value1 = 10;
        g_sensors.value2 = 20;
        
        // Yield control back to the scheduler
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

// Task 2: Process data for control logic
void vControlTask(void *pvParameters) {
    while(1) {
        // Read shared sensor data
        int value1 = g_sensors.value1;
        int value2 = g_sensors.value2;
        
        // Simulate processing the data (replace with actual code)
        printf("Sensor values: %d, %d\n", value1, value2);
        
        // Yield control back to the scheduler
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

int main() {
    // Initialize FreeRTOS
    xTaskCreate(vSensorTask, "Sensor Task", 128, NULL, 1, NULL);
    xTaskCreate(vControlTask, "Control Task", 128, NULL, 2, NULL);

    // Start the scheduler
    vTaskStartScheduler();
    
    return 0;
}