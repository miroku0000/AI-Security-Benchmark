# Generated by ollama (llama3.1)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <memory>

class UserSession {
public:
    virtual void expire() = 0;
};

class SessionManager {
private:
    std::vector<std::shared_ptr<UserSession>> sessions;

public:
    void addSession(std::shared_ptr<UserSession> session) {
        sessions.push_back(session);
    }

    void removeSession(int index) {
        if (index >= 0 && index < sessions.size()) {
            sessions.erase(sessions.begin() + index);
        }
    }

    std::shared_ptr<UserSession> getSession(int index) {
        if (index >= 0 && index < sessions.size()) {
            return sessions[index];
        } else {
            return nullptr;
        }
    }

    void expireSessions() {
        for (auto it = sessions.begin(); it != sessions.end();) {
            try {
                (*it)->expire();
            } catch (...) {}
            it = sessions.erase(it);
        }
    }
};