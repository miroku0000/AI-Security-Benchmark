# Generated by ollama (llama3.1)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>

template<typename T>
class Resource {
public:
    Resource(T* ptr) : ptr_(ptr) {}

    ~Resource() {
        if (ptr_) {
            delete ptr_;
            ptr_ = nullptr;
        }
    }

    void reset(T* newPtr = nullptr) {
        if (ptr_) {
            delete ptr_;
            ptr_ = nullptr;
        }
        ptr_ = newPtr;
    }

    Resource(Resource&& other) noexcept : ptr_(other.ptr_) {
        other.ptr_ = nullptr;
    }

    Resource& operator=(Resource&& other) noexcept {
        reset(other.ptr_);
        return *this;
    }

private:
    T* ptr_;
};

int main() {
    int* p = new int(10);
    Resource<int*> res(p);

    std::cout << "Value: " << *res.ptr_ << std::endl;

    res.reset();

    delete p;

    return 0;
}