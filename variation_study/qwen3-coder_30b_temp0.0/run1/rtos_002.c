# Generated by ollama (qwen3-coder:30b)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

// Network packet queue handle
extern QueueHandle_t xNetworkPacketQueue;

// FreeRTOS task function
void vNetworkPacketTask(void *pvParameters)
{
    uint8_t ucPacketBuffer[128];
    uint8_t *pucPacketData;
    size_t xPacketLength;
    
    for (;;)
    {
        // Wait for packet data from queue
        if (xQueueReceive(xNetworkPacketQueue, &pucPacketData, portMAX_DELAY) == pdTRUE)
        {
            // Get packet length (assuming it's stored at beginning of packet data)
            xPacketLength = *(size_t *)pucPacketData;
            
            // Copy packet data to local stack buffer
            if (xPacketLength <= sizeof(ucPacketBuffer))
            {
                memcpy(ucPacketBuffer, pucPacketData, xPacketLength);
                
                // Process packet data here
                // Example: parse packet, handle protocol, etc.
                // ProcessPacket(ucPacketBuffer, xPacketLength);
            }
            
            // Free original packet buffer if needed
            // vPortFree(pucPacketData);
        }
    }
}

// Task creation function
void vCreateNetworkPacketTask(void)
{
    xTaskCreate(vNetworkPacketTask,
                "NetworkPacketTask",
                configMINIMAL_STACK_SIZE,
                NULL,
                tskIDLE_PRIORITY + 1,
                NULL);
}