# Generated by ollama (qwen3-coder:30b)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <memory>
#include <queue>
#include <mutex>
#include <condition_variable>
#include <atomic>
#include <chrono>
#include <functional>
#include <unordered_map>
#include <thread>

class Connection {
private:
    std::atomic<bool> connected_;
    std::atomic<bool> in_use_;
    std::atomic<int> retry_count_;
    std::string address_;
    int port_;
    std::mutex connection_mutex_;

public:
    Connection(const std::string& address, int port) 
        : connected_(false), in_use_(false), retry_count_(0), 
          address_(address), port_(port) {}

    bool connect() {
        std::lock_guard<std::mutex> lock(connection_mutex_);
        // Simulate connection logic
        connected_ = true;
        retry_count_ = 0;
        return true;
    }

    void disconnect() {
        std::lock_guard<std::mutex> lock(connection_mutex_);
        connected_ = false;
    }

    bool is_connected() const {
        return connected_.load();
    }

    bool is_in_use() const {
        return in_use_.load();
    }

    void set_in_use(bool in_use) {
        in_use_.store(in_use);
    }

    int get_retry_count() const {
        return retry_count_.load();
    }

    void increment_retry_count() {
        retry_count_++;
    }

    const std::string& get_address() const {
        return address_;
    }

    int get_port() const {
        return port_;
    }
};

class ConnectionPool {
private:
    std::queue<std::shared_ptr<Connection>> available_connections_;
    std::unordered_map<std::shared_ptr<Connection>, bool> in_use_connections_;
    std::mutex pool_mutex_;
    std::condition_variable condition_;
    std::string address_;
    int port_;
    int max_connections_;
    std::atomic<int> active_connections_;

public:
    ConnectionPool(const std::string& address, int port, int max_connections)
        : address_(address), port_(port), max_connections_(max_connections), 
          active_connections_(0) {}

    std::shared_ptr<Connection> get_connection() {
        std::unique_lock<std::mutex> lock(pool_mutex_);
        condition_.wait(lock, [this] { return !available_connections_.empty() || active_connections_ < max_connections_; });

        if (!available_connections_.empty()) {
            auto conn = available_connections_.front();
            available_connections_.pop();
            in_use_connections_[conn] = true;
            conn->set_in_use(true);
            return conn;
        }

        if (active_connections_ < max_connections_) {
            auto conn = std::make_shared<Connection>(address_, port_);
            if (conn->connect()) {
                active_connections_++;
                in_use_connections_[conn] = true;
                conn->set_in_use(true);
                return conn;
            }
        }

        return nullptr;
    }

    void return_connection(std::shared_ptr<Connection> conn) {
        if (!conn) return;

        std::lock_guard<std::mutex> lock(pool_mutex_);
        conn->set_in_use(false);
        in_use_connections_.erase(conn);
        available_connections_.push(conn);
        condition_.notify_one();
    }

    void free_connection(std::shared_ptr<Connection> conn) {
        if (!conn) return;

        std::lock_guard<std::mutex> lock(pool_mutex_);
        conn->disconnect();
        in_use_connections_.erase(conn);
        active_connections_--;
        condition_.notify_one();
    }

    void retry_connection(std::shared_ptr<Connection> conn) {
        if (!conn) return;

        std::lock_guard<std::mutex> lock(pool_mutex_);
        conn->increment_retry_count();
        if (conn->get_retry_count() > 3) {
            free_connection(conn);
        } else {
            conn->disconnect();
            if (conn->connect()) {
                in_use_connections_[conn] = true;
                conn->set_in_use(true);
                available_connections_.push(conn);
                condition_.notify_one();
            } else {
                free_connection(conn);
            }
        }
    }
};

class NetworkClient {
private:
    std::unique_ptr<ConnectionPool> pool_;
    std::atomic<bool> running_;
    std::function<void(std::shared_ptr<Connection>)> on_connection_failure_;

public:
    NetworkClient(const std::string& address, int port, int max_connections = 10)
        : pool_(std::make_unique<ConnectionPool>(address, port, max_connections)),
          running_(true) {}

    std::shared_ptr<Connection> acquire_connection() {
        auto conn = pool_->get_connection();
        if (!conn) {
            // Handle connection failure
            if (on_connection_failure_) {
                on_connection_failure_(nullptr);
            }
        }
        return conn;
    }

    void release_connection(std::shared_ptr<Connection> conn) {
        if (conn && conn->is_connected()) {
            pool_->return_connection(conn);
        } else {
            pool_->free_connection(conn);
        }
    }

    void handle_connection_failure(std::shared_ptr<Connection> conn) {
        if (conn) {
            pool_->retry_connection(conn);
        }
    }

    void set_failure_callback(std::function<void(std::shared_ptr<Connection>)> callback) {
        on_connection_failure_ = callback;
    }

    void shutdown() {
        running_ = false;
    }
};