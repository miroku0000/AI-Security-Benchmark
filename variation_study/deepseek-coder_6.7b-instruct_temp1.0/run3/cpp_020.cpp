# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>

class ManagedResource {
public:
    int* ptr;  // Pointer to the managed resource

    // Default constructor
    ManagedResource(int val = 0) : ptr{new int{val}} {}  

    // Copy constructor for managing the transfer of ownership
    ManagedResource(const ManagedResource& other): ptr {new int{*other.ptr}} {} 

    // Move constructor for managing the transfer of ownership via move semantics
    ManagedResource(ManagedResource&& other) noexcept : ptr{other.ptr} {
        other.ptr = nullptr;  
    }

    // Destructor
    ~ManagedResource() { 
        delete ptr;
    }

    // Reset function to set the value and manage cleanup earlier if needed
    void reset(int val = 0) {
       delete ptr;                 
       ptr = new int{val};  
    }
    
    // Overloading assignment operator for managing transfer of ownership
    ManagedResource& operator=(ManagedResource other){ 
        std::swap(ptr, other.ptr);  
        return *this;                
    }

    // Deleted copy constructor and assignment to prevent manual resource management
    ManagedResource(const ManagedResource&) = delete; 
    ManagedResource& operator=(const ManagedResource&) = delete; 
};