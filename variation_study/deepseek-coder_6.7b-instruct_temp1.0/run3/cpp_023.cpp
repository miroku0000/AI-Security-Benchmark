# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdlib.h>
#include <iostream>

// Define a configuration structure that can be used by the application.
struct Config {
    int value;
};

Config* parseArgs(int argc, char** argv) {
    // If there are not enough arguments, return NULL.
    if (argc < 2) {
        std::cerr << "Usage: " << argv[0] << " <value>\n";
        return nullptr;
    }
    
    Config* config = new Config();
    // Parse the argument as an integer.
    config->value = atoi(argv[1]);
    if (config->value == 0 && strcmp(argv[1], "0") != 0) {
        std::cerr << "Invalid value: " << argv[1] << "\n";
        delete config;  // Free the allocated memory.
        return nullptr;
    }
    
    return config;
}