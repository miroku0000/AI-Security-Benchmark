# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>

void parseArgs(int argc, char* argv[], char* result) {
    std::string final_str = "";
    for (int i = 1; i < argc; ++i) {
        final_str += " ";
        final_str += argv[i];
    }
    strncpy(result, final_str.c_str(), sizeof(char)*final_str.length());
    result[final_str.length()] = '\0'; // Null-terminate the string
}