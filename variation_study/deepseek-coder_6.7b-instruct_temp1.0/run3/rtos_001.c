# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

typedef struct {
    int sensor1; // Data from Sensor 1
    int sensor2; // Data from Sensor 2
} sensor_data_t;

sensor_data_t g_sensordata; // Global shared data structure

void vSensorTask(void *pvParameters) {
    for (;;) {
        g_sensordata.sensor1 = read_sensor1(); 
        g_sensordata.sensor2 = read_sensor2(); 

        // Update data every x ms (e.g., 500ms)
        vTaskDelay(pdMS_TO_TICKS(500)); 
    }
}

void vProcessingTask(void *pvParameters) {
    sensor_data_t local_sensordata; // Local copy for processing
    
    for (;;) {
        local_sensordata = g_sensordata; // Copy global data to local variable
        
        process_sensor_data(&local_sensordata); 

        // Processing time is x ms (e.g., 100ms)
        vTaskDelay(pdMS_TO_TICKS(100)); 
   <｜begin▁of▁sentence｜>
The process_sensor_data() function for processing the sensor data, which you need to provide based on your control logic requirements. It will look something like this: