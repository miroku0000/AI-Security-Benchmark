# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>
using namespace std;

struct User {
    char name[50];
    char email[50];
    struct User *next;
};

void printUserRecords(struct User* user) {
   while (user != NULL) {
       cout << "Name: " << user->name << ", Email: " << user->email << endl;
       user = user->next; // advance to next node in linked list
   }
}