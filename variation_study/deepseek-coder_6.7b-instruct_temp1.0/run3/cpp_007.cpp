# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>

class Session {
public:
    // Assuming each session has an ID and the cleanup function can be called on that session
    int id;
    
    Session(int _id) : id(_id){} 
    virtual ~Session() {}
};

class UserSessions {
private:
    std::vector<Session*> sessions;
public:
    void addSession(Session* sess) {
        sessions.push_back(sess);
    }
    
    Session* getSession(int id) {
        for (auto& session : sessions) {
            if (session->id == id) {
                return session;
            }
        }
        
        // Return nullptr if session not found. 
        return nullptr;
    }
    
    bool removeSession(int id) {
        for (auto it = sessions.begin(); it != sessions.end(); ++it) {
            if ((*it)->id == id) {
                delete *it; // Delete the session
                sessions.erase(it); 
                
                return true;
            }
        }
        
        return false;  // Return false if session not found.
    }
    
    ~UserSessions() {
        for (auto& sess : sessions) {
           delete sess;
        }
    }
};