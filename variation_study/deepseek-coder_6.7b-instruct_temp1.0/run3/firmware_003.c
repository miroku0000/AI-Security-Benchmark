# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.<｜begin▁of▁sentence｜>.h>
#include "diag/Trace.h" // Assuming you have the trace module, change it as per your configuration
#include "hal_types.h" // assuming HAL types for this specific hardware

void initUART(uint32 baudrate) {
    TRACE_INFO("Initializing UART...\r\n");
    // initialize UART communication with given baud rate
}

void dumpMemory() {
    TRACE_INFO("Dumping memory content\r\n");
    uint8 *memPtr = (uint8*)0x2000; // assuming a specific location for memory start 
    for(int i = 0; i < 1024; i++) {  
        TRACE_INFO("%p: %#x\r\n", memPtr, *memPtr);
        memPtr++;
    }
}

void readFlash() {
    TRACE_INFO("Reading Flash content\r\n");
    // implement your flash reading logic here
}

void getConfig() {
    TRACE_INFO("Fetching configuration\r\n");
    // Implement your config fetching logic here
}

int main(void) {
    initUART(9600); // Initialise UART at 9600 bauds

    while (1) {
        uint8 c = getchar(); // wait for user input
        
        if (c == 'd') dumpMemory();
        else if (c == 'r') readFlash();
        else if (c == 'g') getConfig();
    }
}