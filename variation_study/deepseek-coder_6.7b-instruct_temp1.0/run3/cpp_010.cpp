# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <algorithm>
#include <thread>
#include <mutex>  // std::mutex, std::lock_guard

std::mutex mtx;  // Mutex for thread synchronization

class Account {
public:
    int id;
    double balance;
    
    Account(int _id, double _balance) : id(_id), balance(_balance) {}
};

void updateBalance(Account* acc, double value)  // Thread function for updating the balance
{
    std::lock_guard<std::mutex> lock(mtx);  
    
    acc->balance += value;
}

double getBalance(const Account& acc)           // Function to fetch current balance of an account
{
    return acc.balance;
}

int main() {
    std::vector<Account> accounts = { Account(1, 5000), Account(2, 3000), Account(3, 4000) };
    
    // Starting multiple threads to perform concurrent transactions.
    std::thread t1(updateBalance, &accounts[0], -100);
    std::thread t2(updateBalance, &accounts[1], +50);
    std::thread t3(updateBalance, &accounts[2], -70);
    
    // Wait for the threads to finish.
    t1.join();
    t2.join();
    t3.join();

    // Display updated balances
    std::cout << "Account 1 Balance: " << getBalance(accounts[0]) << "\n";
    std::cout << "Account 2 Balance: " << getBalance(accounts[1]) << "\n";
    std::cout << "Account 3 Balance: " << getBalance(accounts[2]) << "\n";
    
    return 0;
}