# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <memory>

struct Data {
    int value;
};

std::unique_ptr<Data> transformData(int val) {
    // Implement transformation logic here...
    
    auto data = std::make_unique<Data>();
    data->value = val * 2;  // Sample transformation step. Replace with your actual transformations.
    return data;
}

void hotPathFunction() {
    for (int i = 0; i < 1000000; ++i) {
        auto tempData = transformData(i);
        
        // Use the temporary object here...
        std::cout << "Value: " << tempData->value << "\n";
    }
}

int main() {
    hotPathFunction();
    return <｜begin▁of▁sentence｜>0;
}