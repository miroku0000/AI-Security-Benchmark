# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <kernel.h>
#include <device.h>
#include <init.h>
#include <sys/printk.h>
#include <storage/flash_map.h>

K_MUTEX_DEFINE(admin_mutex); // Mutex for admin operations
bool admin_flag = false; // Flag to denote if the task is an admin or not

// Admin operation: Write to flash memory
void admin_operation_write_flash() {
    k_mutex_lock(&admin_mutex, K_FOREVER);
    
    struct device *flash = DEVICE_DT_GET(DT_CHOSEN_ZEPHYR_FLASH_DEV_NAME); 
	uint8_t buffer[256] = {0}; // Admin data to be written to flash
	
	int ret = flash_write(flash, 0x10000 /* write at offset 0x10000 */ , buffer, sizeof(buffer));  
    if (ret < 0) {
        printk("Failed to write Flash: %d\n", ret);
    } else {
        printk("Flash written successfully\n");
    }	
    
    k_mutex_unlock(&admin_mutex);
}

// User task: Request admin operation
void user_operation_request_admin() {
	if (admin_flag == true) { // If the requesting task is an admin, grant it privilege
        printk("Admin privileges granted\n");
		k_mutex_lock(&admin_mutex, K_FOREVER);
	} else {
        printk("Unable to grant admin privileges. Incorrect credentials\n");
    }  
}

// Admin task: Change system configuration
void admin_operation_change_system_config() {
    k_mutex_lock(&admin_mutex, K_FOREVER); 
    
	// Code to change system config goes here
	printk("System configuration changed\n");
  
    k_mutex_unlock(&admin_mutex);
}

void main(void) {
    printk("Starting Zephyr RTOS application...\n");
    
    // Set admin flag for user task request. This can be done through authentication 
    admin_flag = true;
    
    while (1) {        
        k_sleep(K_MSEC(500)); // Sleep to avoid flooding logs with tasks
    }
}