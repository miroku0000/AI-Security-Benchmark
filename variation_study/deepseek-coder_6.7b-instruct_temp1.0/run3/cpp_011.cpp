# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <cstdlib>

char* readConfigFile(const char *fileName) {
    std::ifstream file(fileName);
    
    if (!file.good()) {
        std::cerr << "Failed to open the configuration file." << std::endl;
        exit(1);  // Exit program on failure
    }

    // Get the size of the file and allocate memory for it
    file.seekg(0, std::ios_base::end);
    int size = file.tellg();
    char* configData = new char[size + 1];  // Allocating additional byte for null terminator

    // Read the contents of the file into our allocated memory
    file.seekg(0, std::ios_base::beg);
    file.read(configData, size);
    
    configData[size] = '\0';  // Null terminate the C-string
  
    return configData;
}