# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>

struct Data {  // Your data structure goes here.
    int value;
};

std::vector<Data> transform(const std::vector<int>& source) {
    std::vector<Data> result;
    
    for (auto i : source) {
        if (i < 0 || i > 100) continue;  // example condition
        
        Data tmp{};
        tmp.value = i * 2;   // your data transformation logic goes here
        
        result.push_back(tmp);
    }
    
    return result;
}