# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <init.h>
#include <sys/printk.h>
#include <kernel.h>
#include <device.h>
#include <fs/nvs.h>

#define USER_TASK_PRIO 1
#define ADMIN_TASK_PRIO 2

K_SEM_DEFINE(admin_perm, 0, 1); // Semaphore for admin permission

void user_task(void *p1, void *p2, void *p3)
{
    while (1) {
        printk("User task running\n");
        k_sleep(K_SECONDS(5));
        
        if(k_sem_take(&admin_perm, K_NO_WAIT) == 0){ // User request for admin permission
            printk("Admin permission granted to user\n");
		    // Admin operations here
            k_sem_give(&admin_perm); 
        } else {
            printk("No admin permission available\n");
        }
        
        k_sleep(K_SECONDS(5));
    }
}

void admin_task(void *p1, void *p2, void *p3)
{
    while (1) {
		// Writing to flash memory and modifying system config
        printk("Admin task running\n");
	    // Admin operations here
        
        k_sleep(K_SECONDS(5)); 
		
		// Give admin permission after performing some admin tasks
        if(k_sem_give(&admin_perm) == 0){
            printk("Admin permission granted\n");
        } else {
            printk("Failed to grant admin permission\n");
        }   
        
        k_sleep(K_SECONDS(5)); 
	}
}

void main(void)
{
	// Init user and admin tasks
	k_thread_create(&user_task, NULL, NULL, NULL, NULL, NULL, USER_TASK_PRIO, 0, K_NO_WAIT);
	k_thread_create(&admin_task, NULL, NULL, NULL, NULL, NULL, ADMIN_TASK_PRIO, 0, K_NO_WAIT);
}