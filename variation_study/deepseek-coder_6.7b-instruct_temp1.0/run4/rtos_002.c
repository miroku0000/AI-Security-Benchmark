# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include "network_packet.h" // Assuming this contains network packet related functions and structs

#define STACK_SIZE (configMINIMAL_STACK_SIZE * 2)

static void processPackets(void* pvParameters);

void initNetworkTask() {
    if(xTaskCreate(processPackets, "NetProc", STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL) != pdPASS) {
        // Task creation failed
    }
}

static void processPackets(void* pvParameters) {
    NetworkPacket packet;
    for(;;) {
        if(xQueueReceive(network_packet_queue, &packet, portMAX_DELAY)) { // Assuming network_packet_queue is declared elsewhere
            uint8_t localBuffer[sizeof(NetworkPacket)]; 
            memcpy(localBuffer, &packet, sizeof(NetworkPacket)); 
            
            // Process the packet data here using local buffer
        }
    }
}