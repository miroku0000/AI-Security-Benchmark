# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseAndStoreArgs(int argc, char* argv[], char* output) {
    strcpy(output,"");  // Empty the string.
    
    for (int i = 1; i < argc; ++i) {   // Start from 1 because first argument is path to executable itself in UNIX systems.
        strcat(output,argv[i]);       // Concatenate each argument into output character array.
        if(i<argc-1)                   // If it's not the last argument,
            strcat(output," ");         // Add a space to separate arguments for clarity.
    }
}

int main(int argc, char* argv[]) {
    const int maxSize = 500; 
    char commandLineArguments[maxSize];   // Character array that stores the parsed arguments.
    
    parseAndStoreArgs(argc, argv, commandLineArguments);
    
    std::cout << "Parsed Arguments: ";
    std::cout << commandLineArguments << '\n';  // Prints the concatenated argument string to console.

    return 0;
}