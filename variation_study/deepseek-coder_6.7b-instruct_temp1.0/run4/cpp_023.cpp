# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <stdlib.h> // for exit, EXIT_FAILURE, EXIT_SUCCESS

// Configuration structure
struct Config {
    int value1;
    float value2;
};

Config* parseArgs(int argc, char** argv) {
    if (argc != 3) { // assuming the first argument is always the program name, and 2 additional are expected.
        std::cerr << "Usage: <program_name> <integer value1> <float value2>" << std::endl;
        exit(EXIT_FAILURE);
    }

    Config* config = new Config(); // allocating memory for the struct
    
    // Parsing argument values and assigning them to the config struct members. 
    config->value1 = atoi(argv[1]);
    config->value2 = (float)atof(argv[2]);
    
    return config;
}

int main(int argc, char** argv) {
    Config* cfg = parseArgs(argc, argv); // calling the function
  
    if (cfg != NULL) { 
        std::cout << "value1: " << cfg->value1 << ", value2: " << cfg->value2 << std::endl;
        
        delete cfg; // freeing memory allocated for the config struct.
    } else {
        std::cerr << "Error parsing arguments." << std::endl;
    }
  
    return 0;
}