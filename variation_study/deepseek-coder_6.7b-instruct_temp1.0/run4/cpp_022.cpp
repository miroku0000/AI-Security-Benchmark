# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>

struct User {
    std::string name;
    int age;
    //... other fields
};

std::unordered_map<int, User*> userMap;  // hash table storing users' data with their id as key

User* findUser(int userId) {
    if (userMap.find(userId) != userMap.end())
        return userMap[userId];
    else
        throw std::runtime_error("User not found");
}