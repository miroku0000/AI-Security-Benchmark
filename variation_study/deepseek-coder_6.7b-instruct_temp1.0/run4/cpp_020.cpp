# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
using namespace std;

class Resource {
    int* m_resource; // Assume that this represents some kind of resource 
public:
    explicit Resource(int size) : m_resource(new int[size]) { 
        cout << "Resource allocated" << endl;
     }  
    ~Resource() {
        delete [] m_resource;
        cout << "Resource deallocated" << endl;
    }

    Resource(const Resource&) = delete; // prevent copying of resources. 
    Resource& operator= (const Resource&) = delete;
  
    Resource(Resource&& other) noexcept : m_resource(other.m_resource) { // move constructor
        other.m_resource = nullptr; // this prevents deletion of the resource in the source 
                                   // object when it is destroyed.
    }    

    Resource& operator= (Resource&& other) noexcept {   // move assignment
        if(this != &other){
            delete[] m_resource;               // first we need to free any resource this 
                                                 // instance is holding, then take the resources
                                                  // from the source object.
            m_resource = other.m_resource;    
            other.m_resource = nullptr;  
        }
        return *this;                         
    } 

    void reset() {                      
         delete [] m_resource;           // clean up any existing resource, then set to null.
         m_resource=nullptr;             
     }                    
};