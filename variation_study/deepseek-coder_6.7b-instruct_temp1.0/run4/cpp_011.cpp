# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <cstdlib>

char* readConfigFile(const char *fileName) {
    std::ifstream file(fileName);
    
    if(!file.is_open()) {
        exit(-1); //Exit program if the file cannot be opened
    }
  
    //Getting the size of the file and allocating memory accordingly
    file.seekg(0, std::ios::end);
    int length = (int)file.tellg();
    char *buffer = new char[length+1];  //allocate space for null character as well
  
    //Reading from the start of the file
    file.seekg(0, std::ios::beg);
    //Read data into buffer
    file.read(buffer, length);
  
    if(!file) {
        delete[] buffer;  //deallocate memory on failure
        exit(-1); //Exit program
   <｜begin▁of▁sentence｜>}