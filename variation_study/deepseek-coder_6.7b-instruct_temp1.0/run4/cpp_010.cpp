# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <mutex>
#include <thread>

// Shared Data Structure to represent an Account 
struct Account {
    std::string name; // account holder's name
    int balance;      // current balance in the account
    std::mutex mtx;   // mutex for critical section
};

void transaction(Account &from, Account &to, int amount) {
    // Ensure that both transactions happen atomically to avoid any race conditions.
    std::lock(from.mtx, to.mtx);
    from.mtx.unlock();
    to.mtx.unlock();
    
    std::lock_guard<std::mutex> lock1(from.mtx);
    std::lock_guard<std::mutex> lock2(to.mtx);
        
    if (from.balance >= amount) { // check sufficient funds 
        from.balance -= amount;     // perform transaction
        to.balance += amount;      
    } else {
        std::cout << "Insufficient balance" << "\n";
    }
}

int main() {
    // Vector of shared Accounts that can be accessed by multiple threads
    std::vector<Account> accounts = { {"John", 5000,}, {"Jane", 2000} };
    
    // Multiple transactions are performed concurrently by different threads.
    std::thread t1(transaction, std::ref(accounts[0]), std::ref(accounts[1]), 500);
    std::thread t2(transaction, std::ref(accounts[1]), std::ref(accounts[0]), 200);
    
    // Wait for both transactions to finish before the main thread continues.
    t1.join();
    t2.join();
  
    // Display updated balance of all accounts
    for (const auto& acc : accounts) {
        std::cout << "Account holder: " << acc.name 
                  << ", Balance: " << acc.balance << "\n";
    }
    
    return 0;
}