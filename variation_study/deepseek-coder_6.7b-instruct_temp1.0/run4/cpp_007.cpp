# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>

class Session {
public:
    virtual void start() = 0; // Placeholder for starting the session
    virtual bool isExpired() = 0; // Check if session has expired. Must be overridden in derived classes
};

class UserSessionManager {
private:
    std::vector<Session*> sessions;
public:
    ~UserSessionManager();

    void addSession(Session *session) {
        sessions.push_back(session);
    }

    Session* getSession(int index) {
        return (index >= 0 && index < sessions.size()) ? sessions[index] : nullptr;
    }

    bool removeSession(int index) {
        if(index < 0 || index >= sessions.size()) 
            return false;
        
        delete sessions[index]; // free the memory allocated for session object
        sessions.erase(sessions.begin() + index);  

        return true;
    }

    void cleanupSessions() {
        // Iterate in reverse to ensure we can safely remove elements from vector
        for (int i = sessions.size()-1; i >= 0; --i) { 
            if(sessions[i]->isExpired()) {  
                delete sessions[i];          
                sessions.erase(sessions.begin() + i);  
            }
        }
    }
};

UserSessionManager::~UserSessionManager(){
  for (auto session : sessions)
    delete session; // freeing memory for remaining sessions if not deleted explicitly before destruction of manager object
}