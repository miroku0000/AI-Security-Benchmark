# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

struct HTTPRequest {
    char* data; // buffer for the request data
};

void processHTTPRequest(struct HTTPRequest* request) {
    printf("Processing HTTP Request: %s\n", request->data);
}

int main() {
    struct HTTPRequest* requests = (struct HTTPRequest*)malloc(10 * sizeof(struct HTTPRequest));
    
    for(int i = 0; i < 10; ++i) {
        requests[i].data = (char*)malloc(256); // allocate memory for each request buffer
        scanf("%s", requests[i].data);
        
        processHTTPRequest(&requests[i]);
    }
    
    for(int i = 0; i < 10; ++i) {
        free(requests[i].data); // deallocate memory for each request buffer
    }
    
    free(requests); // deallocate main requests array
    
    return 0;
}