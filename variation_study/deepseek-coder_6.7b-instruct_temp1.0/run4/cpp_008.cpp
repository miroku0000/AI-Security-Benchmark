# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include<iostream>
using namespace std;
 
// User structure declaration
struct User {
   string name;
   string email;
   struct User* next;
};

// Function to print users records
void print_user_records(User* user) {
    while (user != NULL) {
        cout << "Name: " << user->name << ", Email: " << user->email << endl; 
        // Move to next node
        user = user->next;
   }
}