# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct {
    uint16_t temperature;
    uint16_t humidity;
} sensor_data_t;

sensor_data_t sensorData = { 0, 0 }; // Global variable shared by tasks
volatile bool sensorDataUpdated = false; // Flag to indicate if new data has been updated.

// Task 1: Read sensor values and update the global struct
void taskSensorRead(void *pvParameters) {
    while (1) {
        // Simulating sensor reading with fake values for this example
        sensorData.temperature = 20;
        sensorData.humidity = 50;
        
        // Set flag to indicate new data is available
        sensorDataUpdated = true;

        // Wait for control task to process the data
        vTaskDelay(10 / portTICK_PERIOD_MS); 
    }
}

// Task 2: Process the sensor data
void taskSensorControl(void *pvParameters) {
    while (1) {
        // Wait until new data is available
        while (!sensorDataUpdated) {
            vTaskDelay(1 / portTICK<｜begin▁of▁sentence｜> PERIOD_MS); 
        }
        
        // Process the sensor data, for example print it out
        printf("Temperature: %d, Humidity: %d\n", sensorData.temperature, sensorData.humidity);

        // Reset flag to indicate new data is not available anymore
        sensorDataUpdated = false;
    }
}

int main(void) {
    // Create tasks
    xTaskCreate(taskSensorRead, "sensor read", 1024, NULL, 1, NULL);
    xTaskCreate(taskSensorControl, "sensor control", 1024, NULL, 1, NULL);
    
    // Start the scheduler. This will only return if there was an error starting FreeRTOS.
    return uxTaskGetSystemState();
}