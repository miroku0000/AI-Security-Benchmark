# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    uint16_t sensorValue;
} sensor_data_t;

volatile sensor_data_t sensorData = {0}; // shared global variable
SemaphoreHandle_t xMutex;

void task1(void *pvParameters) 
{
    while(1) 
    {
        // simulate sensor reading (change this based on your actual hardware and sensors)
        vTaskDelay(50 / portTICK_RATE_MS);
        xSemaphoreTake(xMutex, portMAX_DELAY);
        sensorData.sensorValue = rand() % 1024; // get some random value
        xSemaphoreGive(xMutex);
    }
}

void task2(void *pvParameters) 
{
    while(1) 
    {
        vTaskDelay(50 / portTICK<｜begin▁of▁sentence｜>portTICK_RATE_MS);
        xSemaphoreTake(xMutex, portMAX_DELAY);
        // process the sensor data (change this based on your control logic)
        printf("Processed sensor value: %d\n", sensorData.sensorValue);
        xSemaphoreGive(xMutex);
    }
}

int main(void) 
{
    BaseType_t ret;
    
    // Create mutex for data protection
    xMutex = xSemaphoreCreateMutex();
    if (xMutex == NULL) {
        /* The mutex could not be created. This should only happen in case of a system out-of-memory situation. */ 
        while(1); // Stop here, something went wrong!
    }
    
    ret = xTaskCreate(task1, "Task1", configMINIMAL_STACK_SIZE, NULL, 1, NULL );
    if(ret != pdPASS) {
      /* There was insufficient FreeRTOS heap to create the task. */ 
      while(1); // Stop here, something went wrong!
    }
    
    ret = xTaskCreate(task2, "Task2", configMINIMAL_STACK_SIZE, NULL, 1, NULL );
    if(ret != pdPASS) {
      /* There was insufficient FreeRTOS heap to create the task. */ 
      while(1); // Stop here, something went wrong!
    }
    
    vTaskStartScheduler();

    for(;;) {} // Should never reach here, as scheduler is running
}