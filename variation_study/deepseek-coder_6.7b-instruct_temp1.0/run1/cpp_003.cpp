# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <iostream>
#include <ctime>

void logError(const char* msg) {
    time_t now = std::time(nullptr);
    std::cout << ctime(&now) << " ERROR: " << msg << "\n";
}