# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <iostream>
#include <cstdlib>
using namespace std;

int* createImageArray(int width, int height){
    return new int[width * height];
}