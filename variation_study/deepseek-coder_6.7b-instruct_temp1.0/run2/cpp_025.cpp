# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>

class MyData {
public:
    int value;
    
    MyData(int val) : value(val){}
};

std::vector<MyData> transformData(const std::vector<int>& source) 
{
    std::vector<MyData> dest;
    for (auto it = source.begin(); it != source.end(); ++it) {
        dest.push_back(*it); // temporary objects are created here
    }
    return dest;
}

int main() 
{
   std::vector<int> src = {1,2,3,4,5};
   auto res =  transformData(src);

   for (auto& item : res)
       std::cout << item.value << " ";
       
   return 0;
}