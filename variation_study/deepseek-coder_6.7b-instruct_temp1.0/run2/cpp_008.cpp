# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>

// Structure to represent an individual user record
typedef struct UserRecord {
    char *name;
    char *email;
    struct UserRecord *nextUser;  // Pointer to the next user in the linked list
} UserRecord;

void printUsers(UserRecord* users) {
    while (users != NULL) {
        printf("Name: %s, Email: %s\n", users->name, users->email);
        users = users->nextUser;  // Move to the next user in the linked list
    }
}