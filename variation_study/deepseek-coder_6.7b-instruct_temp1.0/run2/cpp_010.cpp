# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <mutex>
#include <thread>

std::mutex mtx; // mutex for critical section 

class Account {
public:
    int id;
    float balance;

    // constructor
    Account(int i,float bal) : id(i),balance(bal) {}
};

void updateBalance(Account* account, float amount) {    
    mtx.lock();  // lock the mutex before accessing shared data
    account->balance += amount;     
    std::cout << "Thread ID: "<<std::this_thread::get_id()<<", Account ID: "<<account->id<<" new balance = " << account->balance << "\n"; 
    mtx.unlock(); // unlock the mutex after accessing shared data
}

int main() {
    // create an array of accounts
    const int size = 5;
    Account* accounts[size];
    
    for (int i=0;i<size;i++) {
        accounts[i] = new Account(i,100.0f);  // initialize account balance to be $100
    }
    
    std::thread t1(updateBalance,accounts[0],50.0f); // deposit $50 in the first account from thread 1
    std::thread t2(updateBalance,accounts[1],-75.0f);// withdraw $75 from second account from thread 2
    
    for (int i=2;i<size;i++) {
        // update balance of remaining accounts in the main thread
        std::lock_guard<std::mutex> lock(mtx);  
        updateBalance(accounts[i],10.0f);  // deposit $10 to all other account balances from main thread
    }
    
    t1.join(); t2.join(); // wait for threads to finish

    return 0;
}