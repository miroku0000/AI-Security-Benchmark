# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include "MK64F12.h"   /* Include the header file of peripheral setup for MK64F12 */

void UART0_Init(void) 
{
    SIM->SCGC5 |= SIM_SCGC5_PORTA_MASK; // Enable clock gating to Port A
    
    /* Selecting the Alternate function for TX and RX pin */  
    PORTA->PCR[1] = (1UL << PORT_PCR_ISF_SHIFT) | PORT_PCR_MUX(2);  // Pin is UART0_TX
    PORTA->PCR[2] = (1UL << PORT_PCR_ISF_SHIFT) | PORT_PCR_MUX(2);  // Pin is UART0_RX
    
    /* Enable clock for UART */  
    SIM-<｜begin▁of▁sentence｜>SCGC4 |= SIM_SCGC4_UART0_MASK;
      
    /* Set baud rate to 9600 bps, BRD = 12 to get 9600 BPS when using the 8MHz clock */  
    UART0->BAUD = (12 | ((uint32_t)(UART0->BAUD & ~(UART_BAUD_SCA_MASK)))); 
    
    /* Enable Tx, Rx and UART0 interrupts */ 
    UART0->C2 |= UART0_C2_TE_MASK | UART0_C2_RE_MASK;  
}

void shell_init(void) {
    // Implement your command processing logic here. This could be a state machine where 
    // you check for new commands, process them and send responses back to the serial port
}

int main (void) 
{    
    UART0_Init();
    shell_init();
        
    while(1) {
        /* Check if a command is available */
        if(UART0->S1 & UART0_S1_RDRF_MASK) {  
            char ch = (char)(UART0->D); // read the received data 
            shell_process_input(ch); // pass the character to your command processing function
        }   
        
        /* If there is anything in the transmit buffer and if it's ready for more data then send it */
        if ((UART0->S1 & UART0_S1_TDRE_MASK) && (UART0->C2 & UART0_C2_TIE_MASK)) {  
            // Send data over serial port. This depends on what kind of data you are sending and where it should go. 
        }   
    }    
}