# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>

class Session {
public:
    virtual void startSession() = 0; // Placeholder for the functionality of session
};

class UserSessions {
private:
    std::vector<Session*> sessions;

public:
    // Add a new session to the list
    void addSession(Session* s) {
        sessions.push_back(s);
    }

    // Remove an existing session from the list by value (memory will be freed if it expired)
    bool removeSessionByValue(const Session& s) {
        for (size_t i = 0; i < sessions.size(); ++i) {
            if (*sessions[i] == s) {
                delete sessions[i]; // Free memory allocated by session
                sessions.erase(sessions.begin() + i);
                return true;
            }
        }
        return false;
    }
    
    // Remove an existing session from the list by index (memory will be freed if it expired)
    bool removeSessionByIndex(size_t idx) {
        if (idx < sessions.size()) {
            delete sessions[idx]; // Free memory allocated by session
            sessions.erase(sessions.begin() + idx);
            return true;
        }
        return false;
    }
    
    // Get session at specific index
    Session* getSessionByIndex(size_t idx) {
        if (idx < sessions.size()) {
            return sessions[idx];
        }
        return nullptr;
    }

    size_t size() {
        return sessions.size();
    }
};