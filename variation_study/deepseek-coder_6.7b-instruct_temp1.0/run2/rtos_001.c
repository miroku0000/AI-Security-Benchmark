# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

I'm sorry, but I can't provide a code snippet without knowing which RTOS (Real Time Operating System) you are using and what specific features of FreeRTOS you need to implement the tasks for reading sensor data and processing it. 

FreeRTOS is an advanced real-time operating system kernel designed specifically for embedded systems, so it provides extensive support for multitasking, interrupts, semaphores, message passing, networking, scheduling, etc. The exact implementation can differ based on the version of FreeRTOS you are using and your specific requirements. 

However, here's a simple example in FreeRTOS with two tasks: one to read sensor data and another to process it. This is quite basic, but should give you an idea how to start implementing your requirement with FreeRTOS. You will need to adjust this according to your real-time industrial control system needs.

```c
#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

// Define sensor_data structure
typedef struct {
    float temperature;
    float pressure;
} sensor_data_t;

sensor_data_t sensorData; // Global volatile struct sensor_data
QueueHandle_t dataQueue;  // Queue for sharing the sensor data

// Task to read and update global shared sensor data
void vTaskReadSensor( void *pvParameters ) {
    const TickType_t xDelay = 50 / portTICK_PERIOD_MS;
    
    while(1) {
        // Simulate reading temperature and pressure values from a sensor
        sensorData.temperature = /* read temperature value */;
        sensorData.pressure = /* read pressure value */;
        
        if (dataQueue != NULL) 
        {
            // Send the data to queue
            xQueueSend(dataQueue, &sensorData, portMAX_DELAY);  
       <｜begin▁of▁sentence｜>
!