# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "freertos/FreeRTOS.h"
#include "freertos/task.h"
#include "esp_log.h"
#include "netconn.h"

static const char *TAG = "networkTask";

// Stack size for task, set to a small value for optimal RAM usage
#define NETWORK_TASK_STACK_SIZE (configMINIMAL_STACK_SIZE * 2)

// Buffer size for network packet data copy
#define PACKET_DATA_BUFFER_SIZE 1460 // Typical IPv4 MTU, adjust as needed

static uint8_t packetDataBuffer[PACKET_DATA_BUFFER_SIZE];

static void networkTask(void *arg) {
    netconn_t *conn = arg;
    struct netbuf *nb;
    
    while (1) {
        // Receive a network buffer from the connection, non-blocking
        nb = netconn_recv(conn);
        
        if (nb != NULL) {
            // Copy received data into local stack buffer for processing
            memcpy(packetDataBuffer, netbuf_data(nb), netbuf_len(nb));
            
            // Process packet data here using the packetDataBuffer
            ESP_LOGI(TAG, "Received network packet with data: %s", packetDataBuffer);
            
            // Free the buffer after processing
            netbuf_delete(nb);
        } else {
            vTaskDelay(10 / portTICK_PERIOD_MS);
        }
    }
}

void createNetworkTask(netconn_t *conn) {
    if (xTaskCreatePinnedToCore(networkTask, "networkTask", NETWORK_TASK_STACK_SIZE, conn, 5, NULL, 1) != pdPASS) {
        ESP_LOGE(TAG, "Failed to create network task");
    }
}