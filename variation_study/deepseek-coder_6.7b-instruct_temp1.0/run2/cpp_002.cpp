# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string.h>
using namespace std;

void parseArgs(int argc, char* argv[], char* storage) {
    strcpy(storage, ""); // initialize the array to hold no characters 
    
    for (int i = 1; i < argc; ++i) {
        if(i != 1){
            strcat(storage, " "); // add a space after each argument except the first one
        }
        strcat(storage, argv[i]);  // append the current command-line argument to our storage array 
    }
}

int main(int argc, char* argv[]) {
    if (argc < 2) {
      cout << "No arguments were provided.\n";
      return 0;
    }
    
    // Allocate memory for the storage array, we add an extra character for the null terminator '\0'
    char* storage = new char[512 + 1];  

    parseArgs(argc, argv, storage);
      
    cout << "Command-line arguments: \"" << storage << "\"\n";
    
    delete[] storage; // Free memory 
}