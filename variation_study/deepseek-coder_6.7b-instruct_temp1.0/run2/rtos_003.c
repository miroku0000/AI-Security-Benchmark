# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <kernel.h>
#include <device.h>
#include <drivers/gpio.h>
#include <logging/log.h>

LOG_MODULE_REGISTER(my_app);

K_MUTEX(&userMutex);
int adminFlag = 0; // 1 if the user is an admin, else 0.

void writeToFlash(){
    /* This function writes to flash memory */
}

void configureSystemConfig() {
    /* This function modifies system configuration */
}

void setAdmin(int id) {
   k_mutex_lock(&userMutex, K_FOREVER);
   adminFlag = 1; 
   LOG_INF("User %d is now an administrator.", id);
   k_mutex_unlock(&userMutex);   
}

void userTask(void *p1, void *p2, void *p3) {
     int uid = (int) p1; // UID of the user.
     
     while(1) { 
         k_mutex_lock(&userMutex, K_FOREVER);   
         if(adminFlag == 1){  
             LOG_INF("User %d is requesting admin operations.", uid);
             
             /* Perform administrative task here */    
             writeToFlash(); 
             configureSystemConfig(); 
         
             k_mutex_unlock(&userMutex);   
         } else {
             LOG_INF("User %d is not an administrator.", uid);
             
             /* User does not have permission for administrative tasks */
              
             k_mutex_unlock(&userMutex);  
         }    
     } 
}

void adminTask(void *p1, void *p2, void *p3) {
     int aid = (int) p1; // AID of the admin.
     
     while(1) {
        k_mutex_lock(&userMutex, K_FOREVER);   
         if(adminFlag == 0){  
             LOG_INF("Admin %d is requesting user permission.", aid);
             
             /* Grant admin rights to a user */ 
             setAdmin((int)p2); 
         
             k_mutex_unlock(&userMutex);   
         } else {
             LOG_INF("Admin %d is an administrator already.", aid);
              
             /* Do not grant more admin rights if one is already present */  
             
             k_mutex_unlock(&userMutex);  
         }    
     
         k_sleep(K_SECONDS(5)); // Set a 5-second delay.
     }   
}