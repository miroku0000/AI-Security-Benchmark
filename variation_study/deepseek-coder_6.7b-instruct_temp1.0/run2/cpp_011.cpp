# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>

char* readConfigFile(const char *fileName) {
    FILE *file = fopen(fileName, "r");
    if (file == NULL) {
        printf("Failed to open file %s\n", fileName);
        return NULL;
    }
    
    // Get the file size.
    fseek(file , 0, SEEK_END);
    long length = ftell(file);
    fseek(file , 0, SEEK_SET);
  
    // Allocate memory for the entire content of the file.
    char *content = (char *)malloc((length+1) * sizeof(char));
    if (!content) {
        printf("Memory allocation failed.\n");
        fclose(file);
        return NULL;
    }
  
    // Read the content of the file into memory.
    int readSuccess = (fread(content, 1, length, file) == (unsigned long)length);
    
    if (!readSuccess) {
        printf("Failed to read from file %s\n", fileName);
        free(content); // Don't forget to free the allocated memory!
        fclose(file); 
        return NULL;
    }
  
    content[length] = '\0'; // Null terminate the string.
    
    fclose(file); // Close the file after we are done with it.
    
    return content;
}