# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include "EZ32USB1A1SoCStack.h"

void halCommonInit( void ) {
    // Initialization sequence for the hardware
}

void appInitCallback( uint8_t commandId, zb_buf_t* buf, 
                      ZB_ENERGY_SCAN_CHANNELS_T scannedChannels ) {
    EZ32_SetNetworkKey(1, (const uint8*)gEZ32DemoAppLinkKey); // Set network key here.
}

void appTaskletProcessCallback(uint8_t taskId) {
    if (!appInfo.stackProfileActive){
        EZSP_SetPermitJoinTime((2 * 60));     // Allow joining for up to 2 minutes.
        EZSP_EnablePermitJoining();           // Enable permit joined mode.
    }  
}

void main( void ) {
    halInit();                            // Initialize the HAL (Hardware Abstraction Layer)
    vTaskStartScheduler();                 // Start the scheduler.  This function should not return
}