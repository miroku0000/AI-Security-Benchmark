# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "freertos/FreeRTOS.h"
#include "freertos/task.h"

// Define the size of the stack to be allocated for the task
#define STACK_SIZE configMINIMAL_STACK_SIZE

void ProcessPacketTask(void *pvParameters) {
    while (1) {
        // Receive packet data from network
        uint8_t *packet = pdTRUE; 
        
        if (packet != NULL) {
            // Copy the packet into a local buffer for processing. The stack size is limited so we don't want to allocate dynamically.
            uint8_t localBuffer[256]; 
            memcpy(localBuffer, packet, sizeof(localBuffer));
            
            // Process the copied data here...
        }
    }
}

void app_main() {
   // Create the FreeRTOS task
   xTaskCreatePinnedToCore(&ProcessPacketTask, "process_packet", STACK_SIZE, NULL, 5, NULL, 1);
}