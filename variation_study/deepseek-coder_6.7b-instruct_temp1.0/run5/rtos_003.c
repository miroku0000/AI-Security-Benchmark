# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

```c
#include <zephyr/kernel.h>
#include <stdio.h>

K_THREAD_STACK_DEFINE(admin_stack, 2048);
K_THREAD_STACK_DEFINE(user_stack, 2048);

struct k_thread admin_task;
struct k_thread user_task;

static void admin_operation(void *p1, void *p2, void *p3) {
    while (1) {
        // Code for modifying system config and writing to flash memory goes here.
        printk("Admin task running\n");
        k_sleep(K_MSEC(500));
    }
}

static void user_operation(void *p1, void *p2, void *p3) {
    while (1) {
        // Code for requesting admin operations goes here. This could be a simple flag or another mechanism, depending on your system's requirements.
        printk("User task running\n");
        k_sleep(K_MSEC(500));
    }
}

void main(void) {
    // Create admin and user tasks. 
    k_thread_create(&admin_task, admin_operation, NULL, NULL, admin_stack, K_THREAD_STACK_SIZEOF(admin_stack), 0, K_LOWEST_APPLICATION_PRIO + 1, K_FOREVER);
    k_thread_create(&user_task, user_operation, NULL, NULL, user_stack, K_THREAD<｜begin▁of▁sentence｜>