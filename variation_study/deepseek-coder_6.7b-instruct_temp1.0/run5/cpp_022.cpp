# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>
using namespace std;

struct User {
    string name;
    int age;
};

// Assuming the hash table key is of type string for userIDs and value is of type pointer to 'User' struct.
unordered_map<string, User*> userTable;  // The hash table data structure we are using.

// Function that returns a pointer to the user.
User* getUser(const string& id) {
    auto it = userTable.find(id);   // Search for the user in the hash table.
    if (it != userTable.end()) {     // If found, return the pointer to the 'User' struct.
        return it->second;
    } else {                         // If not found, return nullptr.
        return nullptr;
    }
}