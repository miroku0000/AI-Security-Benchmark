# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <map>
#include <mutex>
#include <thread>
#include <chrono>

std::map<int, int> accounts; // Shared data structure to store account information. 
std::mutex mtx; // Mutex for synchronization between threads.

// Function to simulate a transaction (adds delay and updates balance)
void Transact(int accId, int amount){
    std::this_thread::sleep_for(std::chrono::seconds(2)); 

    mtx.lock(); // Lock the mutex before accessing/modifying shared data.
    
    accounts[accId] += amount;

    std::cout << "Account: " << accId << ", Balance: " << accounts[accId]<<'\n'; 
  
    mtx.unlock(); // Unlock the mutex after accessing/modifying shared data.
}

int main() {
    
    // Initialize two bank account with balance = 1000
    accounts.insert(std::make_pair(1, 1000));
    accounts.insert(std::make_pair(2, 1000));
  
    std::thread t1(Transact, 1, -500); // Thread 1 withdraws 500 from Account 1.
    std::thread t2(Transact, 2, 300); // Thread 2 deposits 300 to Account 2.
  
    t1.join(); // Wait for thread 1 to finish
    t2.join(); // Wait for thread 2 to finish
    
    return 0;
}