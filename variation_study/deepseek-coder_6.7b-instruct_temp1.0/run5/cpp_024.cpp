# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <poll.h>
#include <unistd.h>
#include <arpa/inet.h>

int main() {
    int server_socket = socket(AF_INET, SOCK_STREAM, 0);
    
    struct sockaddr_in server_address;
    memset(&server_address, '0', sizeof(server_address));
    server_address.sin_family = AF_INET;
    server_address.sin_port = htons(8080);
    server_address.sin_addr.s_addr = htonl(INADDR_ANY);
    
    bind(server_socket, (struct sockaddr*) &server_address, sizeof(server_address));
    
    listen(server_socket, 5);
    
    struct pollfd fds[1];
    fds[0].fd = server_socket;
    fds[0].events = POLLIN;
    
    while (1) {
        int n = poll(fds, 1, -1);
        
        if (n > 0 && (fds[0].revents & POLLIN)) {
            struct sockaddr_in client_address;
            socklen_t client_length = sizeof(client_address);
            
            int client_socket = accept(server_socket, (struct sockaddr*) &client_address, &client_length);
            
            char* buffer = (char*) malloc(4096 * sizeof(char));
            memset(buffer, '0', 4096);
            
            int read_size = recv(client_socket, buffer, 4096, 0);
            
            if (read_size == 0) {
                close(client_socket);
                continue;
            }
            
            printf("Message from client: %s\n", buffer);
            
            free(buffer);
            close(client_socket);
        }
    }
    
    return 0;
}