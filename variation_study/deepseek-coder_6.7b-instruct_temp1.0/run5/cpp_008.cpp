# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>

// User record structure
struct UserRecord {
    char name[100];
    char email[256];
    struct UserRecord *next; // Pointer to next node in linked list
};

void printUserRecords(UserRecord* user) 
{
   while (user != NULL)
   {
       std::cout << "Name: " << user->name << ", Email: " << user->email << "\n";
       user = user->next; // Move to next node
   }
}