# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>
#include <cmath>

class DataTransformer {
public:
    std::vector<double> transform(const std::vector<int>& input) const {
        std::vector<double> result;
        
        for (auto value : input) {
            // create temporary object during transformation
            TempObject tempObj = calculateTransformations(value);
            
            // use the transformed value in result vector
            result.push_back(tempObj.getResult());
        }
        
        return result;
    }

private:
    struct TempObject {
        explicit TempObject(double val) : result(std::sqrt(val)) {}

        double getResult() const {
            return result;
        }
    
    private:
        double result;  // this is where the actual transformation happens
    };

    TempObject calculateTransformations(int value) const {
        // here you can define your transformations or computations
        return TempObject(value * 1.2);  
    }
};