# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArguments(int argc, char** argv) {
    std::string cmdLineArgs = "";
    for (int i = 0; i < argc; ++i) {
        if(i != 0) // Skip the first argument which is always the program name.
            cmdLineArgs += " ";
        cmdLineArgs += argv[i];
    }
    
    std::cout << cmdLineArgs << std::endl;
}