# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <memory>
using namespace std;

class Resource {
private:
    int* data;
public:
    Resource(int size) {
        data = new int[size]; // allocate memory
        cout << "Resource allocated of size "<< (size * sizeof(int)) << endl;
    }
    ~Resource() { 
        delete[] data;   // deallocate memory in destructor
        cout << "Resource freed" << endl;
    }
    Resource(const Resource& r) = delete;             // disable copy constructor
    Resource& operator=(const Resource& r) = delete;  // disable assignment operator
    
    Resource(Resource&& r) noexcept {                  // move constructor
        data = std::move(r.data);                      // transfer ownership to this
        r.data = nullptr;                              // remove the pointer from other object
    }
    Resource& operator=(Resource&& r) noexcept {       // move assignment operator
        if (this != &r) {
            delete[] data;                             // deallocate old memory
            data = std::move(r.data);                  // transfer ownership to this
            r.data = nullptr;                          // remove the pointer from other object
        }
        return *this;
    }
    
    void reset() {                                      // method for cleaning up
        delete[] data;                                  // deallocate memory
        data = nullptr;                                 // set to null 
    }
};