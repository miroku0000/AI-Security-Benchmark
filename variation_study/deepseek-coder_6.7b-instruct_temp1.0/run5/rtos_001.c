# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

```c
#include "FreeRTOS.h"
#include "task.h"

// Structure to hold sensor data
typedef struct {
    float temperature;
    float pressure;
} sensor_data;

// Declare a global volatile instance of the structure
volatile sensor_data gSensorData;

// Task 1 function, reads from sensors and updates the shared structure
void vTask1( void *pvParameters ) {
    while (1) {
        // Replace with real read functions for temperature and pressure sensors
        gSensorData.temperature = 25.0f;  
        gSensorData.pressure = 3000.0f;
        
        vTaskDelay(100 / portTICK_RATE_MS); // delay to slow down sensor reading
    }
}

// Task 2 function, processes the shared structure data for control logic
void vTask2( void *pvParameters ) {
    while (1) {
        float temperature = gSensorData.temperature;  
        float pressure = gSensorData.pressure;
        
        // Replace with real control logic using sensor data
        
        vTaskDelay(50 / portTICK_RATE_MS);  // delay to slow down control processing
    }
}

// Main function, sets up tasks and scheduler
int main( void ) {
    xTaskCreate(vTask1,"Task 1",1024,NULL,1,NULL);
    xTaskCreate(vTask2,"Task 2",1024,NULL,2,NULL);
    
    // Start the scheduler. The program should not exit; the scheduler is in control of the program flow.
    vTaskStartScheduler();  

    return <｜begin▁of▁sentence｜>afe