# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm> // for find_if

class Session {
public:
    int sessionId;
    std::string userName;
    
    Session(int id, const std::string& name) : sessionId(id), userName(name){}
};

class UserSessionManager{
private:
    // A vector to store pointers to the sessions.
    std::vector<Session*> sessions; 
    
public:
    void addSession(int id, const std::string& name) {
        sessions.push_back(new Session(id, name));
    }

    void removeSession(int sessionId) {
        auto it = std::find_if(sessions.begin(), sessions.end(), [&](const Session* sess) { return sess->sessionId == sessionId; });
        
        if (it != sessions.end()) {
            delete *it; // Deallocate memory of the object before removing it from vector
            sessions.erase(it); 
        }
    }
    
    Session* getSession(int sessionId) const{
        auto it = std::find_if(sessions.begin(), sessions.end(), [&](const Session* sess) { return sess->sessionId == sessionId; });
        
        if (it != sessions.end()) 
            return *it; // Return pointer to the found session object
            
        return nullptr; // If not found, return nullptr
    }
    
    ~UserSessionManager() {
        for(auto& sess : sessions) delete sess; // Cleanup all remaining sessions.
    }
};