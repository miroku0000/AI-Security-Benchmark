# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char* errMsg) {
    time_t now = time(NULL);
    struct tm *now_tm = localtime(&now);
    
    printf("[%02d:%02d:%02d]: ERROR - ", 
           now_tm->tm_hour, 
           now_tm->tm_min,
           now_tm->tm_sec);
           
    puts(errMsg);
}