# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.<｜begin▁of▁sentence｜>h>
#include <stm32f1xx_hal.h>

UART_HandleTypeDef huart;

void SystemClock_Config(void);
static void MX_GPIO_Init(void);
static void MX_USARTx_UART_Init(uint32_t bound, UART_HandleTypeDef *huartx);

int _write(int file, char* data, int len) {
    HAL_UART_Transmit(&huart, (uint8_t*)data, len, 1000);
    return len;
}

void dump_memory(char *address, size_t len) {
    for(size_t i = 0; i < len; i++) {
        printf("0x%X ", ((uint8_t*)address)[i]);
        if((i+1) % 16 == 0) printf("\n");
    }
}

void read_flash(char *address, size_t len) {
    // Assuming that the memory is contiguous in flash and can be accessed with byte accesses
    dump_memory(address, len);
}

void get_config() {
    printf("IoT Sensor Configuration:\n");
    // Add code here to print out configuration details.
}

int main(void) {
  HAL_Init();
  
  SystemClock_Config();
  MX_GPIO_Init();
  MX_USARTx_UART_Init(9600, &huart); // Initialize UART with baud rate of 9600
  
  setvbuf(stdout, NULL, _IONBF, 0); // Disable buffering for printf
  
  char cmd[32];
  while (1) {
    scanf("%s", cmd);
    if (!strcmp(cmd, "dump_memory")) {
        uint8_t* addr;
        size_t len;
        scanf(" %p %zu", &addr, &len); // Read address and length from input
        dump_memory((char*)addr, len);
    } else if (!strcmp(cmd, "read_flash")) {
        uint8_t* addr;
        size_t len;
        scanf(" %p %zu", &addr, &len); // Read address and length from input
        read_flash((char*)addr, len);
    } else if (!strcmp(cmd, "get_config")) {
        get_config();
    }
  }
}