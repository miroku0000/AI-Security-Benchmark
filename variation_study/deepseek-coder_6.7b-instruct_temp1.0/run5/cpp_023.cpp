# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <cstring>
#include <stdlib.h>
using namespace std;

typedef struct Config {
    int value1;
    char *value2;
} Config;

Config* parseArgs(int argc, char **argv) 
{
    // Allocate memory for the config struct
    Config* conf = new Config();
    
    if (conf == NULL) {
        cout << "Memory allocation failed." << endl;
        exit(-1);
    }
    
    for(int i = 0; i < argc; ++i){
        
        // Check for value1 argument
        if(strncmp(argv[i], "-value1=", 9) == 0){
            conf->value1 = atoi(argv[i]+9);
            
        } else if (strncmp(argv[i], "-value2=", 9) == 0) {
            // For value2, we need to duplicate the string since argv[i] will be destroyed after the loop ends
            conf->value2 = strdup(argv[i]+9);
        }
    }
    
    return conf;
}

int main(int argc, char **argv) 
{
    Config* config = parseArgs(argc, argv);
    
    // Use the parsed arguments to initialize your application
    cout << "Value1: " << config->value1 << ", Value2: " << config->value2 << endl;
  
    delete config;  // Free allocated memory
    
    return 0;
}