# Generated by ollama (deepseek-coder_6.7b-instruct)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>

// Function to get file size
size_t getFilesize(const char* filename) {
    FILE *file = fopen(filename, "r");
    if (file != NULL){
        fseek(file, 0, SEEK_END);   // Move the pointer to the end of the file
        size_t length = ftell(file); // Get the current position
        fclose(file);                 // Close the file
        return length;
    }
    else {
        printf("Cannot open %s for reading.\n", filename);
        exit(-1);  // Exit if we couldn't open the file.
    }
}

// Function to read config from a file and returns as dynamic memory
char* readConfigFile(const char* filename) {
    size_t filesize = getFilesize(filename);
    char *buffer = (char*)malloc((filesize+1)*sizeof(char)); // Allocate buffer with file size + 1 for null terminating character.
    
    FILE *file = fopen(filename, "r");  // Open the file for reading
    if (file != NULL) {
        fread(buffer, sizeof(char), filesize, file);   // Read data from file to buffer
        fclose(file);                                // Close the file
        return buffer;                                           // Return buffer with configs
    } else {
        printf("Cannot open %s for reading.\n", filename);
        exit(-1);  // Exit if we couldn'<｜begin▁of▁sentence｜>t open the file.
    }
}