# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <cstdint>
#include <cstddef>
#include <cstdlib>
#include <cstring>
#include <new>
#include <utility>
#include <type_traits>

#if defined(_MSC_VER)
#include <malloc.h>
#endif

namespace hotpath
{
    static inline void* aligned_alloc_bytes(std::size_t alignment, std::size_t bytes) noexcept
    {
#if defined(_MSC_VER)
        return _aligned_malloc(bytes, alignment);
#elif defined(__APPLE__)
        void* p = nullptr;
        if (posix_memalign(&p, alignment, bytes) != 0) return nullptr;
        return p;
#else
        std::size_t a = alignment < alignof(void*) ? alignof(void*) : alignment;
        std::size_t n = (bytes + a - 1) & ~(a - 1);
        return std::aligned_alloc(a, n);
#endif
    }

    static inline void aligned_free_bytes(void* p) noexcept
    {
#if defined(_MSC_VER)
        _aligned_free(p);
#else
        std::free(p);
#endif
    }

    struct TempArena
    {
        TempArena() = default;

        explicit TempArena(std::size_t initialBytes, std::size_t alignment = 64)
            : defaultAlignment(alignment)
        {
            reserve(initialBytes);
        }

        TempArena(const TempArena&) = delete;
        TempArena& operator=(const TempArena&) = delete;

        TempArena(TempArena&& o) noexcept
            : blocks(o.blocks), blockCount(o.blockCount), blockCap(o.blockCap),
              cur(o.cur), end(o.end), defaultAlignment(o.defaultAlignment)
        {
            o.blocks = nullptr; o.blockCount = 0; o.blockCap = 0; o.cur = nullptr; o.end = nullptr;
        }

        TempArena& operator=(TempArena&& o) noexcept
        {
            if (this == &o) return *this;
            release();
            blocks = o.blocks; blockCount = o.blockCount; blockCap = o.blockCap;
            cur = o.cur; end = o.end; defaultAlignment = o.defaultAlignment;
            o.blocks = nullptr; o.blockCount = 0; o.blockCap = 0; o.cur = nullptr; o.end = nullptr;
            return *this;
        }

        ~TempArena() { release(); }

        void reset() noexcept
        {
            if (blockCount == 0) { cur = end = nullptr; return; }
            cur = blocks[0].data;
            end = blocks[0].data + blocks[0].size;
            for (std::size_t i = 1; i < blockCount; ++i) blocks[i].used = 0;
            blocks[0].used = 0;
        }

        void reserve(std::size_t bytes)
        {
            if (blockCount == 0)
            {
                ensureBlockListCapacity(1);
                addBlock(bytes);
                reset();
            }
            else
            {
                if (blocks[0].size < bytes)
                {
                    release();
                    ensureBlockListCapacity(1);
                    addBlock(bytes);
                    reset();
                }
            }
        }

        struct Marker
        {
            std::size_t blockIndex;
            std::uint8_t* ptr;
        };

        Marker mark() const noexcept
        {
            if (blockCount == 0) return Marker{0, nullptr};
            std::size_t idx = 0;
            for (std::size_t i = 0; i < blockCount; ++i)
            {
                if (cur >= blocks[i].data && cur <= blocks[i].data + blocks[i].size) { idx = i; break; }
            }
            return Marker{idx, cur};
        }

        void rewind(Marker m) noexcept
        {
            if (blockCount == 0) { cur = end = nullptr; return; }
            if (m.ptr == nullptr) { reset(); return; }
            if (m.blockIndex >= blockCount) return;

            for (std::size_t i = m.blockIndex + 1; i < blockCount; ++i) blocks[i].used = 0;
            cur = m.ptr;
            end = blocks[m.blockIndex].data + blocks[m.blockIndex].size;
            blocks[m.blockIndex].used = static_cast<std::size_t>(cur - blocks[m.blockIndex].data);
        }

        void* allocBytes(std::size_t bytes, std::size_t alignment = 0)
        {
            if (alignment == 0) alignment = defaultAlignment;
            if (alignment < alignof(void*)) alignment = alignof(void*);

            if (blockCount == 0) reserve(bytes + alignment);

            for (;;)
            {
                std::uintptr_t p = reinterpret_cast<std::uintptr_t>(cur);
                std::uintptr_t aligned = (p + (alignment - 1)) & ~(alignment - 1);
                std::uint8_t* out = reinterpret_cast<std::uint8_t*>(aligned);
                if (out + bytes <= end)
                {
                    cur = out + bytes;
                    std::size_t idx = currentBlockIndex();
                    blocks[idx].used = static_cast<std::size_t>(cur - blocks[idx].data);
                    return out;
                }

                grow(bytes + alignment);
            }
        }

        template <class T, class... Args>
        T* make(Args&&... args)
        {
            void* mem = allocBytes(sizeof(T), alignof(T));
            return ::new (mem) T(std::forward<Args>(args)...);
        }

        template <class T>
        T* makeArray(std::size_t n)
        {
            if (n == 0) return nullptr;
            void* mem = allocBytes(sizeof(T) * n, alignof(T));
            if constexpr (std::is_trivially_default_constructible_v<T>)
            {
                return static_cast<T*>(mem);
            }
            else
            {
                T* p = static_cast<T*>(mem);
                for (std::size_t i = 0; i < n; ++i) ::new (p + i) T();
                return p;
            }
        }

        template <class T>
        T* dupBytesTo(T const* src, std::size_t bytes)
        {
            void* mem = allocBytes(bytes, alignof(T));
            std::memcpy(mem, src, bytes);
            return static_cast<T*>(mem);
        }

    private:
        struct Block
        {
            std::uint8_t* data = nullptr;
            std::size_t size = 0;
            std::size_t used = 0;
        };

        Block* blocks = nullptr;
        std::size_t blockCount = 0;
        std::size_t blockCap = 0;

        std::uint8_t* cur = nullptr;
        std::uint8_t* end = nullptr;

        std::size_t defaultAlignment = 64;

        void release() noexcept
        {
            if (blocks)
            {
                for (std::size_t i = 0; i < blockCount; ++i) aligned_free_bytes(blocks[i].data);
                std::free(blocks);
            }
            blocks = nullptr; blockCount = 0; blockCap = 0; cur = nullptr; end = nullptr;
        }

        void ensureBlockListCapacity(std::size_t need)
        {
            if (blockCap >= need) return;
            std::size_t newCap = blockCap ? blockCap : 4;
            while (newCap < need) newCap *= 2;
            void* mem = std::realloc(blocks, newCap * sizeof(Block));
            if (!mem) throw std::bad_alloc();
            blocks = static_cast<Block*>(mem);
            for (std::size_t i = blockCap; i < newCap; ++i) blocks[i] = Block{};
            blockCap = newCap;
        }

        void addBlock(std::size_t bytes)
        {
            ensureBlockListCapacity(blockCount + 1);
            void* mem = aligned_alloc_bytes(defaultAlignment, bytes);
            if (!mem) throw std::bad_alloc();
            blocks[blockCount].data = static_cast<std::uint8_t*>(mem);
            blocks[blockCount].size = bytes;
            blocks[blockCount].used = 0;
            ++blockCount;
        }

        std::size_t currentBlockIndex() const noexcept
        {
            if (blockCount == 0) return 0;
            for (std::size_t i = 0; i < blockCount; ++i)
                if (cur >= blocks[i].data && cur <= blocks[i].data + blocks[i].size) return i;
            return blockCount - 1;
        }

        void grow(std::size_t minBytes)
        {
            std::size_t nextSize = 0;
            if (blockCount == 0) nextSize = minBytes;
            else
            {
                std::size_t lastSize = blocks[blockCount - 1].size;
                nextSize = lastSize < (1u << 20) ? lastSize * 2 : lastSize + (1u << 20);
                if (nextSize < minBytes) nextSize = minBytes;
            }

            addBlock(nextSize);
            cur = blocks[blockCount - 1].data;
            end = blocks[blockCount - 1].data + blocks[blockCount - 1].size;
        }
    };

    struct ByteSpan
    {
        const std::uint8_t* data = nullptr;
        std::size_t size = 0;
    };

    struct TransformResult
    {
        ByteSpan output;
        std::uint32_t checksum = 0;
        std::size_t records = 0;
    };

    struct ParsedRecord
    {
        std::uint32_t key = 0;
        std::uint32_t value = 0;
    };

    struct NormalizedRecord
    {
        std::uint64_t packed = 0;
    };

    static inline std::uint32_t rotl32(std::uint32_t x, int r) noexcept
    {
        return (x << r) | (x >> (32 - r));
    }

    static inline std::uint32_t fastChecksum(const std::uint8_t* p, std::size_t n) noexcept
    {
        std::uint32_t h = 0x9E3779B9u;
        for (std::size_t i = 0; i < n; ++i)
        {
            h ^= p[i] + 0x7f4a7c15u + (h << 6) + (h >> 2);
            h = rotl32(h, 5);
        }
        return h;
    }

    static inline std::size_t parseStage(const std::uint8_t* in, std::size_t inSize, ParsedRecord* out, std::size_t outCap) noexcept
    {
        std::size_t n = inSize / 8;
        if (n > outCap) n = outCap;
        const std::uint8_t* p = in;
        for (std::size_t i = 0; i < n; ++i)
        {
            std::uint32_t k, v;
            std::memcpy(&k, p, 4);
            std::memcpy(&v, p + 4, 4);
            out[i].key = k;
            out[i].value = v;
            p += 8;
        }
        return n;
    }

    static inline void normalizeStage(const ParsedRecord* in, std::size_t n, NormalizedRecord* out) noexcept
    {
        for (std::size_t i = 0; i < n; ++i)
        {
            std::uint64_t k = static_cast<std::uint64_t>(in[i].key);
            std::uint64_t v = static_cast<std::uint64_t>(in[i].value);
            std::uint64_t mixed = (k * 11400714819323198485ull) ^ (v * 14029467366897019727ull);
            out[i].packed = mixed;
        }
    }

    static inline std::size_t encodeStage(const NormalizedRecord* in, std::size_t n, std::uint8_t* out) noexcept
    {
        std::uint8_t* p = out;
        for (std::size_t i = 0; i < n; ++i)
        {
            std::uint64_t x = in[i].packed;
            std::memcpy(p, &x, 8);
            p += 8;
        }
        return static_cast<std::size_t>(p - out);
    }

    static inline TransformResult transformHotPath(TempArena& arena, ByteSpan input)
    {
        TempArena::Marker m = arena.mark();

        std::size_t maxRecords = input.size / 8;
        ParsedRecord* parsed = arena.makeArray<ParsedRecord>(maxRecords);
        std::size_t n = parseStage(input.data, input.size, parsed, maxRecords);

        NormalizedRecord* norm = arena.makeArray<NormalizedRecord>(n);
        normalizeStage(parsed, n, norm);

        std::uint8_t* out = static_cast<std::uint8_t*>(arena.allocBytes(n * 8, 8));
        std::size_t outBytes = encodeStage(norm, n, out);

        TransformResult r;
        r.output = ByteSpan{out, outBytes};
        r.checksum = fastChecksum(out, outBytes);
        r.records = n;

        arena.rewind(m);
        return r;
    }
}