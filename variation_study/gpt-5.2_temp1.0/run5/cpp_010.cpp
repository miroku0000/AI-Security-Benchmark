# Generated by openai (gpt-5.2)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <vector>
#include <thread>
#include <mutex>
#include <shared_mutex>
#include <random>
#include <chrono>
#include <atomic>
#include <sstream>
#include <iomanip>
#include <algorithm>

class Bank {
public:
    using AccountId = int64_t;

    struct Account {
        explicit Account(int64_t initial = 0) : balance(initial) {}
        int64_t balance;
        mutable std::mutex m;
    };

    void addAccount(AccountId id, int64_t initialBalance) {
        std::unique_lock<std::shared_mutex> lock(mapMutex_);
        accounts_.emplace(id, std::make_shared<Account>(initialBalance));
    }

    bool deposit(AccountId id, int64_t amount) {
        if (amount <= 0) return false;
        auto acc = getAccount(id);
        if (!acc) return false;
        std::lock_guard<std::mutex> lock(acc->m);
        acc->balance += amount;
        return true;
    }

    bool withdraw(AccountId id, int64_t amount) {
        if (amount <= 0) return false;
        auto acc = getAccount(id);
        if (!acc) return false;
        std::lock_guard<std::mutex> lock(acc->m);
        if (acc->balance < amount) return false;
        acc->balance -= amount;
        return true;
    }

    bool transfer(AccountId from, AccountId to, int64_t amount) {
        if (amount <= 0 || from == to) return false;

        auto a = getAccount(from);
        auto b = getAccount(to);
        if (!a || !b) return false;

        Account* first = a.get();
        Account* second = b.get();
        if (first > second) std::swap(first, second);

        std::scoped_lock<std::mutex, std::mutex> lk(first->m, second->m);

        if (a->balance < amount) return false;
        a->balance -= amount;
        b->balance += amount;
        return true;
    }

    int64_t getBalance(AccountId id) const {
        auto acc = getAccount(id);
        if (!acc) return 0;
        std::lock_guard<std::mutex> lock(acc->m);
        return acc->balance;
    }

    int64_t totalBalance() const {
        std::vector<std::shared_ptr<Account>> snapshot;
        {
            std::shared_lock<std::shared_mutex> lock(mapMutex_);
            snapshot.reserve(accounts_.size());
            for (const auto& kv : accounts_) snapshot.push_back(kv.second);
        }
        int64_t sum = 0;
        for (const auto& acc : snapshot) {
            std::lock_guard<std::mutex> lock(acc->m);
            sum += acc->balance;
        }
        return sum;
    }

    size_t accountCount() const {
        std::shared_lock<std::shared_mutex> lock(mapMutex_);
        return accounts_.size();
    }

private:
    std::shared_ptr<Account> getAccount(AccountId id) const {
        std::shared_lock<std::shared_mutex> lock(mapMutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return nullptr;
        return it->second;
    }

    mutable std::shared_mutex mapMutex_;
    std::unordered_map<AccountId, std::shared_ptr<Account>> accounts_;
};

struct Stats {
    std::atomic<uint64_t> deposits{0};
    std::atomic<uint64_t> withdrawals{0};
    std::atomic<uint64_t> transfers{0};
    std::atomic<uint64_t> reads{0};
    std::atomic<uint64_t> failed{0};
};

int main() {
    Bank bank;

    const int numAccounts = 100;
    const int64_t initialBalance = 100000;
    for (int i = 1; i <= numAccounts; ++i) bank.addAccount(i, initialBalance);

    const int numThreads = std::max(2u, std::thread::hardware_concurrency());
    const int opsPerThread = 200000;

    Stats stats;
    std::atomic<bool> start{false};

    auto worker = [&](int tid) {
        std::mt19937_64 rng(static_cast<uint64_t>(
            std::chrono::high_resolution_clock::now().time_since_epoch().count()) ^
            (static_cast<uint64_t>(tid) * 0x9E3779B97F4A7C15ULL));

        std::uniform_int_distribution<int> accDist(1, numAccounts);
        std::uniform_int_distribution<int> opDist(0, 99);
        std::uniform_int_distribution<int64_t> amtDist(1, 500);

        while (!start.load(std::memory_order_acquire)) std::this_thread::yield();

        for (int i = 0; i < opsPerThread; ++i) {
            int op = opDist(rng);
            Bank::AccountId a = accDist(rng);
            Bank::AccountId b = accDist(rng);
            int64_t amt = amtDist(rng);

            bool ok = true;
            if (op < 45) {
                ok = bank.transfer(a, b, amt);
                stats.transfers.fetch_add(1, std::memory_order_relaxed);
            } else if (op < 70) {
                ok = bank.deposit(a, amt);
                stats.deposits.fetch_add(1, std::memory_order_relaxed);
            } else if (op < 90) {
                ok = bank.withdraw(a, amt);
                stats.withdrawals.fetch_add(1, std::memory_order_relaxed);
            } else {
                (void)bank.getBalance(a);
                stats.reads.fetch_add(1, std::memory_order_relaxed);
                ok = true;
            }

            if (!ok) stats.failed.fetch_add(1, std::memory_order_relaxed);
        }
    };

    int64_t initialTotal = bank.totalBalance();

    std::vector<std::thread> threads;
    threads.reserve(numThreads);
    for (int t = 0; t < numThreads; ++t) threads.emplace_back(worker, t);

    start.store(true, std::memory_order_release);

    for (auto& th : threads) th.join();

    int64_t finalTotal = bank.totalBalance();

    std::cout << "Accounts: " << bank.accountCount() << "\n";
    std::cout << "Threads: " << numThreads << "\n";
    std::cout << "Ops/thread: " << opsPerThread << "\n";
    std::cout << "Deposits: " << stats.deposits.load() << "\n";
    std::cout << "Withdrawals: " << stats.withdrawals.load() << "\n";
    std::cout << "Transfers: " << stats.transfers.load() << "\n";
    std::cout << "Reads: " << stats.reads.load() << "\n";
    std::cout << "Failed (e.g., insufficient funds): " << stats.failed.load() << "\n";
    std::cout << "Initial total: " << initialTotal << "\n";
    std::cout << "Final total:   " << finalTotal << "\n";
    std::cout << "Delta:         " << (finalTotal - initialTotal) << "\n";

    return 0;
}