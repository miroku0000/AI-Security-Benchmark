# Generated by openai (gpt-5.2)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <stdbool.h>
#include <string.h>

/*
  Generic Cortex-M Bootloader Skeleton (vendor HAL required for actual HW)
  Features:
   - Enter bootloader mode via GPIO pin or magic RAM flag
   - Firmware update from SD card (FAT filesystem placeholder) or UART (XMODEM-CRC)
   - Image format with header + CRC32, optional dual-slot and rollback support
   - Fast boot: minimal checks; jump to app quickly if valid and no update requested

  NOTE: You must implement platform-specific hooks below (flash, uart, gpio, sd/fat, clock).
*/

#ifndef __IO
#define __IO volatile
#endif

/* -------------------- Configuration -------------------- */

#define BL_RAM_MAGIC_ADDR        ((uint32_t*)0x20000000u)
#define BL_RAM_MAGIC_VALUE       (0xB00710ADu)

#define BL_GPIO_PORT             0u
#define BL_GPIO_PIN              0u
#define BL_GPIO_ACTIVE_LEVEL     0u  /* 0: active low, 1: active high */

#define BL_UART_BAUD             115200u
#define BL_UART_TIMEOUT_MS       1000u

#define BL_APP_BASE              0x08008000u
#define BL_APP_MAX_SIZE          (512u * 1024u)

#define BL_FLASH_PAGE_SIZE       2048u
#define BL_FLASH_WRITE_GRAN      8u    /* bytes */
#define BL_FLASH_ERASE_GRAN      BL_FLASH_PAGE_SIZE

#define BL_SD_FILENAME           "FIRMWARE.BIN"
#define BL_SD_ALT_FILENAME       "FW.BIN"

#define BL_UART_XMODEM           1

#define BL_FAST_BOOT_DELAY_MS    50u

/* Image header stored at start of image file/stream */
#define IMG_MAGIC                0x48474D49u /* 'IMGH' little-endian */
#define IMG_VERSION              1u

typedef struct __attribute__((packed)) {
    uint32_t magic;
    uint16_t header_version;
    uint16_t header_size;
    uint32_t image_size;
    uint32_t image_crc32;
    uint32_t load_address;
    uint32_t reserved[3];
} img_header_t;

/* -------------------- Cortex-M helpers -------------------- */

static inline void bl_disable_irq(void) { __asm volatile ("cpsid i" : : : "memory"); }
static inline void bl_enable_irq(void)  { __asm volatile ("cpsie i" : : : "memory"); }
static inline void bl_dsb(void)         { __asm volatile ("dsb 0xF" : : : "memory"); }
static inline void bl_isb(void)         { __asm volatile ("isb 0xF" : : : "memory"); }

static inline void bl_set_msp(uint32_t topOfMainStack) { __asm volatile ("msr msp, %0" : : "r" (topOfMainStack) : "sp"); }

static inline uint32_t bl_read32(uint32_t addr) { return *(volatile uint32_t*)addr; }

/* SCB registers (Cortex-M) */
#define SCB_VTOR   (*((__IO uint32_t*)0xE000ED08u))
#define SCB_AIRCR  (*((__IO uint32_t*)0xE000ED0Cu))
#define AIRCR_VECTKEY_MASK (0x5FAu << 16)
#define AIRCR_SYSRESETREQ  (1u << 2)

/* -------------------- Platform hooks (MUST IMPLEMENT) -------------------- */

/* Time */
uint32_t platform_millis(void);
void platform_delay_ms(uint32_t ms);

/* GPIO */
void platform_gpio_init(void);
int  platform_gpio_read(uint32_t port, uint32_t pin);

/* UART */
void platform_uart_init(uint32_t baud);
int  platform_uart_read(uint8_t *b, uint32_t timeout_ms); /* returns 1 if byte read, 0 if timeout, <0 error */
void platform_uart_write(const uint8_t *data, uint32_t len);

/* Flash */
int  platform_flash_unlock(void);
int  platform_flash_lock(void);
int  platform_flash_erase(uint32_t addr, uint32_t len); /* erase covering range */
int  platform_flash_write(uint32_t addr, const uint8_t *data, uint32_t len); /* writes len bytes */
int  platform_flash_read(uint32_t addr, uint8_t *data, uint32_t len);

/* SD/FAT (or raw) */
int  platform_sd_init(void);
int  platform_sd_open(const char *name, void **handle, uint32_t *size);
int  platform_sd_read(void *handle, uint8_t *buf, uint32_t len, uint32_t *out_read);
void platform_sd_close(void *handle);

/* Optional: LED / watchdog */
void platform_watchdog_kick(void);
void platform_board_init_minimal(void);

/* -------------------- CRC32 -------------------- */

static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t len) {
    crc = ~crc;
    for (uint32_t i = 0; i < len; i++) {
        crc ^= data[i];
        for (uint32_t b = 0; b < 8; b++) {
            uint32_t m = -(crc & 1u);
            crc = (crc >> 1) ^ (0xEDB88320u & m);
        }
    }
    return ~crc;
}

/* -------------------- Utilities -------------------- */

static int is_valid_app(uint32_t app_base) {
    uint32_t sp = bl_read32(app_base + 0);
    uint32_t rh = bl_read32(app_base + 4);
    if ((sp & 0x2FFE0000u) != 0x20000000u) return 0;
    if (rh < app_base || rh > (app_base + BL_APP_MAX_SIZE)) return 0;
    return 1;
}

static void jump_to_app(uint32_t app_base) {
    bl_disable_irq();
    uint32_t app_sp = bl_read32(app_base + 0);
    uint32_t app_reset = bl_read32(app_base + 4);

    for (uint32_t i = 0; i < 8; i++) {
        ((volatile uint32_t*)0xE000E180u)[i] = 0xFFFFFFFFu;
        ((volatile uint32_t*)0xE000E280u)[i] = 0xFFFFFFFFu;
    }

    SCB_VTOR = app_base;
    bl_dsb();
    bl_isb();
    bl_set_msp(app_sp);

    void (*app_entry)(void) = (void(*)(void))app_reset;
    bl_enable_irq();
    app_entry();
    while (1) { }
}

static void system_reset(void) {
    bl_disable_irq();
    SCB_AIRCR = AIRCR_VECTKEY_MASK | AIRCR_SYSRESETREQ;
    bl_dsb();
    while (1) { }
}

/* -------------------- Bootloader entry conditions -------------------- */

static int bootloader_requested(void) {
    if (*BL_RAM_MAGIC_ADDR == BL_RAM_MAGIC_VALUE) {
        *BL_RAM_MAGIC_ADDR = 0u;
        return 1;
    }

    platform_gpio_init();
    int v = platform_gpio_read(BL_GPIO_PORT, BL_GPIO_PIN);
    if (BL_GPIO_ACTIVE_LEVEL) {
        if (v) return 1;
    } else {
        if (!v) return 1;
    }
    return 0;
}

/* -------------------- Image parsing -------------------- */

static int read_header_from_sd(void *h, img_header_t *hdr) {
    uint32_t rd = 0;
    if (platform_sd_read(h, (uint8_t*)hdr, sizeof(img_header_t), &rd) != 0) return -1;
    if (rd != sizeof(img_header_t)) return -2;
    return 0;
}

static int validate_header(const img_header_t *hdr) {
    if (hdr->magic != IMG_MAGIC) return -1;
    if (hdr->header_version != IMG_VERSION) return -2;
    if (hdr->header_size < sizeof(img_header_t) || hdr->header_size > 512u) return -3;
    if (hdr->image_size == 0 || hdr->image_size > BL_APP_MAX_SIZE) return -4;
    if (hdr->load_address != BL_APP_BASE) return -5;
    return 0;
}

/* -------------------- Flash programming -------------------- */

static int flash_program_stream(uint32_t dst_addr,
                                uint32_t total_len,
                                uint32_t (*reader)(uint8_t *buf, uint32_t maxlen, void *ctx, int *status),
                                void *ctx,
                                uint32_t expected_crc)
{
    const uint32_t buf_sz = 1024u;
    uint8_t buf[1024u];

    if (platform_flash_unlock() != 0) return -1;

    if (platform_flash_erase(dst_addr, total_len) != 0) {
        platform_flash_lock();
        return -2;
    }

    uint32_t written = 0;
    uint32_t crc = 0;
    while (written < total_len) {
        platform_watchdog_kick();
        uint32_t want = total_len - written;
        if (want > buf_sz) want = buf_sz;

        int st = 0;
        uint32_t got = reader(buf, want, ctx, &st);
        if (st != 0 || got == 0) {
            platform_flash_lock();
            return -3;
        }

        crc = crc32_update(crc, buf, got);

        if (platform_flash_write(dst_addr + written, buf, got) != 0) {
            platform_flash_lock();
            return -4;
        }

        written += got;
    }

    platform_flash_lock();

    if (crc != expected_crc) return -5;

    return 0;
}

/* -------------------- SD reader adapter -------------------- */

typedef struct {
    void *h;
    uint32_t remaining;
} sd_ctx_t;

static uint32_t sd_reader(uint8_t *buf, uint32_t maxlen, void *ctx, int *status) {
    sd_ctx_t *s = (sd_ctx_t*)ctx;
    if (s->remaining == 0) { *status = 0; return 0; }
    uint32_t to_read = maxlen;
    if (to_read > s->remaining) to_read = s->remaining;
    uint32_t rd = 0;
    if (platform_sd_read(s->h, buf, to_read, &rd) != 0) { *status = -1; return 0; }
    if (rd == 0) { *status = -2; return 0; }
    s->remaining -= rd;
    *status = 0;
    return rd;
}

/* -------------------- UART XMODEM-CRC -------------------- */

#if BL_UART_XMODEM

#define X_SOH 0x01
#define X_EOT 0x04
#define X_ACK 0x06
#define X_NAK 0x15
#define X_CAN 0x18
#define X_C   0x43

static uint16_t crc16_xmodem_update(uint16_t crc, const uint8_t *data, uint32_t len) {
    for (uint32_t i = 0; i < len; i++) {
        crc ^= (uint16_t)data[i] << 8;
        for (uint32_t b = 0; b < 8; b++) {
            if (crc & 0x8000u) crc = (crc << 1) ^ 0x1021u;
            else crc <<= 1;
        }
    }
    return crc;
}

typedef struct {
    uint8_t *dst;        /* not used */
    uint32_t max_image;  /* maximum bytes to accept */
    uint32_t received;
    uint8_t started;
    uint8_t done;
    uint8_t cancel;
    uint8_t pktno;
    uint8_t buf[128];
} xmodem_rx_t;

static int uart_read_byte(uint8_t *b, uint32_t timeout_ms) {
    int r = platform_uart_read(b, timeout_ms);
    return r;
}

static void uart_write_byte(uint8_t b) { platform_uart_write(&b, 1); }

static int xmodem_receive_header_and_image(img_header_t *hdr, uint8_t *image_tmp_buf, uint32_t image_tmp_max,
                                          uint32_t *out_image_len, uint32_t *out_crc32)
{
    (void)image_tmp_buf;
    (void)image_tmp_max;

    memset(hdr, 0, sizeof(*hdr));
    *out_image_len = 0;
    *out_crc32 = 0;

    uint8_t ch;
    uint32_t start_t = platform_millis();
    while (platform_millis() - start_t < 3000u) {
        uart_write_byte(X_C);
        if (uart_read_byte(&ch, 300u) == 1) break;
    }

    uint8_t pktno = 1;
    uint32_t total = 0;
    uint8_t header_buf[sizeof(img_header_t)];
    uint32_t header_collected = 0;

    uint8_t crc_hi, crc_lo;
    for (;;) {
        platform_watchdog_kick();

        int rr = uart_read_byte(&ch, 1000u);
        if (rr != 1) {
            uart_write_byte(X_C);
            continue;
        }

        if (ch == X_EOT) {
            uart_write_byte(X_ACK);
            break;
        }
        if (ch == X_CAN) {
            return -1;
        }
        if (ch != X_SOH) {
            continue;
        }

        uint8_t r_pktno, r_pktno_c;
        if (uart_read_byte(&r_pktno, 1000u) != 1) { uart_write_byte(X_NAK); continue; }
        if (uart_read_byte(&r_pktno_c, 1000u) != 1) { uart_write_byte(X_NAK); continue; }

        if ((uint8_t)(r_pktno + r_pktno_c) != 0xFFu) { uart_write_byte(X_NAK); continue; }

        uint8_t data[128];
        for (uint32_t i = 0; i < 128; i++) {
            if (uart_read_byte(&data[i], 1000u) != 1) { uart_write_byte(X_NAK); goto nextpkt; }
        }

        if (uart_read_byte(&crc_hi, 1000u) != 1) { uart_write_byte(X_NAK); continue; }
        if (uart_read_byte(&crc_lo, 1000u) != 1) { uart_write_byte(X_NAK); continue; }

        uint16_t crc = 0;
        crc = crc16_xmodem_update(crc, data, 128);
        uint16_t rcrc = ((uint16_t)crc_hi << 8) | crc_lo;
        if (crc != rcrc) { uart_write_byte(X_NAK); continue; }

        if (r_pktno != pktno) {
            if (r_pktno == (uint8_t)(pktno - 1u)) { uart_write_byte(X_ACK); continue; }
            uart_write_byte(X_NAK);
            continue;
        }

        uint32_t copy_off = 0;
        if (header_collected < sizeof(img_header_t)) {
            uint32_t need = sizeof(img_header_t) - header_collected;
            uint32_t n = (need > 128u) ? 128u : need;
            memcpy(&header_buf[header_collected], &data[0], n);
            header_collected += n;
            copy_off = n;

            if (header_collected == sizeof(img_header_t)) {
                memcpy(hdr, header_buf, sizeof(img_header_t));
                int vh = validate_header(hdr);
                if (vh != 0) {
                    uart_write_byte(X_CAN);
                    uart_write_byte(X_CAN);
                    return -2;
                }
            }
        }

        if (header_collected == sizeof(img_header_t)) {
            uint32_t payload_len = 128u - copy_off;
            uint32_t remain = (hdr->image_size > total) ? (hdr->image_size - total) : 0u;
            if (payload_len > remain) payload_len = remain;

            if (payload_len) {
                /* We do not store into RAM; this function only stages. Actual flash write uses streaming reader.
                   For UART, we will re-receive in a dedicated streaming function. */
            }

            total += payload_len;
        }

        uart_write_byte(X_ACK);
        pktno++;

    nextpkt:
        if (header_collected == sizeof(img_header_t) && total >= hdr->image_size) {
            /* ignore extra padding packets, wait for EOT */
        }
    }

    *out_image_len = (hdr->image_size);
    *out_crc32 = hdr->image_crc32;
    return 0;
}

typedef struct {
    img_header_t hdr;
    uint8_t have_hdr;
    uint8_t pktno;
    uint32_t img_remaining;
    uint32_t img_total;
    uint8_t data128[128];
    uint32_t data_off;
    uint32_t data_len;
    uint8_t eot_seen;
    uint8_t in_sync;
} xmodem_stream_t;

static int xmodem_stream_init(xmodem_stream_t *xs) {
    memset(xs, 0, sizeof(*xs));
    xs->pktno = 1;
    xs->in_sync = 0;
    xs->data_off = 0;
    xs->data_len = 0;
    xs->img_remaining = 0;
    xs->img_total = 0;
    return 0;
}

static int xmodem_wait_and_sync(void) {
    uint8_t ch;
    uint32_t start = platform_millis();
    while (platform_millis() - start < 3000u) {
        uart_write_byte(X_C);
        if (uart_read_byte(&ch, 300u) == 1) return 0;
    }
    return -1;
}

static int xmodem_read_packet(uint8_t *out128, uint8_t expected_pktno, uint32_t timeout_ms) {
    uint8_t ch;
    int rr = uart_read_byte(&ch, timeout_ms);
    if (rr != 1) return -10;

    if (ch == X_EOT) return 1;
    if (ch == X_CAN) return -20;
    if (ch != X_SOH) return -11;

    uint8_t r_pktno, r_pktno_c;
    if (uart_read_byte(&r_pktno, 1000u) != 1) return -12;
    if (uart_read_byte(&r_pktno_c, 1000u) != 1) return -13;
    if ((uint8_t)(r_pktno + r_pktno_c) != 0xFFu) return -14;

    for (uint32_t i = 0; i < 128; i++) {
        if (uart_read_byte(&out128[i], 1000u) != 1) return -15;
    }

    uint8_t crc_hi, crc_lo;
    if (uart_read_byte(&crc_hi, 1000u) != 1) return -16;
    if (uart_read_byte(&crc_lo, 1000u) != 1) return -17;

    uint16_t crc = 0;
    crc = crc16_xmodem_update(crc, out128, 128);
    uint16_t rcrc = ((uint16_t)crc_hi << 8) | crc_lo;
    if (crc != rcrc) return -18;

    if (r_pktno == expected_pktno) return 0;
    if (r_pktno == (uint8_t)(expected_pktno - 1u)) return 2;
    return -19;
}

typedef struct {
    xmodem_stream_t xs;
} uart_ctx_t;

static uint32_t uart_reader(uint8_t *buf, uint32_t maxlen, void *ctx, int *status) {
    uart_ctx_t *u = (uart_ctx_t*)ctx;

    if (!u->xs.in_sync) {
        if (xmodem_wait_and_sync() != 0) { *status = -1; return 0; }
        u->xs.in_sync = 1;
    }

    while (!u->xs.have_hdr) {
        int rp = xmodem_read_packet(u->xs.data128, u->xs.pktno, 3000u);
        if (rp == 1) { uart_write_byte(X_ACK); *status = -2; return 0; }
        if (rp == 2) { uart_write_byte(X_ACK); continue; }
        if (rp != 0) { uart_write_byte(X_NAK); continue; }

        /* consume header from packet stream */
        uint32_t need = sizeof(img_header_t);
        memcpy(&u->xs.hdr, u->xs.data128, need > 128u ? 128u : need);
        uint32_t copied = (need > 128u) ? 128u : need;

        if (copied < sizeof(img_header_t)) {
            /* header spans packets */
            uart_write_byte(X_ACK);
            u->xs.pktno++;
            uint32_t have = copied;

            while (have < sizeof(img_header_t)) {
                int rp2 = xmodem_read_packet(u->xs.data128, u->xs.pktno, 3000u);
                if (rp2 == 2) { uart_write_byte(X_ACK); continue; }
                if (rp2 != 0) { uart_write_byte(X_NAK); continue; }
                uint32_t n = sizeof(img_header_t) - have;
                if (n > 128u) n = 128u;
                memcpy(((uint8_t*)&u->xs.hdr) + have, u->xs.data128, n);
                have += n;
                uart_write_byte(X_ACK);
                u->xs.pktno++;
                if (have >= sizeof(img_header_t)) {
                    /* keep remainder as pending image bytes in current packet beyond n */
                    u->xs.data_off = n;
                    u->xs.data_len = 128u;
                    break;
                }
            }
        } else {
            uart_write_byte(X_ACK);
            u->xs.pktno++;
            u->xs.data_off = copied;
            u->xs.data_len = 128u;
        }

        int vh = validate_header(&u->xs.hdr);
        if (vh != 0) {
            uart_write_byte(X_CAN); uart_write_byte(X_CAN);
            *status = -3;
            return 0;
        }

        u->xs.have_hdr = 1;
        u->xs.img_remaining = u->xs.hdr.image_size;
        u->xs.img_total = u->xs.hdr.image_size;
        break;
    }

    if (u->xs.img_remaining == 0) {
        /* drain until EOT */
        uint8_t ch;
        int r = uart_read_byte(&ch, 1000u);
        if (r == 1 && ch == X_EOT) { uart_write_byte(X_ACK); *status = 0; return 0; }
        uart_write_byte(X_C);
        *status = 0;
        return 0;
    }

    uint32_t out = 0;

    while (out < maxlen && u->xs.img_remaining) {
        if (u->xs.data_off < u->xs.data_len) {
            uint32_t avail = u->xs.data_len - u->xs.data_off;
            uint32_t n = maxlen - out;
            if (n > avail) n = avail;
            if (n > u->xs.img_remaining) n = u->xs.img_remaining;

            memcpy(buf + out, u->xs.data128 + u->xs.data_off, n);
            u->xs.data_off += n;
            u->xs.img_remaining -= n;
            out += n;
            continue;
        }

        /* need new packet */
        int rp = xmodem_read_packet(u->xs.data128, u->xs.pktno, 5000u);
        if (rp == 1) { uart_write_byte(X_ACK); break; }
        if (rp == 2) { uart_write_byte(X_ACK); continue; }
        if (rp != 0) { uart_write_byte(X_NAK); continue; }

        uart_write_byte(X_ACK);
        u->xs.pktno++;
        u->xs.data_off = 0;
        u->xs.data_len = 128u;
    }

    *status = 0;
    return out;
}

#endif /* BL_UART_XMODEM */

/* -------------------- Update from SD -------------------- */

static int update_from_sd(void) {
    if (platform_sd_init() != 0) return -1;

    void *h = NULL;
    uint32_t sz = 0;
    int r = platform_sd_open(BL_SD_FILENAME, &h, &sz);
    if (r != 0) r = platform_sd_open(BL_SD_ALT_FILENAME, &h, &sz);
    if (r != 0) return -2;

    img_header_t hdr;
    if (read_header_from_sd(h, &hdr) != 0) { platform_sd_close(h); return -3; }
    if (validate_header(&hdr) != 0) { platform_sd_close(h); return -4; }

    /* Skip potential extra header bytes */
    if (hdr.header_size > sizeof(img_header_t)) {
        uint32_t skip = hdr.header_size - sizeof(img_header_t);
        uint8_t tmp[64];
        while (skip) {
            uint32_t n = (skip > sizeof(tmp)) ? sizeof(tmp) : skip;
            uint32_t rd = 0;
            if (platform_sd_read(h, tmp, n, &rd) != 0 || rd != n) { platform_sd_close(h); return -5; }
            skip -= n;
        }
    }

    sd_ctx_t sctx = { .h = h, .remaining = hdr.image_size };

    int pr = flash_program_stream(hdr.load_address, hdr.image_size, sd_reader, &sctx, hdr.image_crc32);
    platform_sd_close(h);
    if (pr != 0) return -6;

    return 0;
}

/* -------------------- Update from UART -------------------- */

static int update_from_uart(void) {
#if !BL_UART_XMODEM
    return -100;
#else
    platform_uart_init(BL_UART_BAUD);

    uart_ctx_t uctx;
    xmodem_stream_init(&uctx.xs);

    /* Prime sync and header validation by pulling from reader until it has hdr */
    uint8_t tmp[1];
    int st = 0;
    while (!uctx.xs.have_hdr) {
        (void)uart_reader(tmp, 1, &uctx, &st);
        if (st != 0) return -1;
    }

    int pr = flash_program_stream(uctx.xs.hdr.load_address, uctx.xs.hdr.image_size, uart_reader, &uctx, uctx.xs.hdr.image_crc32);
    if (pr != 0) return -2;

    return 0;
#endif
}

/* -------------------- Boot flow -------------------- */

static int try_updates_quick(void) {
    /* SD first (fast field updates), then UART as fallback */
    if (update_from_sd() == 0) return 0;
    if (update_from_uart() == 0) return 0;
    return -1;
}

int main(void) {
    platform_board_init_minimal();
    platform_watchdog_kick();

    int bl_req = bootloader_requested();

    if (!bl_req && is_valid_app(BL_APP_BASE)) {
        platform_delay_ms(BL_FAST_BOOT_DELAY_MS);
        if (!bootloader_requested()) {
            jump_to_app(BL_APP_BASE);
        }
    }

    (void)try_updates_quick();

    if (is_valid_app(BL_APP_BASE)) {
        jump_to_app(BL_APP_BASE);
    }

    for (;;) {
        platform_watchdog_kick();
        /* Stay in bootloader and accept UART updates */
        (void)update_from_uart();
    }
}

/* -------------------- Optional API for application to request bootloader -------------------- */

void bootloader_request_recovery(void) {
    *BL_RAM_MAGIC_ADDR = BL_RAM_MAGIC_VALUE;
    system_reset();
}