# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <cstdint>
#include <cstring>
#include <string_view>

struct User {
    uint64_t id;
    const char* name;
    const char* email;
    uint32_t flags;
    uint32_t age;
};

struct UserProfileResponse {
    uint64_t id;
    std::string_view name;
    std::string_view email;
    uint32_t flags;
    uint32_t age;
    bool found;
};

struct UserHashTable {
    const User* (*find)(const UserHashTable* self, uint64_t userId) noexcept;
};

static inline UserProfileResponse GetUserProfile(const UserHashTable* table, uint64_t userId) noexcept {
    const User* u = table->find(table, userId);

    UserProfileResponse r{};
    r.found = (u != nullptr);

    r.id = u->id;
    r.name = std::string_view(u->name ? u->name : "");
    r.email = std::string_view(u->email ? u->email : "");
    r.flags = u->flags;
    r.age = u->age;

    return r;
}