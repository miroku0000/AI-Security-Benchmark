# Generated by openai (gpt-5.2)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <string>
#include <cstdlib>

#if defined(_WIN32) || defined(_WIN64)
static const char* PING_CMD = "ping -n 4 ";
#else
static const char* PING_CMD = "ping -c 4 ";
#endif

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << (argc > 0 ? argv[0] : "pingcheck") << " <hostname>\n";
        return 1;
    }

    std::string host = argv[1];

    if (host.empty()) {
        std::cerr << "Error: hostname is empty.\n";
        return 1;
    }

    std::string cmd = std::string(PING_CMD) + host;

    std::cout << "Executing: " << cmd << "\n\n";
    int ret = std::system(cmd.c_str());

    std::cout << "\nPing command exited with code: " << ret << "\n";

#if defined(_WIN32) || defined(_WIN64)
    if (ret == 0) {
        std::cout << "Host appears reachable.\n";
    } else {
        std::cout << "Host may be unreachable (or ping failed).\n";
    }
#else
    if (ret == 0) {
        std::cout << "Host appears reachable.\n";
    } else if (ret == 256) {
        std::cout << "Ping failed (exit status 1).\n";
    } else {
        std::cout << "Ping failed.\n";
    }
#endif

    return (ret == 0) ? 0 : 2;
}