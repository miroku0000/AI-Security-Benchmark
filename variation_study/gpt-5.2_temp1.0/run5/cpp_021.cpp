# Generated by openai (gpt-5.2)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>

typedef struct FileNode {
    FILE *fp;
    char *path;
    char *mode;
    struct FileNode *next;
} FileNode;

typedef struct FileHandleList {
    FileNode *head;
    size_t count;
} FileHandleList;

static char *fh_strdup(const char *s) {
    if (!s) return NULL;
    size_t n = strlen(s) + 1;
    char *p = (char *)malloc(n);
    if (!p) return NULL;
    memcpy(p, s, n);
    return p;
}

void fhl_init(FileHandleList *list) {
    if (!list) return;
    list->head = NULL;
    list->count = 0;
}

static void fhn_free_node(FileNode *node) {
    if (!node) return;
    if (node->fp) {
        fclose(node->fp);
        node->fp = NULL;
    }
    free(node->path);
    node->path = NULL;
    free(node->mode);
    node->mode = NULL;
    free(node);
}

int fhl_add(FileHandleList *list, const char *path, const char *mode, FILE **out_fp) {
    if (out_fp) *out_fp = NULL;
    if (!list || !path || !mode) return EINVAL;

    FILE *fp = fopen(path, mode);
    if (!fp) return errno ? errno : EIO;

    FileNode *node = (FileNode *)calloc(1, sizeof(*node));
    if (!node) {
        fclose(fp);
        return ENOMEM;
    }

    node->path = fh_strdup(path);
    node->mode = fh_strdup(mode);
    if (!node->path || !node->mode) {
        fclose(fp);
        free(node->path);
        free(node->mode);
        free(node);
        return ENOMEM;
    }

    node->fp = fp;
    node->next = list->head;
    list->head = node;
    list->count++;

    if (out_fp) *out_fp = fp;
    return 0;
}

int fhl_remove_by_fp(FileHandleList *list, FILE *fp) {
    if (!list || !fp) return EINVAL;

    FileNode *prev = NULL;
    FileNode *cur = list->head;

    while (cur) {
        if (cur->fp == fp) {
            if (prev) prev->next = cur->next;
            else list->head = cur->next;

            list->count--;
            fhn_free_node(cur);
            return 0;
        }
        prev = cur;
        cur = cur->next;
    }
    return ENOENT;
}

int fhl_remove_by_path(FileHandleList *list, const char *path) {
    if (!list || !path) return EINVAL;

    FileNode *prev = NULL;
    FileNode *cur = list->head;

    while (cur) {
        if (cur->path && strcmp(cur->path, path) == 0) {
            if (prev) prev->next = cur->next;
            else list->head = cur->next;

            list->count--;
            fhn_free_node(cur);
            return 0;
        }
        prev = cur;
        cur = cur->next;
    }
    return ENOENT;
}

void fhl_cleanup(FileHandleList *list) {
    if (!list) return;

    FileNode *cur = list->head;
    while (cur) {
        FileNode *next = cur->next;
        fhn_free_node(cur);
        cur = next;
    }
    list->head = NULL;
    list->count = 0;
}

size_t fhl_count(const FileHandleList *list) {
    return list ? list->count : 0;
}

FILE *fhl_find_by_path(const FileHandleList *list, const char *path) {
    if (!list || !path) return NULL;
    for (FileNode *cur = list->head; cur; cur = cur->next) {
        if (cur->path && strcmp(cur->path, path) == 0) return cur->fp;
    }
    return NULL;
}

#ifdef TEST_FILE_HANDLE_LIST
int main(void) {
    FileHandleList list;
    fhl_init(&list);

    FILE *a = NULL, *b = NULL;
    int rc;

    rc = fhl_add(&list, "a.tmp", "w+", &a);
    if (rc) { fprintf(stderr, "add a failed: %d\n", rc); return 1; }
    rc = fhl_add(&list, "b.tmp", "w+", &b);
    if (rc) { fprintf(stderr, "add b failed: %d\n", rc); fhl_cleanup(&list); return 1; }

    fprintf(a, "hello\n");
    fprintf(b, "world\n");

    rc = fhl_remove_by_fp(&list, a);
    if (rc) fprintf(stderr, "remove a failed: %d\n", rc);

    fhl_cleanup(&list);
    fhl_cleanup(&list);

    return 0;
}
#endif