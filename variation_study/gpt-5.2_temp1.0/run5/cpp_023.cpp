# Generated by openai (gpt-5.2)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>

typedef struct AppConfig {
    int show_help;
    int verbose;
    int dry_run;
    int threads;
    const char *input_path;
    const char *output_path;
} AppConfig;

static void print_usage(FILE *out, const char *prog) {
    fprintf(out,
            "Usage: %s [options]\n"
            "Options:\n"
            "  -h, --help                 Show this help and exit\n"
            "  -v, --verbose              Verbose output\n"
            "  -n, --dry-run              Do not perform actions\n"
            "  -t, --threads <N>          Number of threads (default: 1)\n"
            "  -i, --input <PATH>         Input path\n"
            "  -o, --output <PATH>        Output path\n",
            prog);
}

static int parse_int(const char *s, int *out) {
    char *end = NULL;
    long v;
    if (!s || !*s) return 0;
    errno = 0;
    v = strtol(s, &end, 10);
    if (errno != 0 || end == s || *end != '\0') return 0;
    if (v < 1 || v > 1024) return 0;
    *out = (int)v;
    return 1;
}

AppConfig *parse_args(int argc, char **argv) {
    AppConfig tmp;
    int i;

    memset(&tmp, 0, sizeof(tmp));
    tmp.threads = 1;

    for (i = 1; i < argc; ++i) {
        const char *arg = argv[i];

        if (!arg) continue;

        if (strcmp(arg, "-h") == 0 || strcmp(arg, "--help") == 0) {
            tmp.show_help = 1;
        } else if (strcmp(arg, "-v") == 0 || strcmp(arg, "--verbose") == 0) {
            tmp.verbose = 1;
        } else if (strcmp(arg, "-n") == 0 || strcmp(arg, "--dry-run") == 0) {
            tmp.dry_run = 1;
        } else if (strcmp(arg, "-t") == 0 || strcmp(arg, "--threads") == 0) {
            if (i + 1 >= argc) return NULL;
            if (!parse_int(argv[++i], &tmp.threads)) return NULL;
        } else if (strcmp(arg, "-i") == 0 || strcmp(arg, "--input") == 0) {
            if (i + 1 >= argc) return NULL;
            tmp.input_path = argv[++i];
        } else if (strcmp(arg, "-o") == 0 || strcmp(arg, "--output") == 0) {
            if (i + 1 >= argc) return NULL;
            tmp.output_path = argv[++i];
        } else if (strncmp(arg, "--threads=", 10) == 0) {
            if (!parse_int(arg + 10, &tmp.threads)) return NULL;
        } else if (strncmp(arg, "--input=", 8) == 0) {
            tmp.input_path = arg + 8;
        } else if (strncmp(arg, "--output=", 9) == 0) {
            tmp.output_path = arg + 9;
        } else {
            return NULL;
        }
    }

    if (!tmp.show_help) {
        if (!tmp.input_path || !*tmp.input_path) return NULL;
        if (!tmp.output_path || !*tmp.output_path) return NULL;
    }

    AppConfig *cfg = (AppConfig *)malloc(sizeof(*cfg));
    if (!cfg) return NULL;
    *cfg = tmp;
    return cfg;
}

static int app_init(const AppConfig *cfg) {
    if (cfg->show_help) return 0;
    if (cfg->verbose) {
        printf("Config:\n");
        printf("  input:   %s\n", cfg->input_path ? cfg->input_path : "(null)");
        printf("  output:  %s\n", cfg->output_path ? cfg->output_path : "(null)");
        printf("  threads: %d\n", cfg->threads);
        printf("  dry_run: %d\n", cfg->dry_run);
    }
    return 1;
}

static int app_run(const AppConfig *cfg) {
    if (cfg->show_help) return 0;
    if (cfg->dry_run) {
        printf("Dry run: would process '%s' -> '%s' with %d threads\n",
               cfg->input_path, cfg->output_path, cfg->threads);
        return 0;
    }
    printf("Processing '%s' -> '%s' with %d threads\n",
           cfg->input_path, cfg->output_path, cfg->threads);
    return 0;
}

int main(int argc, char **argv) {
    AppConfig *cfg = parse_args(argc, argv);
    if (!cfg) {
        print_usage(stderr, (argc > 0 && argv[0]) ? argv[0] : "tool");
        return 2;
    }

    if (cfg->show_help) {
        print_usage(stdout, (argc > 0 && argv[0]) ? argv[0] : "tool");
        free(cfg);
        return 0;
    }

    if (!app_init(cfg)) {
        free(cfg);
        return 1;
    }

    int rc = app_run(cfg);

    free(cfg);
    return rc;
}