# Generated by openai (gpt-5.2)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <string>
#include <unordered_map>
#include <chrono>
#include <algorithm>
#include <cstddef>
#include <utility>

class Session {
public:
    using Clock = std::chrono::steady_clock;

    explicit Session(std::string id, std::chrono::seconds ttl)
        : id_(std::move(id)), expiresAt_(Clock::now() + ttl) {}

    virtual ~Session() = default;

    const std::string& id() const { return id_; }
    bool expired(Clock::time_point now = Clock::now()) const { return now >= expiresAt_; }
    void extend(std::chrono::seconds ttl) { expiresAt_ = Clock::now() + ttl; }
    Clock::time_point expiresAt() const { return expiresAt_; }

private:
    std::string id_;
    Clock::time_point expiresAt_;
};

class SessionManager {
public:
    using Clock = Session::Clock;

    SessionManager() = default;
    ~SessionManager() { clear(); }

    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    SessionManager(SessionManager&& other) noexcept { moveFrom(std::move(other)); }
    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this != &other) {
            clear();
            moveFrom(std::move(other));
        }
        return *this;
    }

    bool add(Session* session) {
        if (!session) return false;
        auto it = indexById_.find(session->id());
        if (it != indexById_.end()) return false;
        sessions_.push_back(session);
        indexById_.emplace(session->id(), sessions_.size() - 1);
        return true;
    }

    template <class T, class... Args>
    T* emplace(Args&&... args) {
        T* s = new T(std::forward<Args>(args)...);
        if (!add(s)) {
            delete s;
            return nullptr;
        }
        return s;
    }

    bool removeById(const std::string& id) {
        auto it = indexById_.find(id);
        if (it == indexById_.end()) return false;
        removeAt(it->second);
        return true;
    }

    bool remove(Session* session) {
        if (!session) return false;
        return removeById(session->id());
    }

    Session* getById(const std::string& id) const {
        auto it = indexById_.find(id);
        if (it == indexById_.end()) return nullptr;
        return sessions_[it->second];
    }

    Session* at(std::size_t i) const {
        return i < sessions_.size() ? sessions_[i] : nullptr;
    }

    std::size_t size() const { return sessions_.size(); }
    bool empty() const { return sessions_.empty(); }

    std::size_t cleanupExpired(Clock::time_point now = Clock::now()) {
        std::size_t removed = 0;
        for (std::size_t i = 0; i < sessions_.size();) {
            Session* s = sessions_[i];
            if (!s || s->expired(now)) {
                removeAt(i);
                ++removed;
            } else {
                ++i;
            }
        }
        return removed;
    }

    void clear() {
        for (Session* s : sessions_) delete s;
        sessions_.clear();
        indexById_.clear();
    }

private:
    void removeAt(std::size_t idx) {
        if (idx >= sessions_.size()) return;

        Session* victim = sessions_[idx];
        if (victim) indexById_.erase(victim->id());
        delete victim;

        std::size_t last = sessions_.size() - 1;
        if (idx != last) {
            Session* moved = sessions_[last];
            sessions_[idx] = moved;
            if (moved) {
                auto it = indexById_.find(moved->id());
                if (it != indexById_.end()) it->second = idx;
                else indexById_.emplace(moved->id(), idx);
            }
        }
        sessions_.pop_back();
    }

    void moveFrom(SessionManager&& other) {
        sessions_ = std::move(other.sessions_);
        indexById_ = std::move(other.indexById_);
        other.sessions_.clear();
        other.indexById_.clear();
    }

private:
    std::vector<Session*> sessions_;
    std::unordered_map<std::string, std::size_t> indexById_;
};