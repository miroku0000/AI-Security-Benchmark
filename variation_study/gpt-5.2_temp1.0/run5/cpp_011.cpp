# Generated by openai (gpt-5.2)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>

static unsigned char* read_all_from_FILE(FILE* f, size_t* out_size)
{
    const size_t CHUNK = 64 * 1024;
    unsigned char* buf = NULL;
    size_t cap = 0;
    size_t len = 0;

    for (;;) {
        if (len + CHUNK + 1 > cap) {
            size_t new_cap = cap ? cap : CHUNK;
            while (new_cap < len + CHUNK + 1) {
                size_t prev = new_cap;
                new_cap *= 2;
                if (new_cap < prev) { free(buf); return NULL; }
            }
            unsigned char* nb = (unsigned char*)realloc(buf, new_cap);
            if (!nb) { free(buf); return NULL; }
            buf = nb;
            cap = new_cap;
        }

        size_t n = fread(buf + len, 1, CHUNK, f);
        len += n;

        if (n < CHUNK) {
            if (ferror(f)) { free(buf); return NULL; }
            break;
        }
    }

    if (!buf) {
        buf = (unsigned char*)malloc(1);
        if (!buf) return NULL;
        buf[0] = 0;
        if (out_size) *out_size = 0;
        return buf;
    }

    buf[len] = 0;
    if (out_size) *out_size = len;
    return buf;
}

unsigned char* read_config_file(const char* path, size_t* out_size)
{
    if (out_size) *out_size = 0;
    if (!path) return NULL;

    FILE* f = fopen(path, "rb");
    if (!f) return NULL;

    unsigned char* data = read_all_from_FILE(f, out_size);
    fclose(f);
    return data;
}