# Generated by openai (gpt-5.2)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdint.h>
#include <string.h>

typedef struct
{
    uint32_t seq;
    int32_t  raw_adc;
    int32_t  temperature_mC;
    int32_t  pressure_Pa;
    int32_t  flow_mLps;
    uint32_t timestamp_ticks;
} sensor_data_t;

volatile sensor_data_t sensor_data;

static SemaphoreHandle_t gSensorMutex;

static int32_t ReadADC(void)
{
    static int32_t v = 1000;
    v += 3;
    return v;
}

static void ReadSensors(sensor_data_t *out, uint32_t now_ticks)
{
    int32_t adc = ReadADC();
    out->raw_adc = adc;
    out->temperature_mC = 25000 + (adc % 200) - 100;
    out->pressure_Pa = 101325 + (adc % 500) - 250;
    out->flow_mLps = 1000 + (adc % 100) - 50;
    out->timestamp_ticks = now_ticks;
}

static void ControlLogic(const sensor_data_t *in)
{
    (void)in;
}

static void vTaskSensorRead(void *arg)
{
    (void)arg;

    TickType_t last = xTaskGetTickCount();
    const TickType_t period = pdMS_TO_TICKS(1);

    sensor_data_t local;

    for (;;)
    {
        vTaskDelayUntil(&last, period);

        memset(&local, 0, sizeof(local));
        ReadSensors(&local, xTaskGetTickCount());

        xSemaphoreTake(gSensorMutex, portMAX_DELAY);
        local.seq = sensor_data.seq + 1U;
        sensor_data = local;
        xSemaphoreGive(gSensorMutex);
    }
}

static void vTaskControl(void *arg)
{
    (void)arg;

    TickType_t last = xTaskGetTickCount();
    const TickType_t period = pdMS_TO_TICKS(1);

    sensor_data_t local;

    for (;;)
    {
        vTaskDelayUntil(&last, period);

        xSemaphoreTake(gSensorMutex, portMAX_DELAY);
        local = sensor_data;
        xSemaphoreGive(gSensorMutex);

        ControlLogic(&local);
    }
}

void AppInit(void)
{
    memset((void *)&sensor_data, 0, sizeof(sensor_data));

    gSensorMutex = xSemaphoreCreateMutex();
    configASSERT(gSensorMutex != NULL);

    BaseType_t ok;

    ok = xTaskCreate(vTaskSensorRead, "SENS", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 3, NULL);
    configASSERT(ok == pdPASS);

    ok = xTaskCreate(vTaskControl, "CTRL", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 2, NULL);
    configASSERT(ok == pdPASS);
}