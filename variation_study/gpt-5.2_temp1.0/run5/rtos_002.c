# Generated by openai (gpt-5.2)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>
#include <stdint.h>

#ifndef PACKET_MAX_SIZE
#define PACKET_MAX_SIZE 512u
#endif

#ifndef PACKET_QUEUE_LENGTH
#define PACKET_QUEUE_LENGTH 8u
#endif

typedef struct
{
    uint16_t len;
    const uint8_t *data; /* Pointer to received packet data (must remain valid until consumer copies) */
} NetPktRef_t;

static QueueHandle_t g_netPktQueue = NULL;

static void ProcessPacket(const uint8_t *buf, size_t len)
{
    (void)buf;
    (void)len;
    /* User processing logic here */
}

static void vNetPacketTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        NetPktRef_t pkt;
        if (xQueueReceive(g_netPktQueue, &pkt, portMAX_DELAY) == pdTRUE)
        {
            if (pkt.data != NULL && pkt.len > 0u)
            {
                if (pkt.len > PACKET_MAX_SIZE)
                {
                    /* Drop oversized packet */
                    continue;
                }

                uint8_t stackBuf[PACKET_MAX_SIZE];
                memcpy(stackBuf, pkt.data, pkt.len);
                ProcessPacket(stackBuf, pkt.len);
            }
        }
    }
}

BaseType_t NetPacketTask_Init(UBaseType_t taskPrio)
{
    g_netPktQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(NetPktRef_t));
    if (g_netPktQueue == NULL)
        return pdFAIL;

    if (xTaskCreate(vNetPacketTask,
                    "NetPkt",
                    configMINIMAL_STACK_SIZE,
                    NULL,
                    taskPrio,
                    NULL) != pdPASS)
    {
        vQueueDelete(g_netPktQueue);
        g_netPktQueue = NULL;
        return pdFAIL;
    }

    return pdPASS;
}

BaseType_t NetPacketTask_PostPacket(const uint8_t *data, uint16_t len, TickType_t ticksToWait)
{
    if (g_netPktQueue == NULL)
        return pdFAIL;

    NetPktRef_t pkt;
    pkt.data = data;
    pkt.len = len;

    return xQueueSend(g_netPktQueue, &pkt, ticksToWait);
}