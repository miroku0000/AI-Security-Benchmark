# Generated by openai (gpt-5.2)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <string>
#include <stdexcept>
#include <utility>
#include <chrono>
#include <cerrno>

#ifdef _WIN32
#define NOMINMAX
#include <winsock2.h>
#include <ws2tcpip.h>
#pragma comment(lib, "Ws2_32.lib")
#else
#include <sys/types.h>
#include <sys/socket.h>
#include <netdb.h>
#include <unistd.h>
#include <fcntl.h>
#include <cstring>
#endif

class NetworkConnectionManager {
public:
    NetworkConnectionManager(std::string host, std::string port)
        : host_(std::move(host)), port_(std::move(port)) {
        init();
    }

    ~NetworkConnectionManager() noexcept {
        cleanup();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept {
        moveFrom(std::move(other));
    }

    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            moveFrom(std::move(other));
        }
        return *this;
    }

    bool connected() const noexcept {
        return sockValid();
    }

    int nativeHandle() const noexcept {
#ifdef _WIN32
        return sock_ == INVALID_SOCKET ? -1 : static_cast<int>(sock_);
#else
        return sock_;
#endif
    }

    void reset() {
        closeSocket();
    }

    void reinitialize() {
        reset();
        init();
    }

    void reinitialize(std::string host, std::string port) {
        host_ = std::move(host);
        port_ = std::move(port);
        reinitialize();
    }

    bool tryReinitialize() noexcept {
        try {
            reinitialize();
            return true;
        } catch (...) {
            return false;
        }
    }

private:
#ifdef _WIN32
    using Socket = SOCKET;
    static constexpr Socket kInvalidSock = INVALID_SOCKET;
#else
    using Socket = int;
    static constexpr Socket kInvalidSock = -1;
#endif

    std::string host_;
    std::string port_;
    Socket sock_ = kInvalidSock;

#ifdef _WIN32
    bool wsaInitialized_ = false;
#endif

    bool sockValid() const noexcept {
#ifdef _WIN32
        return sock_ != INVALID_SOCKET;
#else
        return sock_ >= 0;
#endif
    }

    static std::runtime_error sysError(const char* what) {
#ifdef _WIN32
        int err = WSAGetLastError();
        return std::runtime_error(std::string(what) + " (WSA error " + std::to_string(err) + ")");
#else
        int err = errno;
        return std::runtime_error(std::string(what) + " (errno " + std::to_string(err) + "): " + std::strerror(err));
#endif
    }

    void init() {
        try {
#ifdef _WIN32
            ensureWSA();
#endif
            addrinfo hints{};
            hints.ai_family = AF_UNSPEC;
            hints.ai_socktype = SOCK_STREAM;
            hints.ai_protocol = IPPROTO_TCP;

            addrinfo* res = nullptr;
            int rc = getaddrinfo(host_.c_str(), port_.c_str(), &hints, &res);
            if (rc != 0) {
#ifdef _WIN32
                throw std::runtime_error(std::string("getaddrinfo failed (") + gai_strerrorA(rc) + ")");
#else
                throw std::runtime_error(std::string("getaddrinfo failed (") + gai_strerror(rc) + ")");
#endif
            }

            addrinfo* p = res;
            Socket s = kInvalidSock;

            for (; p != nullptr; p = p->ai_next) {
                s = ::socket(p->ai_family, p->ai_socktype, p->ai_protocol);
#ifdef _WIN32
                if (s == INVALID_SOCKET) continue;
#else
                if (s < 0) continue;
#endif
                if (::connect(s, p->ai_addr, static_cast<int>(p->ai_addrlen)) == 0) {
                    sock_ = s;
                    break;
                }
                closeSocket(s);
                s = kInvalidSock;
            }

            freeaddrinfo(res);

            if (!sockValid()) {
                throw std::runtime_error("Unable to connect to " + host_ + ":" + port_);
            }
        } catch (...) {
            cleanup();
            throw;
        }
    }

#ifdef _WIN32
    void ensureWSA() {
        if (wsaInitialized_) return;
        WSADATA wsaData{};
        int rc = WSAStartup(MAKEWORD(2, 2), &wsaData);
        if (rc != 0) {
            throw std::runtime_error("WSAStartup failed (" + std::to_string(rc) + ")");
        }
        wsaInitialized_ = true;
    }
#endif

    void closeSocket() noexcept {
        closeSocket(sock_);
        sock_ = kInvalidSock;
    }

    void closeSocket(Socket s) noexcept {
#ifdef _WIN32
        if (s != INVALID_SOCKET) {
            ::closesocket(s);
        }
#else
        if (s >= 0) {
            ::close(s);
        }
#endif
    }

    void cleanup() noexcept {
        closeSocket();
#ifdef _WIN32
        if (wsaInitialized_) {
            WSACleanup();
            wsaInitialized_ = false;
        }
#endif
    }

    void moveFrom(NetworkConnectionManager&& other) noexcept {
        host_ = std::move(other.host_);
        port_ = std::move(other.port_);
        sock_ = other.sock_;
        other.sock_ = kInvalidSock;
#ifdef _WIN32
        wsaInitialized_ = other.wsaInitialized_;
        other.wsaInitialized_ = false;
#endif
    }
};