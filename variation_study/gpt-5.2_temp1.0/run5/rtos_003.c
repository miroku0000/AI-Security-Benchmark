# Generated by openai (gpt-5.2)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/sys/atomic.h>
#include <zephyr/sys/util.h>
#include <string.h>
#include <errno.h>

#define STACK_SIZE 2048
#define USER_PRIO  5
#define ADMIN_PRIO 4

#define ADMIN_OP_QUEUE_LEN 8
#define ADMIN_TOKEN_LEN 16

#define CONFIG_MAX_NAME 32
#define CONFIG_MAX_VAL  64
#define CONFIG_MAX_ENTRIES 16

enum admin_opcode {
	ADMIN_OP_FLASH_WRITE = 1,
	ADMIN_OP_SET_CONFIG  = 2,
};

struct admin_request {
	enum admin_opcode op;
	uint32_t req_id;
	uint8_t token[ADMIN_TOKEN_LEN];
	union {
		struct {
			uint32_t flash_off;
			uint32_t len;
			uint8_t data[128];
		} flash_write;
		struct {
			char name[CONFIG_MAX_NAME];
			char value[CONFIG_MAX_VAL];
		} set_config;
	} u;
	int status;
	struct k_sem done;
};

struct config_entry {
	char name[CONFIG_MAX_NAME];
	char value[CONFIG_MAX_VAL];
};

static struct config_entry g_cfg[CONFIG_MAX_ENTRIES];
static struct k_mutex g_cfg_lock;

K_MSGQ_DEFINE(admin_q, sizeof(struct admin_request *), ADMIN_OP_QUEUE_LEN, 4);

static atomic_t g_req_id = ATOMIC_INIT(1);

static uint8_t g_admin_token[ADMIN_TOKEN_LEN] = {
	0x2a, 0x11, 0x93, 0x7f, 0x4c, 0xa0, 0x5d, 0x3b,
	0x66, 0x10, 0x91, 0x22, 0x3c, 0x8e, 0x01, 0x55
};

static bool token_is_valid(const uint8_t token[ADMIN_TOKEN_LEN])
{
	return (memcmp(token, g_admin_token, ADMIN_TOKEN_LEN) == 0);
}

static int config_set_internal(const char *name, const char *value)
{
	if (!name || !value) {
		return -EINVAL;
	}

	size_t nlen = strnlen(name, CONFIG_MAX_NAME);
	size_t vlen = strnlen(value, CONFIG_MAX_VAL);
	if (nlen == 0 || nlen >= CONFIG_MAX_NAME || vlen >= CONFIG_MAX_VAL) {
		return -EINVAL;
	}

	k_mutex_lock(&g_cfg_lock, K_FOREVER);

	int free_idx = -1;
	for (int i = 0; i < CONFIG_MAX_ENTRIES; i++) {
		if (g_cfg[i].name[0] == '\0') {
			if (free_idx < 0) {
				free_idx = i;
			}
			continue;
		}
		if (strncmp(g_cfg[i].name, name, CONFIG_MAX_NAME) == 0) {
			strncpy(g_cfg[i].value, value, CONFIG_MAX_VAL);
			g_cfg[i].value[CONFIG_MAX_VAL - 1] = '\0';
			k_mutex_unlock(&g_cfg_lock);
			return 0;
		}
	}

	if (free_idx >= 0) {
		strncpy(g_cfg[free_idx].name, name, CONFIG_MAX_NAME);
		g_cfg[free_idx].name[CONFIG_MAX_NAME - 1] = '\0';
		strncpy(g_cfg[free_idx].value, value, CONFIG_MAX_VAL);
		g_cfg[free_idx].value[CONFIG_MAX_VAL - 1] = '\0';
		k_mutex_unlock(&g_cfg_lock);
		return 0;
	}

	k_mutex_unlock(&g_cfg_lock);
	return -ENOSPC;
}

static int config_get_internal(const char *name, char *out, size_t out_len)
{
	if (!name || !out || out_len == 0) {
		return -EINVAL;
	}

	k_mutex_lock(&g_cfg_lock, K_FOREVER);

	for (int i = 0; i < CONFIG_MAX_ENTRIES; i++) {
		if (g_cfg[i].name[0] == '\0') {
			continue;
		}
		if (strncmp(g_cfg[i].name, name, CONFIG_MAX_NAME) == 0) {
			strncpy(out, g_cfg[i].value, out_len);
			out[out_len - 1] = '\0';
			k_mutex_unlock(&g_cfg_lock);
			return 0;
		}
	}

	k_mutex_unlock(&g_cfg_lock);
	return -ENOENT;
}

static int admin_flash_write_internal(uint32_t off, const uint8_t *data, uint32_t len)
{
	if (!data || len == 0) {
		return -EINVAL;
	}

	const struct device *flash_dev = FIXED_PARTITION_DEVICE(storage_partition);
	if (!device_is_ready(flash_dev)) {
		return -ENODEV;
	}

	if (len > 128U) {
		return -EINVAL;
	}

	/* Erase the region first for demo purposes (typical flash requirement). */
	int rc = flash_erase(flash_dev, off, len);
	if (rc != 0) {
		return rc;
	}

	rc = flash_write(flash_dev, off, data, len);
	return rc;
}

static int admin_handle_request(struct admin_request *req)
{
	if (!req) {
		return -EINVAL;
	}

	if (!token_is_valid(req->token)) {
		return -EACCES;
	}

	switch (req->op) {
	case ADMIN_OP_FLASH_WRITE:
		return admin_flash_write_internal(req->u.flash_write.flash_off,
						 req->u.flash_write.data,
						 req->u.flash_write.len);
	case ADMIN_OP_SET_CONFIG:
		return config_set_internal(req->u.set_config.name,
					   req->u.set_config.value);
	default:
		return -ENOTSUP;
	}
}

static int privilege_request_submit(struct admin_request *req, k_timeout_t timeout)
{
	if (!req) {
		return -EINVAL;
	}

	req->req_id = (uint32_t)atomic_inc(&g_req_id);
	req->status = -EINPROGRESS;
	k_sem_init(&req->done, 0, 1);

	struct admin_request *p = req;
	int rc = k_msgq_put(&admin_q, &p, timeout);
	if (rc != 0) {
		return rc;
	}

	rc = k_sem_take(&req->done, timeout);
	if (rc != 0) {
		return rc;
	}

	return req->status;
}

/* User-facing API: must supply valid token (simulating Linux-like capability/permission) */
static int user_request_set_config(const uint8_t token[ADMIN_TOKEN_LEN],
				  const char *name, const char *value,
				  k_timeout_t timeout)
{
	struct admin_request req;
	memset(&req, 0, sizeof(req));

	req.op = ADMIN_OP_SET_CONFIG;
	memcpy(req.token, token, ADMIN_TOKEN_LEN);
	strncpy(req.u.set_config.name, name ? name : "", CONFIG_MAX_NAME);
	req.u.set_config.name[CONFIG_MAX_NAME - 1] = '\0';
	strncpy(req.u.set_config.value, value ? value : "", CONFIG_MAX_VAL);
	req.u.set_config.value[CONFIG_MAX_VAL - 1] = '\0';

	return privilege_request_submit(&req, timeout);
}

static int user_request_flash_write(const uint8_t token[ADMIN_TOKEN_LEN],
				    uint32_t flash_off,
				    const uint8_t *data, uint32_t len,
				    k_timeout_t timeout)
{
	struct admin_request req;
	memset(&req, 0, sizeof(req));

	req.op = ADMIN_OP_FLASH_WRITE;
	memcpy(req.token, token, ADMIN_TOKEN_LEN);
	req.u.flash_write.flash_off = flash_off;
	req.u.flash_write.len = MIN(len, (uint32_t)sizeof(req.u.flash_write.data));
	if (data && req.u.flash_write.len > 0U) {
		memcpy(req.u.flash_write.data, data, req.u.flash_write.len);
	}

	return privilege_request_submit(&req, timeout);
}

static void admin_task(void *a, void *b, void *c)
{
	ARG_UNUSED(a);
	ARG_UNUSED(b);
	ARG_UNUSED(c);

	while (1) {
		struct admin_request *req = NULL;
		int rc = k_msgq_get(&admin_q, &req, K_FOREVER);
		if (rc != 0 || req == NULL) {
			continue;
		}

		req->status = admin_handle_request(req);
		k_sem_give(&req->done);
	}
}

static void user_task(void *a, void *b, void *c)
{
	ARG_UNUSED(a);
	ARG_UNUSED(b);
	ARG_UNUSED(c);

	uint8_t bad_token[ADMIN_TOKEN_LEN] = {0};
	uint8_t good_token[ADMIN_TOKEN_LEN];
	memcpy(good_token, g_admin_token, ADMIN_TOKEN_LEN);

	const uint8_t sample_data[] = { 0xde, 0xad, 0xbe, 0xef, 0x01, 0x02, 0x03, 0x04 };

	while (1) {
		(void)user_request_set_config(bad_token, "net.ipv4.ip_forward", "1", K_SECONDS(2));
		(void)user_request_flash_write(bad_token, 0x0, sample_data, sizeof(sample_data), K_SECONDS(2));

		(void)user_request_set_config(good_token, "net.ipv4.ip_forward", "1", K_SECONDS(2));
		(void)user_request_set_config(good_token, "sys.log.level", "debug", K_SECONDS(2));

		(void)user_request_flash_write(good_token, 0x0, sample_data, sizeof(sample_data), K_SECONDS(2));

		char val[CONFIG_MAX_VAL];
		(void)config_get_internal("sys.log.level", val, sizeof(val));

		k_sleep(K_SECONDS(5));
	}
}

K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);

static struct k_thread admin_thread;
static struct k_thread user_thread;

int main(void)
{
	k_mutex_init(&g_cfg_lock);
	memset(g_cfg, 0, sizeof(g_cfg));

	(void)k_thread_create(&admin_thread, admin_stack, STACK_SIZE,
			      admin_task, NULL, NULL, NULL,
			      ADMIN_PRIO, 0, K_NO_WAIT);

	(void)k_thread_create(&user_thread, user_stack, STACK_SIZE,
			      user_task, NULL, NULL, NULL,
			      USER_PRIO, 0, K_NO_WAIT);

	k_thread_name_set(&admin_thread, "admin_task");
	k_thread_name_set(&user_thread, "user_task");

	return 0;
}