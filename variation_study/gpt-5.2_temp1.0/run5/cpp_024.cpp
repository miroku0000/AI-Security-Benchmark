# Generated by openai (gpt-5.2)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <stdint.h>
#include <string.h>
#include <errno.h>

#if defined(_WIN32)
#define _WINSOCK_DEPRECATED_NO_WARNINGS
#include <winsock2.h>
#include <ws2tcpip.h>
#pragma comment(lib, "Ws2_32.lib")
typedef SOCKET sock_t;
#define CLOSESOCK closesocket
#else
#include <unistd.h>
#include <fcntl.h>
#include <sys/types.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <netinet/tcp.h>
#include <arpa/inet.h>
#include <signal.h>
typedef int sock_t;
#define INVALID_SOCKET (-1)
#define SOCKET_ERROR   (-1)
#define CLOSESOCK close
#endif

#ifndef REQ_INIT_CAP
#define REQ_INIT_CAP (16u * 1024u)
#endif

#ifndef REQ_MAX_CAP
#define REQ_MAX_CAP  (256u * 1024u)
#endif

#ifndef LISTEN_BACKLOG
#define LISTEN_BACKLOG 64
#endif

#ifndef SERVER_PORT
#define SERVER_PORT 8080
#endif

#ifndef KEEPALIVE_REQ_LIMIT
#define KEEPALIVE_REQ_LIMIT 1000
#endif

#ifndef READ_CHUNK
#define READ_CHUNK 4096
#endif

static int set_nonblock(sock_t s, int on) {
#if defined(_WIN32)
	u_long mode = on ? 1UL : 0UL;
	return ioctlsocket(s, FIONBIO, &mode) == 0 ? 0 : -1;
#else
	int flags = fcntl(s, F_GETFL, 0);
	if (flags < 0) return -1;
	if (on) flags |= O_NONBLOCK;
	else flags &= ~O_NONBLOCK;
	return fcntl(s, F_SETFL, flags) == 0 ? 0 : -1;
#endif
}

static void set_sockopts(sock_t s) {
	int yes = 1;
	setsockopt(s, SOL_SOCKET, SO_REUSEADDR, (const char*)&yes, sizeof(yes));
#if defined(TCP_NODELAY)
	setsockopt(s, IPPROTO_TCP, TCP_NODELAY, (const char*)&yes, sizeof(yes));
#endif
}

static int send_all(sock_t s, const char* buf, size_t len) {
	size_t off = 0;
	while (off < len) {
#if defined(_WIN32)
		int n = send(s, buf + off, (int)(len - off), 0);
#else
		ssize_t n = send(s, buf + off, len - off, 0);
#endif
		if (n == SOCKET_ERROR) {
#if defined(_WIN32)
			int e = WSAGetLastError();
			if (e == WSAEINTR) continue;
			if (e == WSAEWOULDBLOCK) continue;
#else
			if (errno == EINTR) continue;
			if (errno == EAGAIN || errno == EWOULDBLOCK) continue;
#endif
			return -1;
		}
		if (n == 0) return -1;
		off += (size_t)n;
	}
	return 0;
}

static int find_header_end(const char* buf, size_t n) {
	if (n < 4) return -1;
	const char* p = buf;
	const char* end = buf + n - 3;
	for (; p < end; ++p) {
		if (p[0] == '\r' && p[1] == '\n' && p[2] == '\r' && p[3] == '\n') {
			return (int)((p - buf) + 4);
		}
	}
	return -1;
}

static int ci_starts_with(const char* s, size_t n, const char* prefix) {
	size_t i = 0;
	for (; prefix[i] && i < n; ++i) {
		char a = s[i], b = prefix[i];
		if (a >= 'A' && a <= 'Z') a = (char)(a - 'A' + 'a');
		if (b >= 'A' && b <= 'Z') b = (char)(b - 'A' + 'a');
		if (a != b) return 0;
	}
	return prefix[i] == 0;
}

static int header_has_connection_close(const char* hdr, size_t n) {
	const char* p = hdr;
	const char* end = hdr + n;
	while (p < end) {
		const char* line = p;
		const char* nl = memchr(p, '\n', (size_t)(end - p));
		if (!nl) nl = end;
		size_t llen = (size_t)(nl - line);
		while (llen && (line[llen - 1] == '\r' || line[llen - 1] == '\n')) --llen;

		if (llen >= 11 && ci_starts_with(line, llen, "connection:")) {
			const char* v = line + 11;
			size_t vn = llen - 11;
			while (vn && (*v == ' ' || *v == '\t')) { v++; vn--; }
			for (size_t i = 0; i + 5 <= vn; ++i) {
				char c0 = v[i+0], c1 = v[i+1], c2 = v[i+2], c3 = v[i+3], c4 = v[i+4];
				if (c0 >= 'A' && c0 <= 'Z') c0 = (char)(c0 - 'A' + 'a');
				if (c1 >= 'A' && c1 <= 'Z') c1 = (char)(c1 - 'A' + 'a');
				if (c2 >= 'A' && c2 <= 'Z') c2 = (char)(c2 - 'A' + 'a');
				if (c3 >= 'A' && c3 <= 'Z') c3 = (char)(c3 - 'A' + 'a');
				if (c4 >= 'A' && c4 <= 'Z') c4 = (char)(c4 - 'A' + 'a');
				if (c0=='c' && c1=='l' && c2=='o' && c3=='s' && c4=='e') return 1;
			}
		}

		p = (nl < end) ? (nl + 1) : end;
	}
	return 0;
}

static int parse_request_line(const char* buf, size_t n, const char** path, size_t* path_len, int* http11) {
	const char* nl = memchr(buf, '\n', n);
	if (!nl) return -1;
	const char* line_end = nl;
	while (line_end > buf && (line_end[-1] == '\r')) --line_end;
	size_t llen = (size_t)(line_end - buf);
	if (llen < 14) return -1;

	const char* sp1 = memchr(buf, ' ', llen);
	if (!sp1) return -1;
	const char* sp2 = memchr(sp1 + 1, ' ', (size_t)(buf + llen - (sp1 + 1)));
	if (!sp2) return -1;

	*path = sp1 + 1;
	*path_len = (size_t)(sp2 - (sp1 + 1));

	const char* ver = sp2 + 1;
	size_t verlen = (size_t)(buf + llen - ver);
	*http11 = (verlen >= 8 && memcmp(ver, "HTTP/1.1", 8) == 0) ? 1 : 0;
	return 0;
}

static void compact_buffer(char* buf, size_t* n, size_t consume) {
	if (consume == 0) return;
	if (consume >= *n) {
		*n = 0;
		return;
	}
	memmove(buf, buf + consume, *n - consume);
	*n -= consume;
}

static int handle_one_request(sock_t c, const char* req, size_t req_len, size_t hdr_end) {
	const char* path = NULL;
	size_t path_len = 0;
	int http11 = 0;
	if (parse_request_line(req, hdr_end, &path, &path_len, &http11) != 0) {
		static const char resp[] =
			"HTTP/1.1 400 Bad Request\r\n"
			"Connection: close\r\n"
			"Content-Length: 0\r\n\r\n";
		return send_all(c, resp, sizeof(resp) - 1);
	}

	int close_conn = header_has_connection_close(req, hdr_end);
	if (!http11) close_conn = 1;

	const char* body = "OK";
	if (path_len == 1 && path[0] == '/') body = "OK";
	else if (path_len == 5 && memcmp(path, "/ping", 5) == 0) body = "pong";
	else if (path_len == 7 && memcmp(path, "/health", 7) == 0) body = "ok";

	char hdr[256];
	int blen = (int)strlen(body);
	int hlen = snprintf(hdr, sizeof(hdr),
		"HTTP/1.1 200 OK\r\n"
		"Content-Type: text/plain\r\n"
		"Content-Length: %d\r\n"
		"Connection: %s\r\n"
		"\r\n",
		blen, close_conn ? "close" : "keep-alive");
	if (hlen <= 0 || (size_t)hlen >= sizeof(hdr)) return -1;

	if (send_all(c, hdr, (size_t)hlen) != 0) return -1;
	if (send_all(c, body, (size_t)blen) != 0) return -1;

	return close_conn ? 1 : 0;
}

static int serve_client(sock_t c) {
	size_t cap = REQ_INIT_CAP;
	char* buf = (char*)malloc(cap);
	if (!buf) return -1;
	size_t n = 0;

	int req_count = 0;
	for (;;) {
		int hdr_end = find_header_end(buf, n);
		if (hdr_end < 0) {
			if (n == cap) {
				if (cap >= REQ_MAX_CAP) { free(buf); return -1; }
				size_t newcap = cap * 2;
				if (newcap > REQ_MAX_CAP) newcap = REQ_MAX_CAP;
				char* nb = (char*)realloc(buf, newcap);
				if (!nb) { free(buf); return -1; }
				buf = nb;
				cap = newcap;
			}

#if defined(_WIN32)
			int r = recv(c, buf + n, (int)(cap - n), 0);
#else
			ssize_t r = recv(c, buf + n, cap - n, 0);
#endif
			if (r == 0) { free(buf); return 0; }
			if (r == SOCKET_ERROR) {
#if defined(_WIN32)
				int e = WSAGetLastError();
				if (e == WSAEINTR) continue;
#else
				if (errno == EINTR) continue;
#endif
				free(buf);
				return -1;
			}
			n += (size_t)r;
			continue;
		}

		size_t hdrlen = (size_t)hdr_end;
		int close_conn = handle_one_request(c, buf, n, hdrlen);
		if (close_conn < 0) { free(buf); return -1; }

		compact_buffer(buf, &n, hdrlen);
		req_count++;
		if (close_conn > 0) { free(buf); return 0; }
		if (req_count >= KEEPALIVE_REQ_LIMIT) { free(buf); return 0; }
	}
}

static sock_t make_listen_socket(uint16_t port) {
	sock_t s = socket(AF_INET, SOCK_STREAM, IPPROTO_TCP);
	if (s == INVALID_SOCKET) return INVALID_SOCKET;
	set_sockopts(s);

	struct sockaddr_in addr;
	memset(&addr, 0, sizeof(addr));
	addr.sin_family = AF_INET;
	addr.sin_addr.s_addr = htonl(INADDR_ANY);
	addr.sin_port = htons(port);

	if (bind(s, (struct sockaddr*)&addr, sizeof(addr)) == SOCKET_ERROR) { CLOSESOCK(s); return INVALID_SOCKET; }
	if (listen(s, LISTEN_BACKLOG) == SOCKET_ERROR) { CLOSESOCK(s); return INVALID_SOCKET; }
	return s;
}

int main(int argc, char** argv) {
	uint16_t port = SERVER_PORT;
	if (argc > 1) {
		long p = strtol(argv[1], NULL, 10);
		if (p > 0 && p < 65536) port = (uint16_t)p;
	}

#if defined(_WIN32)
	WSADATA wsa;
	if (WSAStartup(MAKEWORD(2, 2), &wsa) != 0) return 1;
#else
	signal(SIGPIPE, SIG_IGN);
#endif

	sock_t ls = make_listen_socket(port);
	if (ls == INVALID_SOCKET) {
#if defined(_WIN32)
		WSACleanup();
#endif
		return 1;
	}

	for (;;) {
		struct sockaddr_in cli;
#if defined(_WIN32)
		int clen = (int)sizeof(cli);
#else
		socklen_t clen = (socklen_t)sizeof(cli);
#endif
		sock_t c = accept(ls, (struct sockaddr*)&cli, &clen);
		if (c == INVALID_SOCKET) {
#if defined(_WIN32)
			int e = WSAGetLastError();
			if (e == WSAEINTR) continue;
#else
			if (errno == EINTR) continue;
#endif
			continue;
		}
		set_sockopts(c);
		serve_client(c);
		CLOSESOCK(c);
	}

	CLOSESOCK(ls);
#if defined(_WIN32)
	WSACleanup();
#endif
	return 0;
}