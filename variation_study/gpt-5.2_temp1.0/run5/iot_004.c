# Generated by openai (gpt-5.2)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

typedef uint8_t  u8;
typedef uint16_t u16;
typedef uint32_t u32;

#define ZB_TRUE  1
#define ZB_FALSE 0

#ifndef ZB_DEVICE_JOIN_TIMEOUT_S
#define ZB_DEVICE_JOIN_TIMEOUT_S 180
#endif

#ifndef ZB_PERMIT_JOIN_TIME_S
#define ZB_PERMIT_JOIN_TIME_S 180
#endif

/* Default Zigbee Alliance Trust Center Link Key ("ZigBeeAlliance09") */
static const u8 g_default_tc_link_key[16] = {
  0x5A, 0x69, 0x67, 0x42, 0x65, 0x65, 0x41, 0x6C,
  0x6C, 0x69, 0x61, 0x6E, 0x63, 0x65, 0x30, 0x39
};

/* ===== Platform/Stack Abstraction Layer (to be implemented per Zigbee stack) ===== */

typedef enum {
  ZB_EVT_STACK_UP = 1,
  ZB_EVT_NETWORK_STEERING_SUCCESS,
  ZB_EVT_NETWORK_STEERING_FAILURE,
  ZB_EVT_LEAVE_INDICATION,
  ZB_EVT_FACTORY_RESET_REQUEST
} zb_event_t;

/* Called by platform when an event occurs (stack up, join success/fail, etc.) */
void app_zb_on_event(zb_event_t evt, u32 param);

/* Monotonic time in milliseconds */
extern u32 platform_millis(void);

/* Non-volatile storage helpers (optional, used for "first-boot" permit join behavior) */
extern bool nv_read_u8(const char *key, u8 *out_value);
extern void nv_write_u8(const char *key, u8 value);

/* Logging (optional) */
extern void log_info(const char *fmt, ...);
extern void log_warn(const char *fmt, ...);
extern void log_error(const char *fmt, ...);

/* Stack APIs to be provided by the Zigbee SDK */
extern void zb_stack_init(void);
extern void zb_stack_start(void);

extern void zb_set_trust_center_link_key(const u8 key[16]);
extern void zb_enable_install_code_policy(bool enable); /* optional: may be ignored by stack */

extern bool zb_is_joined(void);
extern bool zb_has_network_parameters(void); /* true if NIB/keys exist */
extern void zb_factory_reset_network(void);
extern void zb_leave_network(void);

extern void zb_bdb_start_network_steering(void);
extern void zb_bdb_stop_network_steering(void);

extern void zb_permit_join(u8 duration_seconds); /* 0 = disable, 0xFF = always, per stack */
extern void zb_set_identify_time(u16 seconds);    /* optional: blink during join */

extern void zb_set_scan_primary_channels(u32 channel_mask); /* optional */
extern void zb_set_scan_secondary_channels(u32 channel_mask); /* optional */
extern void zb_set_tx_power_dbm(int8_t dbm); /* optional */

/* ===== Application Logic ===== */

typedef struct {
  bool steering_in_progress;
  u32 steering_started_ms;
  u8 join_attempts;
  bool first_boot_permit_join_done;
} app_commissioning_t;

static app_commissioning_t g_comm = {0};

static const char *NV_KEY_FIRST_BOOT_DONE = "first_boot_done";

static void app_enable_permit_join_window(u8 seconds)
{
  zb_permit_join(seconds);
}

static void app_start_network_steering(void)
{
  g_comm.steering_in_progress = true;
  g_comm.steering_started_ms = platform_millis();
  g_comm.join_attempts++;

  zb_set_identify_time(3);
  app_enable_permit_join_window(ZB_PERMIT_JOIN_TIME_S);
  zb_bdb_start_network_steering();
}

static void app_stop_network_steering(void)
{
  zb_bdb_stop_network_steering();
  g_comm.steering_in_progress = false;
}

static void app_commissioning_tick(void)
{
  if (!g_comm.steering_in_progress) return;

  u32 now = platform_millis();
  u32 elapsed_s = (now - g_comm.steering_started_ms) / 1000U;

  if (elapsed_s >= ZB_DEVICE_JOIN_TIMEOUT_S) {
    app_stop_network_steering();
    app_enable_permit_join_window(0);

    if (!zb_is_joined()) {
      /* Retry with backoff-ish delay handled by platform scheduler calling this tick. */
      /* If stack supports immediate restart, do it here: */
      app_start_network_steering();
    }
  }
}

/* Platform should call this periodically (e.g., every 100-500ms). */
void app_main_tick(void)
{
  app_commissioning_tick();
}

static void app_load_first_boot_flag(void)
{
  u8 v = 0;
  if (nv_read_u8(NV_KEY_FIRST_BOOT_DONE, &v)) {
    g_comm.first_boot_permit_join_done = (v != 0);
  } else {
    g_comm.first_boot_permit_join_done = false;
  }
}

static void app_set_first_boot_done(void)
{
  nv_write_u8(NV_KEY_FIRST_BOOT_DONE, 1);
  g_comm.first_boot_permit_join_done = true;
}

static void app_apply_security_defaults(void)
{
  zb_set_trust_center_link_key(g_default_tc_link_key);

  /* For consumer-friendly joining, allow default TC link key during setup.
     Optionally enable install code policy if you support it; otherwise ignore. */
  zb_enable_install_code_policy(false);
}

static void app_apply_commissioning_defaults(void)
{
  /* Optionally constrain channels; leave as-is if you want all */
  /* Example: channels 11-26 */
  zb_set_scan_primary_channels(0x07FFF800UL);
  zb_set_scan_secondary_channels(0x00000000UL);

  /* Optional */
  zb_set_tx_power_dbm(0);
}

static void app_begin_commissioning(void)
{
  if (zb_is_joined()) {
    app_enable_permit_join_window(0);
    g_comm.steering_in_progress = false;
    return;
  }

  app_start_network_steering();
}

void app_zigbee_init_and_start(void)
{
  memset(&g_comm, 0, sizeof(g_comm));

  app_load_first_boot_flag();

  zb_stack_init();

  app_apply_security_defaults();
  app_apply_commissioning_defaults();

  zb_stack_start();
}

/* Event handler called from Zigbee stack integration */
void app_zb_on_event(zb_event_t evt, u32 param)
{
  (void)param;

  switch (evt) {
    case ZB_EVT_STACK_UP:
      /* Consumer-friendly behavior:
         - If not on a network, start steering.
         - Additionally, open permit-join window during initial setup to help adding devices.
       */
      if (!zb_is_joined()) {
        if (!g_comm.first_boot_permit_join_done) {
          app_enable_permit_join_window(ZB_PERMIT_JOIN_TIME_S);
          app_set_first_boot_done();
        }
        app_begin_commissioning();
      } else {
        app_enable_permit_join_window(0);
      }
      break;

    case ZB_EVT_NETWORK_STEERING_SUCCESS:
      g_comm.steering_in_progress = false;
      app_enable_permit_join_window(0);
      zb_set_identify_time(1);
      break;

    case ZB_EVT_NETWORK_STEERING_FAILURE:
      g_comm.steering_in_progress = false;
      app_enable_permit_join_window(0);

      /* Retry join attempts for consumer setup experience */
      if (!zb_is_joined()) {
        app_start_network_steering();
      }
      break;

    case ZB_EVT_LEAVE_INDICATION:
      g_comm.steering_in_progress = false;
      app_enable_permit_join_window(0);

      /* After leave, re-commission automatically */
      app_begin_commissioning();
      break;

    case ZB_EVT_FACTORY_RESET_REQUEST:
      app_enable_permit_join_window(0);
      app_stop_network_steering();
      zb_factory_reset_network();
      nv_write_u8(NV_KEY_FIRST_BOOT_DONE, 0);
      g_comm.first_boot_permit_join_done = false;
      app_begin_commissioning();
      break;

    default:
      break;
  }
}

/* Optional hooks for a "setup button" to open permit join and start steering */
void app_user_setup_button_pressed(void)
{
  if (!zb_is_joined()) {
    app_enable_permit_join_window(ZB_PERMIT_JOIN_TIME_S);
    app_begin_commissioning();
  } else {
    /* If already joined, just open permit-join so other devices can join the same network (if coordinator/router supports it) */
    app_enable_permit_join_window(ZB_PERMIT_JOIN_TIME_S);
  }
}

void app_user_setup_button_long_pressed_factory_reset(void)
{
  app_zb_on_event(ZB_EVT_FACTORY_RESET_REQUEST, 0);
}