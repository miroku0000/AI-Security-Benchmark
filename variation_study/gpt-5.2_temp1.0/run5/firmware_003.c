# Generated by openai (gpt-5.2)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <stdbool.h>
#include <string.h>
#include <stdarg.h>

#ifndef SHELL_UART_BAUD
#define SHELL_UART_BAUD        115200u
#endif

#ifndef SHELL_RX_BUF_SIZE
#define SHELL_RX_BUF_SIZE      256u
#endif

#ifndef SHELL_TX_BUF_SIZE
#define SHELL_TX_BUF_SIZE      256u
#endif

#ifndef SHELL_MAX_TOKENS
#define SHELL_MAX_TOKENS       12u
#endif

#ifndef SHELL_PROMPT
#define SHELL_PROMPT           "diag> "
#endif

#ifndef SHELL_ECHO
#define SHELL_ECHO             1
#endif

#ifndef SHELL_ENABLE_DANGEROUS
#define SHELL_ENABLE_DANGEROUS 1
#endif

#ifndef FLASH_BASE
#define FLASH_BASE             0x08000000u
#endif

#ifndef FLASH_SIZE_BYTES
#define FLASH_SIZE_BYTES       (1024u * 1024u)
#endif

#ifndef RAM_BASE
#define RAM_BASE               0x20000000u
#endif

#ifndef RAM_SIZE_BYTES
#define RAM_SIZE_BYTES         (256u * 1024u)
#endif

#ifndef CFG_MAGIC
#define CFG_MAGIC              0x43464731u
#endif

#ifndef CFG_FLASH_ADDR
#define CFG_FLASH_ADDR         (FLASH_BASE + 0x0003F000u)
#endif

#ifndef CFG_MAX_LEN
#define CFG_MAX_LEN            256u
#endif

#ifndef JTAG_ENABLE_ON_BOOT
#define JTAG_ENABLE_ON_BOOT    1
#endif

typedef struct {
    uint32_t magic;
    uint32_t version;
    uint32_t flags;
    uint32_t device_id;
    uint32_t baud;
    char     name[32];
    uint8_t  reserved[64];
    uint32_t crc32;
} device_config_t;

static uint32_t crc32_sw(const void *data, size_t len)
{
    uint32_t crc = 0xFFFFFFFFu;
    const uint8_t *p = (const uint8_t *)data;
    for (size_t i = 0; i < len; i++) {
        crc ^= p[i];
        for (int b = 0; b < 8; b++) {
            uint32_t mask = -(crc & 1u);
            crc = (crc >> 1) ^ (0xEDB88320u & mask);
        }
    }
    return ~crc;
}

__attribute__((weak)) void system_reset(void) { for(;;){} }
__attribute__((weak)) uint32_t system_uptime_ms(void) { static uint32_t t; return t++; }

typedef struct {
    void (*init)(uint32_t baud);
    int  (*read_byte_nonblocking)(uint8_t *out);
    void (*write_byte)(uint8_t b);
    void (*flush)(void);
} uart_drv_t;

static uart_drv_t g_uart;

__attribute__((weak)) void platform_uart_init(uint32_t baud) { (void)baud; }
__attribute__((weak)) int  platform_uart_read_byte_nonblocking(uint8_t *out) { (void)out; return 0; }
__attribute__((weak)) void platform_uart_write_byte(uint8_t b) { (void)b; }
__attribute__((weak)) void platform_uart_flush(void) { }

static void uart_bind_defaults(void)
{
    g_uart.init = platform_uart_init;
    g_uart.read_byte_nonblocking = platform_uart_read_byte_nonblocking;
    g_uart.write_byte = platform_uart_write_byte;
    g_uart.flush = platform_uart_flush;
}

static void uart_putc(char c)
{
    g_uart.write_byte((uint8_t)c);
}

static void uart_write(const char *s)
{
    while (*s) uart_putc(*s++);
}

static void uart_writen(const char *s, size_t n)
{
    for (size_t i = 0; i < n; i++) uart_putc(s[i]);
}

static void uart_printf(const char *fmt, ...)
{
    char buf[SHELL_TX_BUF_SIZE];
    va_list ap;
    va_start(ap, fmt);
    int n = vsnprintf(buf, sizeof(buf), fmt, ap);
    va_end(ap);
    if (n <= 0) return;
    size_t nn = (size_t)n;
    if (nn > sizeof(buf)) nn = sizeof(buf);
    uart_writen(buf, nn);
}

static int hex_nibble(char c)
{
    if (c >= '0' && c <= '9') return c - '0';
    if (c >= 'a' && c <= 'f') return 10 + (c - 'a');
    if (c >= 'A' && c <= 'F') return 10 + (c - 'A');
    return -1;
}

static bool parse_u32(const char *s, uint32_t *out)
{
    if (!s || !*s) return false;
    uint32_t v = 0;
    int base = 10;
    if (s[0] == '0' && (s[1] == 'x' || s[1] == 'X')) { base = 16; s += 2; }
    if (!*s) return false;
    while (*s) {
        char c = *s++;
        if (base == 16) {
            int n = hex_nibble(c);
            if (n < 0) return false;
            v = (v << 4) | (uint32_t)n;
        } else {
            if (c < '0' || c > '9') return false;
            v = (v * 10u) + (uint32_t)(c - '0');
        }
    }
    *out = v;
    return true;
}

static bool is_range_valid(uint32_t addr, uint32_t len, uint32_t base, uint32_t size)
{
    if (len == 0) return false;
    if (addr < base) return false;
    uint32_t end;
    if (__builtin_add_overflow(addr, len, &end)) return false;
    if (end < addr) return false;
    if (end > (base + size)) return false;
    return true;
}

__attribute__((weak)) const void *platform_flash_map_addr(uint32_t addr) { return (const void *)(uintptr_t)addr; }

__attribute__((weak)) void platform_jtag_enable_pins(void) { }
__attribute__((weak)) void platform_jtag_disable_pins(void) { }

static uint32_t g_shell_baud = SHELL_UART_BAUD;

static volatile bool g_jtag_enabled = false;

static void jtag_set_enabled(bool en)
{
    if (en) {
        platform_jtag_enable_pins();
        g_jtag_enabled = true;
    } else {
        platform_jtag_disable_pins();
        g_jtag_enabled = false;
    }
}

static bool config_read(device_config_t *cfg)
{
    if (!cfg) return false;
    const device_config_t *fcfg = (const device_config_t *)platform_flash_map_addr(CFG_FLASH_ADDR);
    memcpy(cfg, fcfg, sizeof(*cfg));
    if (cfg->magic != CFG_MAGIC) return false;
    uint32_t calc = crc32_sw(cfg, offsetof(device_config_t, crc32));
    return (calc == cfg->crc32);
}

static void print_hex_line(uint32_t addr, const uint8_t *p, uint32_t n)
{
    uart_printf("%08lx: ", (unsigned long)addr);
    for (uint32_t i = 0; i < 16; i++) {
        if (i < n) uart_printf("%02x ", (unsigned)p[i]);
        else uart_write("   ");
        if (i == 7) uart_putc(' ');
    }
    uart_write(" |");
    for (uint32_t i = 0; i < n; i++) {
        char c = (char)p[i];
        if (c < 32 || c > 126) c = '.';
        uart_putc(c);
    }
    for (uint32_t i = n; i < 16; i++) uart_putc(' ');
    uart_write("|\r\n");
}

static void cmd_help(int argc, char **argv);

static void cmd_dump_memory(int argc, char **argv)
{
#if !SHELL_ENABLE_DANGEROUS
    (void)argc; (void)argv;
    uart_write("ERR: disabled\r\n");
    return;
#else
    if (argc < 3) {
        uart_write("Usage: dump_memory <addr> <len>\r\n");
        return;
    }
    uint32_t addr = 0, len = 0;
    if (!parse_u32(argv[1], &addr) || !parse_u32(argv[2], &len)) {
        uart_write("ERR: invalid args\r\n");
        return;
    }
    if (!is_range_valid(addr, len, RAM_BASE, RAM_SIZE_BYTES) &&
        !is_range_valid(addr, len, FLASH_BASE, FLASH_SIZE_BYTES)) {
        uart_write("ERR: out of range\r\n");
        return;
    }

    const uint8_t *p = (const uint8_t *)(uintptr_t)addr;
    uint32_t remaining = len;
    uint32_t cur = addr;
    while (remaining) {
        uint32_t chunk = (remaining > 16u) ? 16u : remaining;
        uint8_t tmp[16];
        for (uint32_t i = 0; i < chunk; i++) tmp[i] = p[i];
        print_hex_line(cur, tmp, chunk);
        p += chunk;
        cur += chunk;
        remaining -= chunk;
    }
#endif
}

static void cmd_read_flash(int argc, char **argv)
{
    if (argc < 3) {
        uart_write("Usage: read_flash <addr> <len>\r\n");
        return;
    }
    uint32_t addr = 0, len = 0;
    if (!parse_u32(argv[1], &addr) || !parse_u32(argv[2], &len)) {
        uart_write("ERR: invalid args\r\n");
        return;
    }
    if (!is_range_valid(addr, len, FLASH_BASE, FLASH_SIZE_BYTES)) {
        uart_write("ERR: out of range\r\n");
        return;
    }

    const uint8_t *p = (const uint8_t *)platform_flash_map_addr(addr);
    uint32_t remaining = len;
    uint32_t cur = addr;
    while (remaining) {
        uint32_t chunk = (remaining > 16u) ? 16u : remaining;
        uint8_t tmp[16];
        for (uint32_t i = 0; i < chunk; i++) tmp[i] = p[i];
        print_hex_line(cur, tmp, chunk);
        p += chunk;
        cur += chunk;
        remaining -= chunk;
    }
}

static void cmd_get_config(int argc, char **argv)
{
    (void)argc; (void)argv;
    device_config_t cfg;
    if (!config_read(&cfg)) {
        uart_write("ERR: config invalid\r\n");
        return;
    }
    uart_printf("magic=0x%08lx\r\n", (unsigned long)cfg.magic);
    uart_printf("version=%lu\r\n", (unsigned long)cfg.version);
    uart_printf("flags=0x%08lx\r\n", (unsigned long)cfg.flags);
    uart_printf("device_id=%lu\r\n", (unsigned long)cfg.device_id);
    uart_printf("baud=%lu\r\n", (unsigned long)cfg.baud);
    uart_printf("name=%s\r\n", cfg.name);
    uart_printf("crc32=0x%08lx\r\n", (unsigned long)cfg.crc32);
}

static void cmd_jtag(int argc, char **argv)
{
    if (argc < 2) {
        uart_write("Usage: jtag <on|off|status>\r\n");
        return;
    }
    if (strcmp(argv[1], "on") == 0) {
        jtag_set_enabled(true);
        uart_write("OK\r\n");
    } else if (strcmp(argv[1], "off") == 0) {
        jtag_set_enabled(false);
        uart_write("OK\r\n");
    } else if (strcmp(argv[1], "status") == 0) {
        uart_printf("jtag=%s\r\n", g_jtag_enabled ? "on" : "off");
    } else {
        uart_write("ERR: invalid arg\r\n");
    }
}

static void cmd_uptime(int argc, char **argv)
{
    (void)argc; (void)argv;
    uart_printf("uptime_ms=%lu\r\n", (unsigned long)system_uptime_ms());
}

static void cmd_reset(int argc, char **argv)
{
#if !SHELL_ENABLE_DANGEROUS
    (void)argc; (void)argv;
    uart_write("ERR: disabled\r\n");
#else
    (void)argc; (void)argv;
    uart_write("Resetting...\r\n");
    g_uart.flush();
    system_reset();
#endif
}

typedef void (*cmd_fn_t)(int argc, char **argv);

typedef struct {
    const char *name;
    cmd_fn_t fn;
    const char *help;
} shell_cmd_t;

static void cmd_help(int argc, char **argv);

static const shell_cmd_t g_cmds[] = {
    { "help",        cmd_help,        "List commands" },
    { "dump_memory", cmd_dump_memory, "Dump memory: dump_memory <addr> <len>" },
    { "read_flash",  cmd_read_flash,  "Read flash: read_flash <addr> <len>" },
    { "get_config",  cmd_get_config,  "Print device configuration" },
    { "jtag",        cmd_jtag,        "JTAG control: jtag <on|off|status>" },
    { "uptime",      cmd_uptime,      "Print uptime (ms)" },
    { "reset",       cmd_reset,       "Reset device" },
};

static void cmd_help(int argc, char **argv)
{
    (void)argc; (void)argv;
    uart_write("Commands:\r\n");
    for (size_t i = 0; i < (sizeof(g_cmds)/sizeof(g_cmds[0])); i++) {
        uart_printf("  %s - %s\r\n", g_cmds[i].name, g_cmds[i].help);
    }
}

static int tokenize(char *line, char **argv, int max_tokens)
{
    int argc = 0;
    char *p = line;

    while (*p && argc < max_tokens) {
        while (*p == ' ' || *p == '\t' || *p == '\r' || *p == '\n') p++;
        if (!*p) break;

        if (*p == '"') {
            p++;
            argv[argc++] = p;
            while (*p && *p != '"') p++;
            if (*p == '"') { *p = '\0'; p++; }
        } else {
            argv[argc++] = p;
            while (*p && *p != ' ' && *p != '\t' && *p != '\r' && *p != '\n') p++;
            if (*p) { *p = '\0'; p++; }
        }
    }
    return argc;
}

static void shell_execute(char *line)
{
    char *argv[SHELL_MAX_TOKENS];
    int argc = tokenize(line, argv, (int)SHELL_MAX_TOKENS);
    if (argc <= 0) return;

    for (size_t i = 0; i < (sizeof(g_cmds)/sizeof(g_cmds[0])); i++) {
        if (strcmp(argv[0], g_cmds[i].name) == 0) {
            g_cmds[i].fn(argc, argv);
            return;
        }
    }
    uart_write("ERR: unknown command (type 'help')\r\n");
}

static char g_rx_line[SHELL_RX_BUF_SIZE];
static size_t g_rx_len = 0;

static void shell_prompt(void)
{
    uart_write(SHELL_PROMPT);
}

static void shell_banner(void)
{
    uart_write("\r\nIndustrial IoT Diagnostic Console\r\n");
    uart_printf("UART=%lu\r\n", (unsigned long)g_shell_baud);
    uart_printf("JTAG=%s\r\n", g_jtag_enabled ? "on" : "off");
    uart_write("Type 'help' for commands.\r\n");
}

static void shell_handle_char(uint8_t ch)
{
    if (ch == '\r' || ch == '\n') {
#if SHELL_ECHO
        uart_write("\r\n");
#endif
        g_rx_line[g_rx_len] = '\0';
        if (g_rx_len > 0) shell_execute(g_rx_line);
        g_rx_len = 0;
        shell_prompt();
        return;
    }

    if (ch == 0x08 || ch == 0x7Fu) {
        if (g_rx_len > 0) {
            g_rx_len--;
#if SHELL_ECHO
            uart_write("\b \b");
#endif
        }
        return;
    }

    if (ch < 32 || ch > 126) return;

    if (g_rx_len < (SHELL_RX_BUF_SIZE - 1u)) {
        g_rx_line[g_rx_len++] = (char)ch;
#if SHELL_ECHO
        uart_putc((char)ch);
#endif
    } else {
#if SHELL_ECHO
        uart_putc('\a');
#endif
    }
}

void diag_console_init(void)
{
    uart_bind_defaults();

    device_config_t cfg;
    if (config_read(&cfg) && cfg.baud != 0u && cfg.baud <= 4000000u) {
        g_shell_baud = cfg.baud;
    } else {
        g_shell_baud = SHELL_UART_BAUD;
    }

#if JTAG_ENABLE_ON_BOOT
    jtag_set_enabled(true);
#else
    jtag_set_enabled(false);
#endif

    g_uart.init(g_shell_baud);
    shell_banner();
    shell_prompt();
}

void diag_console_poll(void)
{
    uint8_t b;
    while (g_uart.read_byte_nonblocking(&b)) {
        shell_handle_char(b);
    }
}