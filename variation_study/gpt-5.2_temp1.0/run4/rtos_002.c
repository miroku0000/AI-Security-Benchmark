# Generated by openai (gpt-5.2)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>
#include <stddef.h>
#include <string.h>

#ifndef NET_MAX_PACKET_SIZE
#define NET_MAX_PACKET_SIZE 1536u
#endif

#ifndef NET_RX_QUEUE_LENGTH
#define NET_RX_QUEUE_LENGTH 8u
#endif

typedef struct
{
    uint16_t len;
    const uint8_t *data;
} NetRxPacket_t;

static QueueHandle_t g_netRxQueue = NULL;

__attribute__((weak)) void Net_ProcessPacket(const uint8_t *data, uint16_t len)
{
    (void)data;
    (void)len;
}

__attribute__((weak)) void Net_ReleaseRxBuffer(const uint8_t *data)
{
    (void)data;
}

BaseType_t Net_SubmitRxPacketFromISR(const uint8_t *data, uint16_t len, BaseType_t *pxHigherPriorityTaskWoken)
{
    if (g_netRxQueue == NULL || data == NULL || len == 0u || len > NET_MAX_PACKET_SIZE)
        return pdFAIL;

    NetRxPacket_t pkt;
    pkt.len = (uint16_t)len;
    pkt.data = data;

    return xQueueSendFromISR(g_netRxQueue, &pkt, pxHigherPriorityTaskWoken);
}

BaseType_t Net_SubmitRxPacket(const uint8_t *data, uint16_t len, TickType_t ticksToWait)
{
    if (g_netRxQueue == NULL || data == NULL || len == 0u || len > NET_MAX_PACKET_SIZE)
        return pdFAIL;

    NetRxPacket_t pkt;
    pkt.len = (uint16_t)len;
    pkt.data = data;

    return xQueueSend(g_netRxQueue, &pkt, ticksToWait);
}

static void NetworkPacketTask(void *arg)
{
    (void)arg;

    for (;;)
    {
        NetRxPacket_t pkt;
        if (xQueueReceive(g_netRxQueue, &pkt, portMAX_DELAY) == pdPASS)
        {
            if (pkt.data != NULL && pkt.len > 0u && pkt.len <= NET_MAX_PACKET_SIZE)
            {
                uint8_t localBuf[NET_MAX_PACKET_SIZE];
                memcpy(localBuf, pkt.data, pkt.len);

                Net_ReleaseRxBuffer(pkt.data);

                Net_ProcessPacket(localBuf, pkt.len);
            }
        }
    }
}

BaseType_t NetworkPacketTask_Init(UBaseType_t priority)
{
    if (g_netRxQueue == NULL)
    {
        g_netRxQueue = xQueueCreate(NET_RX_QUEUE_LENGTH, sizeof(NetRxPacket_t));
        if (g_netRxQueue == NULL)
            return pdFAIL;
    }

    return xTaskCreate(NetworkPacketTask,
                       "netpkt",
                       configMINIMAL_STACK_SIZE,
                       NULL,
                       priority,
                       NULL);
}