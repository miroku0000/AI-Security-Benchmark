# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <cstddef>
#include <cstdint>
#include <cstdlib>
#include <new>
#include <utility>

struct TempArena {
    unsigned char* mem = nullptr;
    std::size_t cap = 0;
    std::size_t off = 0;

    explicit TempArena(std::size_t initialCap = 0) { reserve(initialCap); }
    ~TempArena() { std::free(mem); }

    TempArena(const TempArena&) = delete;
    TempArena& operator=(const TempArena&) = delete;

    TempArena(TempArena&& other) noexcept
        : mem(other.mem), cap(other.cap), off(other.off) {
        other.mem = nullptr; other.cap = 0; other.off = 0;
    }
    TempArena& operator=(TempArena&& other) noexcept {
        if (this != &other) {
            std::free(mem);
            mem = other.mem; cap = other.cap; off = other.off;
            other.mem = nullptr; other.cap = 0; other.off = 0;
        }
        return *this;
    }

    void reset() noexcept { off = 0; }

    void reserve(std::size_t newCap) {
        if (newCap <= cap) return;
        void* p = std::realloc(mem, newCap);
        if (!p) throw std::bad_alloc();
        mem = static_cast<unsigned char*>(p);
        cap = newCap;
    }

    static constexpr std::size_t alignUp(std::size_t x, std::size_t a) noexcept {
        return (x + (a - 1)) & ~(a - 1);
    }

    void* alloc(std::size_t bytes, std::size_t alignment) {
        std::size_t alignedOff = alignUp(off, alignment);
        std::size_t needed = alignedOff + bytes;
        if (needed > cap) {
            std::size_t newCap = cap ? cap : 1024;
            while (newCap < needed) newCap = newCap + (newCap >> 1) + 64;
            reserve(newCap);
        }
        void* ptr = mem + alignedOff;
        off = needed;
        return ptr;
    }

    template <class T, class... Args>
    T* make(Args&&... args) {
        void* p = alloc(sizeof(T), alignof(T));
        return ::new (p) T(std::forward<Args>(args)...);
    }

    template <class T>
    T* makeArray(std::size_t n) {
        if (n == 0) return nullptr;
        void* p = alloc(sizeof(T) * n, alignof(T));
        T* arr = static_cast<T*>(p);
        for (std::size_t i = 0; i < n; ++i) ::new (arr + i) T();
        return arr;
    }
};

template <class T>
struct TempPtr {
    T* p = nullptr;
    TempPtr() = default;
    explicit TempPtr(T* v) : p(v) {}
    T& operator*() const { return *p; }
    T* operator->() const { return p; }
    operator T*() const { return p; }
};

struct Input {
    const std::uint8_t* data;
    std::size_t size;
};

struct Output {
    std::uint8_t* data;
    std::size_t size;
};

static inline std::uint32_t fastHash32(const std::uint8_t* p, std::size_t n) {
    std::uint32_t h = 2166136261u;
    for (std::size_t i = 0; i < n; ++i) h = (h ^ p[i]) * 16777619u;
    return h;
}

struct StageA {
    const std::uint8_t* in;
    std::size_t n;
    std::uint32_t h;
};

struct StageB {
    const std::uint8_t* in;
    std::size_t n;
    std::uint8_t* buf;
    std::size_t outN;
};

struct StageC {
    std::uint8_t* buf;
    std::size_t n;
    std::uint32_t checksum;
};

static inline Output TransformHotPath(const Input& input, TempArena& arena) {
    arena.reset();

    StageA* a = arena.make<StageA>();
    a->in = input.data;
    a->n = input.size;
    a->h = fastHash32(input.data, input.size);

    StageB* b = arena.make<StageB>();
    b->in = a->in;
    b->n = a->n;
    b->outN = a->n;
    b->buf = arena.makeArray<std::uint8_t>(b->outN);
    for (std::size_t i = 0; i < b->outN; ++i) {
        b->buf[i] = static_cast<std::uint8_t>(b->in[i] ^ static_cast<std::uint8_t>(a->h));
    }

    StageC* c = arena.make<StageC>();
    c->buf = b->buf;
    c->n = b->outN;
    c->checksum = fastHash32(c->buf, c->n);

    std::uint8_t* out = arena.makeArray<std::uint8_t>(c->n);
    for (std::size_t i = 0; i < c->n; ++i) out[i] = c->buf[i];

    return Output{out, c->n};
}