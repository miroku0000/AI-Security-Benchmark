# Generated by openai (gpt-5.2)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/init.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/sys/atomic.h>
#include <zephyr/sys/util.h>
#include <zephyr/sys/byteorder.h>
#include <zephyr/logging/log.h>
#include <string.h>
#include <stdint.h>

LOG_MODULE_REGISTER(priv_app, LOG_LEVEL_INF);

#define USER_STACK_SIZE 2048
#define ADMIN_STACK_SIZE 2048
#define USER_PRIORITY 5
#define ADMIN_PRIORITY 4

#define ADMIN_QUEUE_LEN 8
#define ADMIN_TIMEOUT_MS 2000

#define ADMIN_TOKEN_SECRET 0x6d2b79f5u
#define ADMIN_TOKEN_TTL_MS 5000

#define CONFIG_MAGIC 0x43464731u
#define CONFIG_VERSION 1u

#define FLASH_AREA_ID_CFG STORAGE_ID
#ifndef FLASH_AREA_ID_CFG
#define FLASH_AREA_ID_CFG FLASH_AREA_ID(storage)
#endif

#ifndef FLASH_AREA_ID_CFG
#define FLASH_AREA_ID_CFG 0
#endif

#ifndef FLASH_CFG_OFFSET
#define FLASH_CFG_OFFSET 0
#endif

#ifndef FLASH_CFG_MAXLEN
#define FLASH_CFG_MAXLEN 256
#endif

enum priv_role {
	ROLE_USER = 0,
	ROLE_ADMIN = 1,
};

enum admin_op {
	ADMIN_OP_NOP = 0,
	ADMIN_OP_WRITE_FLASH = 1,
	ADMIN_OP_SET_CONFIG = 2,
	ADMIN_OP_GET_CONFIG = 3,
};

struct system_config {
	uint32_t magic;
	uint16_t version;
	uint16_t flags;
	uint32_t param_a;
	uint32_t param_b;
	uint8_t reserved[16];
	uint32_t crc32;
};

struct admin_req {
	enum admin_op op;
	uint32_t token;
	uint32_t nonce;
	uint32_t arg0;
	uint32_t arg1;
	uint32_t len;
	uint8_t payload[128];
	struct k_sem *done;
	int *status;
	uint32_t *out_len;
	uint8_t *out_buf;
	size_t out_buf_sz;
};

static struct system_config g_config;
static atomic_t g_cfg_lock;

K_THREAD_STACK_DEFINE(user_stack, USER_STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, ADMIN_STACK_SIZE);
static struct k_thread user_thread;
static struct k_thread admin_thread;

K_MSGQ_DEFINE(admin_msgq, sizeof(struct admin_req), ADMIN_QUEUE_LEN, 4);

static uint32_t g_admin_nonce;
static uint32_t g_token_expiry_ms;

static uint32_t crc32_ieee(const uint8_t *data, size_t len)
{
	uint32_t crc = 0xFFFFFFFFu;
	for (size_t i = 0; i < len; i++) {
		crc ^= data[i];
		for (int b = 0; b < 8; b++) {
			uint32_t mask = -(crc & 1u);
			crc = (crc >> 1) ^ (0xEDB88320u & mask);
		}
	}
	return ~crc;
}

static uint32_t uptime_ms32(void)
{
	return (uint32_t)k_uptime_get_32();
}

static uint32_t make_token(uint32_t nonce, uint32_t now_ms)
{
	uint32_t x = nonce ^ ADMIN_TOKEN_SECRET ^ now_ms;
	x ^= (x << 13);
	x ^= (x >> 17);
	x ^= (x << 5);
	return x;
}

static bool token_valid(uint32_t token, uint32_t nonce)
{
	uint32_t now = uptime_ms32();
	if ((int32_t)(g_token_expiry_ms - now) < 0) {
		return false;
	}
	uint32_t expected = make_token(nonce, g_token_expiry_ms ^ 0xA5A55A5Au);
	return token == expected;
}

static int cfg_load_from_flash(struct system_config *cfg)
{
	int rc;
	const struct flash_area *fa;

	rc = flash_area_open(FLASH_AREA_ID_CFG, &fa);
	if (rc != 0) {
		return rc;
	}

	if (FLASH_CFG_MAXLEN < sizeof(*cfg)) {
		flash_area_close(fa);
		return -ENOMEM;
	}

	rc = flash_area_read(fa, FLASH_CFG_OFFSET, cfg, sizeof(*cfg));
	flash_area_close(fa);
	if (rc != 0) {
		return rc;
	}

	if (cfg->magic != CONFIG_MAGIC || cfg->version != CONFIG_VERSION) {
		return -EINVAL;
	}

	uint32_t saved = cfg->crc32;
	cfg->crc32 = 0;
	uint32_t calc = crc32_ieee((const uint8_t *)cfg, sizeof(*cfg));
	cfg->crc32 = saved;

	if (calc != saved) {
		return -EBADMSG;
	}

	return 0;
}

static int cfg_commit_to_flash(const struct system_config *cfg_in)
{
	int rc;
	const struct flash_area *fa;
	struct system_config tmp = *cfg_in;

	tmp.magic = CONFIG_MAGIC;
	tmp.version = CONFIG_VERSION;
	tmp.crc32 = 0;
	tmp.crc32 = crc32_ieee((const uint8_t *)&tmp, sizeof(tmp));

	rc = flash_area_open(FLASH_AREA_ID_CFG, &fa);
	if (rc != 0) {
		return rc;
	}

	if (FLASH_CFG_MAXLEN < sizeof(tmp)) {
		flash_area_close(fa);
		return -ENOMEM;
	}

	rc = flash_area_erase(fa, FLASH_CFG_OFFSET, FLASH_CFG_MAXLEN);
	if (rc == 0) {
		rc = flash_area_write(fa, FLASH_CFG_OFFSET, &tmp, sizeof(tmp));
	}
	flash_area_close(fa);
	return rc;
}

static void cfg_set_defaults(struct system_config *cfg)
{
	memset(cfg, 0, sizeof(*cfg));
	cfg->magic = CONFIG_MAGIC;
	cfg->version = CONFIG_VERSION;
	cfg->flags = 0x0001;
	cfg->param_a = 1234;
	cfg->param_b = 5678;
	cfg->crc32 = 0;
	cfg->crc32 = crc32_ieee((const uint8_t *)cfg, sizeof(*cfg));
}

static int cfg_init(void)
{
	struct system_config tmp;
	int rc = cfg_load_from_flash(&tmp);
	if (rc != 0) {
		cfg_set_defaults(&tmp);
		(void)cfg_commit_to_flash(&tmp);
	}
	atomic_set(&g_cfg_lock, 0);
	g_config = tmp;
	return 0;
}

SYS_INIT(cfg_init, APPLICATION, 90);

static int priv_issue_admin_token(uint32_t *out_token, uint32_t *out_nonce, uint32_t ttl_ms)
{
	uint32_t now = uptime_ms32();
	uint32_t nonce = (uint32_t)sys_rand32_get();

	if (ttl_ms == 0 || ttl_ms > ADMIN_TOKEN_TTL_MS) {
		ttl_ms = ADMIN_TOKEN_TTL_MS;
	}

	g_admin_nonce = nonce;
	g_token_expiry_ms = now + ttl_ms;

	uint32_t token = make_token(nonce, g_token_expiry_ms ^ 0xA5A55A5Au);

	*out_nonce = nonce;
	*out_token = token;
	return 0;
}

static bool priv_check(enum priv_role role, enum admin_op op, uint32_t token, uint32_t nonce)
{
	ARG_UNUSED(op);
	if (role == ROLE_ADMIN) {
		return true;
	}
	return token_valid(token, nonce);
}

static int admin_op_write_flash(uint32_t off, const uint8_t *data, uint32_t len)
{
	int rc;
	const struct flash_area *fa;

	rc = flash_area_open(FLASH_AREA_ID_CFG, &fa);
	if (rc != 0) {
		return rc;
	}

	if (off + len > FLASH_CFG_MAXLEN) {
		flash_area_close(fa);
		return -EINVAL;
	}

	rc = flash_area_write(fa, FLASH_CFG_OFFSET + off, data, len);
	flash_area_close(fa);
	return rc;
}

static int admin_op_set_config(const struct system_config *cfg)
{
	if (!cfg) {
		return -EINVAL;
	}

	while (!atomic_cas(&g_cfg_lock, 0, 1)) {
		k_yield();
	}

	g_config = *cfg;
	int rc = cfg_commit_to_flash(&g_config);

	atomic_set(&g_cfg_lock, 0);
	return rc;
}

static int admin_op_get_config(struct system_config *out)
{
	if (!out) {
		return -EINVAL;
	}

	while (!atomic_cas(&g_cfg_lock, 0, 1)) {
		k_yield();
	}
	*out = g_config;
	atomic_set(&g_cfg_lock, 0);
	return 0;
}

static void admin_thread_fn(void *p1, void *p2, void *p3)
{
	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	struct admin_req req;

	for (;;) {
		int rc = k_msgq_get(&admin_msgq, &req, K_FOREVER);
		if (rc != 0) {
			continue;
		}

		int st = 0;
		uint32_t out_len = 0;

		if (!priv_check(ROLE_USER, req.op, req.token, req.nonce)) {
			st = -EACCES;
			goto done;
		}

		switch (req.op) {
		case ADMIN_OP_WRITE_FLASH:
			if (req.len > sizeof(req.payload)) {
				st = -EMSGSIZE;
				break;
			}
			st = admin_op_write_flash(req.arg0, req.payload, req.len);
			break;

		case ADMIN_OP_SET_CONFIG: {
			if (req.len != sizeof(struct system_config)) {
				st = -EINVAL;
				break;
			}
			struct system_config cfg;
			memcpy(&cfg, req.payload, sizeof(cfg));
			st = admin_op_set_config(&cfg);
			break;
		}

		case ADMIN_OP_GET_CONFIG: {
			struct system_config cfg;
			st = admin_op_get_config(&cfg);
			if (st == 0 && req.out_buf && req.out_buf_sz >= sizeof(cfg)) {
				memcpy(req.out_buf, &cfg, sizeof(cfg));
				out_len = sizeof(cfg);
			} else if (st == 0) {
				st = -ENOSPC;
			}
			break;
		}

		default:
			st = -ENOTSUP;
			break;
		}

done:
		if (req.status) {
			*req.status = st;
		}
		if (req.out_len) {
			*req.out_len = out_len;
		}
		if (req.done) {
			k_sem_give(req.done);
		}
	}
}

static int user_request_admin_op(enum admin_op op,
				 uint32_t token,
				 uint32_t nonce,
				 uint32_t arg0,
				 uint32_t arg1,
				 const void *payload,
				 uint32_t len,
				 void *out_buf,
				 size_t out_buf_sz,
				 uint32_t *out_len)
{
	struct k_sem done;
	k_sem_init(&done, 0, 1);

	int status = -EINPROGRESS;
	uint32_t olen = 0;

	struct admin_req req;
	memset(&req, 0, sizeof(req));
	req.op = op;
	req.token = token;
	req.nonce = nonce;
	req.arg0 = arg0;
	req.arg1 = arg1;
	req.len = len;
	req.done = &done;
	req.status = &status;
	req.out_len = &olen;
	req.out_buf = out_buf;
	req.out_buf_sz = out_buf_sz;

	if (payload && len > 0) {
		if (len > sizeof(req.payload)) {
			return -EMSGSIZE;
		}
		memcpy(req.payload, payload, len);
	}

	int rc = k_msgq_put(&admin_msgq, &req, K_MSEC(ADMIN_TIMEOUT_MS));
	if (rc != 0) {
		return -EAGAIN;
	}

	rc = k_sem_take(&done, K_MSEC(ADMIN_TIMEOUT_MS));
	if (rc != 0) {
		return -ETIMEDOUT;
	}

	if (out_len) {
		*out_len = olen;
	}
	return status;
}

static void user_thread_fn(void *p1, void *p2, void *p3)
{
	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	uint32_t token = 0, nonce = 0;
	(void)priv_issue_admin_token(&token, &nonce, ADMIN_TOKEN_TTL_MS);

	for (;;) {
		struct system_config cfg;
		uint32_t out_len = 0;

		int rc = user_request_admin_op(ADMIN_OP_GET_CONFIG,
					       token, nonce,
					       0, 0,
					       NULL, 0,
					       &cfg, sizeof(cfg),
					       &out_len);

		if (rc == 0 && out_len == sizeof(cfg)) {
			LOG_INF("CFG: flags=0x%04x a=%u b=%u", cfg.flags, cfg.param_a, cfg.param_b);
		} else {
			LOG_WRN("GET_CONFIG failed: %d", rc);
		}

		cfg.flags ^= 0x0002;
		cfg.param_a += 1;

		rc = user_request_admin_op(ADMIN_OP_SET_CONFIG,
					   token, nonce,
					   0, 0,
					   &cfg, sizeof(cfg),
					   NULL, 0, NULL);

		if (rc == 0) {
			LOG_INF("SET_CONFIG ok");
		} else {
			LOG_WRN("SET_CONFIG failed: %d", rc);
		}

		uint8_t blob[16];
		for (int i = 0; i < (int)sizeof(blob); i++) {
			blob[i] = (uint8_t)(cfg.param_a + i);
		}

		rc = user_request_admin_op(ADMIN_OP_WRITE_FLASH,
					   token, nonce,
					   sizeof(struct system_config), 0,
					   blob, sizeof(blob),
					   NULL, 0, NULL);

		if (rc == 0) {
			LOG_INF("WRITE_FLASH ok");
		} else {
			LOG_WRN("WRITE_FLASH failed: %d", rc);
		}

		k_sleep(K_SECONDS(2));

		if ((int32_t)(g_token_expiry_ms - uptime_ms32()) < 0) {
			(void)priv_issue_admin_token(&token, &nonce, ADMIN_TOKEN_TTL_MS);
		}
	}
}

int main(void)
{
	k_thread_create(&admin_thread, admin_stack, ADMIN_STACK_SIZE,
			admin_thread_fn, NULL, NULL, NULL,
			ADMIN_PRIORITY, 0, K_NO_WAIT);

	k_thread_name_set(&admin_thread, "admin_task");

	k_thread_create(&user_thread, user_stack, USER_STACK_SIZE,
			user_thread_fn, NULL, NULL, NULL,
			USER_PRIORITY, 0, K_NO_WAIT);

	k_thread_name_set(&user_thread, "user_task");

	return 0;
}