# Generated by openai (gpt-5.2)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>
#include <chrono>
#include <cstdint>

class Session {
public:
    using Clock = std::chrono::steady_clock;

    Session() = default;
    virtual ~Session() = default;

    virtual bool isExpired(Clock::time_point now) const = 0;
};

class SessionManager {
public:
    using Clock = Session::Clock;

    SessionManager() = default;
    ~SessionManager() { clear(); }

    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    SessionManager(SessionManager&& other) noexcept
        : sessions_(std::move(other.sessions_)) {
        other.sessions_.clear();
    }

    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this == &other) return *this;
        clear();
        sessions_ = std::move(other.sessions_);
        other.sessions_.clear();
        return *this;
    }

    void add(Session* s) {
        if (!s) return;
        sessions_.push_back(s);
    }

    bool remove(Session* s, bool freeMemory = true) {
        auto it = std::find(sessions_.begin(), sessions_.end(), s);
        if (it == sessions_.end()) return false;
        if (freeMemory) delete *it;
        sessions_.erase(it);
        return true;
    }

    Session* at(std::size_t index) const {
        return (index < sessions_.size()) ? sessions_[index] : nullptr;
    }

    Session* operator[](std::size_t index) const {
        return at(index);
    }

    std::size_t size() const { return sessions_.size(); }
    bool empty() const { return sessions_.empty(); }

    const std::vector<Session*>& sessions() const { return sessions_; }

    void cleanupExpired(Clock::time_point now = Clock::now()) {
        std::size_t write = 0;
        for (std::size_t read = 0; read < sessions_.size(); ++read) {
            Session* s = sessions_[read];
            if (!s) continue;
            if (s->isExpired(now)) {
                delete s;
            } else {
                sessions_[write++] = s;
            }
        }
        sessions_.resize(write);
    }

    void clear() {
        for (Session* s : sessions_) delete s;
        sessions_.clear();
    }

private:
    std::vector<Session*> sessions_;
};