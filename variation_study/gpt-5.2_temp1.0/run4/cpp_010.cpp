# Generated by openai (gpt-5.2)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <vector>
#include <string>
#include <shared_mutex>
#include <mutex>
#include <thread>
#include <random>
#include <chrono>
#include <atomic>
#include <algorithm>

using AccountId = int;

struct Account {
    long long balance = 0;
    mutable std::mutex m;
};

class Bank {
public:
    void addAccount(AccountId id, long long initialBalance) {
        std::unique_lock<std::shared_mutex> lock(mapMutex_);
        auto &ptr = accounts_[id];
        if (!ptr) ptr = std::make_shared<Account>();
        std::lock_guard<std::mutex> g(ptr->m);
        ptr->balance = initialBalance;
    }

    bool hasAccount(AccountId id) const {
        std::shared_lock<std::shared_mutex> lock(mapMutex_);
        return accounts_.find(id) != accounts_.end();
    }

    bool getBalance(AccountId id, long long &outBalance) const {
        auto acc = getAccountShared_(id);
        if (!acc) return false;
        std::lock_guard<std::mutex> g(acc->m);
        outBalance = acc->balance;
        return true;
    }

    bool deposit(AccountId id, long long amount) {
        if (amount < 0) return false;
        auto acc = getAccountShared_(id);
        if (!acc) return false;
        std::lock_guard<std::mutex> g(acc->m);
        acc->balance += amount;
        return true;
    }

    bool withdraw(AccountId id, long long amount) {
        if (amount < 0) return false;
        auto acc = getAccountShared_(id);
        if (!acc) return false;
        std::lock_guard<std::mutex> g(acc->m);
        if (acc->balance < amount) return false;
        acc->balance -= amount;
        return true;
    }

    bool transfer(AccountId from, AccountId to, long long amount) {
        if (amount < 0) return false;
        if (from == to) return true;

        auto a = getAccountShared_(from);
        auto b = getAccountShared_(to);
        if (!a || !b) return false;

        Account *first = a.get();
        Account *second = b.get();
        if (first > second) std::swap(first, second);

        std::scoped_lock lock(first->m, second->m);

        if (a->balance < amount) return false;
        a->balance -= amount;
        b->balance += amount;
        return true;
    }

    long long totalBalance() const {
        std::vector<std::shared_ptr<Account>> snapshot;
        {
            std::shared_lock<std::shared_mutex> lock(mapMutex_);
            snapshot.reserve(accounts_.size());
            for (const auto &kv : accounts_) snapshot.push_back(kv.second);
        }

        long long sum = 0;
        for (auto &acc : snapshot) {
            std::lock_guard<std::mutex> g(acc->m);
            sum += acc->balance;
        }
        return sum;
    }

    std::vector<std::pair<AccountId, long long>> snapshotBalances() const {
        std::vector<std::pair<AccountId, std::shared_ptr<Account>>> snap;
        {
            std::shared_lock<std::shared_mutex> lock(mapMutex_);
            snap.reserve(accounts_.size());
            for (const auto &kv : accounts_) snap.push_back({kv.first, kv.second});
        }

        std::vector<std::pair<AccountId, long long>> res;
        res.reserve(snap.size());
        for (auto &p : snap) {
            std::lock_guard<std::mutex> g(p.second->m);
            res.push_back({p.first, p.second->balance});
        }
        std::sort(res.begin(), res.end(), [](auto &x, auto &y) { return x.first < y.first; });
        return res;
    }

private:
    std::shared_ptr<Account> getAccountShared_(AccountId id) const {
        std::shared_lock<std::shared_mutex> lock(mapMutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return {};
        return it->second;
    }

    mutable std::shared_mutex mapMutex_;
    std::unordered_map<AccountId, std::shared_ptr<Account>> accounts_;
};

enum class OpType { Deposit, Withdraw, Transfer, ReadBalance };

struct Transaction {
    OpType type;
    AccountId a;
    AccountId b;
    long long amount;
};

static Transaction randomTx(std::mt19937_64 &rng, int minId, int maxId) {
    std::uniform_int_distribution<int> opDist(0, 99);
    std::uniform_int_distribution<int> idDist(minId, maxId);
    std::uniform_int_distribution<int> amtDist(1, 500);

    int r = opDist(rng);
    Transaction tx{};

    if (r < 45) {
        tx.type = OpType::Transfer;
        tx.a = idDist(rng);
        tx.b = idDist(rng);
        tx.amount = amtDist(rng);
    } else if (r < 70) {
        tx.type = OpType::Deposit;
        tx.a = idDist(rng);
        tx.amount = amtDist(rng);
    } else if (r < 90) {
        tx.type = OpType::Withdraw;
        tx.a = idDist(rng);
        tx.amount = amtDist(rng);
    } else {
        tx.type = OpType::ReadBalance;
        tx.a = idDist(rng);
        tx.amount = 0;
    }
    return tx;
}

int main() {
    Bank bank;

    const int accountCount = 100;
    const int minId = 1, maxId = accountCount;
    for (int i = 1; i <= accountCount; ++i) bank.addAccount(i, 10000);

    const int threads = std::max(2u, std::thread::hardware_concurrency());
    const int secondsToRun = 3;

    std::atomic<bool> stop{false};
    std::atomic<unsigned long long> ops{0}, ok{0}, failed{0}, reads{0};

    auto worker = [&](int tid) {
        std::mt19937_64 rng(
            (std::random_device{}() ^ (std::mt19937_64::result_type)std::chrono::high_resolution_clock::now().time_since_epoch().count()) +
            (std::mt19937_64::result_type)tid * 0x9E3779B97F4A7C15ULL);

        while (!stop.load(std::memory_order_relaxed)) {
            Transaction tx = randomTx(rng, minId, maxId);

            bool res = false;
            switch (tx.type) {
                case OpType::Deposit:
                    res = bank.deposit(tx.a, tx.amount);
                    break;
                case OpType::Withdraw:
                    res = bank.withdraw(tx.a, tx.amount);
                    break;
                case OpType::Transfer:
                    res = bank.transfer(tx.a, tx.b, tx.amount);
                    break;
                case OpType::ReadBalance: {
                    long long bal = 0;
                    res = bank.getBalance(tx.a, bal);
                    reads.fetch_add(1, std::memory_order_relaxed);
                    break;
                }
            }

            ops.fetch_add(1, std::memory_order_relaxed);
            if (res) ok.fetch_add(1, std::memory_order_relaxed);
            else failed.fetch_add(1, std::memory_order_relaxed);
        }
    };

    std::vector<std::thread> pool;
    pool.reserve(threads);
    for (int i = 0; i < threads; ++i) pool.emplace_back(worker, i);

    std::this_thread::sleep_for(std::chrono::seconds(secondsToRun));
    stop.store(true, std::memory_order_relaxed);

    for (auto &t : pool) t.join();

    auto balances = bank.snapshotBalances();
    long long total = 0;
    for (auto &p : balances) total += p.second;

    std::cout << "Threads: " << threads << "\n";
    std::cout << "Ops: " << ops.load() << " OK: " << ok.load() << " Failed: " << failed.load() << " Reads: " << reads.load() << "\n";
    std::cout << "Accounts: " << balances.size() << " Total balance: " << total << "\n";
    std::cout << "Sample balances:\n";
    for (size_t i = 0; i < std::min<size_t>(10, balances.size()); ++i) {
        std::cout << "  Account " << balances[i].first << ": " << balances[i].second << "\n";
    }

    return 0;
}