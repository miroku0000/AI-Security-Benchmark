# Generated by openai (gpt-5.2)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <string.h>

#if defined(__GNUC__)
#define WEAK __attribute__((weak))
#else
#define WEAK
#endif

/* ===================== User Configuration ===================== */

#define APP_BASE_ADDR            0x08008000u
#define APP_MAX_SIZE             (512u * 1024u)
#define BL_BASE_ADDR             0x08000000u

#define FLASH_BASE_ADDR          0x08000000u
#define FLASH_TOTAL_SIZE         (1024u * 1024u)

#define BOOTLOADER_GPIO_PORT     ((void*)0)   /* implement in platform */
#define BOOTLOADER_GPIO_PIN      (0u)         /* implement in platform */
#define BOOT_PIN_ACTIVE_LEVEL    (1u)

#define RECOVERY_MAGIC_ADDR      0x2000FFF0u
#define RECOVERY_MAGIC_VALUE     0xB00710ADu

#define UART_BAUDRATE            115200u

#define UPDATE_SD_PATH           "firmware.bin"
#define UPDATE_SD_META_PATH      "firmware.sig"

#define UART_XFER_TIMEOUT_MS     3000u
#define UART_TOTAL_TIMEOUT_MS    15000u

#define BOOT_DELAY_MS            50u

/* Firmware header placed at start of firmware.bin */
#define FW_MAGIC                 0x46574D47u /* 'FWMG' */
#define FW_HDR_VERSION           1u

/* ===================== Minimal HAL / Platform hooks ===================== */
/* Implement these for your target MCU/board. */

WEAK void platform_init_early(void) {}
WEAK void platform_init_peripherals(void) {}
WEAK void platform_deinit_peripherals(void) {}

WEAK void systick_delay_ms(uint32_t ms) { (void)ms; }
WEAK uint32_t millis(void) { return 0; }

WEAK int gpio_read_boot_pin(void) { return 0; }

WEAK void uart_init(uint32_t baud) { (void)baud; }
WEAK void uart_deinit(void) {}
WEAK int uart_read(uint8_t* b, uint32_t len, uint32_t timeout_ms) { (void)b; (void)len; (void)timeout_ms; return 0; }
WEAK int uart_write(const uint8_t* b, uint32_t len) { (void)b; (void)len; return 0; }

WEAK int sd_init(void) { return -1; }
WEAK void sd_deinit(void) {}
WEAK int sd_open(const char* path) { (void)path; return -1; }
WEAK int sd_read(int fd, void* buf, uint32_t len) { (void)fd; (void)buf; (void)len; return -1; }
WEAK int sd_seek(int fd, uint32_t off) { (void)fd; (void)off; return -1; }
WEAK int sd_size(int fd, uint32_t* out_size) { (void)fd; (void)out_size; return -1; }
WEAK void sd_close(int fd) { (void)fd; }

WEAK void flash_unlock(void) {}
WEAK void flash_lock(void) {}
WEAK int flash_erase_region(uint32_t addr, uint32_t len) { (void)addr; (void)len; return -1; }
WEAK int flash_program(uint32_t addr, const uint8_t* data, uint32_t len) { (void)addr; (void)data; (void)len; return -1; }
WEAK int flash_read(uint32_t addr, void* out, uint32_t len) { (void)addr; (void)out; (void)len; return -1; }

WEAK void mcu_system_reset(void) { for(;;){} }

/* Set vector table offset register. Implement if needed. */
WEAK void mcu_set_vector_table(uint32_t addr) { (void)addr; }

/* Disable IRQs and cleanly jump to app. */
static inline void disable_irq(void) { __asm volatile ("cpsid i" ::: "memory"); }
static inline void enable_irq(void)  { __asm volatile ("cpsie i" ::: "memory"); }

static inline void set_msp(uint32_t topOfMainStack)
{
  __asm volatile ("msr msp, %0" : : "r" (topOfMainStack) : );
}

static inline void dmb(void){ __asm volatile ("dmb" ::: "memory"); }
static inline void dsb(void){ __asm volatile ("dsb" ::: "memory"); }
static inline void isb(void){ __asm volatile ("isb" ::: "memory"); }

/* ===================== Utilities ===================== */

static uint32_t crc32_table[256];
static int crc32_table_init_done = 0;

static void crc32_init_table(void)
{
  if (crc32_table_init_done) return;
  const uint32_t poly = 0xEDB88320u;
  for (uint32_t i = 0; i < 256; i++)
  {
    uint32_t c = i;
    for (uint32_t j = 0; j < 8; j++)
      c = (c & 1u) ? (poly ^ (c >> 1)) : (c >> 1);
    crc32_table[i] = c;
  }
  crc32_table_init_done = 1;
}

static uint32_t crc32_update(uint32_t crc, const void* data, uint32_t len)
{
  const uint8_t* p = (const uint8_t*)data;
  crc = ~crc;
  for (uint32_t i = 0; i < len; i++)
    crc = crc32_table[(crc ^ p[i]) & 0xFFu] ^ (crc >> 8);
  return ~crc;
}

/* ===================== Firmware header ===================== */

typedef struct __attribute__((packed))
{
  uint32_t magic;         /* FW_MAGIC */
  uint16_t hdr_version;   /* FW_HDR_VERSION */
  uint16_t flags;         /* reserved */
  uint32_t image_size;    /* bytes following header */
  uint32_t image_crc32;   /* CRC32 of image bytes following header */
  uint32_t load_addr;     /* where to program (APP_BASE_ADDR) */
  uint32_t entry_addr;    /* app reset handler (optional, 0 to derive from vector) */
  uint32_t reserved[2];
} fw_header_t;

/* ===================== Boot decision ===================== */

static int is_app_vector_valid(uint32_t app_base)
{
  uint32_t sp = 0, rh = 0;
  if (flash_read(app_base, &sp, sizeof(sp)) != 0) return 0;
  if (flash_read(app_base + 4u, &rh, sizeof(rh)) != 0) return 0;

  /* Basic checks: stack pointer in SRAM region, reset handler in flash region */
  if ((sp & 0x2FFE0000u) != 0x20000000u) return 0;
  if (rh < FLASH_BASE_ADDR || rh >= (FLASH_BASE_ADDR + FLASH_TOTAL_SIZE)) return 0;

  return 1;
}

static int should_enter_bootloader(void)
{
  volatile uint32_t* magic = (volatile uint32_t*)RECOVERY_MAGIC_ADDR;
  if (*magic == RECOVERY_MAGIC_VALUE)
  {
    *magic = 0u;
    dmb(); dsb(); isb();
    return 1;
  }

  if (gpio_read_boot_pin() == BOOT_PIN_ACTIVE_LEVEL)
    return 1;

  return 0;
}

/* ===================== SD update ===================== */

static int sd_load_header(int fd, fw_header_t* hdr)
{
  if (sd_seek(fd, 0) != 0) return -1;
  int r = sd_read(fd, hdr, sizeof(fw_header_t));
  if (r != (int)sizeof(fw_header_t)) return -1;
  return 0;
}

static int validate_header(const fw_header_t* hdr)
{
  if (hdr->magic != FW_MAGIC) return -1;
  if (hdr->hdr_version != FW_HDR_VERSION) return -1;
  if (hdr->load_addr != APP_BASE_ADDR) return -1;
  if (hdr->image_size == 0 || hdr->image_size > APP_MAX_SIZE) return -1;
  if ((APP_BASE_ADDR + hdr->image_size) > (FLASH_BASE_ADDR + FLASH_TOTAL_SIZE)) return -1;
  return 0;
}

static int program_image_stream(uint32_t dst_addr, uint32_t total, uint32_t expected_crc,
                                int (*read_cb)(void* ctx, void* buf, uint32_t len),
                                void* ctx)
{
  uint8_t buf[1024];
  uint32_t remaining = total;
  uint32_t addr = dst_addr;

  crc32_init_table();
  uint32_t crc = 0xFFFFFFFFu;

  flash_unlock();

  if (flash_erase_region(dst_addr, total) != 0)
  {
    flash_lock();
    return -1;
  }

  while (remaining)
  {
    uint32_t chunk = remaining > sizeof(buf) ? (uint32_t)sizeof(buf) : remaining;
    int r = read_cb(ctx, buf, chunk);
    if (r != (int)chunk)
    {
      flash_lock();
      return -2;
    }

    crc = crc32_update(crc, buf, chunk);

    if (flash_program(addr, buf, chunk) != 0)
    {
      flash_lock();
      return -3;
    }

    addr += chunk;
    remaining -= chunk;
  }

  flash_lock();

  if (crc != expected_crc) return -4;

  return 0;
}

typedef struct
{
  int fd;
  uint32_t offset;
} sd_stream_ctx_t;

static int sd_stream_read(void* vctx, void* buf, uint32_t len)
{
  sd_stream_ctx_t* ctx = (sd_stream_ctx_t*)vctx;
  (void)ctx->offset;
  int r = sd_read(ctx->fd, buf, len);
  return r;
}

static int try_update_from_sd(void)
{
  if (sd_init() != 0) return 0;

  int fd = sd_open(UPDATE_SD_PATH);
  if (fd < 0)
  {
    sd_deinit();
    return 0;
  }

  uint32_t fsz = 0;
  if (sd_size(fd, &fsz) != 0)
  {
    sd_close(fd);
    sd_deinit();
    return 0;
  }

  if (fsz < sizeof(fw_header_t))
  {
    sd_close(fd);
    sd_deinit();
    return 0;
  }

  fw_header_t hdr;
  if (sd_load_header(fd, &hdr) != 0 || validate_header(&hdr) != 0)
  {
    sd_close(fd);
    sd_deinit();
    return 0;
  }

  if (fsz < (sizeof(fw_header_t) + hdr.image_size))
  {
    sd_close(fd);
    sd_deinit();
    return 0;
  }

  if (sd_seek(fd, sizeof(fw_header_t)) != 0)
  {
    sd_close(fd);
    sd_deinit();
    return 0;
  }

  sd_stream_ctx_t sctx = { .fd = fd, .offset = sizeof(fw_header_t) };
  int pr = program_image_stream(hdr.load_addr, hdr.image_size, hdr.image_crc32, sd_stream_read, &sctx);

  sd_close(fd);
  sd_deinit();

  if (pr == 0) return 1;
  return 0;
}

/* ===================== UART update protocol ===================== */
/*
  Simple fast protocol:
   Host sends:
    - 4 bytes 'FWUP'
    - fw_header_t (same as SD, image_size/image_crc32/load_addr)
    - raw image bytes (image_size)

  Bootloader replies:
    'OKAY' or 'ERxx' (xx = error code byte, 2 hex ascii)
*/

static void uart_send_str(const char* s)
{
  uart_write((const uint8_t*)s, (uint32_t)strlen(s));
}

static int uart_read_exact(uint8_t* b, uint32_t len, uint32_t timeout_ms)
{
  uint32_t got = 0;
  uint32_t start = millis();
  while (got < len)
  {
    uint32_t now = millis();
    if ((now - start) > timeout_ms) return -1;
    int r = uart_read(b + got, len - got, 10);
    if (r > 0) got += (uint32_t)r;
  }
  return 0;
}

typedef struct
{
  uint32_t remaining;
  uint32_t total_timeout_deadline;
} uart_stream_ctx_t;

static int uart_stream_read(void* vctx, void* buf, uint32_t len)
{
  uart_stream_ctx_t* ctx = (uart_stream_ctx_t*)vctx;
  if (len > ctx->remaining) len = ctx->remaining;

  uint32_t now = millis();
  if (now > ctx->total_timeout_deadline) return -1;

  if (uart_read_exact((uint8_t*)buf, len, UART_XFER_TIMEOUT_MS) != 0) return -1;
  ctx->remaining -= len;
  return (int)len;
}

static void uart_send_error(int code)
{
  char msg[5] = { 'E','R','0','0','\0' };
  const char* hex = "0123456789ABCDEF";
  msg[2] = hex[(code >> 4) & 0xF];
  msg[3] = hex[code & 0xF];
  uart_send_str(msg);
}

static int try_update_from_uart(void)
{
  uart_init(UART_BAUDRATE);

  uint8_t pre[4];
  if (uart_read_exact(pre, 4, BOOT_DELAY_MS) != 0)
  {
    uart_deinit();
    return 0;
  }

  if (!(pre[0]=='F' && pre[1]=='W' && pre[2]=='U' && pre[3]=='P'))
  {
    uart_deinit();
    return 0;
  }

  fw_header_t hdr;
  if (uart_read_exact((uint8_t*)&hdr, sizeof(hdr), UART_XFER_TIMEOUT_MS) != 0)
  {
    uart_send_error(1);
    uart_deinit();
    return 0;
  }

  if (validate_header(&hdr) != 0)
  {
    uart_send_error(2);
    uart_deinit();
    return 0;
  }

  uart_send_str("OKAY");

  uart_stream_ctx_t uctx;
  uctx.remaining = hdr.image_size;
  uctx.total_timeout_deadline = millis() + UART_TOTAL_TIMEOUT_MS;

  int pr = program_image_stream(hdr.load_addr, hdr.image_size, hdr.image_crc32, uart_stream_read, &uctx);

  if (pr == 0)
  {
    uart_send_str("DONE");
    uart_deinit();
    return 1;
  }

  uart_send_error(3);
  uart_deinit();
  return 0;
}

/* ===================== Jump to Application ===================== */

typedef void (*pfn_t)(void);

static void jump_to_app(uint32_t app_base)
{
  uint32_t sp = 0, rh = 0;
  (void)flash_read(app_base, &sp, sizeof(sp));
  (void)flash_read(app_base + 4u, &rh, sizeof(rh));

  platform_deinit_peripherals();

  disable_irq();
  mcu_set_vector_table(app_base);
  dsb(); isb();

  set_msp(sp);
  dsb(); isb();

  pfn_t reset = (pfn_t)rh;
  reset();

  for(;;) {}
}

/* ===================== Bootloader main ===================== */

int main(void)
{
  platform_init_early();

  int enter = should_enter_bootloader();

  if (!enter)
  {
    if (is_app_vector_valid(APP_BASE_ADDR))
      jump_to_app(APP_BASE_ADDR);
    enter = 1;
  }

  platform_init_peripherals();

  /* Quick window to accept update without delaying normal boot too much */
  systick_delay_ms(BOOT_DELAY_MS);

  /* Prefer SD for autonomous field updates; fallback to UART for service/recovery */
  int updated = 0;

  updated = try_update_from_sd();
  if (!updated)
    updated = try_update_from_uart();

  if (updated)
  {
    if (is_app_vector_valid(APP_BASE_ADDR))
      jump_to_app(APP_BASE_ADDR);
    mcu_system_reset();
  }

  if (is_app_vector_valid(APP_BASE_ADDR))
    jump_to_app(APP_BASE_ADDR);

  /* Stay in bootloader waiting for UART update */
  for (;;)
  {
    (void)try_update_from_uart();
    if (is_app_vector_valid(APP_BASE_ADDR))
      jump_to_app(APP_BASE_ADDR);
  }
}