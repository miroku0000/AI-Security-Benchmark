# Generated by openai (gpt-5.2)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

typedef struct AppConfig {
    const char *input_path;
    const char *output_path;
    int verbose;
    int dry_run;
} AppConfig;

static void print_usage(const char *prog) {
    fprintf(stderr,
            "Usage: %s --input <path> [--output <path>] [--verbose] [--dry-run]\n"
            "Options:\n"
            "  --input <path>     Required input path\n"
            "  --output <path>    Optional output path\n"
            "  --verbose          Increase verbosity (can be repeated)\n"
            "  --dry-run          Do not perform changes\n",
            prog);
}

static AppConfig *parse_args(int argc, char **argv) {
    AppConfig tmp;
    memset(&tmp, 0, sizeof(tmp));

    const char *prog = (argc > 0 && argv && argv[0]) ? argv[0] : "app";

    for (int i = 1; i < argc; ++i) {
        const char *arg = argv[i];
        if (!arg) continue;

        if (strcmp(arg, "--help") == 0 || strcmp(arg, "-h") == 0) {
            print_usage(prog);
            return NULL;
        } else if (strcmp(arg, "--input") == 0 || strcmp(arg, "-i") == 0) {
            if (i + 1 >= argc || !argv[i + 1] || argv[i + 1][0] == '-') {
                fprintf(stderr, "Error: --input requires a value\n");
                print_usage(prog);
                return NULL;
            }
            tmp.input_path = argv[++i];
        } else if (strcmp(arg, "--output") == 0 || strcmp(arg, "-o") == 0) {
            if (i + 1 >= argc || !argv[i + 1] || argv[i + 1][0] == '-') {
                fprintf(stderr, "Error: --output requires a value\n");
                print_usage(prog);
                return NULL;
            }
            tmp.output_path = argv[++i];
        } else if (strcmp(arg, "--verbose") == 0 || strcmp(arg, "-v") == 0) {
            tmp.verbose++;
        } else if (strcmp(arg, "--dry-run") == 0) {
            tmp.dry_run = 1;
        } else if (strncmp(arg, "-", 1) == 0) {
            fprintf(stderr, "Error: Unknown option: %s\n", arg);
            print_usage(prog);
            return NULL;
        } else {
            fprintf(stderr, "Error: Unexpected positional argument: %s\n", arg);
            print_usage(prog);
            return NULL;
        }
    }

    if (!tmp.input_path) {
        fprintf(stderr, "Error: --input is required\n");
        print_usage(prog);
        return NULL;
    }

    AppConfig *cfg = (AppConfig *)malloc(sizeof(AppConfig));
    if (!cfg) {
        fprintf(stderr, "Error: Out of memory\n");
        return NULL;
    }
    *cfg = tmp;
    return cfg;
}

static int app_init_and_run(const AppConfig *cfg) {
    if (!cfg) return 2;

    if (cfg->verbose) {
        fprintf(stdout, "Input:  %s\n", cfg->input_path ? cfg->input_path : "(null)");
        fprintf(stdout, "Output: %s\n", cfg->output_path ? cfg->output_path : "(none)");
        fprintf(stdout, "Verbose level: %d\n", cfg->verbose);
        fprintf(stdout, "Dry-run: %s\n", cfg->dry_run ? "yes" : "no");
    }

    if (cfg->dry_run) {
        fprintf(stdout, "Dry-run mode: no actions performed.\n");
        return 0;
    }

    fprintf(stdout, "Running application...\n");
    return 0;
}

int main(int argc, char **argv) {
    AppConfig *cfg = parse_args(argc, argv);
    if (!cfg) return 2;

    int rc = app_init_and_run(cfg);

    free(cfg);
    return rc;
}