# Generated by openai (gpt-5.2)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>

typedef struct FileNode {
    FILE *fp;
    int owned;
    struct FileNode *next;
} FileNode;

typedef struct FileHandleList {
    FileNode *head;
} FileHandleList;

static FileNode* fhl_find(FileHandleList *list, FILE *fp) {
    if (!list || !fp) return NULL;
    for (FileNode *n = list->head; n; n = n->next) {
        if (n->fp == fp) return n;
    }
    return NULL;
}

void fhl_init(FileHandleList *list) {
    if (!list) return;
    list->head = NULL;
}

int fhl_add(FileHandleList *list, FILE *fp, int owned) {
    if (!list || !fp) return -1;
    if (fhl_find(list, fp)) return 0;

    FileNode *n = (FileNode*)calloc(1, sizeof(*n));
    if (!n) return -1;

    n->fp = fp;
    n->owned = owned ? 1 : 0;
    n->next = list->head;
    list->head = n;
    return 0;
}

int fhl_add_path(FileHandleList *list, const char *path, const char *mode, FILE **out_fp) {
    if (out_fp) *out_fp = NULL;
    if (!list || !path || !mode) return -1;

    FILE *fp = fopen(path, mode);
    if (!fp) return -1;

    if (fhl_add(list, fp, 1) != 0) {
        fclose(fp);
        return -1;
    }

    if (out_fp) *out_fp = fp;
    return 0;
}

int fhl_remove(FileHandleList *list, FILE *fp, int close_if_owned) {
    if (!list || !fp) return -1;

    FileNode **pp = &list->head;
    while (*pp) {
        FileNode *cur = *pp;
        if (cur->fp == fp) {
            *pp = cur->next;

            if (close_if_owned && cur->owned && cur->fp) {
                fclose(cur->fp);
            }

            cur->fp = NULL;
            free(cur);
            return 0;
        }
        pp = &((*pp)->next);
    }
    return -1;
}

size_t fhl_cleanup(FileHandleList *list) {
    if (!list) return 0;

    size_t count = 0;
    FileNode *n = list->head;
    list->head = NULL;

    while (n) {
        FileNode *next = n->next;
        if (n->owned && n->fp) {
            fclose(n->fp);
        }
        n->fp = NULL;
        n->next = NULL;
        free(n);
        n = next;
        count++;
    }
    return count;
}

/* Optional demo main */
#ifdef FILE_HANDLE_LIST_DEMO
int main(void) {
    FileHandleList list;
    fhl_init(&list);

    FILE *a = NULL;
    if (fhl_add_path(&list, "a.txt", "w", &a) != 0) {
        perror("open a.txt");
    }

    FILE *b = fopen("b.txt", "w");
    if (b) {
        fhl_add(&list, b, 0);
    }

    fhl_remove(&list, b, 1);
    if (b) fclose(b);

    fhl_cleanup(&list);
    fhl_cleanup(&list);

    return 0;
}
#endif