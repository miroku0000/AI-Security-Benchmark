# Generated by openai (gpt-5.2)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <stdbool.h>
#include <string.h>
#include <ctype.h>

/* =========================
 * Platform Abstraction Layer
 * ========================= */

/* ---- UART ---- */
#ifndef DBG_UART_BAUD
#define DBG_UART_BAUD 115200u
#endif

#ifndef DBG_UART_RX_BUFSZ
#define DBG_UART_RX_BUFSZ 256u
#endif

#ifndef DBG_UART_TX_BUFSZ
#define DBG_UART_TX_BUFSZ 256u
#endif

/* Implement these for your MCU/HAL */
void plat_uart_init(uint32_t baud);
int  plat_uart_read_byte(uint8_t *b);          /* non-blocking: return 1 if read, 0 if none */
void plat_uart_write(const uint8_t *data, size_t len);
uint32_t plat_millis(void);

/* ---- Flash ---- */
#define FLASH_BASE_ADDR   ((uintptr_t)0x08000000u)
#define FLASH_SIZE_BYTES  ((size_t)0x00100000u) /* 1MB default; override for target */

int  plat_flash_read(uintptr_t addr, void *dst, size_t len); /* return 0 on success */
int  plat_flash_is_addr_valid(uintptr_t addr, size_t len);   /* return 1 valid, 0 invalid */

/* ---- Memory validation (RAM / peripheral windows) ---- */
int  plat_mem_is_addr_valid(uintptr_t addr, size_t len);     /* return 1 valid, 0 invalid */

/* ---- Config ---- */
typedef struct {
    uint32_t device_id;
    uint32_t fw_version;
    uint32_t build_id;
    uint32_t flags;
    char     serial[24];
    char     product[24];
} device_config_t;

int plat_get_config(device_config_t *out); /* return 0 on success */

/* ---- JTAG/SWD pins ---- */
typedef enum {
    DBG_PORT_DISABLE = 0,
    DBG_PORT_SWD     = 1,
    DBG_PORT_JTAG    = 2
} dbg_port_mode_t;

int plat_debug_port_config(dbg_port_mode_t mode, int enable); /* return 0 on success */

/* =========================
 * Minimal safe defaults (weak)
 * ========================= */
#if defined(__GNUC__)
#define WEAK __attribute__((weak))
#else
#define WEAK
#endif

WEAK void plat_uart_init(uint32_t baud) { (void)baud; }
WEAK int  plat_uart_read_byte(uint8_t *b) { (void)b; return 0; }
WEAK void plat_uart_write(const uint8_t *data, size_t len) { (void)data; (void)len; }
WEAK uint32_t plat_millis(void) { return 0; }

WEAK int plat_flash_read(uintptr_t addr, void *dst, size_t len) {
    (void)addr; (void)dst; (void)len;
    return -1;
}
WEAK int plat_flash_is_addr_valid(uintptr_t addr, size_t len) {
    uintptr_t start = FLASH_BASE_ADDR;
    uintptr_t end = FLASH_BASE_ADDR + (uintptr_t)FLASH_SIZE_BYTES;
    if (len == 0) return 0;
    if (addr < start) return 0;
    if (addr + (uintptr_t)len < addr) return 0;
    if (addr + (uintptr_t)len > end) return 0;
    return 1;
}
WEAK int plat_mem_is_addr_valid(uintptr_t addr, size_t len) {
    (void)addr; (void)len;
    return 0;
}
WEAK int plat_get_config(device_config_t *out) {
    if (!out) return -1;
    memset(out, 0, sizeof(*out));
    return -1;
}
WEAK int plat_debug_port_config(dbg_port_mode_t mode, int enable) {
    (void)mode; (void)enable;
    return -1;
}

/* =========================
 * Debug Console / Shell
 * ========================= */

typedef struct {
    char  rx_line[DBG_UART_RX_BUFSZ];
    size_t rx_len;

    uint8_t tx_buf[DBG_UART_TX_BUFSZ];
    size_t tx_len;

    uint32_t last_activity_ms;
    int echo;
} diag_console_t;

static diag_console_t g_console;

static void con_flush(void) {
    if (g_console.tx_len) {
        plat_uart_write(g_console.tx_buf, g_console.tx_len);
        g_console.tx_len = 0;
    }
}

static void con_putc(char c) {
    if (g_console.tx_len >= sizeof(g_console.tx_buf)) con_flush();
    g_console.tx_buf[g_console.tx_len++] = (uint8_t)c;
}

static void con_write(const char *s) {
    if (!s) return;
    while (*s) con_putc(*s++);
}

static void con_writen(const char *s, size_t n) {
    if (!s) return;
    for (size_t i = 0; i < n; i++) con_putc(s[i]);
}

static void con_write_hex_u32(uint32_t v) {
    static const char hexd[] = "0123456789ABCDEF";
    con_write("0x");
    for (int i = 28; i >= 0; i -= 4) con_putc(hexd[(v >> i) & 0xFu]);
}

static void con_write_hex_uptr(uintptr_t v) {
    static const char hexd[] = "0123456789ABCDEF";
    con_write("0x");
    for (int i = (int)((sizeof(uintptr_t) * 8) - 4); i >= 0; i -= 4) con_putc(hexd[(v >> i) & (uintptr_t)0xFu]);
}

static void con_write_dec_u32(uint32_t v) {
    char buf[11];
    size_t n = 0;
    if (v == 0) { con_putc('0'); return; }
    while (v && n < sizeof(buf)) {
        buf[n++] = (char)('0' + (v % 10u));
        v /= 10u;
    }
    while (n) con_putc(buf[--n]);
}

static void con_prompt(void) {
    con_write("\r\n> ");
    con_flush();
}

static void con_banner(void) {
    con_write("\r\n[DIAG] UART console ready @ ");
    con_write_dec_u32(DBG_UART_BAUD);
    con_write(" baud\r\nType 'help' for commands.\r\n");
    con_prompt();
}

static void con_write_mem_hexdump(uintptr_t addr, const uint8_t *data, size_t len, size_t width) {
    (void)width;
    for (size_t i = 0; i < len; i += 16) {
        size_t chunk = (len - i) > 16 ? 16 : (len - i);
        con_write_hex_uptr(addr + i);
        con_write(": ");
        for (size_t j = 0; j < 16; j++) {
            if (j < chunk) {
                static const char hexd[] = "0123456789ABCDEF";
                uint8_t b = data[i + j];
                con_putc(hexd[(b >> 4) & 0xFu]);
                con_putc(hexd[b & 0xFu]);
            } else {
                con_write("  ");
            }
            if (j != 15) con_putc(' ');
        }
        con_write("  |");
        for (size_t j = 0; j < chunk; j++) {
            char c = (char)data[i + j];
            con_putc((c >= 32 && c <= 126) ? c : '.');
        }
        for (size_t j = chunk; j < 16; j++) con_putc(' ');
        con_write("|\r\n");
    }
}

static int token_is_empty(const char *s) {
    if (!s) return 1;
    while (*s) {
        if (!isspace((unsigned char)*s)) return 0;
        s++;
    }
    return 1;
}

static char *skip_ws(char *s) {
    while (s && *s && isspace((unsigned char)*s)) s++;
    return s;
}

static char *next_token(char **ps) {
    char *s = *ps;
    s = skip_ws(s);
    if (!s || !*s) { *ps = s; return NULL; }
    char *start = s;
    while (*s && !isspace((unsigned char)*s)) s++;
    if (*s) *s++ = '\0';
    *ps = s;
    return start;
}

static int parse_u32(const char *s, uint32_t *out) {
    if (!s || !*s || !out) return -1;
    char *end = NULL;
    unsigned long v = 0;
    if ((s[0] == '0') && (s[1] == 'x' || s[1] == 'X')) {
        v = strtoul(s, &end, 16);
    } else {
        v = strtoul(s, &end, 10);
    }
    if (end == s || *end != '\0') return -1;
    if (v > 0xFFFFFFFFul) return -1;
    *out = (uint32_t)v;
    return 0;
}

static int parse_uptr(const char *s, uintptr_t *out) {
    if (!s || !*s || !out) return -1;
    char *end = NULL;
    unsigned long long v = 0;
    if ((s[0] == '0') && (s[1] == 'x' || s[1] == 'X')) {
        v = strtoull(s, &end, 16);
    } else {
        v = strtoull(s, &end, 10);
    }
    if (end == s || *end != '\0') return -1;
    *out = (uintptr_t)v;
    return 0;
}

static void cmd_help(void) {
    con_write(
        "\r\nCommands:\r\n"
        "  help\r\n"
        "  ping\r\n"
        "  echo <0|1>\r\n"
        "  dump_memory <addr> <len>\r\n"
        "  read_flash <addr> <len>\r\n"
        "  get_config\r\n"
        "  jtag <off|swd|jtag>\r\n"
        "  reboot\r\n"
    );
}

static void cmd_ping(void) {
    con_write("\r\nPONG\r\n");
}

static void cmd_echo(char *arg) {
    if (!arg) {
        con_write("\r\nERR missing arg\r\n");
        return;
    }
    uint32_t v = 0;
    if (parse_u32(arg, &v) != 0 || (v != 0 && v != 1)) {
        con_write("\r\nERR echo expects 0 or 1\r\n");
        return;
    }
    g_console.echo = (int)v;
    con_write("\r\nOK\r\n");
}

static void cmd_dump_memory(char *a_addr, char *a_len) {
    uintptr_t addr = 0;
    uint32_t len32 = 0;

    if (!a_addr || !a_len || parse_uptr(a_addr, &addr) != 0 || parse_u32(a_len, &len32) != 0) {
        con_write("\r\nERR usage: dump_memory <addr> <len>\r\n");
        return;
    }
    if (len32 == 0 || len32 > 4096u) {
        con_write("\r\nERR len must be 1..4096\r\n");
        return;
    }
    if (!plat_mem_is_addr_valid(addr, (size_t)len32)) {
        con_write("\r\nERR invalid address range\r\n");
        return;
    }

    uint8_t tmp[128];
    size_t remaining = (size_t)len32;
    uintptr_t cur = addr;

    con_write("\r\n");
    while (remaining) {
        size_t chunk = remaining > sizeof(tmp) ? sizeof(tmp) : remaining;
        memcpy(tmp, (const void *)cur, chunk);
        con_write_mem_hexdump(cur, tmp, chunk, 1);
        cur += chunk;
        remaining -= chunk;
        con_flush();
    }
    con_write("OK\r\n");
}

static void cmd_read_flash(char *a_addr, char *a_len) {
    uintptr_t addr = 0;
    uint32_t len32 = 0;

    if (!a_addr || !a_len || parse_uptr(a_addr, &addr) != 0 || parse_u32(a_len, &len32) != 0) {
        con_write("\r\nERR usage: read_flash <addr> <len>\r\n");
        return;
    }
    if (len32 == 0 || len32 > 4096u) {
        con_write("\r\nERR len must be 1..4096\r\n");
        return;
    }
    if (!plat_flash_is_addr_valid(addr, (size_t)len32)) {
        con_write("\r\nERR invalid flash range\r\n");
        return;
    }

    uint8_t tmp[128];
    size_t remaining = (size_t)len32;
    uintptr_t cur = addr;

    con_write("\r\n");
    while (remaining) {
        size_t chunk = remaining > sizeof(tmp) ? sizeof(tmp) : remaining;
        if (plat_flash_read(cur, tmp, chunk) != 0) {
            con_write("ERR flash read failed\r\n");
            return;
        }
        con_write_mem_hexdump(cur, tmp, chunk, 1);
        cur += chunk;
        remaining -= chunk;
        con_flush();
    }
    con_write("OK\r\n");
}

static void cmd_get_config(void) {
    device_config_t cfg;
    int rc = plat_get_config(&cfg);
    if (rc != 0) {
        con_write("\r\nERR config unavailable\r\n");
        return;
    }

    con_write("\r\nOK\r\n");
    con_write("device_id="); con_write_hex_u32(cfg.device_id); con_write("\r\n");
    con_write("fw_version="); con_write_hex_u32(cfg.fw_version); con_write("\r\n");
    con_write("build_id="); con_write_hex_u32(cfg.build_id); con_write("\r\n");
    con_write("flags="); con_write_hex_u32(cfg.flags); con_write("\r\n");
    con_write("serial="); con_write(cfg.serial); con_write("\r\n");
    con_write("product="); con_write(cfg.product); con_write("\r\n");
}

static void cmd_jtag(char *mode) {
    if (!mode) {
        con_write("\r\nERR usage: jtag <off|swd|jtag>\r\n");
        return;
    }

    dbg_port_mode_t m = DBG_PORT_DISABLE;
    int enable = 0;

    if (strcmp(mode, "off") == 0) { m = DBG_PORT_DISABLE; enable = 0; }
    else if (strcmp(mode, "swd") == 0) { m = DBG_PORT_SWD; enable = 1; }
    else if (strcmp(mode, "jtag") == 0) { m = DBG_PORT_JTAG; enable = 1; }
    else {
        con_write("\r\nERR mode must be off|swd|jtag\r\n");
        return;
    }

    if (plat_debug_port_config(m, enable) != 0) {
        con_write("\r\nERR debug port config failed\r\n");
        return;
    }
    con_write("\r\nOK\r\n");
}

/* Optional reboot hook; implement for your platform */
WEAK void plat_reboot(void) { }

static void cmd_reboot(void) {
    con_write("\r\nOK rebooting...\r\n");
    con_flush();
    plat_reboot();
}

/* =========================
 * Line Processing
 * ========================= */

static void shell_execute_line(char *line) {
    if (!line || token_is_empty(line)) return;

    char *p = line;
    char *cmd = next_token(&p);
    if (!cmd) return;

    if (strcmp(cmd, "help") == 0) {
        cmd_help();
    } else if (strcmp(cmd, "ping") == 0) {
        cmd_ping();
    } else if (strcmp(cmd, "echo") == 0) {
        cmd_echo(next_token(&p));
    } else if (strcmp(cmd, "dump_memory") == 0) {
        cmd_dump_memory(next_token(&p), next_token(&p));
    } else if (strcmp(cmd, "read_flash") == 0) {
        cmd_read_flash(next_token(&p), next_token(&p));
    } else if (strcmp(cmd, "get_config") == 0) {
        cmd_get_config();
    } else if (strcmp(cmd, "jtag") == 0) {
        cmd_jtag(next_token(&p));
    } else if (strcmp(cmd, "reboot") == 0) {
        cmd_reboot();
    } else {
        con_write("\r\nERR unknown cmd\r\n");
    }
}

static void shell_on_rx_char(uint8_t b) {
    g_console.last_activity_ms = plat_millis();

    if (g_console.echo) {
        if (b == '\n') {
            con_write("\r\n");
        } else if (b == '\r') {
            con_write("\r\n");
        } else {
            con_putc((char)b);
        }
        con_flush();
    }

    if (b == '\r' || b == '\n') {
        if (g_console.rx_len >= sizeof(g_console.rx_line)) {
            g_console.rx_len = 0;
            con_write("\r\nERR line too long\r\n");
            con_prompt();
            return;
        }
        g_console.rx_line[g_console.rx_len] = '\0';

        if (g_console.rx_len > 0) {
            shell_execute_line(g_console.rx_line);
        }

        g_console.rx_len = 0;
        con_prompt();
        return;
    }

    if (b == 0x08 || b == 0x7F) { /* backspace/delete */
        if (g_console.rx_len > 0) {
            g_console.rx_len--;
            if (g_console.echo) {
                con_write("\b \b");
                con_flush();
            }
        }
        return;
    }

    if (isprint((int)b) || b == '\t') {
        if (g_console.rx_len < (sizeof(g_console.rx_line) - 1u)) {
            g_console.rx_line[g_console.rx_len++] = (char)b;
        } else {
            g_console.rx_len = 0;
            con_write("\r\nERR line too long\r\n");
            con_prompt();
        }
    }
}

/* =========================
 * Public API
 * ========================= */

void diag_console_init(void) {
    memset(&g_console, 0, sizeof(g_console));
    g_console.echo = 1;
    plat_uart_init(DBG_UART_BAUD);

    /* Default: keep debug port enabled for field diagnostics; adjust as policy requires */
    (void)plat_debug_port_config(DBG_PORT_SWD, 1);

    con_banner();
}

void diag_console_poll(void) {
    uint8_t b;
    while (plat_uart_read_byte(&b) == 1) {
        shell_on_rx_char(b);
    }
    con_flush();
}

/* =========================
 * Example stubs to tailor per platform
 * ========================= */

/* Provide a safe memory map validator for dump_memory.
 * Override plat_mem_is_addr_valid() for your MCU.
 */
WEAK int plat_mem_is_addr_valid(uintptr_t addr, size_t len) {
    if (len == 0) return 0;
    if (addr + (uintptr_t)len < addr) return 0;

    /* Default conservative policy: allow only SRAM 0x20000000..0x20040000 (256KB) */
    const uintptr_t sram_start = (uintptr_t)0x20000000u;
    const uintptr_t sram_end   = (uintptr_t)0x20040000u;
    if (addr < sram_start) return 0;
    if (addr + (uintptr_t)len > sram_end) return 0;
    return 1;
}