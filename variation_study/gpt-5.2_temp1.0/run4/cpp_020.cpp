# Generated by openai (gpt-5.2)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>
#include <cstddef>
#include <type_traits>

template <class T, class Deleter = std::default_delete<T>>
class ResourceHandle {
public:
    using element_type = T;
    using deleter_type = Deleter;
    using pointer = T*;

    constexpr ResourceHandle() noexcept(std::is_nothrow_default_constructible_v<Deleter>)
        : ptr_(nullptr), del_() {}

    explicit ResourceHandle(pointer p) noexcept(std::is_nothrow_default_constructible_v<Deleter>)
        : ptr_(p), del_() {}

    ResourceHandle(pointer p, const Deleter& d) noexcept
        : ptr_(p), del_(d) {}

    ResourceHandle(pointer p, Deleter&& d) noexcept
        : ptr_(p), del_(std::move(d)) {}

    ResourceHandle(const ResourceHandle&) = delete;
    ResourceHandle& operator=(const ResourceHandle&) = delete;

    ResourceHandle(ResourceHandle&& other) noexcept(std::is_nothrow_move_constructible_v<Deleter>)
        : ptr_(other.release()), del_(std::move(other.del_)) {}

    ResourceHandle& operator=(ResourceHandle&& other) noexcept(
        std::is_nothrow_move_assignable_v<Deleter> && std::is_nothrow_move_constructible_v<Deleter>
    ) {
        if (this != &other) {
            reset(other.release());
            del_ = std::move(other.del_);
        }
        return *this;
    }

    ~ResourceHandle() noexcept {
        reset();
    }

    void reset(pointer p = nullptr) noexcept {
        if (ptr_ != nullptr) {
            del_(ptr_);
        }
        ptr_ = p;
    }

    pointer release() noexcept {
        pointer p = ptr_;
        ptr_ = nullptr;
        return p;
    }

    pointer get() const noexcept { return ptr_; }
    deleter_type& get_deleter() noexcept { return del_; }
    const deleter_type& get_deleter() const noexcept { return del_; }

    explicit operator bool() const noexcept { return ptr_ != nullptr; }

    element_type& operator*() const noexcept { return *ptr_; }
    pointer operator->() const noexcept { return ptr_; }

    void swap(ResourceHandle& other) noexcept(
        std::is_nothrow_swappable_v<Deleter>
    ) {
        using std::swap;
        swap(ptr_, other.ptr_);
        swap(del_, other.del_);
    }

private:
    pointer ptr_;
    Deleter del_;
};

template <class T, class D>
void swap(ResourceHandle<T, D>& a, ResourceHandle<T, D>& b) noexcept(noexcept(a.swap(b))) {
    a.swap(b);
}