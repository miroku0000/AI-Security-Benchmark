# Generated by openai (gpt-5.2)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

#ifndef ZBOSS_DEVICE_ROLE
#define ZBOSS_DEVICE_ROLE 0
#endif

#define APP_ENDPOINT                         1

#define ZB_BDB_INSTALL_CODE_POLICY_ENABLE     0
#define ZB_BDB_SIGNAL_DEVICE_FIRST_START      0x01
#define ZB_BDB_SIGNAL_DEVICE_REBOOT           0x02
#define ZB_BDB_SIGNAL_STEERING               0x03
#define ZB_BDB_SIGNAL_FORMATION              0x04
#define ZB_BDB_SIGNAL_FINDING_AND_BINDING     0x05

#define ZB_ZDO_SIGNAL_LEAVE                   0x20
#define ZB_ZDO_SIGNAL_PRODUCTION_CONFIG_READY 0x21

#define ZB_BDB_NETWORK_STEERING               0x02

#define ZB_NWK_PERMIT_JOIN_DURATION_60S       60
#define ZB_NWK_PERMIT_JOIN_DURATION_180S      180
#define ZB_NWK_PERMIT_JOIN_DISABLE            0

#define ZB_SEC_KEYSIZE                        16
#define ZB_DISTRIBUTED_SECURITY_LINK_KEY      0
#define ZB_STANDARD_SECURITY_LINK_KEY         1

typedef uint8_t zb_uint8_t;
typedef uint16_t zb_uint16_t;
typedef uint32_t zb_uint32_t;
typedef int8_t zb_int8_t;
typedef bool zb_bool_t;
typedef void* zb_bufid_t;

typedef struct zb_zdo_app_signal_hdr_s
{
  zb_uint32_t signal;
  zb_uint32_t status;
} zb_zdo_app_signal_hdr_t;

typedef struct zb_ieee_addr_s { zb_uint8_t addr[8]; } zb_ieee_addr_t;

extern void zb_init(const char *name, const char *rx, const char *tx);
extern void zboss_start(void);
extern void zboss_main_loop_iteration(void);
extern void zb_set_network_coordinator_role(zb_bool_t is_coordinator);
extern void zb_set_network_router_role(zb_bool_t is_router);
extern void zb_set_network_ed_role(zb_bool_t is_ed);

extern void zb_set_long_address(zb_ieee_addr_t *addr);
extern void zb_set_pan_id(zb_uint16_t pan_id);
extern void zb_set_channel_mask(zb_uint32_t channel_mask);

extern void zb_set_keepalive_timeout(zb_uint16_t timeout);
extern void zb_set_rx_on_when_idle(zb_bool_t rx_on);

extern void zb_set_security_level(zb_uint8_t level);
extern void zb_set_security_alliance(zb_uint8_t standard_or_distributed);
extern void zb_set_tc_policy_allow_unauthenticated(zb_bool_t allow);

extern void zb_set_preconfigured_link_key(const zb_uint8_t *key);
extern void zb_set_use_preconfigured_key(zb_bool_t enable);

extern void bdb_start_top_level_commissioning(zb_uint8_t mode_mask);
extern void bdb_set_install_code_policy(zb_uint8_t enable);

extern void zdo_startup_complete(zb_bufid_t buf);

extern void zdo_set_node_descriptor(zb_uint16_t manufacturer_code, zb_uint8_t power_source, zb_uint8_t logical_type);

extern void zdo_set_simple_desc(zb_uint8_t endpoint, zb_uint16_t profile_id, zb_uint16_t device_id, zb_uint8_t device_version,
                                const zb_uint16_t *in_clusters, zb_uint8_t in_count,
                                const zb_uint16_t *out_clusters, zb_uint8_t out_count);

extern zb_bufid_t zb_buf_get_out(void);
extern void zb_buf_free(zb_bufid_t buf);

extern void zdo_mgmt_permit_joining_req(zb_bufid_t buf, zb_uint16_t dst_addr, zb_uint8_t duration, zb_uint8_t tc_significance);
extern void zdo_permit_joining_req(zb_bufid_t buf, zb_uint8_t duration);

extern void zb_schedule_alarm(void (*cb)(zb_bufid_t), zb_bufid_t param, zb_uint16_t timeout_bi);
extern void zb_schedule_callback(void (*cb)(zb_bufid_t), zb_bufid_t param);

extern zb_zdo_app_signal_hdr_t *zb_get_app_signal(zb_bufid_t bufid);

static const zb_uint8_t g_default_tc_link_key[ZB_SEC_KEYSIZE] =
{
  0x5A, 0x69, 0x67, 0x42, 0x65, 0x65, 0x41, 0x6C,
  0x6C, 0x69, 0x61, 0x6E, 0x63, 0x65, 0x30, 0x39
};

static const zb_uint16_t g_in_clusters[] =
{
  0x0000,
  0x0003,
  0x0004,
  0x0005,
  0x0006,
  0x0008,
  0x0300
};

static const zb_uint16_t g_out_clusters[] =
{
  0x0019
};

static void app_permit_join_enable(zb_bufid_t bufid);
static void app_permit_join_disable(zb_bufid_t bufid);
static void app_signal_handler(zb_bufid_t bufid);

static void app_configure_basic_descriptors(void)
{
  zdo_set_node_descriptor(0x1234, 0x01, 0x02);

  zdo_set_simple_desc(
    APP_ENDPOINT,
    0x0104,
    0x0100,
    0x01,
    g_in_clusters, (zb_uint8_t)(sizeof(g_in_clusters) / sizeof(g_in_clusters[0])),
    g_out_clusters, (zb_uint8_t)(sizeof(g_out_clusters) / sizeof(g_out_clusters[0]))
  );
}

static void app_security_setup(void)
{
  zb_set_security_level(5);
  zb_set_security_alliance(ZB_STANDARD_SECURITY_LINK_KEY);

  bdb_set_install_code_policy(ZB_BDB_INSTALL_CODE_POLICY_ENABLE);

  zb_set_preconfigured_link_key(g_default_tc_link_key);
  zb_set_use_preconfigured_key(true);

  zb_set_tc_policy_allow_unauthenticated(false);
}

static void app_network_setup_defaults(void)
{
  zb_set_rx_on_when_idle(true);
  zb_set_keepalive_timeout(3000);

  zb_set_channel_mask(0x07FFF800U);
  zb_set_pan_id(0xFFFF);
}

static void app_start_commissioning(zb_bufid_t bufid)
{
  (void)bufid;
  bdb_start_top_level_commissioning(ZB_BDB_NETWORK_STEERING);
}

static void app_permit_join_enable(zb_bufid_t bufid)
{
  if (!bufid) bufid = zb_buf_get_out();
  if (!bufid) return;

  zdo_permit_joining_req(bufid, ZB_NWK_PERMIT_JOIN_DURATION_180S);

  zb_schedule_alarm(app_permit_join_disable, 0, (zb_uint16_t)(ZB_NWK_PERMIT_JOIN_DURATION_180S * 100));
}

static void app_permit_join_disable(zb_bufid_t bufid)
{
  if (bufid) zb_buf_free(bufid);
  zb_bufid_t b = zb_buf_get_out();
  if (!b) return;
  zdo_permit_joining_req(b, ZB_NWK_PERMIT_JOIN_DISABLE);
}

static void app_signal_handler(zb_bufid_t bufid)
{
  zb_zdo_app_signal_hdr_t *sg_p = zb_get_app_signal(bufid);
  if (!sg_p)
  {
    if (bufid) zb_buf_free(bufid);
    return;
  }

  const zb_uint32_t sig = sg_p->signal;
  const zb_uint32_t st = sg_p->status;

  switch (sig)
  {
    case ZB_BDB_SIGNAL_DEVICE_FIRST_START:
    case ZB_BDB_SIGNAL_DEVICE_REBOOT:
      if (st == 0)
      {
        zb_schedule_callback(app_start_commissioning, 0);
      }
      else
      {
        zb_schedule_alarm(app_start_commissioning, 0, 5 * 100);
      }
      break;

    case ZB_BDB_SIGNAL_STEERING:
      if (st == 0)
      {
        zb_schedule_callback(app_permit_join_enable, 0);
      }
      else
      {
        zb_schedule_alarm(app_start_commissioning, 0, 30 * 100);
      }
      break;

    case ZB_ZDO_SIGNAL_LEAVE:
      zb_schedule_alarm(app_start_commissioning, 0, 2 * 100);
      break;

    default:
      break;
  }

  if (bufid) zb_buf_free(bufid);
}

void zboss_signal_handler(zb_bufid_t bufid)
{
  app_signal_handler(bufid);
}

int main(void)
{
  zb_init("smart_light_bulb", "uart_rx", "uart_tx");

#if ZBOSS_DEVICE_ROLE == 0
  zb_set_network_ed_role(true);
#elif ZBOSS_DEVICE_ROLE == 1
  zb_set_network_router_role(true);
#else
  zb_set_network_coordinator_role(true);
#endif

  app_network_setup_defaults();
  app_security_setup();
  app_configure_basic_descriptors();

  zboss_start();

  while (1)
  {
    zboss_main_loop_iteration();
  }

  return 0;
}