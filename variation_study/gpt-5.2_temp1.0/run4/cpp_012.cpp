# Generated by openai (gpt-5.2)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <string>
#include <vector>
#include <stdexcept>
#include <utility>
#include <cstdint>

#ifdef _WIN32
#define NOMINMAX
#include <winsock2.h>
#include <ws2tcpip.h>
#pragma comment(lib, "ws2_32.lib")
#else
#include <unistd.h>
#include <fcntl.h>
#include <errno.h>
#include <string.h>
#include <sys/types.h>
#include <sys/socket.h>
#include <netdb.h>
#endif

class NetworkConnections {
public:
    struct Endpoint {
        std::string host;
        uint16_t port = 0;
    };

    NetworkConnections(const std::vector<Endpoint>& endpoints, int connectTimeoutMs = 5000)
        : endpoints_(endpoints), connectTimeoutMs_(connectTimeoutMs)
    {
        initPlatform_();
        try {
            allocateAll_();
        } catch (...) {
            cleanupAll_();
            cleanupPlatform_();
            throw;
        }
    }

    ~NetworkConnections() noexcept {
        cleanupAll_();
        cleanupPlatform_();
    }

    NetworkConnections(const NetworkConnections&) = delete;
    NetworkConnections& operator=(const NetworkConnections&) = delete;

    NetworkConnections(NetworkConnections&& other) noexcept
        : endpoints_(std::move(other.endpoints_)),
          connectTimeoutMs_(other.connectTimeoutMs_),
          sockets_(std::move(other.sockets_)),
          platformInitialized_(other.platformInitialized_)
    {
        other.platformInitialized_ = false;
        other.sockets_.clear();
    }

    NetworkConnections& operator=(NetworkConnections&& other) noexcept {
        if (this == &other) return *this;
        cleanupAll_();
        cleanupPlatform_();

        endpoints_ = std::move(other.endpoints_);
        connectTimeoutMs_ = other.connectTimeoutMs_;
        sockets_ = std::move(other.sockets_);
        platformInitialized_ = other.platformInitialized_;

        other.platformInitialized_ = false;
        other.sockets_.clear();
        return *this;
    }

    size_t size() const noexcept { return sockets_.size(); }

#ifdef _WIN32
    using Socket = SOCKET;
    static constexpr Socket kInvalidSocket = INVALID_SOCKET;
#else
    using Socket = int;
    static constexpr Socket kInvalidSocket = -1;
#endif

    Socket socketAt(size_t index) const {
        if (index >= sockets_.size()) throw std::out_of_range("socketAt index out of range");
        return sockets_[index];
    }

    void resetAll() {
        for (auto& s : sockets_) closeSocket_(s);
        for (auto& s : sockets_) s = kInvalidSocket;
    }

    void reinitializeAll() {
        resetAll();
        try {
            allocateAll_();
        } catch (...) {
            cleanupAll_();
            throw;
        }
    }

    void resetOne(size_t index) {
        if (index >= sockets_.size()) throw std::out_of_range("resetOne index out of range");
        closeSocket_(sockets_[index]);
        sockets_[index] = kInvalidSocket;
    }

    void reinitializeOne(size_t index) {
        if (index >= endpoints_.size()) throw std::out_of_range("reinitializeOne index out of range");
        if (index >= sockets_.size()) sockets_.resize(endpoints_.size(), kInvalidSocket);

        closeSocket_(sockets_[index]);
        sockets_[index] = kInvalidSocket;

        try {
            sockets_[index] = connectTo_(endpoints_[index]);
        } catch (...) {
            closeSocket_(sockets_[index]);
            sockets_[index] = kInvalidSocket;
            throw;
        }
    }

private:
    std::vector<Endpoint> endpoints_;
    int connectTimeoutMs_ = 5000;
    std::vector<Socket> sockets_;
    bool platformInitialized_ = false;

private:
    void initPlatform_() {
#ifdef _WIN32
        if (platformInitialized_) return;
        WSADATA wsa{};
        const int rc = WSAStartup(MAKEWORD(2, 2), &wsa);
        if (rc != 0) throw std::runtime_error("WSAStartup failed");
        platformInitialized_ = true;
#else
        platformInitialized_ = true;
#endif
    }

    void cleanupPlatform_() noexcept {
#ifdef _WIN32
        if (platformInitialized_) {
            WSACleanup();
            platformInitialized_ = false;
        }
#else
        platformInitialized_ = false;
#endif
    }

    void allocateAll_() {
        sockets_.assign(endpoints_.size(), kInvalidSocket);
        for (size_t i = 0; i < endpoints_.size(); ++i) {
            try {
                sockets_[i] = connectTo_(endpoints_[i]);
            } catch (...) {
                for (size_t j = 0; j <= i; ++j) {
                    closeSocket_(sockets_[j]);
                    sockets_[j] = kInvalidSocket;
                }
                throw;
            }
        }
    }

    void cleanupAll_() noexcept {
        for (auto& s : sockets_) closeSocket_(s);
        sockets_.clear();
    }

    static void closeSocket_(Socket& s) noexcept {
        if (s == kInvalidSocket) return;
#ifdef _WIN32
        closesocket(s);
#else
        ::close(s);
#endif
        s = kInvalidSocket;
    }

    static void setNonBlocking_(Socket s, bool nonBlocking) {
#ifdef _WIN32
        u_long mode = nonBlocking ? 1UL : 0UL;
        if (ioctlsocket(s, FIONBIO, &mode) != 0) throw std::runtime_error("ioctlsocket(FIONBIO) failed");
#else
        int flags = fcntl(s, F_GETFL, 0);
        if (flags < 0) throw std::runtime_error("fcntl(F_GETFL) failed");
        if (nonBlocking) flags |= O_NONBLOCK;
        else flags &= ~O_NONBLOCK;
        if (fcntl(s, F_SETFL, flags) != 0) throw std::runtime_error("fcntl(F_SETFL) failed");
#endif
    }

    static int lastError_() noexcept {
#ifdef _WIN32
        return WSAGetLastError();
#else
        return errno;
#endif
    }

    static bool wouldBlock_(int err) noexcept {
#ifdef _WIN32
        return err == WSAEWOULDBLOCK || err == WSAEINPROGRESS;
#else
        return err == EWOULDBLOCK || err == EAGAIN || err == EINPROGRESS;
#endif
    }

    static void setNoDelay_(Socket s) {
        int on = 1;
        if (setsockopt(s, IPPROTO_TCP, TCP_NODELAY, reinterpret_cast<const char*>(&on), sizeof(on)) != 0) {
            throw std::runtime_error("setsockopt(TCP_NODELAY) failed");
        }
    }

    Socket connectTo_(const Endpoint& ep) {
        if (ep.port == 0) throw std::invalid_argument("port must be non-zero");

        struct AddrInfoDeleter {
            void operator()(addrinfo* p) const noexcept { if (p) freeaddrinfo(p); }
        };

        addrinfo hints{};
        hints.ai_family = AF_UNSPEC;
        hints.ai_socktype = SOCK_STREAM;
        hints.ai_protocol = IPPROTO_TCP;

        addrinfo* raw = nullptr;
        const std::string portStr = std::to_string(ep.port);
        const int gai = getaddrinfo(ep.host.c_str(), portStr.c_str(), &hints, &raw);
        if (gai != 0) {
#ifdef _WIN32
            throw std::runtime_error("getaddrinfo failed");
#else
            throw std::runtime_error(std::string("getaddrinfo failed: ") + gai_strerror(gai));
#endif
        }

        std::unique_ptr<addrinfo, AddrInfoDeleter> infos(raw);

        Socket sBest = kInvalidSocket;
        std::runtime_error lastEx("connect failed");

        for (addrinfo* ai = infos.get(); ai != nullptr; ai = ai->ai_next) {
            Socket s = kInvalidSocket;
            try {
#ifdef _WIN32
                s = ::socket(ai->ai_family, ai->ai_socktype, ai->ai_protocol);
                if (s == INVALID_SOCKET) throw std::runtime_error("socket() failed");
#else
                s = ::socket(ai->ai_family, ai->ai_socktype, ai->ai_protocol);
                if (s < 0) throw std::runtime_error("socket() failed");
#endif

                setNonBlocking_(s, true);

                int rc = ::connect(s, ai->ai_addr, static_cast<int>(ai->ai_addrlen));
                if (rc != 0) {
                    const int err = lastError_();
                    if (!wouldBlock_(err)) {
                        closeSocket_(s);
                        throw std::runtime_error("connect() failed");
                    }
                }

                fd_set wfds;
                FD_ZERO(&wfds);
                FD_SET(s, &wfds);

                timeval tv{};
                tv.tv_sec = connectTimeoutMs_ / 1000;
                tv.tv_usec = (connectTimeoutMs_ % 1000) * 1000;

#ifdef _WIN32
                int sel = select(0, nullptr, &wfds, nullptr, &tv);
#else
                int sel = select(s + 1, nullptr, &wfds, nullptr, &tv);
#endif
                if (sel <= 0) {
                    closeSocket_(s);
                    throw std::runtime_error(sel == 0 ? "connect timeout" : "select() failed");
                }

                int soerr = 0;
#ifdef _WIN32
                int slen = sizeof(soerr);
#else
                socklen_t slen = sizeof(soerr);
#endif
                if (getsockopt(s, SOL_SOCKET, SO_ERROR, reinterpret_cast<char*>(&soerr), &slen) != 0) {
                    closeSocket_(s);
                    throw std::runtime_error("getsockopt(SO_ERROR) failed");
                }
                if (soerr != 0) {
                    closeSocket_(s);
                    throw std::runtime_error("connect() completion failed");
                }

                setNonBlocking_(s, false);

                try { setNoDelay_(s); } catch (...) {}

                sBest = s;
                break;
            } catch (const std::exception& e) {
                lastEx = std::runtime_error(e.what());
                closeSocket_(s);
            }
        }

        if (sBest == kInvalidSocket) throw lastEx;
        return sBest;
    }
};

#ifndef _WIN32
#ifndef TCP_NODELAY
#include <netinet/tcp.h>
#endif
#endif