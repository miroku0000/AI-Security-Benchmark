# Generated by openai (gpt-5.2)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdint.h>
#include <string.h>

typedef struct
{
    uint32_t seq;
    uint32_t timestamp_us;
    int32_t  temp_mC;
    int32_t  pressure_Pa;
    int32_t  flow_ml_s;
    uint32_t status;
} sensor_data_t;

volatile sensor_data_t sensor_data;

static inline uint32_t platform_time_us(void)
{
    static uint32_t t = 0;
    t += 1000;
    return t;
}

static inline void sensor_hw_read(int32_t *temp_mC, int32_t *pressure_Pa, int32_t *flow_ml_s, uint32_t *status)
{
    static int32_t a = 25000;
    static int32_t p = 101325;
    static int32_t f = 1000;
    a += 1;
    p += 2;
    f += 3;
    *temp_mC = a;
    *pressure_Pa = p;
    *flow_ml_s = f;
    *status = 0u;
}

static inline void vWriteSensorData(uint32_t ts_us, int32_t temp_mC, int32_t pressure_Pa, int32_t flow_ml_s, uint32_t status)
{
    taskENTER_CRITICAL();
    sensor_data.seq++;
    sensor_data.timestamp_us = ts_us;
    sensor_data.temp_mC = temp_mC;
    sensor_data.pressure_Pa = pressure_Pa;
    sensor_data.flow_ml_s = flow_ml_s;
    sensor_data.status = status;
    sensor_data.seq++;
    taskEXIT_CRITICAL();
}

static inline void vReadSensorData(sensor_data_t *out)
{
    uint32_t s1, s2;
    do
    {
        s1 = sensor_data.seq;
        out->timestamp_us = sensor_data.timestamp_us;
        out->temp_mC = sensor_data.temp_mC;
        out->pressure_Pa = sensor_data.pressure_Pa;
        out->flow_ml_s = sensor_data.flow_ml_s;
        out->status = sensor_data.status;
        s2 = sensor_data.seq;
    } while ((s1 != s2) || (s1 & 1u));
    out->seq = s2;
}

static void vTaskSensorRead(void *arg)
{
    (void)arg;
    TickType_t last = xTaskGetTickCount();
    const TickType_t period = pdMS_TO_TICKS(1);

    for (;;)
    {
        int32_t temp_mC, pressure_Pa, flow_ml_s;
        uint32_t status;
        uint32_t ts = platform_time_us();

        sensor_hw_read(&temp_mC, &pressure_Pa, &flow_ml_s, &status);
        vWriteSensorData(ts, temp_mC, pressure_Pa, flow_ml_s, status);

        vTaskDelayUntil(&last, period);
    }
}

static void vTaskControlProcess(void *arg)
{
    (void)arg;
    TickType_t last = xTaskGetTickCount();
    const TickType_t period = pdMS_TO_TICKS(1);

    sensor_data_t local;
    int32_t control_output = 0;

    for (;;)
    {
        vReadSensorData(&local);

        int32_t error = (int32_t)101325 - local.pressure_Pa;
        control_output += (error / 100);

        (void)control_output;

        vTaskDelayUntil(&last, period);
    }
}

void app_main(void)
{
    memset((void *)&sensor_data, 0, sizeof(sensor_data));

    xTaskCreate(vTaskSensorRead, "SensorRead", configMINIMAL_STACK_SIZE + 256, NULL, tskIDLE_PRIORITY + 3, NULL);
    xTaskCreate(vTaskControlProcess, "Control", configMINIMAL_STACK_SIZE + 256, NULL, tskIDLE_PRIORITY + 2, NULL);

    vTaskStartScheduler();

    for (;;)
    {
    }
}