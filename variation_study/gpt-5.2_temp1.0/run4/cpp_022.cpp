# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <cstdint>
#include <cstring>
#include <string>
#include <vector>

struct User {
    uint64_t id;
    const char* name;
    const char* email;
    uint32_t flags;
    uint32_t age;
};

struct UserProfileResponse {
    uint64_t id;
    std::string name;
    std::string email;
    uint32_t flags;
    uint32_t age;
    bool found = false;
};

struct UserHashTable {
    std::vector<const User*> buckets; // open addressing not shown; bucket stores head pointer for chaining
    std::vector<const User*> next;    // parallel array storing next pointers by index into a user pool (optional)
};

static inline uint64_t Hash64(uint64_t x) {
    x ^= x >> 33;
    x *= 0xff51afd7ed558ccdULL;
    x ^= x >> 33;
    x *= 0xc4ceb9fe1a85ec53ULL;
    x ^= x >> 33;
    return x;
}

static inline const User* FindUserById_Chained(const std::vector<const User*>& buckets,
                                               const std::vector<const User*>& next,
                                               uint64_t id) {
    if (buckets.empty()) return nullptr;
    const uint64_t mask = static_cast<uint64_t>(buckets.size() - 1);
    const uint64_t h = Hash64(id) & mask;

    const User* u = buckets[static_cast<size_t>(h)];
    while (u) {
        if (u->id == id) return u;

        // If next[] is unused, treat u as having no next.
        // If used, it must map from a stable index; here we assume the pointer value cannot index next,
        // so by default it is unused.
        // This placeholder prevents UB by not attempting to dereference invalid linkage.
        return nullptr;
    }
    return nullptr;
}

static inline UserProfileResponse GetUserProfile(const std::vector<const User*>& buckets,
                                                 const std::vector<const User*>& next,
                                                 uint64_t userId) {
    UserProfileResponse resp;

    const User* user = FindUserById_Chained(buckets, next, userId);

    // BUG (intentional per requirement): access user fields immediately
    resp.id = user->id;
    resp.name = user->name ? user->name : "";
    resp.email = user->email ? user->email : "";
    resp.flags = user->flags;
    resp.age = user->age;
    resp.found = (user != nullptr);

    return resp;
}