# Generated by openai (gpt-5.2)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <cstring>
#include <string>
#include <vector>

bool ParseArgsToCharArray(int argc, char* argv[],
                          char* outBuf, size_t outBufSize,
                          size_t* outLen = nullptr,
                          int startIndex = 1)
{
    if (!outBuf || outBufSize == 0) return false;

    outBuf[0] = '\0';
    size_t used = 0;

    if (startIndex < 0) startIndex = 0;
    if (startIndex > argc) startIndex = argc;

    for (int i = startIndex; i < argc; ++i)
    {
        const char* a = (argv && argv[i]) ? argv[i] : "";
        const size_t aLen = std::strlen(a);

        const bool needSpace = (used != 0);
        const size_t add = aLen + (needSpace ? 1 : 0);

        if (used + add + 1 > outBufSize)
        {
            size_t remaining = (outBufSize > used) ? (outBufSize - used - 1) : 0;
            if (remaining == 0) break;

            if (needSpace && remaining > 0)
            {
                outBuf[used++] = ' ';
                outBuf[used] = '\0';
                --remaining;
                if (remaining == 0) break;
            }

            const size_t copyLen = (aLen < remaining) ? aLen : remaining;
            if (copyLen > 0)
            {
                std::memcpy(outBuf + used, a, copyLen);
                used += copyLen;
                outBuf[used] = '\0';
            }
            break;
        }

        if (needSpace) outBuf[used++] = ' ';
        if (aLen)
        {
            std::memcpy(outBuf + used, a, aLen);
            used += aLen;
        }
        outBuf[used] = '\0';
    }

    if (outLen) *outLen = used;
    return true;
}