# Generated by openai (gpt-5.2)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <errno.h>
#include <signal.h>

#if defined(_WIN32)
#define WIN32_LEAN_AND_MEAN
#include <winsock2.h>
#include <ws2tcpip.h>
#pragma comment(lib, "ws2_32.lib")
typedef SOCKET socket_t;
static int sock_init(void){ WSADATA w; return WSAStartup(MAKEWORD(2,2), &w); }
static void sock_deinit(void){ WSACleanup(); }
static void sock_close(socket_t s){ closesocket(s); }
static int sock_errno(void){ return WSAGetLastError(); }
static int set_nonblocking(socket_t s, int nb){
	u_long mode = nb ? 1UL : 0UL;
	return ioctlsocket(s, FIONBIO, &mode);
}
#else
#include <unistd.h>
#include <fcntl.h>
#include <sys/types.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <netdb.h>
typedef int socket_t;
static int sock_init(void){ return 0; }
static void sock_deinit(void){ }
static void sock_close(socket_t s){ close(s); }
static int sock_errno(void){ return errno; }
static int set_nonblocking(socket_t s, int nb){
	int flags = fcntl(s, F_GETFL, 0);
	if(flags < 0) return -1;
	if(nb) flags |= O_NONBLOCK; else flags &= ~O_NONBLOCK;
	return fcntl(s, F_SETFL, flags);
}
#endif

#ifndef REQ_BUF_SIZE
#define REQ_BUF_SIZE (16 * 1024)
#endif

#ifndef MAX_HEADER_BYTES
#define MAX_HEADER_BYTES (64 * 1024)
#endif

#ifndef LISTEN_BACKLOG
#define LISTEN_BACKLOG 128
#endif

#ifndef PORT_DEFAULT
#define PORT_DEFAULT 8080
#endif

#ifndef MAX_IOV
#define MAX_IOV 4
#endif

static volatile sig_atomic_t g_running = 1;

static void on_signal(int sig){
	(void)sig;
	g_running = 0;
}

static int set_reuseaddr(socket_t s){
	int opt = 1;
	return setsockopt(s, SOL_SOCKET, SO_REUSEADDR, (const char*)&opt, (socklen_t)sizeof(opt));
}

static int set_nodelay(socket_t s){
	int opt = 1;
	return setsockopt(s, IPPROTO_TCP, TCP_NODELAY, (const char*)&opt, (socklen_t)sizeof(opt));
}

static int set_keepalive(socket_t s){
	int opt = 1;
	return setsockopt(s, SOL_SOCKET, SO_KEEPALIVE, (const char*)&opt, (socklen_t)sizeof(opt));
}

static int set_rcvtimeo(socket_t s, int ms){
#if defined(_WIN32)
	DWORD tv = (DWORD)ms;
	return setsockopt(s, SOL_SOCKET, SO_RCVTIMEO, (const char*)&tv, (socklen_t)sizeof(tv));
#else
	struct timeval tv;
	tv.tv_sec = ms / 1000;
	tv.tv_usec = (ms % 1000) * 1000;
	return setsockopt(s, SOL_SOCKET, SO_RCVTIMEO, (const char*)&tv, (socklen_t)sizeof(tv));
#endif
}

static int set_sndtimeo(socket_t s, int ms){
#if defined(_WIN32)
	DWORD tv = (DWORD)ms;
	return setsockopt(s, SOL_SOCKET, SO_SNDTIMEO, (const char*)&tv, (socklen_t)sizeof(tv));
#else
	struct timeval tv;
	tv.tv_sec = ms / 1000;
	tv.tv_usec = (ms % 1000) * 1000;
	return setsockopt(s, SOL_SOCKET, SO_SNDTIMEO, (const char*)&tv, (socklen_t)sizeof(tv));
#endif
}

static ssize_t send_all(socket_t s, const void *buf, size_t len){
	const uint8_t *p = (const uint8_t*)buf;
	size_t off = 0;
	while(off < len){
#if defined(_WIN32)
		int n = send(s, (const char*)(p + off), (int)(len - off), 0);
#else
		ssize_t n = send(s, p + off, len - off, 0);
#endif
		if(n <= 0) return -1;
		off += (size_t)n;
	}
	return (ssize_t)off;
}

static const char* memmem_crlfcrlf(const char* buf, size_t n){
	if(n < 4) return NULL;
	const char *end = buf + n - 3;
	for(const char* p = buf; p < end; ++p){
		if(p[0] == '\r' && p[1] == '\n' && p[2] == '\r' && p[3] == '\n') return p;
	}
	return NULL;
}

static int parse_request_line(const char* buf, size_t n, size_t* method_len, size_t* path_off, size_t* path_len, int* http11){
	*method_len = 0; *path_off = 0; *path_len = 0; *http11 = 0;
	const char* eol = memchr(buf, '\n', n);
	if(!eol) return -1;
	const char* line_end = eol;
	if(line_end > buf && line_end[-1] == '\r') line_end--;
	size_t line_len = (size_t)(line_end - buf);
	const char* sp1 = memchr(buf, ' ', line_len);
	if(!sp1) return -1;
	const char* sp2 = memchr(sp1 + 1, ' ', (size_t)(buf + line_len - (sp1 + 1)));
	if(!sp2) return -1;
	*method_len = (size_t)(sp1 - buf);
	*path_off = (size_t)((sp1 + 1) - buf);
	*path_len = (size_t)(sp2 - (sp1 + 1));
	const char* ver = sp2 + 1;
	size_t ver_len = (size_t)(buf + line_len - ver);
	if(ver_len >= 8 && memcmp(ver, "HTTP/1.1", 8) == 0) *http11 = 1;
	else *http11 = 0;
	return 0;
}

static int find_content_length(const char* headers, size_t header_len, size_t* out_len){
	*out_len = 0;
	const char* p = headers;
	const char* end = headers + header_len;
	while(p < end){
		const char* nl = memchr(p, '\n', (size_t)(end - p));
		if(!nl) break;
		const char* line_end = nl;
		if(line_end > p && line_end[-1] == '\r') line_end--;
		size_t len = (size_t)(line_end - p);
		if(len == 0) break;
		if(len >= 16){
			const char* key = "Content-Length:";
			size_t klen = 15;
			if(strncasecmp(p, key, klen) == 0){
				const char* v = p + klen;
				while(v < line_end && (*v == ' ' || *v == '\t')) v++;
				uint64_t val = 0;
				int any = 0;
				while(v < line_end && *v >= '0' && *v <= '9'){
					any = 1;
					val = val * 10 + (uint64_t)(*v - '0');
					v++;
					if(val > (uint64_t)SIZE_MAX) return -1;
				}
				if(!any) return -1;
				*out_len = (size_t)val;
				return 0;
			}
		}
		p = nl + 1;
	}
	return 1;
}

static int has_connection_close(const char* headers, size_t header_len){
	const char* p = headers;
	const char* end = headers + header_len;
	while(p < end){
		const char* nl = memchr(p, '\n', (size_t)(end - p));
		if(!nl) break;
		const char* line_end = nl;
		if(line_end > p && line_end[-1] == '\r') line_end--;
		size_t len = (size_t)(line_end - p);
		if(len == 0) break;
		if(len >= 11){
			const char* key = "Connection:";
			size_t klen = 11;
			if(strncasecmp(p, key, klen) == 0){
				const char* v = p + klen;
				while(v < line_end && (*v == ' ' || *v == '\t')) v++;
				if((size_t)(line_end - v) >= 5 && strncasecmp(v, "close", 5) == 0) return 1;
			}
		}
		p = nl + 1;
	}
	return 0;
}

static int build_response(const char* method, size_t method_len,
                          const char* path, size_t path_len,
                          int keep_alive,
                          char* out, size_t out_cap, size_t* out_len){
	static const char body_prefix[] = "OK\n";
	char path_tmp[256];
	size_t cp = path_len < sizeof(path_tmp)-1 ? path_len : sizeof(path_tmp)-1;
	memcpy(path_tmp, path, cp);
	path_tmp[cp] = 0;

	const char* status = "200 OK";
	const char* ctype = "text/plain";
	char body[512];
	int bl = snprintf(body, sizeof(body), "%s", body_prefix);
	if(bl < 0) bl = 0;
	size_t body_len = (size_t)bl;

	(void)method;
	(void)method_len;
	(void)path_tmp;

	int hl = snprintf(out, out_cap,
		"HTTP/1.1 %s\r\n"
		"Server: embedded\r\n"
		"Content-Type: %s\r\n"
		"Content-Length: %zu\r\n"
		"Connection: %s\r\n"
		"\r\n",
		status, ctype, body_len, keep_alive ? "keep-alive" : "close");
	if(hl < 0) return -1;
	size_t header_len = (size_t)hl;
	if(header_len + body_len > out_cap) return -1;
	memcpy(out + header_len, body, body_len);
	*out_len = header_len + body_len;
	return 0;
}

static int process_connection(socket_t cs){
	char *req = (char*)malloc(REQ_BUF_SIZE);
	if(!req) return -1;

	char *resp = (char*)malloc(2048);
	if(!resp){ free(req); return -1; }

	size_t have = 0;
	int keep = 1;

	set_keepalive(cs);
	set_nodelay(cs);
	set_rcvtimeo(cs, 5000);
	set_sndtimeo(cs, 5000);

	while(g_running && keep){
		have = 0;

		const char* header_end = NULL;
		while(!header_end){
			if(have == REQ_BUF_SIZE){
				const char* msg = "HTTP/1.1 413 Payload Too Large\r\nConnection: close\r\nContent-Length: 0\r\n\r\n";
				send_all(cs, msg, strlen(msg));
				keep = 0;
				goto next_or_close;
			}
#if defined(_WIN32)
			int n = recv(cs, req + have, (int)(REQ_BUF_SIZE - have), 0);
			if(n == 0){ keep = 0; goto next_or_close; }
			if(n < 0){ keep = 0; goto next_or_close; }
#else
			ssize_t n = recv(cs, req + have, REQ_BUF_SIZE - have, 0);
			if(n == 0){ keep = 0; goto next_or_close; }
			if(n < 0){ keep = 0; goto next_or_close; }
#endif
			have += (size_t)n;
			header_end = memmem_crlfcrlf(req, have);
			if(have > MAX_HEADER_BYTES){
				const char* msg = "HTTP/1.1 431 Request Header Fields Too Large\r\nConnection: close\r\nContent-Length: 0\r\n\r\n";
				send_all(cs, msg, strlen(msg));
				keep = 0;
				goto next_or_close;
			}
		}

		size_t header_bytes = (size_t)((header_end + 4) - req);

		size_t method_len=0, path_off=0, path_len=0;
		int http11 = 0;
		if(parse_request_line(req, header_bytes, &method_len, &path_off, &path_len, &http11) != 0){
			const char* msg = "HTTP/1.1 400 Bad Request\r\nConnection: close\r\nContent-Length: 0\r\n\r\n";
			send_all(cs, msg, strlen(msg));
			keep = 0;
			goto next_or_close;
		}

		size_t content_len = 0;
		int cl = find_content_length(req, header_bytes, &content_len);
		if(cl < 0){
			const char* msg = "HTTP/1.1 400 Bad Request\r\nConnection: close\r\nContent-Length: 0\r\n\r\n";
			send_all(cs, msg, strlen(msg));
			keep = 0;
			goto next_or_close;
		}
		if(cl == 1) content_len = 0;

		size_t need = header_bytes + content_len;
		if(need > REQ_BUF_SIZE){
			const char* msg = "HTTP/1.1 413 Payload Too Large\r\nConnection: close\r\nContent-Length: 0\r\n\r\n";
			send_all(cs, msg, strlen(msg));
			keep = 0;
			goto next_or_close;
		}

		while(have < need){
#if defined(_WIN32)
			int n = recv(cs, req + have, (int)(REQ_BUF_SIZE - have), 0);
			if(n <= 0){ keep = 0; goto next_or_close; }
#else
			ssize_t n = recv(cs, req + have, REQ_BUF_SIZE - have, 0);
			if(n <= 0){ keep = 0; goto next_or_close; }
#endif
			have += (size_t)n;
		}

		int close_hdr = has_connection_close(req, header_bytes);
		int keep_alive = http11 && !close_hdr;
		keep = keep_alive ? 1 : 0;

		size_t resp_len = 0;
		if(build_response(req, method_len, req + path_off, path_len, keep_alive, resp, 2048, &resp_len) != 0){
			const char* msg = "HTTP/1.1 500 Internal Server Error\r\nConnection: close\r\nContent-Length: 0\r\n\r\n";
			send_all(cs, msg, strlen(msg));
			keep = 0;
			goto next_or_close;
		}

		if(send_all(cs, resp, resp_len) < 0){
			keep = 0;
			goto next_or_close;
		}

next_or_close:
		;
	}

	free(resp);
	free(req);
	return 0;
}

static socket_t create_listen_socket(uint16_t port){
	socket_t ls = (socket_t)socket(AF_INET, SOCK_STREAM, IPPROTO_TCP);
#if defined(_WIN32)
	if(ls == INVALID_SOCKET) return INVALID_SOCKET;
#else
	if(ls < 0) return -1;
#endif
	set_reuseaddr(ls);

	struct sockaddr_in addr;
	memset(&addr, 0, sizeof(addr));
	addr.sin_family = AF_INET;
	addr.sin_addr.s_addr = htonl(INADDR_ANY);
	addr.sin_port = htons(port);

	if(bind(ls, (struct sockaddr*)&addr, (socklen_t)sizeof(addr)) != 0){
		sock_close(ls);
#if defined(_WIN32)
		return INVALID_SOCKET;
#else
		return -1;
#endif
	}

	if(listen(ls, LISTEN_BACKLOG) != 0){
		sock_close(ls);
#if defined(_WIN32)
		return INVALID_SOCKET;
#else
		return -1;
#endif
	}

	return ls;
}

int main(int argc, char** argv){
	uint16_t port = PORT_DEFAULT;
	if(argc > 1){
		long p = strtol(argv[1], NULL, 10);
		if(p > 0 && p < 65536) port = (uint16_t)p;
	}

#if !defined(_WIN32)
	signal(SIGPIPE, SIG_IGN);
#endif
	signal(SIGINT, on_signal);
	signal(SIGTERM, on_signal);

	if(sock_init() != 0) return 1;

	socket_t ls = create_listen_socket(port);
#if defined(_WIN32)
	if(ls == INVALID_SOCKET){ sock_deinit(); return 1; }
#else
	if(ls < 0){ sock_deinit(); return 1; }
#endif

	while(g_running){
		struct sockaddr_in cli;
		socklen_t clen = (socklen_t)sizeof(cli);
		socket_t cs = accept(ls, (struct sockaddr*)&cli, &clen);
#if defined(_WIN32)
		if(cs == INVALID_SOCKET){
			int e = sock_errno();
			if(!g_running) break;
			(void)e;
			continue;
		}
#else
		if(cs < 0){
			if(errno == EINTR) continue;
			if(!g_running) break;
			continue;
		}
#endif
		(void)process_connection(cs);
		sock_close(cs);
	}

	sock_close(ls);
	sock_deinit();
	return 0;
}