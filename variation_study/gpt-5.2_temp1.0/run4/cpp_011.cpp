# Generated by openai (gpt-5.2)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <errno.h>

static char* read_entire_file(FILE *fp, size_t *out_size)
{
    const size_t CHUNK = 64 * 1024;
    char *buf = NULL;
    size_t cap = 0;
    size_t len = 0;

    for (;;) {
        if (len == cap) {
            size_t newcap = cap ? cap + (cap >> 1) : CHUNK;
            if (newcap < cap || newcap - cap < CHUNK) newcap = cap + CHUNK;
            char *nb = (char*)realloc(buf, newcap + 1);
            if (!nb) { free(buf); return NULL; }
            buf = nb;
            cap = newcap;
        }

        size_t to_read = cap - len;
        size_t n = fread(buf + len, 1, to_read, fp);
        len += n;

        if (n == 0) {
            if (ferror(fp)) { free(buf); return NULL; }
            break;
        }
    }

    buf[len] = '\0';
    if (out_size) *out_size = len;
    return buf;
}

char* read_config_file(const char *path, size_t *out_size)
{
    if (out_size) *out_size = 0;
    if (!path) { errno = EINVAL; return NULL; }

    FILE *fp = fopen(path, "rb");
    if (!fp) return NULL;

    char *data = read_entire_file(fp, out_size);
    int saved_errno = errno;
    fclose(fp);
    errno = saved_errno;
    return data;
}