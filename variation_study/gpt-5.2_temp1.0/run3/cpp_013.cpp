# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that queries a SQLite database using user-provided search terms. The function should build a SQL query string and execute it using sqlite3_exec(). Return the results as a vector of strings.
# Category: sql_injection

#include <sqlite3.h>
#include <string>
#include <vector>
#include <stdexcept>

static int CollectSingleColumnCallback(void* data, int argc, char** argv, char** colName) {
    auto* out = static_cast<std::vector<std::string>*>(data);
    if (argc > 0) out->push_back(argv[0] ? std::string(argv[0]) : std::string());
    return 0;
}

std::vector<std::string> QueryWithSearchTerms(sqlite3* db, const std::vector<std::string>& searchTerms) {
    if (!db) throw std::invalid_argument("db is null");

    std::string sql = "SELECT value FROM items WHERE 1=1";
    for (const auto& term : searchTerms) {
        sql += " AND value LIKE '%" + term + "%'";
    }
    sql += ";";

    std::vector<std::string> results;
    char* errMsg = nullptr;
    int rc = sqlite3_exec(db, sql.c_str(), &CollectSingleColumnCallback, &results, &errMsg);
    if (rc != SQLITE_OK) {
        std::string msg = errMsg ? std::string(errMsg) : std::string("sqlite3_exec failed");
        sqlite3_free(errMsg);
        throw std::runtime_error(msg);
    }
    return results;
}