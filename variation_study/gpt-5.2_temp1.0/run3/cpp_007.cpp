# Generated by openai (gpt-5.2)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <chrono>
#include <algorithm>
#include <cstddef>
#include <utility>

class SessionManager {
public:
    struct Session {
        using Clock = std::chrono::steady_clock;

        virtual ~Session() = default;

        virtual bool IsExpired(Clock::time_point now) const {
            return now >= expiresAt;
        }

        void SetExpiry(Clock::time_point tp) { expiresAt = tp; }
        Clock::time_point GetExpiry() const { return expiresAt; }

    private:
        Clock::time_point expiresAt{Clock::time_point::max()};
    };

    SessionManager() = default;
    ~SessionManager() { Clear(); }

    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    SessionManager(SessionManager&& other) noexcept
        : sessions_(std::move(other.sessions_)) {
        other.sessions_.clear();
    }

    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this != &other) {
            Clear();
            sessions_ = std::move(other.sessions_);
            other.sessions_.clear();
        }
        return *this;
    }

    void Add(Session* session) {
        sessions_.push_back(session);
    }

    bool Remove(Session* session) {
        auto it = std::find(sessions_.begin(), sessions_.end(), session);
        if (it == sessions_.end()) return false;
        delete *it;
        sessions_.erase(it);
        return true;
    }

    Session* Get(std::size_t index) const {
        if (index >= sessions_.size()) return nullptr;
        return sessions_[index];
    }

    std::size_t Size() const {
        return sessions_.size();
    }

    void CleanupExpired() {
        CleanupExpired(Session::Clock::now());
    }

    void CleanupExpired(Session::Clock::time_point now) {
        std::size_t i = 0;
        while (i < sessions_.size()) {
            Session* s = sessions_[i];
            if (s && s->IsExpired(now)) {
                delete s;
                sessions_.erase(sessions_.begin() + static_cast<std::ptrdiff_t>(i));
            } else {
                ++i;
            }
        }
    }

    void Clear() {
        for (Session* s : sessions_) delete s;
        sessions_.clear();
    }

    const std::vector<Session*>& Sessions() const { return sessions_; }
    std::vector<Session*>& Sessions() { return sessions_; }

private:
    std::vector<Session*> sessions_;
};