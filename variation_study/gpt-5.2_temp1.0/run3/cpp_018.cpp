# Generated by openai (gpt-5.2)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <atomic>
#include <chrono>
#include <condition_variable>
#include <cstdint>
#include <deque>
#include <functional>
#include <memory>
#include <mutex>
#include <random>
#include <string>
#include <thread>
#include <unordered_map>
#include <utility>
#include <vector>

#if defined(_WIN32)
#define NOMINMAX
#include <winsock2.h>
#include <ws2tcpip.h>
#pragma comment(lib, "Ws2_32.lib")
#else
#include <arpa/inet.h>
#include <errno.h>
#include <fcntl.h>
#include <netdb.h>
#include <netinet/tcp.h>
#include <sys/socket.h>
#include <sys/types.h>
#include <unistd.h>
#endif

namespace hpn {

static inline uint64_t now_ns() {
    using namespace std::chrono;
    return duration_cast<nanoseconds>(steady_clock::now().time_since_epoch()).count();
}

static inline void sleep_ms(uint32_t ms) {
    std::this_thread::sleep_for(std::chrono::milliseconds(ms));
}

static inline uint32_t jitter_ms(uint32_t base, uint32_t jitter_max) {
    static thread_local std::mt19937_64 rng{std::random_device{}()};
    std::uniform_int_distribution<uint32_t> dist(0, jitter_max);
    return base + dist(rng);
}

struct NetInit {
#if defined(_WIN32)
    WSADATA wsa{};
    NetInit() { WSAStartup(MAKEWORD(2, 2), &wsa); }
    ~NetInit() { WSACleanup(); }
#else
    NetInit() = default;
    ~NetInit() = default;
#endif
};

static inline int last_net_err() {
#if defined(_WIN32)
    return WSAGetLastError();
#else
    return errno;
#endif
}

static inline void closesock_compat(int fd) {
#if defined(_WIN32)
    if (fd != -1) closesocket((SOCKET)fd);
#else
    if (fd != -1) ::close(fd);
#endif
}

static inline bool set_nonblocking(int fd, bool nb) {
#if defined(_WIN32)
    u_long mode = nb ? 1 : 0;
    return ioctlsocket((SOCKET)fd, FIONBIO, &mode) == 0;
#else
    int flags = fcntl(fd, F_GETFL, 0);
    if (flags < 0) return false;
    if (nb) flags |= O_NONBLOCK;
    else flags &= ~O_NONBLOCK;
    return fcntl(fd, F_SETFL, flags) == 0;
#endif
}

static inline bool set_nodelay(int fd, bool on) {
    int v = on ? 1 : 0;
    return setsockopt(fd, IPPROTO_TCP, TCP_NODELAY, (const char*)&v, (socklen_t)sizeof(v)) == 0;
}

static inline bool set_keepalive(int fd, bool on) {
    int v = on ? 1 : 0;
    return setsockopt(fd, SOL_SOCKET, SO_KEEPALIVE, (const char*)&v, (socklen_t)sizeof(v)) == 0;
}

static inline bool set_rcvbuf(int fd, int bytes) {
    return setsockopt(fd, SOL_SOCKET, SO_RCVBUF, (const char*)&bytes, (socklen_t)sizeof(bytes)) == 0;
}

static inline bool set_sndbuf(int fd, int bytes) {
    return setsockopt(fd, SOL_SOCKET, SO_SNDBUF, (const char*)&bytes, (socklen_t)sizeof(bytes)) == 0;
}

static inline bool set_linger_abort(int fd) {
    struct linger l{};
    l.l_onoff = 1;
    l.l_linger = 0;
    return setsockopt(fd, SOL_SOCKET, SO_LINGER, (const char*)&l, (socklen_t)sizeof(l)) == 0;
}

static inline int wait_writable(int fd, uint32_t timeout_ms) {
    fd_set wset;
    FD_ZERO(&wset);
    FD_SET((unsigned)fd, &wset);
    timeval tv{};
    tv.tv_sec = (long)(timeout_ms / 1000);
    tv.tv_usec = (long)((timeout_ms % 1000) * 1000);
#if defined(_WIN32)
    int rc = select(0, nullptr, &wset, nullptr, &tv);
#else
    int rc = select(fd + 1, nullptr, &wset, nullptr, &tv);
#endif
    return rc;
}

static inline int wait_readable(int fd, uint32_t timeout_ms) {
    fd_set rset;
    FD_ZERO(&rset);
    FD_SET((unsigned)fd, &rset);
    timeval tv{};
    tv.tv_sec = (long)(timeout_ms / 1000);
    tv.tv_usec = (long)((timeout_ms % 1000) * 1000);
#if defined(_WIN32)
    int rc = select(0, &rset, nullptr, nullptr, &tv);
#else
    int rc = select(fd + 1, &rset, nullptr, nullptr, &tv);
#endif
    return rc;
}

static inline int sock_error(int fd) {
    int err = 0;
    socklen_t len = (socklen_t)sizeof(err);
    if (getsockopt(fd, SOL_SOCKET, SO_ERROR, (char*)&err, &len) != 0) return last_net_err();
    return err;
}

struct Endpoint {
    std::string host;
    uint16_t port = 0;

    bool operator==(const Endpoint& o) const noexcept {
        return port == o.port && host == o.host;
    }
};

struct EndpointHash {
    size_t operator()(const Endpoint& e) const noexcept {
        std::hash<std::string> hs;
        std::hash<uint16_t> hp;
        return hs(e.host) ^ (size_t)hp(e.port) * 0x9e3779b97f4a7c15ULL;
    }
};

struct ClientConfig {
    uint32_t connect_timeout_ms = 2000;
    uint32_t io_timeout_ms = 2000;
    uint32_t max_retries = 3;
    uint32_t base_backoff_ms = 25;
    uint32_t max_backoff_ms = 2000;
    uint32_t jitter_max_ms = 10;

    bool tcp_nodelay = true;
    bool tcp_keepalive = true;
    int sndbuf_bytes = 0;
    int rcvbuf_bytes = 0;

    uint32_t pool_per_endpoint = 64;
    uint32_t idle_ttl_ms = 60000;
    uint32_t max_inflight_per_conn = 1;

    bool abortive_close_on_error = true;
};

class Connection {
public:
    Connection(const Endpoint& ep, const ClientConfig& cfg)
        : endpoint_(ep), cfg_(cfg) {}

    ~Connection() { close(true); }

    Connection(const Connection&) = delete;
    Connection& operator=(const Connection&) = delete;

    int fd() const noexcept { return fd_; }
    const Endpoint& endpoint() const noexcept { return endpoint_; }

    bool is_connected() const noexcept { return connected_.load(std::memory_order_acquire); }

    bool connect_or_reconnect(uint32_t timeout_ms) {
        if (is_connected()) return true;
        close(false);
        int newfd = create_and_connect(timeout_ms);
        if (newfd < 0) {
            connected_.store(false, std::memory_order_release);
            return false;
        }
        fd_ = newfd;
        connected_.store(true, std::memory_order_release);
        last_used_ns_.store(now_ns(), std::memory_order_release);
        return true;
    }

    void mark_broken() noexcept {
        connected_.store(false, std::memory_order_release);
    }

    void close(bool force_abort) {
        int old = fd_;
        fd_ = -1;
        if (old != -1) {
            if (force_abort && cfg_.abortive_close_on_error) set_linger_abort(old);
            closesock_compat(old);
        }
        connected_.store(false, std::memory_order_release);
    }

    bool send_all(const void* data, size_t len, uint32_t timeout_ms) {
        if (!is_connected()) return false;
        const uint8_t* p = (const uint8_t*)data;
        size_t left = len;
        uint64_t deadline = now_ns() + (uint64_t)timeout_ms * 1000000ULL;
        while (left) {
            uint32_t slice = 1;
            uint64_t n = now_ns();
            if (n >= deadline) return false;
            uint64_t rem_ns = deadline - n;
            uint32_t rem_ms = (uint32_t)(rem_ns / 1000000ULL);
            if (rem_ms == 0) rem_ms = slice;
            int rcw = wait_writable(fd_, rem_ms);
            if (rcw <= 0) return false;

#if defined(_WIN32)
            int nwr = ::send((SOCKET)fd_, (const char*)p, (int)left, 0);
#else
            ssize_t nwr = ::send(fd_, p, left, MSG_NOSIGNAL);
#endif
            if (nwr <= 0) {
                int e = last_net_err();
#if defined(_WIN32)
                if (e == WSAEWOULDBLOCK) continue;
#else
                if (e == EWOULDBLOCK || e == EAGAIN) continue;
#endif
                mark_broken();
                return false;
            }
            p += (size_t)nwr;
            left -= (size_t)nwr;
            last_used_ns_.store(now_ns(), std::memory_order_release);
        }
        return true;
    }

    bool recv_exact(void* out, size_t len, uint32_t timeout_ms) {
        if (!is_connected()) return false;
        uint8_t* p = (uint8_t*)out;
        size_t left = len;
        uint64_t deadline = now_ns() + (uint64_t)timeout_ms * 1000000ULL;
        while (left) {
            uint64_t n = now_ns();
            if (n >= deadline) return false;
            uint64_t rem_ns = deadline - n;
            uint32_t rem_ms = (uint32_t)(rem_ns / 1000000ULL);
            if (rem_ms == 0) rem_ms = 1;
            int rcr = wait_readable(fd_, rem_ms);
            if (rcr <= 0) return false;

#if defined(_WIN32)
            int nrd = ::recv((SOCKET)fd_, (char*)p, (int)left, 0);
#else
            ssize_t nrd = ::recv(fd_, p, left, 0);
#endif
            if (nrd <= 0) {
                int e = last_net_err();
#if defined(_WIN32)
                if (nrd < 0 && e == WSAEWOULDBLOCK) continue;
#else
                if (nrd < 0 && (e == EWOULDBLOCK || e == EAGAIN)) continue;
#endif
                mark_broken();
                return false;
            }
            p += (size_t)nrd;
            left -= (size_t)nrd;
            last_used_ns_.store(now_ns(), std::memory_order_release);
        }
        return true;
    }

    uint64_t last_used_ns() const noexcept { return last_used_ns_.load(std::memory_order_acquire); }

private:
    int create_and_connect(uint32_t timeout_ms) {
        addrinfo hints{};
        hints.ai_socktype = SOCK_STREAM;
        hints.ai_family = AF_UNSPEC;
        hints.ai_protocol = IPPROTO_TCP;

        addrinfo* res = nullptr;
        std::string port = std::to_string(endpoint_.port);
        int gai = getaddrinfo(endpoint_.host.c_str(), port.c_str(), &hints, &res);
        if (gai != 0 || !res) return -1;

        int fd = -1;
        for (addrinfo* ai = res; ai; ai = ai->ai_next) {
#if defined(_WIN32)
            SOCKET s = ::socket(ai->ai_family, ai->ai_socktype, ai->ai_protocol);
            if (s == INVALID_SOCKET) continue;
            fd = (int)s;
#else
            fd = ::socket(ai->ai_family, ai->ai_socktype, ai->ai_protocol);
            if (fd < 0) continue;
#endif
            set_nonblocking(fd, true);
            if (cfg_.tcp_nodelay) set_nodelay(fd, true);
            if (cfg_.tcp_keepalive) set_keepalive(fd, true);
            if (cfg_.sndbuf_bytes > 0) set_sndbuf(fd, cfg_.sndbuf_bytes);
            if (cfg_.rcvbuf_bytes > 0) set_rcvbuf(fd, cfg_.rcvbuf_bytes);

            int rc = ::connect(
#if defined(_WIN32)
                (SOCKET)fd,
#else
                fd,
#endif
                ai->ai_addr, (socklen_t)ai->ai_addrlen);

            if (rc == 0) {
                freeaddrinfo(res);
                return fd;
            }

            int e = last_net_err();
            bool inprog = false;
#if defined(_WIN32)
            inprog = (e == WSAEWOULDBLOCK || e == WSAEINPROGRESS || e == WSAEALREADY);
#else
            inprog = (e == EINPROGRESS || e == EALREADY);
#endif
            if (!inprog) {
                closesock_compat(fd);
                fd = -1;
                continue;
            }

            int wr = wait_writable(fd, timeout_ms);
            if (wr > 0) {
                int soerr = sock_error(fd);
                if (soerr == 0) {
                    freeaddrinfo(res);
                    return fd;
                }
            }
            closesock_compat(fd);
            fd = -1;
        }

        freeaddrinfo(res);
        return -1;
    }

    Endpoint endpoint_;
    ClientConfig cfg_;

    int fd_ = -1;
    std::atomic<bool> connected_{false};
    std::atomic<uint64_t> last_used_ns_{0};
};

struct ConnectionHandle {
    uint64_t id = 0;
};

class NetworkClient;

class PooledConn {
public:
    PooledConn() = default;
    PooledConn(NetworkClient* owner, ConnectionHandle h, std::shared_ptr<Connection> c)
        : owner_(owner), handle_(h), conn_(std::move(c)) {}
    PooledConn(const PooledConn&) = delete;
    PooledConn& operator=(const PooledConn&) = delete;

    PooledConn(PooledConn&& o) noexcept { *this = std::move(o); }
    PooledConn& operator=(PooledConn&& o) noexcept {
        if (this == &o) return *this;
        release();
        owner_ = o.owner_;
        handle_ = o.handle_;
        conn_ = std::move(o.conn_);
        o.owner_ = nullptr;
        o.handle_ = {};
        return *this;
    }

    ~PooledConn() { release(); }

    Connection* get() const noexcept { return conn_.get(); }
    Connection& operator*() const { return *conn_; }
    Connection* operator->() const noexcept { return conn_.get(); }
    explicit operator bool() const noexcept { return (bool)conn_; }
    ConnectionHandle handle() const noexcept { return handle_; }

    void release();

private:
    NetworkClient* owner_ = nullptr;
    ConnectionHandle handle_{};
    std::shared_ptr<Connection> conn_;
};

class NetworkClient {
public:
    explicit NetworkClient(ClientConfig cfg = {}) : cfg_(cfg) {
        (void)netinit_;
        stop_.store(false, std::memory_order_release);
        janitor_ = std::thread([this] { janitor_loop(); });
    }

    ~NetworkClient() {
        stop_.store(true, std::memory_order_release);
        cv_.notify_all();
        if (janitor_.joinable()) janitor_.join();
        std::lock_guard<std::mutex> lk(mu_);
        by_id_.clear();
        pools_.clear();
    }

    NetworkClient(const NetworkClient&) = delete;
    NetworkClient& operator=(const NetworkClient&) = delete;

    PooledConn acquire(const Endpoint& ep, ConnectionHandle* reuse_handle = nullptr) {
        if (reuse_handle && reuse_handle->id) {
            std::shared_ptr<Connection> c;
            {
                std::lock_guard<std::mutex> lk(mu_);
                auto it = by_id_.find(reuse_handle->id);
                if (it != by_id_.end()) {
                    Entry& e = it->second;
                    if (!e.in_use) {
                        e.in_use = true;
                        c = e.conn;
                    }
                }
            }
            if (c) {
                ensure_connected_or_retry(*reuse_handle, c);
                return PooledConn(this, *reuse_handle, std::move(c));
            }
        }

        uint64_t id = 0;
        std::shared_ptr<Connection> c;

        {
            std::lock_guard<std::mutex> lk(mu_);
            auto& dq = pools_[ep];
            while (!dq.empty()) {
                uint64_t cand = dq.front();
                dq.pop_front();
                auto it = by_id_.find(cand);
                if (it == by_id_.end()) continue;
                Entry& e = it->second;
                if (e.in_use) continue;
                e.in_use = true;
                id = cand;
                c = e.conn;
                break;
            }

            if (!c) {
                if ((uint32_t)count_total_unordered(ep) >= cfg_.pool_per_endpoint) {
                    // force-create anyway under pressure: evict oldest idle if possible
                    evict_one_idle_unlocked(ep);
                }
                id = next_id_.fetch_add(1, std::memory_order_relaxed);
                c = std::make_shared<Connection>(ep, cfg_);
                by_id_.emplace(id, Entry{ep, c, true});
            }
        }

        ConnectionHandle h{id};
        ensure_connected_or_retry(h, c);
        return PooledConn(this, h, std::move(c));
    }

    bool perform_with_retry(const Endpoint& ep,
                            std::function<bool(Connection&)> op,
                            ConnectionHandle* inout_handle = nullptr) {
        ConnectionHandle local{};
        ConnectionHandle* ph = inout_handle ? inout_handle : &local;

        uint32_t attempts = cfg_.max_retries + 1;
        for (uint32_t i = 0; i < attempts; ++i) {
            auto pc = acquire(ep, ph);
            if (!pc) {
                backoff(i);
                continue;
            }
            bool ok = false;
            try { ok = op(*pc); }
            catch (...) { ok = false; }

            if (ok && pc->is_connected()) {
                if (inout_handle) *inout_handle = pc.handle();
                return true;
            }

            fail_connection(pc.handle(), true);
            pc.release();
            backoff(i);
        }
        return false;
    }

    void release(ConnectionHandle h, bool healthy) {
        if (!h.id) return;
        std::lock_guard<std::mutex> lk(mu_);
        auto it = by_id_.find(h.id);
        if (it == by_id_.end()) return;

        Entry& e = it->second;
        if (!e.in_use) return;

        e.in_use = false;
        if (!healthy || !e.conn || !e.conn->is_connected()) {
            destroy_unlocked(h.id, true);
            return;
        }
        e.conn->last_used_ns(); // touch
        pools_[e.ep].push_back(h.id);
        cv_.notify_one();
    }

    void fail_connection(ConnectionHandle h, bool destroy) {
        if (!h.id) return;
        std::lock_guard<std::mutex> lk(mu_);
        auto it = by_id_.find(h.id);
        if (it == by_id_.end()) return;
        Entry& e = it->second;
        if (e.conn) e.conn->close(true);
        if (destroy) {
            destroy_unlocked(h.id, false);
        } else {
            e.in_use = false;
            pools_[e.ep].push_back(h.id);
            cv_.notify_one();
        }
    }

private:
    friend class PooledConn;

    struct Entry {
        Endpoint ep;
        std::shared_ptr<Connection> conn;
        bool in_use = false;
    };

    void ensure_connected_or_retry(ConnectionHandle h, const std::shared_ptr<Connection>& c) {
        if (!c) return;
        if (c->is_connected()) return;
        uint32_t attempts = cfg_.max_retries + 1;
        for (uint32_t i = 0; i < attempts; ++i) {
            if (c->connect_or_reconnect(cfg_.connect_timeout_ms)) return;
            backoff(i);
        }
        // leave as disconnected; will be treated as unhealthy on release/op
    }

    void backoff(uint32_t attempt) {
        uint32_t base = cfg_.base_backoff_ms;
        uint32_t maxb = cfg_.max_backoff_ms;
        uint64_t b = (uint64_t)base << (attempt > 16 ? 16 : attempt);
        if (b > maxb) b = maxb;
        sleep_ms(jitter_ms((uint32_t)b, cfg_.jitter_max_ms));
    }

    size_t count_total_unordered(const Endpoint& ep) {
        size_t c = 0;
        for (auto& kv : by_id_) if (kv.second.ep == ep) ++c;
        return c;
    }

    void evict_one_idle_unlocked(const Endpoint& ep) {
        auto pit = pools_.find(ep);
        if (pit == pools_.end()) return;
        auto& dq = pit->second;
        while (!dq.empty()) {
            uint64_t id = dq.front();
            dq.pop_front();
            auto it = by_id_.find(id);
            if (it == by_id_.end()) continue;
            Entry& e = it->second;
            if (e.in_use) continue;
            destroy_unlocked(id, false);
            return;
        }
    }

    void destroy_unlocked(uint64_t id, bool assume_in_use) {
        auto it = by_id_.find(id);
        if (it == by_id_.end()) return;
        Entry& e = it->second;
        if (!assume_in_use && e.in_use) return;

        if (e.conn) e.conn->close(true);

        auto pit = pools_.find(e.ep);
        if (pit != pools_.end()) {
            auto& dq = pit->second;
            for (size_t i = 0; i < dq.size();) {
                if (dq[i] == id) dq.erase(dq.begin() + (ptrdiff_t)i);
                else ++i;
            }
            if (dq.empty()) pools_.erase(pit);
        }

        by_id_.erase(it);
    }

    void janitor_loop() {
        while (!stop_.load(std::memory_order_acquire)) {
            std::unique_lock<std::mutex> lk(mu_);
            cv_.wait_for(lk, std::chrono::milliseconds(250), [&] { return stop_.load(std::memory_order_acquire); });
            if (stop_.load(std::memory_order_acquire)) break;

            uint64_t ttl_ns = (uint64_t)cfg_.idle_ttl_ms * 1000000ULL;
            uint64_t n = now_ns();

            std::vector<uint64_t> to_destroy;
            to_destroy.reserve(64);

            for (auto& kv : by_id_) {
                uint64_t id = kv.first;
                Entry& e = kv.second;
                if (e.in_use) continue;
                if (!e.conn) { to_destroy.push_back(id); continue; }
                uint64_t lu = e.conn->last_used_ns();
                if (lu && (n - lu) > ttl_ns) to_destroy.push_back(id);
                else if (!e.conn->is_connected()) to_destroy.push_back(id);
            }

            for (uint64_t id : to_destroy) destroy_unlocked(id, false);
        }
    }

    NetInit netinit_;
    ClientConfig cfg_;

    std::atomic<bool> stop_{false};
    std::thread janitor_;
    std::condition_variable cv_;
    std::mutex mu_;

    std::atomic<uint64_t> next_id_{1};
    std::unordered_map<uint64_t, Entry> by_id_;
    std::unordered_map<Endpoint, std::deque<uint64_t>, EndpointHash> pools_;
};

inline void PooledConn::release() {
    if (!owner_ || !conn_ || !handle_.id) {
        owner_ = nullptr;
        conn_.reset();
        handle_ = {};
        return;
    }
    bool healthy = conn_->is_connected();
    auto* owner = owner_;
    ConnectionHandle h = handle_;
    owner_ = nullptr;
    handle_ = {};
    conn_.reset();
    owner->release(h, healthy);
}

} // namespace hpn