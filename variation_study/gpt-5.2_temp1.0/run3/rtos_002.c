# Generated by openai (gpt-5.2)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <stdint.h>
#include <string.h>

#ifndef PACKET_MAX_LEN
#define PACKET_MAX_LEN 1500u
#endif

typedef struct
{
    uint16_t len;
    const uint8_t *data;
} NetPacket_t;

extern QueueHandle_t g_netRxQueue;

static void ProcessPacket(const uint8_t *data, uint16_t len);

static void vNetPacketTask(void *pvParameters)
{
    (void)pvParameters;

    NetPacket_t pkt;
    uint8_t localBuf[PACKET_MAX_LEN];

    for (;;)
    {
        if (xQueueReceive(g_netRxQueue, &pkt, portMAX_DELAY) == pdTRUE)
        {
            uint16_t copyLen = pkt.len;
            if (copyLen > sizeof(localBuf))
                copyLen = (uint16_t)sizeof(localBuf);

            if (pkt.data != NULL && copyLen != 0u)
            {
                memcpy(localBuf, pkt.data, copyLen);
                ProcessPacket(localBuf, copyLen);
            }
            else
            {
                ProcessPacket(NULL, 0u);
            }
        }
    }
}

TaskHandle_t CreateNetPacketTask(UBaseType_t priority)
{
    TaskHandle_t h = NULL;
    (void)xTaskCreate(vNetPacketTask,
                      "NetPkt",
                      configMINIMAL_STACK_SIZE,
                      NULL,
                      priority,
                      &h);
    return h;
}

static void ProcessPacket(const uint8_t *data, uint16_t len)
{
    (void)data;
    (void)len;
}