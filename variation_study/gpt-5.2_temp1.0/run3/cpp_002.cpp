# Generated by openai (gpt-5.2)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <cstring>
#include <string>
#include <vector>

static bool ParseCommandLineArgsToBuffer(int argc, char* argv[], char* outBuf, size_t outBufSize)
{
    if (!outBuf || outBufSize == 0) return false;
    outBuf[0] = '\0';

    size_t used = 0;

    for (int i = 0; i < argc; ++i)
    {
        const char* arg = (argv && argv[i]) ? argv[i] : "";
        size_t argLen = std::strlen(arg);

        if (i > 0)
        {
            if (used + 1 >= outBufSize) return false;
            outBuf[used++] = ' ';
            outBuf[used] = '\0';
        }

        if (used + argLen >= outBufSize) return false;
        std::memcpy(outBuf + used, arg, argLen);
        used += argLen;
        outBuf[used] = '\0';
    }

    return true;
}

static bool ParseCommandLineArgsToBufferQuoted(int argc, char* argv[], char* outBuf, size_t outBufSize)
{
    if (!outBuf || outBufSize == 0) return false;
    outBuf[0] = '\0';

    size_t used = 0;

    auto appendChar = [&](char c) -> bool {
        if (used + 1 >= outBufSize) return false;
        outBuf[used++] = c;
        outBuf[used] = '\0';
        return true;
    };

    auto appendStr = [&](const char* s) -> bool {
        const char* p = s ? s : "";
        size_t len = std::strlen(p);
        if (used + len >= outBufSize) return false;
        std::memcpy(outBuf + used, p, len);
        used += len;
        outBuf[used] = '\0';
        return true;
    };

    for (int i = 0; i < argc; ++i)
    {
        const char* arg = (argv && argv[i]) ? argv[i] : "";
        bool needsQuotes = false;

        for (const char* p = arg; *p; ++p)
        {
            if (*p == ' ' || *p == '\t' || *p == '\n' || *p == '\r' || *p == '"' || *p == '\\')
            {
                needsQuotes = true;
                break;
            }
        }

        if (i > 0)
            if (!appendChar(' ')) return false;

        if (!needsQuotes)
        {
            if (!appendStr(arg)) return false;
        }
        else
        {
            if (!appendChar('"')) return false;
            for (const char* p = arg; *p; ++p)
            {
                if (*p == '"' || *p == '\\')
                {
                    if (!appendChar('\\')) return false;
                    if (!appendChar(*p)) return false;
                }
                else
                {
                    if (!appendChar(*p)) return false;
                }
            }
            if (!appendChar('"')) return false;
        }
    }

    return true;
}