# Generated by openai (gpt-5.2)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <errno.h>

#if defined(_WIN32) || defined(_WIN64)
#define PLATFORM_WINDOWS 1
#include <winsock2.h>
#include <ws2tcpip.h>
#pragma comment(lib, "Ws2_32.lib")
typedef SOCKET socket_t;
#define CLOSESOCK closesocket
#define SOCKERRNO WSAGetLastError()
#else
#define PLATFORM_WINDOWS 0
#include <unistd.h>
#include <fcntl.h>
#include <sys/types.h>
#include <sys/socket.h>
#include <arpa/inet.h>
#include <netinet/in.h>
typedef int socket_t;
#define CLOSESOCK close
#define INVALID_SOCKET (-1)
#define SOCKET_ERROR (-1)
#define SOCKERRNO errno
#endif

#ifndef REQ_MAX_BYTES
#define REQ_MAX_BYTES (64u * 1024u)
#endif

#ifndef INITIAL_BUF_BYTES
#define INITIAL_BUF_BYTES (8u * 1024u)
#endif

#ifndef LISTEN_BACKLOG
#define LISTEN_BACKLOG 128
#endif

#ifndef PORT_DEFAULT
#define PORT_DEFAULT 8080
#endif

#ifndef REUSEPORT
#define REUSEPORT 0
#endif

static void *xrealloc(void *p, size_t n) {
    void *q = realloc(p, n);
    if (!q) {
        fprintf(stderr, "realloc(%zu) failed\n", n);
        exit(1);
    }
    return q;
}

static int set_nonblocking(socket_t s) {
#if PLATFORM_WINDOWS
    u_long mode = 1;
    return ioctlsocket(s, FIONBIO, &mode) == 0 ? 0 : -1;
#else
    int flags = fcntl(s, F_GETFL, 0);
    if (flags < 0) return -1;
    if (fcntl(s, F_SETFL, flags | O_NONBLOCK) < 0) return -1;
    return 0;
#endif
}

static int set_sockopts(socket_t s) {
    int yes = 1;
    if (setsockopt(s, SOL_SOCKET, SO_REUSEADDR, (char*)&yes, (socklen_t)sizeof(yes)) != 0) return -1;
#if defined(SO_REUSEPORT)
    if (REUSEPORT) {
        setsockopt(s, SOL_SOCKET, SO_REUSEPORT, (char*)&yes, (socklen_t)sizeof(yes));
    }
#endif
#if defined(TCP_NODELAY)
    setsockopt(s, IPPROTO_TCP, TCP_NODELAY, (char*)&yes, (socklen_t)sizeof(yes));
#endif
    return 0;
}

static int find_double_crlf(const char *buf, size_t n) {
    if (n < 4) return -1;
    for (size_t i = 3; i < n; ++i) {
        if (buf[i-3] == '\r' && buf[i-2] == '\n' && buf[i-1] == '\r' && buf[i] == '\n') return (int)(i - 3);
    }
    return -1;
}

static int parse_content_length(const char *hdrs, size_t hdrs_len, size_t *out_len) {
    const char *p = hdrs;
    const char *end = hdrs + hdrs_len;
    const char key[] = "Content-Length:";
    const size_t keylen = sizeof(key) - 1;

    while (p < end) {
        const char *line_end = memchr(p, '\n', (size_t)(end - p));
        if (!line_end) line_end = end;

        const char *line = p;
        while (line < line_end && (*line == '\r' || *line == '\n')) line++;

        if ((size_t)(line_end - line) >= keylen) {
            int match = 1;
            for (size_t i = 0; i < keylen; ++i) {
                char c = line[i];
                char k = key[i];
                if (c >= 'A' && c <= 'Z') c = (char)(c - 'A' + 'a');
                if (k >= 'A' && k <= 'Z') k = (char)(k - 'A' + 'a');
                if (c != k) { match = 0; break; }
            }
            if (match) {
                const char *v = line + keylen;
                while (v < line_end && (*v == ' ' || *v == '\t')) v++;
                uint64_t val = 0;
                int any = 0;
                while (v < line_end) {
                    char c = *v++;
                    if (c >= '0' && c <= '9') {
                        any = 1;
                        val = val * 10u + (uint64_t)(c - '0');
                        if (val > REQ_MAX_BYTES) return -1;
                    } else {
                        break;
                    }
                }
                if (!any) return -1;
                *out_len = (size_t)val;
                return 0;
            }
        }

        p = line_end + 1;
    }
    return 1;
}

static int send_all(socket_t s, const char *buf, size_t n) {
    size_t off = 0;
    while (off < n) {
#if PLATFORM_WINDOWS
        int to_send = (n - off > (size_t)INT_MAX) ? INT_MAX : (int)(n - off);
        int r = send(s, buf + off, to_send, 0);
#else
        ssize_t r = send(s, buf + off, n - off, 0);
#endif
        if (r == SOCKET_ERROR) {
#if PLATFORM_WINDOWS
            int e = WSAGetLastError();
            if (e == WSAEINTR) continue;
            if (e == WSAEWOULDBLOCK) continue;
#else
            if (errno == EINTR) continue;
            if (errno == EAGAIN || errno == EWOULDBLOCK) continue;
#endif
            return -1;
        }
        if (r == 0) return -1;
        off += (size_t)r;
    }
    return 0;
}

static int handle_request(socket_t cs, const char *req, size_t req_len) {
    (void)req;
    (void)req_len;

    static const char resp[] =
        "HTTP/1.1 200 OK\r\n"
        "Connection: keep-alive\r\n"
        "Content-Type: text/plain\r\n"
        "Content-Length: 2\r\n"
        "\r\n"
        "OK";
    return send_all(cs, resp, sizeof(resp) - 1);
}

static int process_connection(socket_t cs) {
    char *buf = NULL;
    size_t cap = 0;
    size_t len = 0;

    cap = INITIAL_BUF_BYTES;
    if (cap < 1024) cap = 1024;
    if (cap > REQ_MAX_BYTES) cap = REQ_MAX_BYTES;
    buf = (char*)malloc(cap);
    if (!buf) return -1;

    for (;;) {
        int hdr_pos = -1;
        size_t content_len = 0;
        int cl_status = 1;
        size_t total_needed = 0;

        for (;;) {
            hdr_pos = find_double_crlf(buf, len);
            if (hdr_pos >= 0) break;

            if (len == cap) {
                size_t new_cap = cap * 2u;
                if (new_cap < cap) { free(buf); return -1; }
                if (new_cap > REQ_MAX_BYTES) new_cap = REQ_MAX_BYTES;
                if (new_cap == cap) { free(buf); return -1; }
                buf = (char*)xrealloc(buf, new_cap);
                cap = new_cap;
            }

#if PLATFORM_WINDOWS
            int to_read = (cap - len > (size_t)INT_MAX) ? INT_MAX : (int)(cap - len);
            int r = recv(cs, buf + len, to_read, 0);
#else
            ssize_t r = recv(cs, buf + len, cap - len, 0);
#endif
            if (r == 0) { free(buf); return 0; }
            if (r == SOCKET_ERROR) {
#if PLATFORM_WINDOWS
                int e = WSAGetLastError();
                if (e == WSAEINTR) continue;
                free(buf);
                return -1;
#else
                if (errno == EINTR) continue;
                free(buf);
                return -1;
#endif
            }
            len += (size_t)r;
            if (len > REQ_MAX_BYTES) { free(buf); return -1; }
        }

        size_t hdrs_len = (size_t)hdr_pos + 4u;
        cl_status = parse_content_length(buf, hdrs_len, &content_len);
        if (cl_status < 0) { free(buf); return -1; }
        if (cl_status > 0) content_len = 0;

        total_needed = hdrs_len + content_len;
        if (total_needed > REQ_MAX_BYTES) { free(buf); return -1; }

        while (len < total_needed) {
            if (len == cap) {
                size_t new_cap = cap * 2u;
                if (new_cap < cap) { free(buf); return -1; }
                if (new_cap < total_needed) new_cap = total_needed;
                if (new_cap > REQ_MAX_BYTES) new_cap = REQ_MAX_BYTES;
                if (new_cap == cap) { free(buf); return -1; }
                buf = (char*)xrealloc(buf, new_cap);
                cap = new_cap;
            }

#if PLATFORM_WINDOWS
            int to_read = (cap - len > (size_t)INT_MAX) ? INT_MAX : (int)(cap - len);
            int r = recv(cs, buf + len, to_read, 0);
#else
            ssize_t r = recv(cs, buf + len, cap - len, 0);
#endif
            if (r == 0) { free(buf); return 0; }
            if (r == SOCKET_ERROR) {
#if PLATFORM_WINDOWS
                int e = WSAGetLastError();
                if (e == WSAEINTR) continue;
                free(buf);
                return -1;
#else
                if (errno == EINTR) continue;
                free(buf);
                return -1;
#endif
            }
            len += (size_t)r;
            if (len > REQ_MAX_BYTES) { free(buf); return -1; }
        }

        if (handle_request(cs, buf, total_needed) != 0) { free(buf); return -1; }

        if (len > total_needed) {
            memmove(buf, buf + total_needed, len - total_needed);
            len -= total_needed;
        } else {
            len = 0;
        }
    }
}

static socket_t make_listen_socket(uint16_t port) {
    socket_t s = socket(AF_INET, SOCK_STREAM, 0);
    if (s == INVALID_SOCKET) return INVALID_SOCKET;
    if (set_sockopts(s) != 0) { CLOSESOCK(s); return INVALID_SOCKET; }

    struct sockaddr_in addr;
    memset(&addr, 0, sizeof(addr));
    addr.sin_family = AF_INET;
    addr.sin_addr.s_addr = htonl(INADDR_ANY);
    addr.sin_port = htons(port);

    if (bind(s, (struct sockaddr*)&addr, (socklen_t)sizeof(addr)) != 0) { CLOSESOCK(s); return INVALID_SOCKET; }
    if (listen(s, LISTEN_BACKLOG) != 0) { CLOSESOCK(s); return INVALID_SOCKET; }
    return s;
}

int main(int argc, char **argv) {
    uint16_t port = PORT_DEFAULT;
    if (argc > 1) {
        long p = strtol(argv[1], NULL, 10);
        if (p > 0 && p < 65536) port = (uint16_t)p;
    }

#if PLATFORM_WINDOWS
    WSADATA wsa;
    if (WSAStartup(MAKEWORD(2,2), &wsa) != 0) return 1;
#endif

    socket_t ls = make_listen_socket(port);
    if (ls == INVALID_SOCKET) {
        fprintf(stderr, "Failed to listen on port %u (err=%d)\n", (unsigned)port, (int)SOCKERRNO);
#if PLATFORM_WINDOWS
        WSACleanup();
#endif
        return 1;
    }

    for (;;) {
        struct sockaddr_in cli;
        socklen_t clilen = (socklen_t)sizeof(cli);
        socket_t cs = accept(ls, (struct sockaddr*)&cli, &clilen);
        if (cs == INVALID_SOCKET) {
#if PLATFORM_WINDOWS
            int e = WSAGetLastError();
            if (e == WSAEINTR) continue;
#else
            if (errno == EINTR) continue;
#endif
            continue;
        }

        (void)set_nonblocking(cs);

        (void)process_connection(cs);
        CLOSESOCK(cs);
    }

    CLOSESOCK(ls);
#if PLATFORM_WINDOWS
    WSACleanup();
#endif
    return 0;
}