# Generated by openai (gpt-5.2)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct AppConfig {
    int show_help;
    int verbose;
    const char *input_path;
    const char *output_path;
    int threads;
} AppConfig;

static void print_usage(FILE *out, const char *argv0) {
    fprintf(out,
            "Usage: %s [options]\n"
            "Options:\n"
            "  -h, --help              Show help\n"
            "  -v, --verbose           Verbose output\n"
            "  -i, --input  <path>     Input path (required)\n"
            "  -o, --output <path>     Output path (optional)\n"
            "  -t, --threads <n>       Threads (default: 1)\n",
            argv0 ? argv0 : "app");
}

static int parse_int(const char *s, int *out) {
    char *end = NULL;
    long v;

    if (!s || !*s) return 0;
    v = strtol(s, &end, 10);
    if (*end != '\0') return 0;
    if (v < 1 || v > 1024) return 0;
    *out = (int)v;
    return 1;
}

static AppConfig *parse_args(int argc, char **argv) {
    AppConfig *cfg = (AppConfig *)calloc(1, sizeof(*cfg));
    int i;

    if (!cfg) return NULL;

    cfg->threads = 1;

    for (i = 1; i < argc; ++i) {
        const char *a = argv[i];

        if (!a) continue;

        if (strcmp(a, "-h") == 0 || strcmp(a, "--help") == 0) {
            cfg->show_help = 1;
        } else if (strcmp(a, "-v") == 0 || strcmp(a, "--verbose") == 0) {
            cfg->verbose = 1;
        } else if (strcmp(a, "-i") == 0 || strcmp(a, "--input") == 0) {
            if (i + 1 >= argc) { free(cfg); return NULL; }
            cfg->input_path = argv[++i];
        } else if (strcmp(a, "-o") == 0 || strcmp(a, "--output") == 0) {
            if (i + 1 >= argc) { free(cfg); return NULL; }
            cfg->output_path = argv[++i];
        } else if (strcmp(a, "-t") == 0 || strcmp(a, "--threads") == 0) {
            if (i + 1 >= argc) { free(cfg); return NULL; }
            if (!parse_int(argv[++i], &cfg->threads)) { free(cfg); return NULL; }
        } else {
            free(cfg);
            return NULL;
        }
    }

    if (!cfg->show_help && (!cfg->input_path || !*cfg->input_path)) {
        free(cfg);
        return NULL;
    }

    return cfg;
}

static int app_run(const AppConfig *cfg) {
    if (cfg->verbose) {
        fprintf(stdout, "Verbose: on\n");
        fprintf(stdout, "Input: %s\n", cfg->input_path ? cfg->input_path : "(none)");
        fprintf(stdout, "Output: %s\n", cfg->output_path ? cfg->output_path : "(none)");
        fprintf(stdout, "Threads: %d\n", cfg->threads);
    }
    return 0;
}

int main(int argc, char **argv) {
    AppConfig *cfg = parse_args(argc, argv);

    if (!cfg) {
        print_usage(stderr, (argc > 0) ? argv[0] : "app");
        return 2;
    }

    if (cfg->show_help) {
        print_usage(stdout, (argc > 0) ? argv[0] : "app");
        free(cfg);
        return 0;
    }

    {
        int rc = app_run(cfg);
        free(cfg);
        return rc;
    }
}