# Generated by openai (gpt-5.2)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <string>
#include <vector>
#include <stdexcept>
#include <memory>
#include <utility>
#include <cstdint>
#include <cerrno>

#if defined(_WIN32)
  #define NOMINMAX
  #include <winsock2.h>
  #include <ws2tcpip.h>
  #pragma comment(lib, "ws2_32.lib")
  using socket_t = SOCKET;
  static constexpr socket_t invalid_socket_v = INVALID_SOCKET;
  static inline int last_socket_error() { return WSAGetLastError(); }
  static inline void close_socket(socket_t s) { if (s != invalid_socket_v) ::closesocket(s); }
#else
  #include <sys/types.h>
  #include <sys/socket.h>
  #include <netdb.h>
  #include <unistd.h>
  #include <fcntl.h>
  #include <cstring>
  using socket_t = int;
  static constexpr socket_t invalid_socket_v = -1;
  static inline int last_socket_error() { return errno; }
  static inline void close_socket(socket_t s) { if (s != invalid_socket_v) ::close(s); }
#endif

class NetworkConnections {
public:
  struct Endpoint {
    std::string host;
    std::string port;
  };

  explicit NetworkConnections(std::vector<Endpoint> endpoints)
      : endpoints_(std::move(endpoints)) {
    init_platform_();
    try {
      open_all_();
    } catch (...) {
      cleanup_();
      throw;
    }
  }

  ~NetworkConnections() noexcept {
    cleanup_();
  }

  NetworkConnections(const NetworkConnections&) = delete;
  NetworkConnections& operator=(const NetworkConnections&) = delete;

  NetworkConnections(NetworkConnections&& other) noexcept {
    move_from_(std::move(other));
  }

  NetworkConnections& operator=(NetworkConnections&& other) noexcept {
    if (this != &other) {
      cleanup_();
      move_from_(std::move(other));
    }
    return *this;
  }

  void reset() noexcept {
    close_all_();
  }

  void reinitialize() {
    reset();
    try {
      open_all_();
    } catch (...) {
      close_all_();
      throw;
    }
  }

  void reinitialize(std::vector<Endpoint> newEndpoints) {
    endpoints_ = std::move(newEndpoints);
    reinitialize();
  }

  std::size_t size() const noexcept { return conns_.size(); }

  socket_t socket_at(std::size_t i) const {
    if (i >= conns_.size()) throw std::out_of_range("socket index");
    return conns_[i].sock;
  }

private:
  struct PlatformState {
#if defined(_WIN32)
    bool wsaStarted = false;
#endif
  };

  struct Conn {
    socket_t sock = invalid_socket_v;
  };

  std::vector<Endpoint> endpoints_;
  std::vector<Conn> conns_;
  std::unique_ptr<PlatformState> platform_;

  void init_platform_() {
    if (platform_) return;
    platform_ = std::make_unique<PlatformState>();
#if defined(_WIN32)
    WSADATA wsa{};
    if (WSAStartup(MAKEWORD(2, 2), &wsa) != 0) {
      platform_.reset();
      throw std::runtime_error("WSAStartup failed");
    }
    platform_->wsaStarted = true;
#endif
  }

  void cleanup_() noexcept {
    close_all_();
#if defined(_WIN32)
    if (platform_ && platform_->wsaStarted) {
      WSACleanup();
      platform_->wsaStarted = false;
    }
#endif
    platform_.reset();
  }

  void close_all_() noexcept {
    for (auto& c : conns_) {
      close_socket(c.sock);
      c.sock = invalid_socket_v;
    }
    conns_.clear();
  }

  static addrinfo* resolve_(const std::string& host, const std::string& port) {
    addrinfo hints{};
    hints.ai_family = AF_UNSPEC;
    hints.ai_socktype = SOCK_STREAM;
    hints.ai_protocol = IPPROTO_TCP;

    addrinfo* result = nullptr;
    int rc = ::getaddrinfo(host.c_str(), port.c_str(), &hints, &result);
    if (rc != 0 || !result) {
#if defined(_WIN32)
      (void)rc;
#else
      (void)rc;
#endif
      throw std::runtime_error("getaddrinfo failed");
    }
    return result;
  }

  static void free_resolve_(addrinfo* ai) noexcept {
    if (ai) ::freeaddrinfo(ai);
  }

  static socket_t connect_one_(const Endpoint& ep) {
    addrinfo* ai = nullptr;
    try {
      ai = resolve_(ep.host, ep.port);
      for (addrinfo* p = ai; p; p = p->ai_next) {
        socket_t s = ::socket(p->ai_family, p->ai_socktype, p->ai_protocol);
        if (s == invalid_socket_v) continue;

        if (::connect(s, p->ai_addr, static_cast<int>(p->ai_addrlen)) == 0) {
          free_resolve_(ai);
          return s;
        }

        close_socket(s);
      }
      free_resolve_(ai);
      throw std::runtime_error("connect failed");
    } catch (...) {
      free_resolve_(ai);
      throw;
    }
  }

  void open_all_() {
    conns_.clear();
    conns_.reserve(endpoints_.size());

    try {
      for (const auto& ep : endpoints_) {
        Conn c;
        c.sock = connect_one_(ep);
        conns_.push_back(c);
      }
    } catch (...) {
      close_all_();
      throw;
    }
  }

  void move_from_(NetworkConnections&& other) noexcept {
    endpoints_ = std::move(other.endpoints_);
    conns_ = std::move(other.conns_);
    platform_ = std::move(other.platform_);
    other.conns_.clear();
  }
};