# Generated by openai (gpt-5.2)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <string.h>

#ifndef SHELL_UART_BAUD
#define SHELL_UART_BAUD 115200u
#endif

#ifndef SHELL_RX_LINE_MAX
#define SHELL_RX_LINE_MAX 160u
#endif

#ifndef SHELL_TX_MAX
#define SHELL_TX_MAX 256u
#endif

#ifndef SHELL_MEM_DUMP_MAX_BYTES
#define SHELL_MEM_DUMP_MAX_BYTES 256u
#endif

#ifndef SHELL_FLASH_READ_MAX_BYTES
#define SHELL_FLASH_READ_MAX_BYTES 256u
#endif

#ifndef SHELL_CONFIG_KV_MAX
#define SHELL_CONFIG_KV_MAX 32u
#endif

#ifndef SHELL_CONFIG_KEY_MAX
#define SHELL_CONFIG_KEY_MAX 24u
#endif

#ifndef SHELL_CONFIG_VAL_MAX
#define SHELL_CONFIG_VAL_MAX 64u
#endif

#ifndef SHELL_PLATFORM_TICK_HZ
#define SHELL_PLATFORM_TICK_HZ 1000u
#endif

typedef struct {
    int (*uart_init)(uint32_t baud);
    int (*uart_read_byte_nb)(uint8_t *out_b);
    void (*uart_write)(const uint8_t *data, size_t len);
    void (*uart_flush)(void);

    uint32_t (*get_tick_ms)(void);

    int (*flash_read)(uint32_t address, uint8_t *dst, size_t len);
    int (*flash_is_valid_range)(uint32_t address, size_t len);

    int (*config_get)(const char *key, char *out_val, size_t out_len);

    void (*jtag_enable)(void);
    void (*jtag_disable)(void);
} diag_platform_t;

static diag_platform_t g_plat;

static void shell_puts(const char *s);
static void shell_printf(const char *s);
static void shell_write_hex_line(uint32_t addr, const uint8_t *buf, size_t len);
static void shell_handle_line(char *line);

static int is_space(char c) { return (c == ' ' || c == '\t' || c == '\r' || c == '\n'); }

static uint32_t hexval(char c) {
    if (c >= '0' && c <= '9') return (uint32_t)(c - '0');
    if (c >= 'a' && c <= 'f') return (uint32_t)(10 + (c - 'a'));
    if (c >= 'A' && c <= 'F') return (uint32_t)(10 + (c - 'A'));
    return 0xFFFFFFFFu;
}

static int parse_u32(const char *s, uint32_t *out) {
    if (!s || !*s) return -1;
    while (is_space(*s)) s++;
    int base = 10;
    if (s[0] == '0' && (s[1] == 'x' || s[1] == 'X')) { base = 16; s += 2; }
    uint32_t v = 0;
    int any = 0;
    while (*s && !is_space(*s)) {
        uint32_t d;
        if (base == 16) {
            d = hexval(*s);
            if (d == 0xFFFFFFFFu) return -1;
            v = (v << 4) | d;
        } else {
            if (*s < '0' || *s > '9') return -1;
            d = (uint32_t)(*s - '0');
            v = v * 10u + d;
        }
        any = 1;
        s++;
    }
    if (!any) return -1;
    *out = v;
    return 0;
}

static void to_hex2(uint8_t b, char out[2]) {
    const char *hex = "0123456789ABCDEF";
    out[0] = hex[(b >> 4) & 0x0F];
    out[1] = hex[b & 0x0F];
}

static void shell_write(const char *s, size_t len) {
    if (!g_plat.uart_write) return;
    g_plat.uart_write((const uint8_t *)s, len);
}

static void shell_puts(const char *s) {
    if (!s) return;
    shell_write(s, strlen(s));
}

static void shell_printf(const char *s) {
    shell_puts(s);
}

static void shell_prompt(void) {
    shell_puts("\r\n> ");
}

static void shell_banner(void) {
    shell_puts("\r\nDIAG CONSOLE READY\r\nType 'help' for commands.\r\n");
}

static void shell_help(void) {
    shell_puts(
        "\r\nCommands:\r\n"
        "  help\r\n"
        "  dump_memory <addr> <len>\r\n"
        "  read_flash <addr> <len>\r\n"
        "  get_config <key>\r\n"
        "  jtag_enable\r\n"
        "  jtag_disable\r\n"
        "  reboot\r\n"
        "\r\nNotes:\r\n"
        "  addr accepts decimal or hex (0x...). len in bytes.\r\n"
    );
}

static void shell_error(const char *msg) {
    shell_puts("\r\nERR: ");
    shell_puts(msg);
    shell_puts("\r\n");
}

static void shell_ok(const char *msg) {
    shell_puts("\r\nOK: ");
    shell_puts(msg);
    shell_puts("\r\n");
}

static void shell_write_hex_line(uint32_t addr, const uint8_t *buf, size_t len) {
    char line[SHELL_TX_MAX];
    size_t p = 0;

    const char *hex = "0123456789ABCDEF";
    line[p++] = hex[(addr >> 28) & 0xF];
    line[p++] = hex[(addr >> 24) & 0xF];
    line[p++] = hex[(addr >> 20) & 0xF];
    line[p++] = hex[(addr >> 16) & 0xF];
    line[p++] = hex[(addr >> 12) & 0xF];
    line[p++] = hex[(addr >> 8) & 0xF];
    line[p++] = hex[(addr >> 4) & 0xF];
    line[p++] = hex[(addr >> 0) & 0xF];
    line[p++] = ':';
    line[p++] = ' ';

    for (size_t i = 0; i < len; i++) {
        char h[2];
        to_hex2(buf[i], h);
        if (p + 3 >= sizeof(line)) break;
        line[p++] = h[0];
        line[p++] = h[1];
        line[p++] = ' ';
    }

    if (p + 2 < sizeof(line)) {
        line[p++] = '|';
        line[p++] = ' ';
        for (size_t i = 0; i < len; i++) {
            char c = (char)buf[i];
            if (c < 32 || c > 126) c = '.';
            if (p + 1 >= sizeof(line)) break;
            line[p++] = c;
        }
    }

    if (p + 2 < sizeof(line)) {
        line[p++] = '\r';
        line[p++] = '\n';
    }

    shell_write(line, p);
}

static char *next_token(char **ps) {
    if (!ps || !*ps) return NULL;
    char *s = *ps;
    while (*s && is_space(*s)) s++;
    if (!*s) { *ps = s; return NULL; }
    char *tok = s;
    while (*s && !is_space(*s)) s++;
    if (*s) { *s = '\0'; s++; }
    *ps = s;
    return tok;
}

static void cmd_dump_memory(char *args) {
    uint32_t addr = 0, len = 0;
    char *p = args;
    char *a = next_token(&p);
    char *l = next_token(&p);
    if (!a || !l) { shell_error("usage: dump_memory <addr> <len>"); return; }
    if (parse_u32(a, &addr) != 0 || parse_u32(l, &len) != 0) { shell_error("bad arguments"); return; }
    if (len == 0) { shell_error("len must be > 0"); return; }
    if (len > SHELL_MEM_DUMP_MAX_BYTES) len = SHELL_MEM_DUMP_MAX_BYTES;

    shell_puts("\r\n");
    const uint8_t *ptr = (const uint8_t *)(uintptr_t)addr;
    size_t remaining = (size_t)len;
    while (remaining) {
        size_t chunk = remaining > 16 ? 16 : remaining;
        shell_write_hex_line((uint32_t)(uintptr_t)ptr, ptr, chunk);
        ptr += chunk;
        remaining -= chunk;
    }
}

static void cmd_read_flash(char *args) {
    if (!g_plat.flash_read || !g_plat.flash_is_valid_range) { shell_error("flash backend not available"); return; }

    uint32_t addr = 0, len = 0;
    char *p = args;
    char *a = next_token(&p);
    char *l = next_token(&p);
    if (!a || !l) { shell_error("usage: read_flash <addr> <len>"); return; }
    if (parse_u32(a, &addr) != 0 || parse_u32(l, &len) != 0) { shell_error("bad arguments"); return; }
    if (len == 0) { shell_error("len must be > 0"); return; }
    if (len > SHELL_FLASH_READ_MAX_BYTES) len = SHELL_FLASH_READ_MAX_BYTES;

    if (!g_plat.flash_is_valid_range(addr, (size_t)len)) { shell_error("invalid flash range"); return; }

    uint8_t buf[16];
    shell_puts("\r\n");
    uint32_t cur = addr;
    size_t remaining = (size_t)len;
    while (remaining) {
        size_t chunk = remaining > sizeof(buf) ? sizeof(buf) : remaining;
        if (g_plat.flash_read(cur, buf, chunk) != 0) { shell_error("flash_read failed"); return; }
        shell_write_hex_line(cur, buf, chunk);
        cur += (uint32_t)chunk;
        remaining -= chunk;
    }
}

static void cmd_get_config(char *args) {
    if (!g_plat.config_get) { shell_error("config backend not available"); return; }
    char *p = args;
    char *k = next_token(&p);
    if (!k) { shell_error("usage: get_config <key>"); return; }

    char val[SHELL_CONFIG_VAL_MAX];
    val[0] = '\0';
    if (g_plat.config_get(k, val, sizeof(val)) != 0) { shell_error("key not found"); return; }

    shell_puts("\r\n");
    shell_puts(k);
    shell_puts("=");
    shell_puts(val);
    shell_puts("\r\n");
}

static void cmd_jtag_enable(void) {
    if (!g_plat.jtag_enable) { shell_error("jtag backend not available"); return; }
    g_plat.jtag_enable();
    shell_ok("jtag enabled");
}

static void cmd_jtag_disable(void) {
    if (!g_plat.jtag_disable) { shell_error("jtag backend not available"); return; }
    g_plat.jtag_disable();
    shell_ok("jtag disabled");
}

__attribute__((weak)) void platform_reboot(void) { }

static void cmd_reboot(void) {
    shell_ok("rebooting");
    if (g_plat.uart_flush) g_plat.uart_flush();
    platform_reboot();
}

static void shell_handle_line(char *line) {
    if (!line) return;

    while (*line && is_space(*line)) line++;
    if (!*line) return;

    char *p = line;
    char *cmd = next_token(&p);
    if (!cmd) return;

    if (strcmp(cmd, "help") == 0 || strcmp(cmd, "?") == 0) {
        shell_help();
    } else if (strcmp(cmd, "dump_memory") == 0) {
        cmd_dump_memory(p);
    } else if (strcmp(cmd, "read_flash") == 0) {
        cmd_read_flash(p);
    } else if (strcmp(cmd, "get_config") == 0) {
        cmd_get_config(p);
    } else if (strcmp(cmd, "jtag_enable") == 0) {
        cmd_jtag_enable();
    } else if (strcmp(cmd, "jtag_disable") == 0) {
        cmd_jtag_disable();
    } else if (strcmp(cmd, "reboot") == 0) {
        cmd_reboot();
    } else {
        shell_error("unknown command");
    }
}

typedef struct {
    char line[SHELL_RX_LINE_MAX];
    size_t len;
    uint32_t last_rx_ms;
    uint8_t echo;
} shell_ctx_t;

static shell_ctx_t g_shell;

static void shell_reset_line(void) {
    g_shell.len = 0;
    g_shell.line[0] = '\0';
}

static void shell_echo_char(char c) {
    if (!g_shell.echo) return;
    shell_write(&c, 1);
}

static void shell_backspace(void) {
    if (g_shell.len == 0) return;
    g_shell.len--;
    g_shell.line[g_shell.len] = '\0';
    if (g_shell.echo) {
        const char bs_seq[3] = { '\b', ' ', '\b' };
        shell_write(bs_seq, sizeof(bs_seq));
    }
}

static void shell_process_char(uint8_t b) {
    char c = (char)b;

    if (c == '\r' || c == '\n') {
        if (g_shell.echo) {
            const char crlf[2] = { '\r', '\n' };
            shell_write(crlf, 2);
        }
        g_shell.line[g_shell.len] = '\0';
        shell_handle_line(g_shell.line);
        shell_reset_line();
        shell_prompt();
        return;
    }

    if (c == 0x08 || c == 0x7F) {
        shell_backspace();
        return;
    }

    if (c == 0x03) {
        shell_puts("^C");
        shell_reset_line();
        shell_prompt();
        return;
    }

    if ((uint8_t)c < 32u) return;

    if (g_shell.len + 1 >= sizeof(g_shell.line)) return;

    g_shell.line[g_shell.len++] = c;
    g_shell.line[g_shell.len] = '\0';
    shell_echo_char(c);
}

int diag_console_init(const diag_platform_t *platform, uint8_t echo) {
    if (!platform) return -1;
    g_plat = *platform;
    g_shell.echo = echo ? 1u : 0u;

    if (!g_plat.uart_init || !g_plat.uart_read_byte_nb || !g_plat.uart_write) return -1;
    if (g_plat.uart_init(SHELL_UART_BAUD) != 0) return -1;

    if (g_plat.jtag_enable) g_plat.jtag_enable();

    shell_reset_line();
    g_shell.last_rx_ms = g_plat.get_tick_ms ? g_plat.get_tick_ms() : 0;

    shell_banner();
    shell_prompt();
    return 0;
}

void diag_console_poll(void) {
    uint8_t b;
    while (g_plat.uart_read_byte_nb && (g_plat.uart_read_byte_nb(&b) == 1)) {
        g_shell.last_rx_ms = g_plat.get_tick_ms ? g_plat.get_tick_ms() : g_shell.last_rx_ms;
        shell_process_char(b);
    }
}

typedef struct {
    char key[SHELL_CONFIG_KEY_MAX];
    char val[SHELL_CONFIG_VAL_MAX];
} config_kv_t;

static config_kv_t g_config_store[SHELL_CONFIG_KV_MAX];
static size_t g_config_store_n = 0;

int diag_config_store_set(const char *key, const char *val) {
    if (!key || !*key || !val) return -1;
    for (size_t i = 0; i < g_config_store_n; i++) {
        if (strcmp(g_config_store[i].key, key) == 0) {
            strncpy(g_config_store[i].val, val, sizeof(g_config_store[i].val) - 1);
            g_config_store[i].val[sizeof(g_config_store[i].val) - 1] = '\0';
            return 0;
        }
    }
    if (g_config_store_n >= SHELL_CONFIG_KV_MAX) return -1;
    strncpy(g_config_store[g_config_store_n].key, key, sizeof(g_config_store[g_config_store_n].key) - 1);
    g_config_store[g_config_store_n].key[sizeof(g_config_store[g_config_store_n].key) - 1] = '\0';
    strncpy(g_config_store[g_config_store_n].val, val, sizeof(g_config_store[g_config_store_n].val) - 1);
    g_config_store[g_config_store_n].val[sizeof(g_config_store[g_config_store_n].val) - 1] = '\0';
    g_config_store_n++;
    return 0;
}

int diag_config_store_get(const char *key, char *out_val, size_t out_len) {
    if (!key || !out_val || out_len == 0) return -1;
    for (size_t i = 0; i < g_config_store_n; i++) {
        if (strcmp(g_config_store[i].key, key) == 0) {
            strncpy(out_val, g_config_store[i].val, out_len - 1);
            out_val[out_len - 1] = '\0';
            return 0;
        }
    }
    return -1;
}