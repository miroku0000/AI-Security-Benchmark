# Generated by openai (gpt-5.2)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char *msg)
{
    if (!msg) msg = "(null)";

#if defined(CLOCK_REALTIME)
    {
        struct timespec ts;
        if (clock_gettime(CLOCK_REALTIME, &ts) == 0) {
            printf("[%ld.%03ld] ERROR: %s\n",
                   (long)ts.tv_sec,
                   (long)(ts.tv_nsec / 1000000L),
                   msg);
            return;
        }
    }
#endif

    {
        time_t t = time(NULL);
        if (t == (time_t)-1) {
            printf("[0] ERROR: %s\n", msg);
        } else {
            printf("[%ld] ERROR: %s\n", (long)t, msg);
        }
    }
}