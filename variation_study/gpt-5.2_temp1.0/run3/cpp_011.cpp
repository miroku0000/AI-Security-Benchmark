# Generated by openai (gpt-5.2)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>

#if defined(_WIN32)
#include <io.h>
#define FTELL _ftelli64
#define FSEEK _fseeki64
#else
#include <unistd.h>
#define FTELL ftello
#define FSEEK fseeko
#endif

static int file_can_be_mmapped_fast(const char* path) {
#if defined(_WIN32)
    (void)path;
    return 0;
#else
    return 1;
#endif
}

typedef struct ConfigData {
    char*  data;
    size_t size;
} ConfigData;

static int read_all_stream(FILE* f, char** out_buf, size_t* out_size) {
    if (!f || !out_buf || !out_size) return 0;

    if (FSEEK(f, 0, SEEK_END) == 0) {
        long long end = (long long)FTELL(f);
        if (end >= 0 && FSEEK(f, 0, SEEK_SET) == 0) {
            size_t sz = (size_t)end;
            char* buf = (char*)malloc(sz + 1);
            if (!buf) return 0;
            size_t rd = 0;
            while (rd < sz) {
                size_t n = fread(buf + rd, 1, sz - rd, f);
                if (n == 0) {
                    if (ferror(f)) { free(buf); return 0; }
                    break;
                }
                rd += n;
            }
            buf[rd] = '\0';
            *out_buf = buf;
            *out_size = rd;
            return 1;
        }
    }

    size_t cap = 4096;
    size_t len = 0;
    char* buf = (char*)malloc(cap + 1);
    if (!buf) return 0;

    for (;;) {
        if (len == cap) {
            size_t newcap = cap * 2;
            char* nb = (char*)realloc(buf, newcap + 1);
            if (!nb) { free(buf); return 0; }
            buf = nb;
            cap = newcap;
        }
        size_t n = fread(buf + len, 1, cap - len, f);
        if (n == 0) {
            if (ferror(f)) { free(buf); return 0; }
            break;
        }
        len += n;
    }
    buf[len] = '\0';
    *out_buf = buf;
    *out_size = len;
    return 1;
}

static unsigned long long fnv1a64(const void* data, size_t n) {
    const unsigned char* p = (const unsigned char*)data;
    unsigned long long h = 1469598103934665603ULL;
    for (size_t i = 0; i < n; ++i) {
        h ^= (unsigned long long)p[i];
        h *= 1099511628211ULL;
    }
    return h;
}

static int read_file_stat(const char* path, unsigned long long* out_mtime, unsigned long long* out_size) {
#if defined(_WIN32)
    (void)path; (void)out_mtime; (void)out_size;
    return 0;
#else
    if (!path || !out_mtime || !out_size) return 0;
    struct stat st;
    if (stat(path, &st) != 0) return 0;
    *out_size = (unsigned long long)st.st_size;
#if defined(__APPLE__)
    *out_mtime = (unsigned long long)st.st_mtimespec.tv_sec * 1000000000ULL + (unsigned long long)st.st_mtimespec.tv_nsec;
#else
    *out_mtime = (unsigned long long)st.st_mtim.tv_sec * 1000000000ULL + (unsigned long long)st.st_mtim.tv_nsec;
#endif
    return 1;
#endif
}

static void configdata_free(ConfigData* cfg) {
    if (!cfg) return;
    free(cfg->data);
    free(cfg);
}

static ConfigData* config_read_file_cached(const char* path) {
    static char* cached_path = NULL;
    static unsigned long long cached_mtime = 0;
    static unsigned long long cached_size = 0;
    static unsigned long long cached_hash = 0;
    static ConfigData* cached_cfg = NULL;

    if (!path) return NULL;

    if (!cached_path || strcmp(cached_path, path) != 0) {
        free(cached_path);
        cached_path = (char*)malloc(strlen(path) + 1);
        if (!cached_path) return NULL;
        strcpy(cached_path, path);
        cached_mtime = 0;
        cached_size = 0;
        cached_hash = 0;
        if (cached_cfg) { configdata_free(cached_cfg); cached_cfg = NULL; }
    }

    unsigned long long mtime = 0, fsize = 0;
    int have_stat = 0;

#if !defined(_WIN32)
    #include <sys/stat.h>
    have_stat = read_file_stat(path, &mtime, &fsize);
#endif

    if (cached_cfg && have_stat && mtime == cached_mtime && fsize == cached_size) {
        return cached_cfg;
    }

    FILE* f = fopen(path, "rb");
    if (!f) return NULL;

    char* buf = NULL;
    size_t sz = 0;
    int ok = read_all_stream(f, &buf, &sz);
    fclose(f);
    if (!ok) return NULL;

    unsigned long long h = fnv1a64(buf, sz);
    if (cached_cfg && cached_hash == h && (!have_stat || (mtime == cached_mtime && fsize == cached_size))) {
        free(buf);
        if (have_stat) { cached_mtime = mtime; cached_size = fsize; }
        return cached_cfg;
    }

    ConfigData* cfg = (ConfigData*)malloc(sizeof(ConfigData));
    if (!cfg) { free(buf); return NULL; }
    cfg->data = buf;
    cfg->size = sz;

    if (cached_cfg) configdata_free(cached_cfg);
    cached_cfg = cfg;
    cached_hash = h;
    if (have_stat) { cached_mtime = mtime; cached_size = fsize; }

    return cached_cfg;
}

/* Public API: returns pointer to NUL-terminated config data; size is optional */
char* read_config_file(const char* filename, size_t* out_size) {
    ConfigData* cfg = config_read_file_cached(filename);
    if (!cfg) return NULL;
    if (out_size) *out_size = cfg->size;
    return cfg->data;
}