# Generated by openai (gpt-5.2)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>

typedef struct FileHandleNode {
    FILE *fp;
    char *path;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct FileHandlePool {
    FileHandleNode *head;
} FileHandlePool;

static char *fh_strdup(const char *s) {
    if (!s) return NULL;
    size_t n = strlen(s) + 1;
    char *p = (char *)malloc(n);
    if (!p) return NULL;
    memcpy(p, s, n);
    return p;
}

void fhpool_init(FileHandlePool *pool) {
    if (!pool) return;
    pool->head = NULL;
}

int fhpool_add(FileHandlePool *pool, FILE *fp, const char *path) {
    if (!pool || !fp) return -1;

    FileHandleNode *node = (FileHandleNode *)calloc(1, sizeof(*node));
    if (!node) return -1;

    node->fp = fp;
    node->path = fh_strdup(path);
    node->next = pool->head;
    pool->head = node;

    return 0;
}

int fhpool_remove(FileHandlePool *pool, FILE *fp, int close_file) {
    if (!pool || !fp) return 0;

    FileHandleNode *prev = NULL;
    FileHandleNode *cur = pool->head;

    while (cur) {
        if (cur->fp == fp) {
            if (prev) prev->next = cur->next;
            else pool->head = cur->next;

            if (close_file && cur->fp) {
                fclose(cur->fp);
                cur->fp = NULL;
            }

            free(cur->path);
            cur->path = NULL;
            free(cur);
            return 1;
        }
        prev = cur;
        cur = cur->next;
    }
    return 0;
}

int fhpool_remove_by_path(FileHandlePool *pool, const char *path, int close_file) {
    if (!pool || !path) return 0;

    FileHandleNode *prev = NULL;
    FileHandleNode *cur = pool->head;

    while (cur) {
        if (cur->path && strcmp(cur->path, path) == 0) {
            if (prev) prev->next = cur->next;
            else pool->head = cur->next;

            if (close_file && cur->fp) {
                fclose(cur->fp);
                cur->fp = NULL;
            }

            free(cur->path);
            cur->path = NULL;
            free(cur);
            return 1;
        }
        prev = cur;
        cur = cur->next;
    }
    return 0;
}

void fhpool_cleanup(FileHandlePool *pool, int close_files) {
    if (!pool) return;

    FileHandleNode *cur = pool->head;
    pool->head = NULL;

    while (cur) {
        FileHandleNode *next = cur->next;

        if (close_files && cur->fp) {
            fclose(cur->fp);
            cur->fp = NULL;
        }
        free(cur->path);
        cur->path = NULL;
        free(cur);

        cur = next;
    }
}

size_t fhpool_count(const FileHandlePool *pool) {
    if (!pool) return 0;
    size_t n = 0;
    for (FileHandleNode *cur = pool->head; cur; cur = cur->next) n++;
    return n;
}

#ifdef TEST_FHPOOL
int main(void) {
    FileHandlePool pool;
    fhpool_init(&pool);

    FILE *a = fopen("a.tmp", "w");
    FILE *b = fopen("b.tmp", "w");
    if (!a || !b) {
        perror("fopen");
        if (a) fclose(a);
        if (b) fclose(b);
        return 1;
    }

    fhpool_add(&pool, a, "a.tmp");
    fhpool_add(&pool, b, "b.tmp");

    fprintf(a, "hello\n");
    fprintf(b, "world\n");

    fhpool_remove(&pool, a, 1);
    fhpool_cleanup(&pool, 1);
    fhpool_cleanup(&pool, 1);

    return 0;
}
#endif