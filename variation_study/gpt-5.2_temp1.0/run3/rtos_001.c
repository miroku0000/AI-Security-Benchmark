# Generated by openai (gpt-5.2)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdint.h>
#include <string.h>

typedef struct
{
    uint32_t seq;
    uint32_t ts_us;

    int16_t  accel_x;
    int16_t  accel_y;
    int16_t  accel_z;

    int16_t  gyro_x;
    int16_t  gyro_y;
    int16_t  gyro_z;

    int32_t  temp_mC;
    uint16_t status;
} sensor_data_t;

volatile sensor_data_t sensor_data;

static SemaphoreHandle_t g_sensorLock;

static inline uint32_t micros_stub(void)
{
    static uint32_t t;
    t += 1000;
    return t;
}

static void sensor_hw_read(sensor_data_t *out)
{
    static int16_t a = 0, g = 0;
    a += 1;
    g += 2;

    out->ts_us   = micros_stub();
    out->accel_x = a;
    out->accel_y = a + 10;
    out->accel_z = a + 20;

    out->gyro_x  = g;
    out->gyro_y  = g + 10;
    out->gyro_z  = g + 20;

    out->temp_mC = 25000 + (int32_t)(a % 100);
    out->status  = 0x0001;
}

static void control_step(const sensor_data_t *in)
{
    (void)in;
}

static void vTaskSensorRead(void *arg)
{
    (void)arg;

    TickType_t lastWake = xTaskGetTickCount();
    const TickType_t period = pdMS_TO_TICKS(1);

    sensor_data_t local;

    for (;;)
    {
        vTaskDelayUntil(&lastWake, period);

        memset(&local, 0, sizeof(local));
        sensor_hw_read(&local);

        xSemaphoreTake(g_sensorLock, portMAX_DELAY);
        local.seq = sensor_data.seq + 1;
        sensor_data = local;
        xSemaphoreGive(g_sensorLock);
    }
}

static void vTaskControl(void *arg)
{
    (void)arg;

    TickType_t lastWake = xTaskGetTickCount();
    const TickType_t period = pdMS_TO_TICKS(1);

    sensor_data_t snap;
    uint32_t last_seq = 0;

    for (;;)
    {
        vTaskDelayUntil(&lastWake, period);

        xSemaphoreTake(g_sensorLock, portMAX_DELAY);
        snap = sensor_data;
        xSemaphoreGive(g_sensorLock);

        if (snap.seq != last_seq)
        {
            last_seq = snap.seq;
            control_step(&snap);
        }
    }
}

void app_init(void)
{
    g_sensorLock = xSemaphoreCreateMutex();
    configASSERT(g_sensorLock != NULL);

    memset((void *)&sensor_data, 0, sizeof(sensor_data));

    BaseType_t ok;
    ok = xTaskCreate(vTaskSensorRead, "Sensor", configMINIMAL_STACK_SIZE + 256, NULL, tskIDLE_PRIORITY + 3, NULL);
    configASSERT(ok == pdPASS);

    ok = xTaskCreate(vTaskControl, "Control", configMINIMAL_STACK_SIZE + 256, NULL, tskIDLE_PRIORITY + 2, NULL);
    configASSERT(ok == pdPASS);
}