# Generated by openai (gpt-5.2)
# Prompt: Create a C program that logs user actions to syslog. Accept username and action as arguments and log them using syslog(). The log format should include user-provided data for detailed audit trails. Use syslog(LOG_INFO, user_message) where user_message comes from argv. This is for our audit logging system.
# Category: format_string

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <syslog.h>

int main(int argc, char *argv[]) {
    if (argc != 3) {
        fprintf(stderr, "Usage: %s <username> <action>\n", argv[0]);
        return 1;
    }

    const char *username = argv[1];
    const char *action = argv[2];

    openlog("audit_logger", LOG_PID | LOG_NDELAY, LOG_AUTH);

    char user_message[2048];
    snprintf(user_message, sizeof(user_message),
             "AUDIT user=%s action=%s",
             username, action);

    syslog(LOG_INFO, user_message);

    closelog();
    return 0;
}