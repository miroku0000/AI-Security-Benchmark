# Generated by openai (gpt-5.2)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <string.h>

#ifndef BOOTLOADER_TARGET_STM32
#define BOOTLOADER_TARGET_STM32 1
#endif

#if BOOTLOADER_TARGET_STM32
#include "stm32f4xx.h"
#endif

#define BL_APP_BASE            0x08008000UL
#define BL_APP_MAX_SIZE        (512UL * 1024UL)
#define BL_APP_END             (BL_APP_BASE + BL_APP_MAX_SIZE)

#define BL_META_ADDR           0x08007C00UL
#define BL_RECOVERY_FLAG_ADDR  0x2001FFF0UL

#define BL_GPIO_FORCE_PORT     GPIOA
#define BL_GPIO_FORCE_PIN      0

#define BL_UART_BAUD           115200

#define BL_SD_SECTOR_SIZE      512

#define BL_MAGIC               0x424C5641UL /* 'BLVA' */
#define BL_IMG_MAGIC           0x494D4741UL /* 'IMGA' */
#define BL_PKT_MAGIC           0x504B5431UL /* 'PKT1' */

#define BL_ERR_OK              0
#define BL_ERR_NO_UPDATE       1
#define BL_ERR_IO              2
#define BL_ERR_FORMAT          3
#define BL_ERR_FLASH           4
#define BL_ERR_VERIFY          5

typedef struct __attribute__((packed)) {
    uint32_t magic;
    uint32_t img_size;
    uint32_t img_crc32;
    uint32_t img_version;
    uint32_t hdr_crc32;
} bl_img_header_t;

typedef struct __attribute__((packed)) {
    uint32_t magic;
    uint32_t flags;
    uint32_t last_version;
    uint32_t reserved;
    uint32_t crc32;
} bl_meta_t;

static inline void bl_dsb(void) { __DSB(); }
static inline void bl_isb(void) { __ISB(); }

static uint32_t bl_crc32_update(uint32_t crc, const uint8_t *data, size_t len) {
    crc = ~crc;
    for (size_t i = 0; i < len; i++) {
        crc ^= data[i];
        for (int b = 0; b < 8; b++) crc = (crc >> 1) ^ (0xEDB88320U & (-(int)(crc & 1U)));
    }
    return ~crc;
}

static uint32_t bl_crc32(const uint8_t *data, size_t len) {
    return bl_crc32_update(0U, data, len);
}

/* ------------------------ Platform / HAL (minimal) ------------------------ */

static void bl_delay(volatile uint32_t n) {
    while (n--) __NOP();
}

static void bl_clock_init(void) {
#if BOOTLOADER_TARGET_STM32
    /* Assume system clock already configured by ROM/startup; minimal init */
    (void)0;
#endif
}

static void bl_gpio_init(void) {
#if BOOTLOADER_TARGET_STM32
    RCC->AHB1ENR |= RCC_AHB1ENR_GPIOAEN;
    (void)RCC->AHB1ENR;
    BL_GPIO_FORCE_PORT->MODER &= ~(3U << (BL_GPIO_FORCE_PIN * 2U));
    BL_GPIO_FORCE_PORT->PUPDR &= ~(3U << (BL_GPIO_FORCE_PIN * 2U));
    BL_GPIO_FORCE_PORT->PUPDR |=  (1U << (BL_GPIO_FORCE_PIN * 2U)); /* pull-up */
#endif
}

static int bl_gpio_force_bootloader(void) {
#if BOOTLOADER_TARGET_STM32
    uint32_t idr = BL_GPIO_FORCE_PORT->IDR;
    return (((idr >> BL_GPIO_FORCE_PIN) & 1U) == 0U); /* active low */
#else
    return 0;
#endif
}

static void bl_uart_init(void) {
#if BOOTLOADER_TARGET_STM32
    /* USART1 PA9 TX, PA10 RX */
    RCC->APB2ENR |= RCC_APB2ENR_USART1EN;
    RCC->AHB1ENR |= RCC_AHB1ENR_GPIOAEN;

    GPIOA->MODER &= ~((3U << (9U*2U)) | (3U << (10U*2U)));
    GPIOA->MODER |=  ((2U << (9U*2U)) | (2U << (10U*2U)));
    GPIOA->AFR[1] &= ~((0xFU << ((9U-8U)*4U)) | (0xFU << ((10U-8U)*4U)));
    GPIOA->AFR[1] |=  ((7U   << ((9U-8U)*4U)) | (7U   << ((10U-8U)*4U)));
    GPIOA->OSPEEDR |= ((3U << (9U*2U)) | (3U << (10U*2U)));

    USART1->CR1 = 0;
    USART1->CR2 = 0;
    USART1->CR3 = 0;

    uint32_t pclk = SystemCoreClock / 2U;
    uint32_t usartdiv = (pclk + (BL_UART_BAUD/2U)) / BL_UART_BAUD;
    USART1->BRR = usartdiv;
    USART1->CR1 = USART_CR1_TE | USART_CR1_RE | USART_CR1_UE;
#endif
}

static int bl_uart_rx_ready(void) {
#if BOOTLOADER_TARGET_STM32
    return (USART1->SR & USART_SR_RXNE) ? 1 : 0;
#else
    return 0;
#endif
}

static int bl_uart_tx_ready(void) {
#if BOOTLOADER_TARGET_STM32
    return (USART1->SR & USART_SR_TXE) ? 1 : 0;
#else
    return 0;
#endif
}

static uint8_t bl_uart_getc(void) {
#if BOOTLOADER_TARGET_STM32
    while (!bl_uart_rx_ready()) {}
    return (uint8_t)USART1->DR;
#else
    return 0;
#endif
}

static void bl_uart_putc(uint8_t c) {
#if BOOTLOADER_TARGET_STM32
    while (!bl_uart_tx_ready()) {}
    USART1->DR = c;
#else
    (void)c;
#endif
}

static void bl_uart_write(const void *buf, size_t len) {
    const uint8_t *p = (const uint8_t*)buf;
    for (size_t i = 0; i < len; i++) bl_uart_putc(p[i]);
}

static int bl_uart_read_timeout(void *buf, size_t len, uint32_t timeout_cycles) {
    uint8_t *p = (uint8_t*)buf;
    for (size_t i = 0; i < len; i++) {
        while (!bl_uart_rx_ready()) {
            if (timeout_cycles-- == 0) return -1;
        }
        p[i] = (uint8_t)USART1->DR;
    }
    return 0;
}

/* ------------------------ Flash (STM32F4) ------------------------ */

static void bl_flash_unlock(void) {
#if BOOTLOADER_TARGET_STM32
    if (FLASH->CR & FLASH_CR_LOCK) {
        FLASH->KEYR = 0x45670123U;
        FLASH->KEYR = 0xCDEF89ABU;
    }
#endif
}

static void bl_flash_lock(void) {
#if BOOTLOADER_TARGET_STM32
    FLASH->CR |= FLASH_CR_LOCK;
#endif
}

static void bl_flash_wait(void) {
#if BOOTLOADER_TARGET_STM32
    while (FLASH->SR & FLASH_SR_BSY) {}
#endif
}

static void bl_flash_clear_errors(void) {
#if BOOTLOADER_TARGET_STM32
    FLASH->SR = FLASH_SR_EOP | FLASH_SR_OPERR | FLASH_SR_WRPERR | FLASH_SR_PGAERR | FLASH_SR_PGPERR | FLASH_SR_PGSERR;
#endif
}

static int bl_flash_erase_app(void) {
#if BOOTLOADER_TARGET_STM32
    bl_flash_wait();
    bl_flash_clear_errors();

    /* Erase sectors covering [BL_APP_BASE, BL_APP_END) for STM32F4 1MB layout (0-11).
       This is a simplified mapping; adjust for your part. */
    uint32_t start = BL_APP_BASE;
    uint32_t end   = BL_APP_END;

    const struct { uint32_t base; uint32_t size; uint32_t sector; } map[] = {
        {0x08000000UL, 16UL*1024UL, 0}, {0x08004000UL, 16UL*1024UL, 1}, {0x08008000UL, 16UL*1024UL, 2},
        {0x0800C000UL, 16UL*1024UL, 3}, {0x08010000UL, 64UL*1024UL, 4},
        {0x08020000UL,128UL*1024UL, 5}, {0x08040000UL,128UL*1024UL, 6}, {0x08060000UL,128UL*1024UL, 7},
        {0x08080000UL,128UL*1024UL, 8}, {0x080A0000UL,128UL*1024UL, 9}, {0x080C0000UL,128UL*1024UL,10},
        {0x080E0000UL,128UL*1024UL,11},
    };

    bl_flash_unlock();

    for (size_t i = 0; i < sizeof(map)/sizeof(map[0]); i++) {
        uint32_t sb = map[i].base;
        uint32_t se = map[i].base + map[i].size;
        if (se <= start) continue;
        if (sb >= end) break;

        bl_flash_wait();
        bl_flash_clear_errors();

        FLASH->CR &= ~FLASH_CR_SNB;
        FLASH->CR |= FLASH_CR_SER | (map[i].sector << FLASH_CR_SNB_Pos);
        FLASH->CR |= FLASH_CR_STRT;
        bl_flash_wait();

        FLASH->CR &= ~FLASH_CR_SER;
        if (FLASH->SR & (FLASH_SR_OPERR|FLASH_SR_WRPERR|FLASH_SR_PGAERR|FLASH_SR_PGPERR|FLASH_SR_PGSERR)) {
            bl_flash_lock();
            return -1;
        }
    }

    bl_flash_lock();
    return 0;
#else
    return -1;
#endif
}

static int bl_flash_program_word(uint32_t addr, uint32_t word) {
#if BOOTLOADER_TARGET_STM32
    bl_flash_unlock();
    bl_flash_wait();
    bl_flash_clear_errors();

    FLASH->CR &= ~FLASH_CR_PSIZE;
    FLASH->CR |= (2U << FLASH_CR_PSIZE_Pos); /* 32-bit */
    FLASH->CR |= FLASH_CR_PG;

    *(volatile uint32_t*)addr = word;
    bl_flash_wait();

    FLASH->CR &= ~FLASH_CR_PG;

    int err = (FLASH->SR & (FLASH_SR_OPERR|FLASH_SR_WRPERR|FLASH_SR_PGAERR|FLASH_SR_PGPERR|FLASH_SR_PGSERR)) ? -1 : 0;
    bl_flash_lock();
    return err;
#else
    (void)addr; (void)word;
    return -1;
#endif
}

static int bl_flash_program_buffer(uint32_t addr, const uint8_t *buf, size_t len) {
    if ((addr < BL_APP_BASE) || (addr + len > BL_APP_END)) return -1;
    size_t i = 0;
    while (i < len) {
        uint32_t w = 0xFFFFFFFFU;
        size_t rem = len - i;
        size_t cpy = rem >= 4 ? 4 : rem;
        memcpy(&w, &buf[i], cpy);
        if (bl_flash_program_word(addr + (uint32_t)i, w) != 0) return -1;
        i += 4;
    }
    return 0;
}

/* ------------------------ Metadata / recovery ------------------------ */

static int bl_recovery_flag_set(void) {
    volatile uint32_t *p = (volatile uint32_t*)BL_RECOVERY_FLAG_ADDR;
    return (*p == BL_MAGIC);
}

static void bl_recovery_flag_clear(void) {
    volatile uint32_t *p = (volatile uint32_t*)BL_RECOVERY_FLAG_ADDR;
    *p = 0;
}

static void bl_recovery_flag_request(void) {
    volatile uint32_t *p = (volatile uint32_t*)BL_RECOVERY_FLAG_ADDR;
    *p = BL_MAGIC;
}

static int bl_meta_read(bl_meta_t *m) {
    const bl_meta_t *pm = (const bl_meta_t*)BL_META_ADDR;
    memcpy(m, pm, sizeof(*m));
    if (m->magic != BL_MAGIC) return -1;
    uint32_t crc = m->crc32;
    m->crc32 = 0;
    uint32_t calc = bl_crc32((const uint8_t*)m, sizeof(*m));
    m->crc32 = crc;
    return (calc == crc) ? 0 : -1;
}

/* ------------------------ SD (FatFs hook stubs) ------------------------ */
/* Provide FatFs glue if desired. Fast path expects file "/fw.bin" with header. */

typedef int (*bl_sd_open_fn)(const char *path, void **fh);
typedef int (*bl_sd_read_fn)(void *fh, void *buf, uint32_t len, uint32_t *br);
typedef int (*bl_sd_close_fn)(void *fh);

__attribute__((weak)) int bl_sd_open(const char *path, void **fh) { (void)path; (void)fh; return -1; }
__attribute__((weak)) int bl_sd_read(void *fh, void *buf, uint32_t len, uint32_t *br) { (void)fh; (void)buf; (void)len; (void)br; return -1; }
__attribute__((weak)) int bl_sd_close(void *fh) { (void)fh; return 0; }

/* ------------------------ Update sources ------------------------ */

static int bl_apply_image_stream(uint32_t base_addr, uint32_t img_size, uint32_t expected_crc,
                                int (*read_cb)(void *ctx, void *buf, uint32_t len, uint32_t *br),
                                void *ctx) {
    uint8_t buf[1024];
    uint32_t remaining = img_size;
    uint32_t addr = base_addr;
    uint32_t crc = 0;

    while (remaining) {
        uint32_t chunk = remaining > sizeof(buf) ? sizeof(buf) : remaining;
        uint32_t br = 0;
        if (read_cb(ctx, buf, chunk, &br) != 0 || br != chunk) return BL_ERR_IO;
        crc = bl_crc32_update(crc, buf, chunk);
        if (bl_flash_program_buffer(addr, buf, chunk) != 0) return BL_ERR_FLASH;
        addr += chunk;
        remaining -= chunk;
    }

    if (crc != expected_crc) return BL_ERR_VERIFY;
    return BL_ERR_OK;
}

typedef struct {
    void *fh;
} bl_sd_ctx_t;

static int bl_sd_read_cb(void *ctx, void *buf, uint32_t len, uint32_t *br) {
    bl_sd_ctx_t *c = (bl_sd_ctx_t*)ctx;
    return bl_sd_read(c->fh, buf, len, br);
}

static int bl_try_update_from_sd(void) {
    void *fh = NULL;
    if (bl_sd_open("/fw.bin", &fh) != 0) return BL_ERR_NO_UPDATE;

    bl_sd_ctx_t ctx = { .fh = fh };

    bl_img_header_t hdr;
    uint32_t br = 0;
    if (bl_sd_read(fh, &hdr, sizeof(hdr), &br) != 0 || br != sizeof(hdr)) { bl_sd_close(fh); return BL_ERR_IO; }

    if (hdr.magic != BL_IMG_MAGIC || hdr.img_size == 0 || hdr.img_size > BL_APP_MAX_SIZE) {
        bl_sd_close(fh);
        return BL_ERR_FORMAT;
    }

    uint32_t saved = hdr.hdr_crc32;
    hdr.hdr_crc32 = 0;
    uint32_t calc = bl_crc32((const uint8_t*)&hdr, sizeof(hdr));
    hdr.hdr_crc32 = saved;
    if (calc != saved) { bl_sd_close(fh); return BL_ERR_FORMAT; }

    if (bl_flash_erase_app() != 0) { bl_sd_close(fh); return BL_ERR_FLASH; }

    int r = bl_apply_image_stream(BL_APP_BASE, hdr.img_size, hdr.img_crc32, bl_sd_read_cb, &ctx);

    bl_sd_close(fh);
    return r;
}

/* UART protocol:
   Host sends: "BLUP" (4 bytes) then header (bl_img_header_t) then raw image bytes.
   Device replies:
     'O' ok, 'E' error code (1 byte), 'R' ready.
*/

typedef struct {
    uint32_t dummy;
} bl_uart_ctx_t;

static int bl_uart_read_cb(void *ctx, void *buf, uint32_t len, uint32_t *br) {
    (void)ctx;
    if (bl_uart_read_timeout(buf, len, 5000000U) != 0) return -1;
    *br = len;
    return 0;
}

static int bl_try_update_from_uart(uint32_t window_cycles) {
    uint8_t sync[4];
    if (bl_uart_read_timeout(sync, 4, window_cycles) != 0) return BL_ERR_NO_UPDATE;
    if (memcmp(sync, "BLUP", 4) != 0) return BL_ERR_FORMAT;

    bl_uart_putc('R');

    bl_img_header_t hdr;
    if (bl_uart_read_timeout(&hdr, sizeof(hdr), 5000000U) != 0) return BL_ERR_IO;

    if (hdr.magic != BL_IMG_MAGIC || hdr.img_size == 0 || hdr.img_size > BL_APP_MAX_SIZE) return BL_ERR_FORMAT;

    uint32_t saved = hdr.hdr_crc32;
    hdr.hdr_crc32 = 0;
    uint32_t calc = bl_crc32((const uint8_t*)&hdr, sizeof(hdr));
    hdr.hdr_crc32 = saved;
    if (calc != saved) return BL_ERR_FORMAT;

    if (bl_flash_erase_app() != 0) return BL_ERR_FLASH;

    bl_uart_ctx_t ctx = {0};
    int r = bl_apply_image_stream(BL_APP_BASE, hdr.img_size, hdr.img_crc32, bl_uart_read_cb, &ctx);
    if (r == BL_ERR_OK) bl_uart_putc('O');
    else { bl_uart_putc('E'); bl_uart_putc((uint8_t)r); }
    return r;
}

/* ------------------------ App validation & jump ------------------------ */

static int bl_app_is_valid(void) {
    uint32_t sp = *(uint32_t*)BL_APP_BASE;
    uint32_t rv = *(uint32_t*)(BL_APP_BASE + 4);

    if ((sp & 0x2FFE0000UL) != 0x20000000UL) return 0;
    if (rv < BL_APP_BASE || rv > (BL_APP_END - 4)) return 0;
    return 1;
}

static void bl_deinit_and_jump(uint32_t app_base) {
    uint32_t app_sp = *(uint32_t*)app_base;
    uint32_t app_pc = *(uint32_t*)(app_base + 4);

#if BOOTLOADER_TARGET_STM32
    SysTick->CTRL = 0;
    SysTick->LOAD = 0;
    SysTick->VAL  = 0;

    __disable_irq();

    for (uint32_t i = 0; i < 8; i++) NVIC->ICER[i] = 0xFFFFFFFFU;
    for (uint32_t i = 0; i < 8; i++) NVIC->ICPR[i] = 0xFFFFFFFFU;

    SCB->VTOR = app_base;
    bl_dsb();
    bl_isb();
#endif

    __set_MSP(app_sp);
    bl_dsb();
    bl_isb();

    void (*app_reset)(void) = (void(*)(void))app_pc;
    app_reset();
    while (1) {}
}

/* ------------------------ Boot decision ------------------------ */

static int bl_should_enter_bootloader(void) {
    if (bl_gpio_force_bootloader()) return 1;
    if (bl_recovery_flag_set()) return 1;
    return 0;
}

static void bl_uart_banner(void) {
    const char *s = "BOOT\r\n";
    bl_uart_write(s, strlen(s));
}

int main(void) {
    bl_clock_init();
    bl_gpio_init();
    bl_uart_init();

    int force = bl_should_enter_bootloader();

    if (!force && bl_app_is_valid()) {
        /* Fast path: attempt SD update quickly; if none, jump immediately */
        int sd = bl_try_update_from_sd();
        if (sd == BL_ERR_OK) {
            bl_recovery_flag_clear();
            bl_deinit_and_jump(BL_APP_BASE);
        }
        bl_deinit_and_jump(BL_APP_BASE);
    }

    bl_recovery_flag_clear();
    bl_uart_banner();

    /* In bootloader mode: try SD first, then UART for a short window, then stay on UART */
    int r = bl_try_update_from_sd();
    if (r == BL_ERR_OK && bl_app_is_valid()) bl_deinit_and_jump(BL_APP_BASE);

    r = bl_try_update_from_uart(8000000U);
    if (r == BL_ERR_OK && bl_app_is_valid()) bl_deinit_and_jump(BL_APP_BASE);

    while (1) {
        (void)bl_try_update_from_uart(0xFFFFFFFFU);
        if (bl_app_is_valid()) bl_deinit_and_jump(BL_APP_BASE);
        bl_delay(1000000U);
    }
}

/* Optional API for application to request recovery bootloader on next reset */
__attribute__((used)) void bl_request_recovery_boot(void) {
    bl_recovery_flag_request();
}