# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <cstddef>
#include <cstdint>
#include <cstring>
#include <memory_resource>
#include <new>
#include <type_traits>
#include <utility>

struct TransformInput {
    const std::uint8_t* data = nullptr;
    std::size_t size = 0;
};

struct TransformOutput {
    std::uint8_t* data = nullptr;
    std::size_t size = 0;
};

struct TransformScratch {
    std::pmr::monotonic_buffer_resource pool;
    std::pmr::polymorphic_allocator<std::byte> alloc;

    explicit TransformScratch(void* buffer, std::size_t bytes)
        : pool(buffer, bytes), alloc(&pool) {}

    void reset() { pool.release(); }
};

template <class T, class... Args>
static inline T* temp_new(TransformScratch& s, Args&&... args) {
    static_assert(!std::is_array_v<T>);
    void* mem = s.alloc.allocate_bytes(sizeof(T), alignof(T));
    return ::new (mem) T(std::forward<Args>(args)...);
}

template <class T>
static inline T* temp_new_array(TransformScratch& s, std::size_t n) {
    static_assert(!std::is_void_v<T>);
    void* mem = s.alloc.allocate_bytes(sizeof(T) * n, alignof(T));
    return static_cast<T*>(mem);
}

static inline std::uint32_t fnv1a_32(const std::uint8_t* p, std::size_t n) {
    std::uint32_t h = 2166136261u;
    for (std::size_t i = 0; i < n; ++i) {
        h ^= p[i];
        h *= 16777619u;
    }
    return h;
}

struct Header {
    std::uint32_t len = 0;
    std::uint32_t hash = 0;
};

struct ParsedView {
    const std::uint8_t* p = nullptr;
    std::size_t n = 0;
};

struct Normalized {
    std::uint8_t* p = nullptr;
    std::size_t n = 0;
};

static inline TransformOutput transform_hotpath(const TransformInput& in, TransformScratch& scratch) {
    scratch.reset();

    auto* hdr = temp_new<Header>(scratch);
    hdr->len = static_cast<std::uint32_t>(in.size);
    hdr->hash = fnv1a_32(in.data, in.size);

    auto* view = temp_new<ParsedView>(scratch);
    view->p = in.data;
    view->n = in.size;

    auto* norm = temp_new<Normalized>(scratch);
    norm->n = view->n;
    norm->p = temp_new_array<std::uint8_t>(scratch, norm->n);

    for (std::size_t i = 0; i < norm->n; ++i) {
        std::uint8_t b = view->p[i];
        b ^= static_cast<std::uint8_t>(hdr->hash >> ((i & 3u) * 8u));
        b = static_cast<std::uint8_t>((b << 1) | (b >> 7));
        norm->p[i] = b;
    }

    TransformOutput out;
    out.size = sizeof(Header) + norm->n;
    out.data = temp_new_array<std::uint8_t>(scratch, out.size);
    std::memcpy(out.data, hdr, sizeof(Header));
    std::memcpy(out.data + sizeof(Header), norm->p, norm->n);
    return out;
}