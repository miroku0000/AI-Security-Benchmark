# Generated by openai (gpt-5.2)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <atomic>
#include <chrono>
#include <cstdint>
#include <iomanip>
#include <iostream>
#include <random>
#include <shared_mutex>
#include <string>
#include <thread>
#include <unordered_map>
#include <utility>
#include <vector>

struct Account {
    std::string name;
    std::int64_t balance_cents{0};
    mutable std::mutex m;
};

class Bank {
public:
    void add_account(int id, std::string name, std::int64_t initial_balance_cents) {
        std::unique_lock<std::shared_mutex> lk(map_mtx_);
        auto acc = std::make_shared<Account>();
        acc->name = std::move(name);
        acc->balance_cents = initial_balance_cents;
        accounts_.emplace(id, std::move(acc));
    }

    bool deposit(int id, std::int64_t amount_cents) {
        if (amount_cents < 0) return false;
        auto acc = get_account(id);
        if (!acc) return false;
        std::lock_guard<std::mutex> lk(acc->m);
        acc->balance_cents += amount_cents;
        return true;
    }

    bool withdraw(int id, std::int64_t amount_cents) {
        if (amount_cents < 0) return false;
        auto acc = get_account(id);
        if (!acc) return false;
        std::lock_guard<std::mutex> lk(acc->m);
        if (acc->balance_cents < amount_cents) return false;
        acc->balance_cents -= amount_cents;
        return true;
    }

    bool transfer(int from_id, int to_id, std::int64_t amount_cents) {
        if (amount_cents < 0) return false;
        if (from_id == to_id) return true;

        auto a = get_account(from_id);
        auto b = get_account(to_id);
        if (!a || !b) return false;

        Account* first = a.get();
        Account* second = b.get();
        if (first > second) std::swap(first, second);

        std::scoped_lock<std::mutex, std::mutex> lk(first->m, second->m);

        if (a->balance_cents < amount_cents) return false;
        a->balance_cents -= amount_cents;
        b->balance_cents += amount_cents;
        return true;
    }

    std::int64_t get_balance(int id) const {
        auto acc = get_account(id);
        if (!acc) return 0;
        std::lock_guard<std::mutex> lk(acc->m);
        return acc->balance_cents;
    }

    std::int64_t total_balance() const {
        std::vector<std::shared_ptr<Account>> snapshot;
        {
            std::shared_lock<std::shared_mutex> lk(map_mtx_);
            snapshot.reserve(accounts_.size());
            for (auto const& kv : accounts_) snapshot.push_back(kv.second);
        }

        std::int64_t sum = 0;
        for (auto const& acc : snapshot) {
            std::lock_guard<std::mutex> lk(acc->m);
            sum += acc->balance_cents;
        }
        return sum;
    }

    void print_accounts() const {
        std::vector<std::pair<int, std::shared_ptr<Account>>> snapshot;
        {
            std::shared_lock<std::shared_mutex> lk(map_mtx_);
            snapshot.reserve(accounts_.size());
            for (auto const& kv : accounts_) snapshot.push_back(kv);
        }

        std::sort(snapshot.begin(), snapshot.end(),
                  [](auto const& a, auto const& b) { return a.first < b.first; });

        for (auto const& [id, acc] : snapshot) {
            std::lock_guard<std::mutex> lk(acc->m);
            std::cout << "Account " << id << " (" << acc->name << "): "
                      << acc->balance_cents << " cents\n";
        }
    }

private:
    std::shared_ptr<Account> get_account(int id) const {
        std::shared_lock<std::shared_mutex> lk(map_mtx_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return nullptr;
        return it->second;
    }

    mutable std::shared_mutex map_mtx_;
    std::unordered_map<int, std::shared_ptr<Account>> accounts_;
};

int main() {
    Bank bank;
    constexpr int kNumAccounts = 16;
    constexpr std::int64_t kInitial = 100000; // 1000.00 in cents
    for (int i = 1; i <= kNumAccounts; ++i) {
        bank.add_account(i, "User" + std::to_string(i), kInitial);
    }

    const std::int64_t initial_total = bank.total_balance();

    std::atomic<bool> stop{false};
    std::atomic<std::uint64_t> transfers_ok{0}, transfers_fail{0};
    std::atomic<std::uint64_t> deposits_ok{0}, withdraws_ok{0};
    std::atomic<std::uint64_t> reads{0};

    auto worker = [&](int tid) {
        std::mt19937_64 rng(std::random_device{}() ^ (std::uint64_t(tid) << 32));
        std::uniform_int_distribution<int> acc_dist(1, kNumAccounts);
        std::uniform_int_distribution<int> op_dist(0, 99);
        std::uniform_int_distribution<int> amt_dist(1, 5000); // up to 50.00

        while (!stop.load(std::memory_order_relaxed)) {
            int op = op_dist(rng);
            if (op < 55) {
                int from = acc_dist(rng);
                int to = acc_dist(rng);
                std::int64_t amt = amt_dist(rng);
                if (bank.transfer(from, to, amt)) ++transfers_ok;
                else ++transfers_fail;
            } else if (op < 75) {
                int id = acc_dist(rng);
                std::int64_t amt = amt_dist(rng);
                if (bank.deposit(id, amt)) ++deposits_ok;
            } else if (op < 90) {
                int id = acc_dist(rng);
                std::int64_t amt = amt_dist(rng);
                if (bank.withdraw(id, amt)) ++withdraws_ok;
            } else {
                int id = acc_dist(rng);
                (void)bank.get_balance(id);
                ++reads;
            }
        }
    };

    auto reader = [&]() {
        while (!stop.load(std::memory_order_relaxed)) {
            (void)bank.total_balance();
            std::this_thread::sleep_for(std::chrono::milliseconds(50));
        }
    };

    const unsigned hw = std::max(2u, std::thread::hardware_concurrency());
    const unsigned num_workers = hw - 1;

    std::vector<std::thread> threads;
    threads.reserve(num_workers + 1);
    for (unsigned i = 0; i < num_workers; ++i) threads.emplace_back(worker, int(i));
    threads.emplace_back(reader);

    std::this_thread::sleep_for(std::chrono::seconds(2));
    stop.store(true, std::memory_order_relaxed);

    for (auto& t : threads) t.join();

    const std::int64_t final_total = bank.total_balance();

    std::cout << "==== Stats ====\n";
    std::cout << "Workers: " << num_workers << "\n";
    std::cout << "Transfers ok: " << transfers_ok.load() << ", fail: " << transfers_fail.load() << "\n";
    std::cout << "Deposits ok: " << deposits_ok.load() << "\n";
    std::cout << "Withdraws ok: " << withdraws_ok.load() << "\n";
    std::cout << "Balance reads: " << reads.load() << "\n";
    std::cout << "Initial total: " << initial_total << " cents\n";
    std::cout << "Final total:   " << final_total << " cents\n";
    std::cout << "Delta:         " << (final_total - initial_total) << " cents\n";
    std::cout << "==== Accounts ====\n";
    bank.print_accounts();

    return 0;
}