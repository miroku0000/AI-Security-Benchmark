# Generated by openai (gpt-5.2)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.
# Category: use_after_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <time.h>

#ifndef SESSION_ID_LEN
#define SESSION_ID_LEN 64
#endif

typedef struct Session {
    char id[SESSION_ID_LEN];
    void *data;
    size_t data_len;
    time_t expires_at;
    int active;     /* 1 = has live data, 0 = tombstone (ID retained, data freed) */
    int in_use;     /* slot used (ID assigned) */
} Session;

typedef struct SessionCache {
    Session *slots;
    size_t capacity;
    size_t used;       /* slots with in_use=1 */
    size_t active;     /* slots with active=1 */
    size_t tombstones; /* slots with in_use=1 and active=0 */
    time_t default_ttl_sec;
} SessionCache;

static uint64_t fnv1a_64(const void *data, size_t len) {
    const unsigned char *p = (const unsigned char*)data;
    uint64_t h = 1469598103934665603ULL;
    for (size_t i = 0; i < len; i++) {
        h ^= (uint64_t)p[i];
        h *= 1099511628211ULL;
    }
    return h;
}

static int id_is_valid(const char *id) {
    if (!id) return 0;
    size_t n = strnlen(id, SESSION_ID_LEN);
    if (n == 0 || n >= SESSION_ID_LEN) return 0;
    return 1;
}

static int session_is_expired(const Session *s, time_t now) {
    if (!s->in_use) return 0;
    if (!s->active) return 0;
    return s->expires_at <= now;
}

static void session_free_data(Session *s) {
    if (!s) return;
    if (s->data) {
        free(s->data);
        s->data = NULL;
    }
    s->data_len = 0;
    s->active = 0;
    s->expires_at = 0;
}

static size_t find_slot(SessionCache *c, const char *id, int *found) {
    *found = 0;
    uint64_t h = fnv1a_64(id, strnlen(id, SESSION_ID_LEN));
    size_t cap = c->capacity;
    size_t idx = (size_t)(h % cap);

    ssize_t first_tomb = -1;

    for (size_t probe = 0; probe < cap; probe++) {
        size_t i = (idx + probe) % cap;
        Session *s = &c->slots[i];

        if (!s->in_use) {
            if (first_tomb >= 0) return (size_t)first_tomb;
            return i;
        }

        if (strncmp(s->id, id, SESSION_ID_LEN) == 0) {
            *found = 1;
            return i;
        }

        if (s->in_use && !s->active && first_tomb < 0) {
            first_tomb = (ssize_t)i;
        }
    }

    if (first_tomb >= 0) return (size_t)first_tomb;
    return cap;
}

static int cache_rehash(SessionCache *c, size_t new_cap) {
    Session *old = c->slots;
    size_t old_cap = c->capacity;

    Session *ns = (Session*)calloc(new_cap, sizeof(Session));
    if (!ns) return 0;

    c->slots = ns;
    c->capacity = new_cap;
    c->used = 0;
    c->active = 0;
    c->tombstones = 0;

    for (size_t i = 0; i < old_cap; i++) {
        Session *os = &old[i];
        if (!os->in_use) continue;

        int found = 0;
        size_t pos = find_slot(c, os->id, &found);
        if (pos == c->capacity) {
            if (os->data) free(os->data);
            continue;
        }

        Session *ds = &c->slots[pos];
        *ds = *os;
        c->used++;
        if (ds->active) c->active++;
        else c->tombstones++;
    }

    free(old);
    return 1;
}

static int cache_maybe_grow(SessionCache *c) {
    if (c->capacity == 0) return 0;
    double load = (double)c->used / (double)c->capacity;
    if (load > 0.75) {
        size_t new_cap = c->capacity * 2;
        if (new_cap < c->capacity) return 0;
        return cache_rehash(c, new_cap);
    }
    return 1;
}

SessionCache *session_cache_create(size_t capacity, time_t default_ttl_sec) {
    if (capacity < 16) capacity = 16;
    SessionCache *c = (SessionCache*)calloc(1, sizeof(SessionCache));
    if (!c) return NULL;
    c->slots = (Session*)calloc(capacity, sizeof(Session));
    if (!c->slots) {
        free(c);
        return NULL;
    }
    c->capacity = capacity;
    c->default_ttl_sec = default_ttl_sec > 0 ? default_ttl_sec : 1800;
    return c;
}

void session_cache_destroy(SessionCache *c) {
    if (!c) return;
    if (c->slots) {
        for (size_t i = 0; i < c->capacity; i++) {
            if (c->slots[i].in_use && c->slots[i].data) {
                free(c->slots[i].data);
            }
        }
        free(c->slots);
    }
    free(c);
}

static void cache_expire_one(SessionCache *c, Session *s, time_t now) {
    if (session_is_expired(s, now)) {
        session_free_data(s);
        c->active--;
        c->tombstones++;
    }
}

void session_cache_sweep_expired(SessionCache *c) {
    if (!c) return;
    time_t now = time(NULL);
    for (size_t i = 0; i < c->capacity; i++) {
        Session *s = &c->slots[i];
        if (session_is_expired(s, now)) {
            session_free_data(s);
            c->active--;
            c->tombstones++;
        }
    }
}

static Session *session_get_or_create_slot(SessionCache *c, const char *id, time_t now, int *was_existing) {
    if (!c || !id_is_valid(id)) return NULL;

    if (!cache_maybe_grow(c)) return NULL;

    int found = 0;
    size_t pos = find_slot(c, id, &found);
    if (pos == c->capacity) return NULL;

    Session *s = &c->slots[pos];

    if (found) {
        *was_existing = 1;
        cache_expire_one(c, s, now);
        return s;
    }

    *was_existing = 0;
    memset(s, 0, sizeof(*s));
    strncpy(s->id, id, SESSION_ID_LEN - 1);
    s->id[SESSION_ID_LEN - 1] = '\0';
    s->in_use = 1;
    s->active = 0;
    s->data = NULL;
    s->data_len = 0;
    s->expires_at = 0;

    c->used++;
    c->tombstones++;
    return s;
}

Session *session_create(SessionCache *c, const char *id, const void *data, size_t data_len, time_t ttl_sec) {
    if (!c || !id_is_valid(id)) return NULL;
    time_t now = time(NULL);

    int was_existing = 0;
    Session *s = session_get_or_create_slot(c, id, now, &was_existing);
    if (!s) return NULL;

    if (s->active && s->data) {
        free(s->data);
        s->data = NULL;
        s->data_len = 0;
    }

    void *copy = NULL;
    if (data_len > 0) {
        copy = malloc(data_len);
        if (!copy) return NULL;
        if (data) memcpy(copy, data, data_len);
        else memset(copy, 0, data_len);
    }

    if (!s->active) {
        if (c->tombstones > 0) c->tombstones--;
        c->active++;
    }

    s->data = copy;
    s->data_len = data_len;

    time_t use_ttl = (ttl_sec > 0) ? ttl_sec : c->default_ttl_sec;
    s->expires_at = now + use_ttl;
    s->active = 1;

    return s;
}

Session *session_access(SessionCache *c, const char *id) {
    if (!c || !id_is_valid(id)) return NULL;
    time_t now = time(NULL);

    int found = 0;
    size_t pos = find_slot(c, id, &found);
    if (!found || pos == c->capacity) return NULL;

    Session *s = &c->slots[pos];
    cache_expire_one(c, s, now);
    if (!s->active) return NULL;

    return s;
}

Session *session_access_or_reinit(SessionCache *c, const char *id, const void *new_data, size_t new_len, time_t ttl_sec) {
    if (!c || !id_is_valid(id)) return NULL;
    time_t now = time(NULL);

    int was_existing = 0;
    Session *s = session_get_or_create_slot(c, id, now, &was_existing);
    if (!s) return NULL;

    if (s->active) return s;

    return session_create(c, id, new_data, new_len, ttl_sec);
}

int session_invalidate(SessionCache *c, const char *id) {
    if (!c || !id_is_valid(id)) return 0;

    int found = 0;
    size_t pos = find_slot(c, id, &found);
    if (!found || pos == c->capacity) return 0;

    Session *s = &c->slots[pos];
    if (s->active) {
        session_free_data(s);
        c->active--;
        c->tombstones++;
    }
    return 1;
}

int session_exists(SessionCache *c, const char *id) {
    if (!c || !id_is_valid(id)) return 0;
    int found = 0;
    size_t pos = find_slot(c, id, &found);
    if (!found || pos == c->capacity) return 0;
    return 1;
}

int session_is_active(SessionCache *c, const char *id) {
    if (!c || !id_is_valid(id)) return 0;
    time_t now = time(NULL);

    int found = 0;
    size_t pos = find_slot(c, id, &found);
    if (!found || pos == c->capacity) return 0;

    Session *s = &c->slots[pos];
    cache_expire_one(c, s, now);
    return s->active ? 1 : 0;
}

const char *session_id(const Session *s) {
    if (!s) return NULL;
    return s->id;
}

void *session_data(Session *s) {
    if (!s || !s->active) return NULL;
    return s->data;
}

size_t session_data_len(const Session *s) {
    if (!s || !s->active) return 0;
    return s->data_len;
}

time_t session_expires_at(const Session *s) {
    if (!s || !s->active) return 0;
    return s->expires_at;
}

int session_touch(SessionCache *c, const char *id, time_t ttl_sec) {
    if (!c || !id_is_valid(id)) return 0;
    time_t now = time(NULL);

    int found = 0;
    size_t pos = find_slot(c, id, &found);
    if (!found || pos == c->capacity) return 0;

    Session *s = &c->slots[pos];
    cache_expire_one(c, s, now);
    if (!s->active) return 0;

    time_t use_ttl = (ttl_sec > 0) ? ttl_sec : c->default_ttl_sec;
    s->expires_at = now + use_ttl;
    return 1;
}

#ifdef SESSION_CACHE_DEMO
static void dump(SessionCache *c) {
    printf("capacity=%zu used=%zu active=%zu tomb=%zu\n", c->capacity, c->used, c->active, c->tombstones);
    for (size_t i = 0; i < c->capacity; i++) {
        Session *s = &c->slots[i];
        if (!s->in_use) continue;
        printf("[%zu] id=%s in_use=%d active=%d data_len=%zu expires_at=%lld\n",
               i, s->id, s->in_use, s->active, s->data_len, (long long)s->expires_at);
    }
}

int main(void) {
    SessionCache *c = session_cache_create(16, 2);
    const char payload[] = "hello";
    session_create(c, "abc", payload, sizeof(payload), 1);
    dump(c);

    Session *s = session_access(c, "abc");
    printf("access: %s\n", s ? (char*)session_data(s) : "NULL");

    printf("sleeping...\n");
#ifdef _WIN32
    Sleep(1500);
#else
    struct timespec ts = { .tv_sec = 1, .tv_nsec = 500000000 };
    nanosleep(&ts, NULL);
#endif

    s = session_access(c, "abc");
    printf("access after expire: %s\n", s ? "ACTIVE" : "NULL");
    printf("exists=%d active=%d\n", session_exists(c, "abc"), session_is_active(c, "abc"));
    dump(c);

    session_access_or_reinit(c, "abc", "world", 6, 10);
    s = session_access(c, "abc");
    printf("reinit: %s\n", s ? (char*)session_data(s) : "NULL");
    dump(c);

    session_invalidate(c, "abc");
    printf("after invalidate: exists=%d active=%d\n", session_exists(c, "abc"), session_is_active(c, "abc"));
    dump(c);

    session_cache_destroy(c);
    return 0;
}
#endif