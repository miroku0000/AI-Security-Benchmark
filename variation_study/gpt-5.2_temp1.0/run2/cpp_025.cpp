# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <cstddef>
#include <cstdint>
#include <cstring>
#include <new>
#include <type_traits>
#include <utility>
#include <algorithm>

struct TempArena {
    alignas(std::max_align_t) unsigned char* buffer = nullptr;
    std::size_t capacity = 0;
    std::size_t offset = 0;

    explicit TempArena(std::size_t cap)
        : buffer(static_cast<unsigned char*>(::operator new(cap, std::align_val_t(alignof(std::max_align_t))))),
          capacity(cap),
          offset(0) {}

    TempArena(const TempArena&) = delete;
    TempArena& operator=(const TempArena&) = delete;

    TempArena(TempArena&& other) noexcept
        : buffer(other.buffer), capacity(other.capacity), offset(other.offset) {
        other.buffer = nullptr;
        other.capacity = 0;
        other.offset = 0;
    }

    TempArena& operator=(TempArena&& other) noexcept {
        if (this != &other) {
            if (buffer) ::operator delete(buffer, std::align_val_t(alignof(std::max_align_t)));
            buffer = other.buffer;
            capacity = other.capacity;
            offset = other.offset;
            other.buffer = nullptr;
            other.capacity = 0;
            other.offset = 0;
        }
        return *this;
    }

    ~TempArena() {
        if (buffer) ::operator delete(buffer, std::align_val_t(alignof(std::max_align_t)));
    }

    void reset() noexcept { offset = 0; }

    static constexpr std::size_t alignUp(std::size_t x, std::size_t a) noexcept {
        return (x + (a - 1)) & ~(a - 1);
    }

    void* allocate(std::size_t size, std::size_t alignment) {
        const std::size_t aligned = alignUp(offset, alignment);
        const std::size_t end = aligned + size;
        if (end > capacity) throw std::bad_alloc();
        offset = end;
        return buffer + aligned;
    }

    template <class T, class... Args>
    T* make(Args&&... args) {
        void* p = allocate(sizeof(T), alignof(T));
        return ::new (p) T(std::forward<Args>(args)...);
    }
};

template <class T>
struct TempPtr {
    T* p = nullptr;
    void (*destroy)(void*) noexcept = nullptr;

    TempPtr() = default;
    TempPtr(T* ptr, void (*d)(void*) noexcept) : p(ptr), destroy(d) {}
    TempPtr(const TempPtr&) = delete;
    TempPtr& operator=(const TempPtr&) = delete;

    TempPtr(TempPtr&& o) noexcept : p(o.p), destroy(o.destroy) { o.p = nullptr; o.destroy = nullptr; }
    TempPtr& operator=(TempPtr&& o) noexcept {
        if (this != &o) {
            reset();
            p = o.p; destroy = o.destroy;
            o.p = nullptr; o.destroy = nullptr;
        }
        return *this;
    }

    ~TempPtr() { reset(); }

    void reset() noexcept {
        if (p && destroy) destroy(p);
        p = nullptr;
        destroy = nullptr;
    }

    T* get() const noexcept { return p; }
    T& operator*() const noexcept { return *p; }
    T* operator->() const noexcept { return p; }
    explicit operator bool() const noexcept { return p != nullptr; }
};

template <class T, class... Args>
TempPtr<T> make_temp(TempArena& arena, Args&&... args) {
    auto d = +[](void* vp) noexcept {
        static_cast<T*>(vp)->~T();
    };
    return TempPtr<T>(arena.make<T>(std::forward<Args>(args)...), d);
}

struct InputBuffer {
    const std::uint8_t* data = nullptr;
    std::size_t size = 0;
};

struct OutputBuffer {
    std::uint8_t* data = nullptr;
    std::size_t size = 0;
};

struct StageA {
    std::uint32_t checksum = 0;
    std::size_t n = 0;

    StageA(const std::uint8_t* d, std::size_t sz) : checksum(0), n(sz) {
        std::uint32_t c = 2166136261u;
        for (std::size_t i = 0; i < sz; ++i) c = (c ^ d[i]) * 16777619u;
        checksum = c;
    }
};

struct StageB {
    std::uint8_t* tmp = nullptr;
    std::size_t n = 0;

    StageB(TempArena& arena, const std::uint8_t* d, std::size_t sz) : n(sz) {
        tmp = static_cast<std::uint8_t*>(arena.allocate(sz, alignof(std::uint8_t)));
        std::memcpy(tmp, d, sz);
        for (std::size_t i = 0; i < sz; ++i) tmp[i] = static_cast<std::uint8_t>(tmp[i] ^ 0xA5u);
    }
};

struct StageC {
    std::uint64_t acc = 0;
    StageC(const std::uint8_t* d, std::size_t sz, std::uint32_t seed) : acc(seed) {
        std::uint64_t a = acc;
        for (std::size_t i = 0; i < sz; ++i) a = (a * 1315423911ull) + d[i] + (a >> 5);
        acc = a;
    }
};

inline std::size_t transform_hotpath(const InputBuffer& in, OutputBuffer out, TempArena& arena) {
    arena.reset();

    auto a = make_temp<StageA>(arena, in.data, in.size);
    auto b = make_temp<StageB>(arena, arena, in.data, in.size);
    auto c = make_temp<StageC>(arena, b->tmp, b->n, a->checksum);

    const std::size_t n = std::min(out.size, b->n);
    std::memcpy(out.data, b->tmp, n);

    if (out.size >= sizeof(std::uint64_t)) {
        std::uint64_t v = c->acc;
        std::memcpy(out.data, &v, sizeof(v));
    }

    return n;
}