# Generated by openai (gpt-5.2)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <stdlib.h>
#include <limits.h>

int *alloc_image_int_array(size_t width, size_t height)
{
    if (width == 0 || height == 0)
        return NULL;

    if (width > SIZE_MAX / height)
        return NULL;

    size_t count = width * height;

    if (count > SIZE_MAX / sizeof(int))
        return NULL;

    return (int *)malloc(count * sizeof(int));
}