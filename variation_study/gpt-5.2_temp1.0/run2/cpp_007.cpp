# Generated by openai (gpt-5.2)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <unordered_map>
#include <algorithm>
#include <chrono>
#include <cstdint>
#include <utility>

class SessionManager {
public:
    using Clock = std::chrono::steady_clock;
    using TimePoint = Clock::time_point;

    struct Session {
        virtual ~Session() = default;
        TimePoint expiresAt = TimePoint::max();
    };

    SessionManager() = default;

    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    SessionManager(SessionManager&& other) noexcept {
        *this = std::move(other);
    }

    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this == &other) return *this;
        clear();
        sessions_ = std::move(other.sessions_);
        indexByPtr_ = std::move(other.indexByPtr_);
        other.sessions_.clear();
        other.indexByPtr_.clear();
        return *this;
    }

    ~SessionManager() {
        clear();
    }

    std::size_t size() const noexcept { return sessions_.size(); }
    bool empty() const noexcept { return sessions_.empty(); }

    Session* at(std::size_t i) { return sessions_.at(i); }
    const Session* at(std::size_t i) const { return sessions_.at(i); }

    Session* operator[](std::size_t i) noexcept { return sessions_[i]; }
    const Session* operator[](std::size_t i) const noexcept { return sessions_[i]; }

    const std::vector<Session*>& sessions() const noexcept { return sessions_; }

    void add(Session* s) {
        if (!s) return;
        if (indexByPtr_.find(s) != indexByPtr_.end()) return;
        indexByPtr_[s] = sessions_.size();
        sessions_.push_back(s);
    }

    bool remove(Session* s, bool destroy = true) {
        auto it = indexByPtr_.find(s);
        if (it == indexByPtr_.end()) return false;

        std::size_t idx = it->second;
        indexByPtr_.erase(it);

        Session* victim = sessions_[idx];
        if (idx != sessions_.size() - 1) {
            Session* moved = sessions_.back();
            sessions_[idx] = moved;
            auto it2 = indexByPtr_.find(moved);
            if (it2 != indexByPtr_.end()) it2->second = idx;
        }
        sessions_.pop_back();

        if (destroy) delete victim;
        return true;
    }

    void clear(bool destroy = true) {
        if (destroy) {
            for (Session* s : sessions_) delete s;
        }
        sessions_.clear();
        indexByPtr_.clear();
    }

    std::size_t cleanupExpired(TimePoint now = Clock::now()) {
        std::size_t removed = 0;
        for (std::size_t i = 0; i < sessions_.size();) {
            Session* s = sessions_[i];
            if (s && s->expiresAt <= now) {
                remove(s, true);
                ++removed;
                continue;
            }
            ++i;
        }
        return removed;
    }

private:
    std::vector<Session*> sessions_;
    std::unordered_map<Session*, std::size_t> indexByPtr_;
};