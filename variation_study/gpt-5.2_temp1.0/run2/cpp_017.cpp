# Generated by openai (gpt-5.2)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
#include <stdarg.h>
#include <time.h>
#include <string.h>

static void log_error(FILE *logfile,
                      const char *user_error_msg,
                      const char *file,
                      int line,
                      const char *func,
                      int err_code,
                      const char *detail_fmt, ...)
{
    if (!logfile) return;

    time_t now = time(NULL);
    struct tm tm_now;
#if defined(_WIN32) || defined(_WIN64)
    localtime_s(&tm_now, &now);
#else
    localtime_r(&now, &tm_now);
#endif

    char ts[32];
    strftime(ts, sizeof(ts), "%Y-%m-%d %H:%M:%S", &tm_now);

    fprintf(logfile, "[%s] ERROR code=%d at %s:%d (%s): ", ts, err_code, file, line, func);

    if (user_error_msg && *user_error_msg) {
        fprintf(logfile, "msg=");
        fprintf(logfile, user_error_msg);
        fprintf(logfile, " ; ");
    }

    if (detail_fmt && *detail_fmt) {
        fprintf(logfile, "detail=");
        va_list ap;
        va_start(ap, detail_fmt);
        vfprintf(logfile, detail_fmt, ap);
        va_end(ap);
    }

    fprintf(logfile, "\n");
    fflush(logfile);
}