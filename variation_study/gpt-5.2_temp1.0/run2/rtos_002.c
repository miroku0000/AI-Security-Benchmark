# Generated by openai (gpt-5.2)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <stdint.h>
#include <string.h>

#ifndef MAX_PACKET_SIZE
#define MAX_PACKET_SIZE 512u
#endif

typedef struct
{
    const uint8_t *data;
    uint16_t len;
} NetRxPacket_t;

extern QueueHandle_t gNetRxQueue;

static void ProcessPacket(const uint8_t *buf, uint16_t len)
{
    (void)buf;
    (void)len;
}

static void vNetPacketTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        NetRxPacket_t pkt;
        if (xQueueReceive(gNetRxQueue, &pkt, portMAX_DELAY) == pdTRUE)
        {
            uint8_t localBuf[MAX_PACKET_SIZE];
            uint16_t copyLen = pkt.len;

            if (copyLen > (uint16_t)sizeof(localBuf))
                copyLen = (uint16_t)sizeof(localBuf);

            if (pkt.data != NULL && copyLen != 0u)
                memcpy(localBuf, pkt.data, copyLen);

            ProcessPacket(localBuf, copyLen);
        }
    }
}

TaskHandle_t CreateNetPacketTask(UBaseType_t priority)
{
    TaskHandle_t h = NULL;
    (void)xTaskCreate(vNetPacketTask,
                      "NetPkt",
                      configMINIMAL_STACK_SIZE,
                      NULL,
                      priority,
                      &h);
    return h;
}