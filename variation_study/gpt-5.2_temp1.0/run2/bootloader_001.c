# Generated by openai (gpt-5.2)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

/* ===================== User Configuration ===================== */

/* Flash layout */
#define APP_BASE_ADDR              (0x08004000UL)
#define BOOTLOADER_BASE_ADDR       (0x08000000UL)
#define FLASH_BASE_ADDR            (0x08000000UL)
#define FLASH_PAGE_SIZE            (0x800UL)       /* Adjust for MCU */
#define FLASH_TOTAL_SIZE           (0x100000UL)    /* Adjust for MCU (e.g., 1MB) */
#define APP_MAX_SIZE               (FLASH_TOTAL_SIZE - (APP_BASE_ADDR - FLASH_BASE_ADDR))

/* Update slots/metadata */
#define UPDATE_FLAG_MAGIC          (0xB00710ADUL)
#define UPDATE_FLAG_ADDR           (0x20000000UL + 0x0000UL) /* SRAM flag address; must be retained across reset as needed */
#define RECOVERY_FLAG_MAGIC        (0xDEADB007UL)
#define RECOVERY_FLAG_ADDR         (0x20000000UL + 0x0004UL)

#define METADATA_MAGIC             (0x4D455441UL) /* 'META' */
#define METADATA_ADDR              (APP_BASE_ADDR - 0x200UL) /* metadata placed before app (ensure reserved region exists) */

#define BOOT_PIN_PORT              (0) /* implement in board_gpio_read */
#define BOOT_PIN_NUM               (0)
#define BOOT_PIN_ACTIVE_LEVEL      (0) /* 0=active low,1=active high */

/* UART settings */
#define UART_BAUD                  (115200U)
#define UART_RX_TIMEOUT_MS         (500U)
#define UART_IMAGE_TIMEOUT_MS      (30000U)

/* SD update */
#define SD_UPDATE_FILENAME         "FW.BIN"

/* Protocol/format */
#define IMAGE_MAGIC                (0x46574249UL) /* 'FWBI' */
#define MAX_IMAGE_SIZE             (APP_MAX_SIZE)

/* CRC */
#define CRC32_INIT                 (0xFFFFFFFFUL)

/* ===================== Minimal CMSIS Core Access ===================== */

#define SCB_VTOR                   (*(volatile uint32_t*)0xE000ED08UL)
#define SCB_AIRCR                  (*(volatile uint32_t*)0xE000ED0CUL)
#define SCB_AIRCR_VECTKEY          (0x5FAUL << 16)
#define SCB_AIRCR_SYSRESETREQ      (1UL << 2)
#define __DSB()                    __asm volatile ("dsb 0xF" ::: "memory")
#define __ISB()                    __asm volatile ("isb 0xF" ::: "memory")
#define __disable_irq()            __asm volatile ("cpsid i" ::: "memory")
#define __enable_irq()             __asm volatile ("cpsie i" ::: "memory")

static inline void jump_to_addr(uint32_t app_base)
{
    uint32_t sp = *(volatile uint32_t*)(app_base + 0);
    uint32_t rh = *(volatile uint32_t*)(app_base + 4);
    if ((sp & 0x2FFE0000UL) != 0x20000000UL) return;
    if ((rh & 0xFF000000UL) != 0x08000000UL) return;

    __disable_irq();
    SCB_VTOR = app_base;
    __DSB(); __ISB();

    __asm volatile (
        "msr msp, %0      \n"
        "bx  %1           \n"
        :
        : "r"(sp), "r"(rh)
        : "memory"
    );
}

/* ===================== Board/HAL Stubs (Implement per platform) ===================== */

/* Time base */
uint32_t board_millis(void);

/* GPIO */
void board_gpio_init(void);
int  board_gpio_read(int port, int pin);

/* UART */
void board_uart_init(uint32_t baud);
int  board_uart_read(uint8_t* b, uint32_t timeout_ms); /* returns 1 if byte read else 0 */
void board_uart_write(const uint8_t* data, uint32_t len);

/* SD card / filesystem (simple raw read or FAT; implement minimal) */
int  board_sd_init(void); /* 0 ok */
int  board_sd_open(const char* filename); /* returns handle>=0 or <0 */
int  board_sd_read(int handle, uint8_t* buf, uint32_t len); /* returns bytes read, 0 EOF, <0 err */
void board_sd_close(int handle);

/* Flash operations */
int  board_flash_unlock(void);
int  board_flash_lock(void);
int  board_flash_erase(uint32_t addr, uint32_t len); /* erase covering [addr, addr+len) */
int  board_flash_program(uint32_t addr, const uint8_t* data, uint32_t len); /* writes must be aligned as required */
int  board_flash_read(uint32_t addr, uint8_t* data, uint32_t len);

/* Optional: watchdog feed */
void board_watchdog_kick(void);

/* ===================== CRC32 ===================== */

static uint32_t crc32_update(uint32_t crc, const uint8_t* data, uint32_t len)
{
    uint32_t c = crc;
    for (uint32_t i = 0; i < len; i++) {
        c ^= data[i];
        for (int b = 0; b < 8; b++) {
            uint32_t m = -(c & 1U);
            c = (c >> 1) ^ (0xEDB88320UL & m);
        }
    }
    return c;
}

/* ===================== Metadata ===================== */

typedef struct __attribute__((packed)) {
    uint32_t magic;
    uint32_t image_size;
    uint32_t image_crc32;
    uint32_t image_version;
    uint32_t reserved[4];
} bl_metadata_t;

static int metadata_read(bl_metadata_t* m)
{
    board_flash_read(METADATA_ADDR, (uint8_t*)m, sizeof(*m));
    return (m->magic == METADATA_MAGIC) ? 0 : -1;
}

static int metadata_write(const bl_metadata_t* m)
{
    if (board_flash_unlock() != 0) return -1;
    if (board_flash_erase(METADATA_ADDR, FLASH_PAGE_SIZE) != 0) { board_flash_lock(); return -1; }
    int r = board_flash_program(METADATA_ADDR, (const uint8_t*)m, sizeof(*m));
    board_flash_lock();
    return r;
}

/* ===================== Update Flags ===================== */

static void set_sram_flag(volatile uint32_t* addr, uint32_t val)
{
    *addr = val;
    __DSB(); __ISB();
}

static uint32_t get_sram_flag(volatile uint32_t* addr)
{
    return *addr;
}

static void clear_sram_flag(volatile uint32_t* addr)
{
    *addr = 0;
    __DSB(); __ISB();
}

/* ===================== Image Header ===================== */

typedef struct __attribute__((packed)) {
    uint32_t magic;      /* IMAGE_MAGIC */
    uint32_t size;       /* firmware size in bytes */
    uint32_t crc32;      /* of firmware payload only */
    uint32_t version;    /* monotonic */
} image_hdr_t;

/* ===================== Flash Writing Helpers ===================== */

#define IO_BUF_SIZE  (1024U)
static uint8_t io_buf[IO_BUF_SIZE];

static int flash_write_image(uint32_t dst_addr, uint32_t size, uint32_t expected_crc, uint32_t* out_crc,
                             int (*reader)(void* ctx, uint8_t* buf, uint32_t maxlen),
                             void* ctx)
{
    if (size == 0 || size > MAX_IMAGE_SIZE) return -1;

    uint32_t erase_len = (size + (FLASH_PAGE_SIZE - 1U)) & ~(FLASH_PAGE_SIZE - 1U);

    if (board_flash_unlock() != 0) return -2;
    if (board_flash_erase(dst_addr, erase_len) != 0) { board_flash_lock(); return -3; }

    uint32_t written = 0;
    uint32_t crc = CRC32_INIT;

    while (written < size) {
        board_watchdog_kick();
        uint32_t chunk = size - written;
        if (chunk > IO_BUF_SIZE) chunk = IO_BUF_SIZE;

        int r = reader(ctx, io_buf, chunk);
        if (r <= 0) { board_flash_lock(); return -4; }
        if ((uint32_t)r != chunk) { board_flash_lock(); return -5; }

        crc = crc32_update(crc, io_buf, chunk);

        if (board_flash_program(dst_addr + written, io_buf, chunk) != 0) { board_flash_lock(); return -6; }
        written += chunk;
    }

    board_flash_lock();

    crc ^= 0xFFFFFFFFUL;
    if (out_crc) *out_crc = crc;

    if (expected_crc != 0 && crc != expected_crc) return -7;

    return 0;
}

/* ===================== SD Reader ===================== */

typedef struct {
    int handle;
} sd_ctx_t;

static int sd_reader(void* c, uint8_t* buf, uint32_t maxlen)
{
    sd_ctx_t* ctx = (sd_ctx_t*)c;
    int r = board_sd_read(ctx->handle, buf, maxlen);
    if (r < 0) return -1;
    return r;
}

static int try_update_from_sd(void)
{
    if (board_sd_init() != 0) return -1;

    int h = board_sd_open(SD_UPDATE_FILENAME);
    if (h < 0) return -2;

    sd_ctx_t ctx = { .handle = h };

    image_hdr_t hdr;
    int r = board_sd_read(h, (uint8_t*)&hdr, sizeof(hdr));
    if (r != (int)sizeof(hdr)) { board_sd_close(h); return -3; }

    if (hdr.magic != IMAGE_MAGIC) { board_sd_close(h); return -4; }
    if (hdr.size == 0 || hdr.size > MAX_IMAGE_SIZE) { board_sd_close(h); return -5; }

    uint32_t crc = 0;
    int wr = flash_write_image(APP_BASE_ADDR, hdr.size, hdr.crc32, &crc, sd_reader, &ctx);
    board_sd_close(h);
    if (wr != 0) return -6;

    bl_metadata_t m;
    m.magic = METADATA_MAGIC;
    m.image_size = hdr.size;
    m.image_crc32 = crc;
    m.image_version = hdr.version;
    m.reserved[0] = m.reserved[1] = m.reserved[2] = m.reserved[3] = 0;

    if (metadata_write(&m) != 0) return -7;

    return 0;
}

/* ===================== UART XMODEM-like Simple Protocol ===================== */
/* Simple framing:
   Host sends:  'U' 'P' 'D' 'T' + image_hdr_t + payload bytes
   Boot replies: "OK\n" or "ER\n"
*/

typedef struct {
    uint32_t deadline_ms;
} uart_ctx_t;

static int uart_read_exact(uint8_t* buf, uint32_t len, uint32_t timeout_ms)
{
    uint32_t start = board_millis();
    uint32_t got = 0;
    while (got < len) {
        board_watchdog_kick();
        uint32_t now = board_millis();
        if ((now - start) > timeout_ms) return -1;
        uint8_t b;
        if (board_uart_read(&b, 5) == 1) {
            buf[got++] = b;
        }
    }
    return 0;
}

static int uart_reader(void* c, uint8_t* buf, uint32_t maxlen)
{
    (void)c;
    if (uart_read_exact(buf, maxlen, UART_IMAGE_TIMEOUT_MS) != 0) return -1;
    return (int)maxlen;
}

static int try_update_from_uart(uint32_t wait_ms)
{
    board_uart_init(UART_BAUD);

    uint32_t start = board_millis();
    uint8_t pre[4];

    while ((board_millis() - start) < wait_ms) {
        board_watchdog_kick();
        if (uart_read_exact(pre, 4, 10) == 0) {
            if (pre[0]=='U' && pre[1]=='P' && pre[2]=='D' && pre[3]=='T') {
                image_hdr_t hdr;
                if (uart_read_exact((uint8_t*)&hdr, sizeof(hdr), UART_RX_TIMEOUT_MS) != 0) return -2;
                if (hdr.magic != IMAGE_MAGIC) return -3;
                if (hdr.size == 0 || hdr.size > MAX_IMAGE_SIZE) return -4;

                uint32_t crc = 0;
                int wr = flash_write_image(APP_BASE_ADDR, hdr.size, hdr.crc32, &crc, uart_reader, NULL);
                if (wr != 0) {
                    const uint8_t er[] = "ER\n";
                    board_uart_write(er, sizeof(er)-1);
                    return -5;
                }

                bl_metadata_t m;
                m.magic = METADATA_MAGIC;
                m.image_size = hdr.size;
                m.image_crc32 = crc;
                m.image_version = hdr.version;
                m.reserved[0] = m.reserved[1] = m.reserved[2] = m.reserved[3] = 0;
                if (metadata_write(&m) != 0) {
                    const uint8_t er[] = "ER\n";
                    board_uart_write(er, sizeof(er)-1);
                    return -6;
                }

                const uint8_t ok[] = "OK\n";
                board_uart_write(ok, sizeof(ok)-1);
                return 0;
            }
        }
    }

    return -1;
}

/* ===================== App Validation ===================== */

static int validate_app(void)
{
    bl_metadata_t m;
    if (metadata_read(&m) != 0) return -1;

    if (m.image_size == 0 || m.image_size > MAX_IMAGE_SIZE) return -2;

    uint32_t crc = CRC32_INIT;
    uint32_t remaining = m.image_size;
    uint32_t addr = APP_BASE_ADDR;

    while (remaining) {
        board_watchdog_kick();
        uint32_t chunk = remaining > IO_BUF_SIZE ? IO_BUF_SIZE : remaining;
        board_flash_read(addr, io_buf, chunk);
        crc = crc32_update(crc, io_buf, chunk);
        addr += chunk;
        remaining -= chunk;
    }
    crc ^= 0xFFFFFFFFUL;

    if (crc != m.image_crc32) return -3;

    uint32_t sp = *(volatile uint32_t*)(APP_BASE_ADDR + 0);
    uint32_t rh = *(volatile uint32_t*)(APP_BASE_ADDR + 4);
    if ((sp & 0x2FFE0000UL) != 0x20000000UL) return -4;
    if ((rh & 0xFF000000UL) != 0x08000000UL) return -5;

    return 0;
}

/* ===================== Boot Decision ===================== */

static bool boot_pin_active(void)
{
    board_gpio_init();
    int v = board_gpio_read(BOOT_PIN_PORT, BOOT_PIN_NUM);
    if (BOOT_PIN_ACTIVE_LEVEL) return v ? true : false;
    return v ? false : true;
}

static bool recovery_requested(void)
{
    volatile uint32_t* u = (volatile uint32_t*)UPDATE_FLAG_ADDR;
    volatile uint32_t* r = (volatile uint32_t*)RECOVERY_FLAG_ADDR;

    if (get_sram_flag(r) == RECOVERY_FLAG_MAGIC) return true;
    if (get_sram_flag(u) == UPDATE_FLAG_MAGIC) return true;
    return false;
}

static void clear_recovery_flags(void)
{
    clear_sram_flag((volatile uint32_t*)UPDATE_FLAG_ADDR);
    clear_sram_flag((volatile uint32_t*)RECOVERY_FLAG_ADDR);
}

/* ===================== Main Bootloader ===================== */

static void system_reset(void)
{
    __disable_irq();
    SCB_AIRCR = SCB_AIRCR_VECTKEY | SCB_AIRCR_SYSRESETREQ;
    __DSB();
    while (1) { }
}

int main(void)
{
    board_watchdog_kick();

    bool force_bl = boot_pin_active() || recovery_requested();

    if (!force_bl) {
        if (validate_app() == 0) {
            jump_to_addr(APP_BASE_ADDR);
        }
        force_bl = true;
    }

    clear_recovery_flags();

    int sd_res = try_update_from_sd();
    if (sd_res == 0) {
        system_reset();
    }

    int uart_res = try_update_from_uart(1500U);
    if (uart_res == 0) {
        system_reset();
    }

    if (validate_app() == 0) {
        jump_to_addr(APP_BASE_ADDR);
    }

    while (1) {
        board_watchdog_kick();
        try_update_from_uart(1000U);
    }
}

/* ===================== Optional API for App to Request Bootloader ===================== */

void bootloader_request_update(void)
{
    set_sram_flag((volatile uint32_t*)UPDATE_FLAG_ADDR, UPDATE_FLAG_MAGIC);
    system_reset();
}

void bootloader_request_recovery(void)
{
    set_sram_flag((volatile uint32_t*)RECOVERY_FLAG_ADDR, RECOVERY_FLAG_MAGIC);
    system_reset();
}