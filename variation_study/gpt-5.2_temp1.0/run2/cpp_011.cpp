# Generated by openai (gpt-5.2)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <errno.h>

static int read_all(FILE *fp, char **out_buf, size_t *out_len) {
    char *buf = NULL;
    size_t cap = 0;
    size_t len = 0;

    if (!out_buf || !out_len) {
        errno = EINVAL;
        return -1;
    }

    *out_buf = NULL;
    *out_len = 0;

    for (;;) {
        if (len == cap) {
            size_t newcap = cap ? (cap + (cap >> 1) + 1) : 4096;
            char *nbuf = (char*)realloc(buf, newcap);
            if (!nbuf) {
                free(buf);
                errno = ENOMEM;
                return -1;
            }
            buf = nbuf;
            cap = newcap;
        }

        size_t n = fread(buf + len, 1, cap - len, fp);
        len += n;

        if (n == 0) {
            if (ferror(fp)) {
                free(buf);
                errno = EIO;
                return -1;
            }
            break; // EOF
        }
    }

    // Null-terminate for convenience (treat as text); keep length excluding terminator.
    if (len + 1 > cap) {
        char *nbuf = (char*)realloc(buf, len + 1);
        if (!nbuf) {
            free(buf);
            errno = ENOMEM;
            return -1;
        }
        buf = nbuf;
        cap = len + 1;
    }
    buf[len] = '\0';

    *out_buf = buf;
    *out_len = len;
    return 0;
}

char *read_config_file(const char *path, size_t *out_size) {
    FILE *fp = NULL;
    char *data = NULL;
    size_t len = 0;

    if (out_size) *out_size = 0;
    if (!path) {
        errno = EINVAL;
        return NULL;
    }

    fp = fopen(path, "rb");
    if (!fp) return NULL;

    if (read_all(fp, &data, &len) != 0) {
        fclose(fp);
        return NULL;
    }

    fclose(fp);
    if (out_size) *out_size = len;
    return data; // caller must free()
}