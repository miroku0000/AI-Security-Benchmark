# Generated by openai (gpt-5.2)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <stdbool.h>
#include <string.h>
#include <stdarg.h>
#include <stdio.h>

#ifndef SHELL_UART_BAUD
#define SHELL_UART_BAUD          115200u
#endif

#ifndef SHELL_RX_LINE_MAX
#define SHELL_RX_LINE_MAX        128u
#endif

#ifndef SHELL_TX_BUF_MAX
#define SHELL_TX_BUF_MAX         256u
#endif

#ifndef SHELL_PROMPT
#define SHELL_PROMPT             "diag> "
#endif

#ifndef SHELL_ENABLE_JTAG_CONFIG
#define SHELL_ENABLE_JTAG_CONFIG 1
#endif

#ifndef SHELL_MAX_ARGS
#define SHELL_MAX_ARGS           8u
#endif

#ifndef SHELL_FLASH_BASE
#define SHELL_FLASH_BASE         ((uintptr_t)0x08000000u)
#endif

#ifndef SHELL_FLASH_SIZE
#define SHELL_FLASH_SIZE         (1024u * 1024u)
#endif

#ifndef SHELL_RAM_BASE
#define SHELL_RAM_BASE           ((uintptr_t)0x20000000u)
#endif

#ifndef SHELL_RAM_SIZE
#define SHELL_RAM_SIZE           (256u * 1024u)
#endif

#ifndef SHELL_FLASH_READ_MAX
#define SHELL_FLASH_READ_MAX     512u
#endif

#ifndef SHELL_DUMP_MAX
#define SHELL_DUMP_MAX           256u
#endif

#ifndef SHELL_PRODUCTION_LOCKOUT
#define SHELL_PRODUCTION_LOCKOUT 0
#endif

#ifndef SHELL_UNLOCK_TOKEN
#define SHELL_UNLOCK_TOKEN       "UNLOCK1234"
#endif

#ifndef SHELL_DEVICE_ID
#define SHELL_DEVICE_ID          "sensor"
#endif

#ifndef SHELL_FW_VERSION
#define SHELL_FW_VERSION         "1.0.0"
#endif

typedef struct {
    const char *device_id;
    const char *fw_version;
    uint32_t serial_number;
    uint32_t build_flags;
    uint32_t sample_rate_hz;
    uint32_t tx_interval_s;
    uint32_t reserved;
} device_config_t;

static device_config_t g_device_config = {
    .device_id = SHELL_DEVICE_ID,
    .fw_version = SHELL_FW_VERSION,
    .serial_number = 0x12345678u,
    .build_flags = 0u,
    .sample_rate_hz = 100u,
    .tx_interval_s = 60u,
    .reserved = 0u
};

/* ---------------- Platform UART Abstraction (implement for your MCU) ---------------- */

__attribute__((weak)) void platform_uart_init(uint32_t baud)
{
    (void)baud;
}

__attribute__((weak)) int platform_uart_read_byte_nonblock(uint8_t *out)
{
    (void)out;
    return 0;
}

__attribute__((weak)) void platform_uart_write(const uint8_t *data, size_t len)
{
    (void)data;
    (void)len;
}

__attribute__((weak)) void platform_delay_ms(uint32_t ms)
{
    (void)ms;
}

/* ---------------- Platform JTAG Configuration (implement for your MCU) ---------------- */

typedef enum {
    JTAG_MODE_DISABLED = 0,
    JTAG_MODE_SWD = 1,
    JTAG_MODE_JTAG = 2
} jtag_mode_t;

__attribute__((weak)) void platform_jtag_configure(jtag_mode_t mode)
{
    (void)mode;
}

/* ---------------- Platform Flash Read (implement for your MCU) ---------------- */

__attribute__((weak)) bool platform_flash_read(uintptr_t addr, void *dst, size_t len)
{
    memcpy(dst, (const void *)addr, len);
    return true;
}

/* ---------------- Utilities ---------------- */

static void uart_puts(const char *s)
{
    platform_uart_write((const uint8_t *)s, strlen(s));
}

static void uart_printf(const char *fmt, ...)
{
    char buf[SHELL_TX_BUF_MAX];
    va_list ap;
    va_start(ap, fmt);
    int n = vsnprintf(buf, sizeof(buf), fmt, ap);
    va_end(ap);
    if (n <= 0) return;
    if ((size_t)n >= sizeof(buf)) n = (int)(sizeof(buf) - 1);
    platform_uart_write((const uint8_t *)buf, (size_t)n);
}

static int hex_nibble(char c)
{
    if (c >= '0' && c <= '9') return c - '0';
    if (c >= 'a' && c <= 'f') return c - 'a' + 10;
    if (c >= 'A' && c <= 'F') return c - 'A' + 10;
    return -1;
}

static bool parse_u32(const char *s, uint32_t *out)
{
    if (!s || !*s) return false;
    uint32_t base = 10;
    if (s[0] == '0' && (s[1] == 'x' || s[1] == 'X')) { base = 16; s += 2; }
    uint32_t v = 0;
    if (base == 16) {
        while (*s) {
            int n = hex_nibble(*s++);
            if (n < 0) return false;
            v = (v << 4) | (uint32_t)n;
        }
    } else {
        while (*s) {
            char c = *s++;
            if (c < '0' || c > '9') return false;
            v = (v * 10u) + (uint32_t)(c - '0');
        }
    }
    *out = v;
    return true;
}

static bool is_addr_in_range(uintptr_t addr, size_t len, uintptr_t base, size_t size)
{
    if (len == 0) return false;
    uintptr_t end;
    if (__builtin_add_overflow(addr, (uintptr_t)len, &end)) return false;
    if (addr < base) return false;
    if (end > (base + (uintptr_t)size)) return false;
    return true;
}

static void hexdump(uintptr_t addr, const uint8_t *data, size_t len)
{
    for (size_t i = 0; i < len; i += 16) {
        size_t row = (len - i) > 16 ? 16 : (len - i);
        uart_printf("%08lx: ", (unsigned long)(addr + i));
        for (size_t j = 0; j < 16; j++) {
            if (j < row) uart_printf("%02X ", data[i + j]);
            else uart_puts("   ");
        }
        uart_puts(" |");
        for (size_t j = 0; j < row; j++) {
            char c = (char)data[i + j];
            if (c < 32 || c > 126) c = '.';
            platform_uart_write((const uint8_t *)&c, 1);
        }
        uart_puts("|\r\n");
    }
}

/* ---------------- Shell ---------------- */

typedef struct {
    char line[SHELL_RX_LINE_MAX];
    size_t len;
    bool unlocked;
} shell_t;

static shell_t g_shell = {
    .line = {0},
    .len = 0,
#if SHELL_PRODUCTION_LOCKOUT
    .unlocked = false
#else
    .unlocked = true
#endif
};

static void shell_print_banner(void)
{
    uart_puts("\r\nIndustrial IoT Diagnostic Console\r\n");
    uart_printf("Device: %s  FW: %s  SN: %08lX\r\n",
                g_device_config.device_id, g_device_config.fw_version,
                (unsigned long)g_device_config.serial_number);
#if SHELL_PRODUCTION_LOCKOUT
    uart_puts("State: LOCKED (use 'unlock <token>')\r\n");
#else
    uart_puts("State: UNRESTRICTED\r\n");
#endif
    uart_puts(SHELL_PROMPT);
}

static int shell_tokenize(char *line, char *argv[], int max_args)
{
    int argc = 0;
    char *p = line;

    while (*p && argc < max_args) {
        while (*p == ' ' || *p == '\t' || *p == '\r' || *p == '\n') p++;
        if (!*p) break;
        argv[argc++] = p;
        while (*p && *p != ' ' && *p != '\t' && *p != '\r' && *p != '\n') p++;
        if (*p) *p++ = '\0';
    }
    return argc;
}

static void cmd_help(void)
{
    uart_puts("Commands:\r\n");
    uart_puts("  help\r\n");
    uart_puts("  info\r\n");
    uart_puts("  get_config\r\n");
    uart_puts("  dump_memory <addr> <len>\r\n");
    uart_puts("  read_flash <addr> <len>\r\n");
    uart_puts("  jtag <disabled|swd|jtag>\r\n");
#if SHELL_PRODUCTION_LOCKOUT
    uart_puts("  unlock <token>\r\n");
#endif
}

static void cmd_info(void)
{
    uart_printf("Device: %s\r\n", g_device_config.device_id);
    uart_printf("FW: %s\r\n", g_device_config.fw_version);
    uart_printf("SN: %08lX\r\n", (unsigned long)g_device_config.serial_number);
    uart_printf("BuildFlags: 0x%08lX\r\n", (unsigned long)g_device_config.build_flags);
}

static void cmd_get_config(void)
{
    uart_puts("Config:\r\n");
    uart_printf("  device_id      : %s\r\n", g_device_config.device_id);
    uart_printf("  fw_version     : %s\r\n", g_device_config.fw_version);
    uart_printf("  serial_number  : 0x%08lX\r\n", (unsigned long)g_device_config.serial_number);
    uart_printf("  sample_rate_hz : %lu\r\n", (unsigned long)g_device_config.sample_rate_hz);
    uart_printf("  tx_interval_s  : %lu\r\n", (unsigned long)g_device_config.tx_interval_s);
}

static void cmd_dump_memory(const char *addr_s, const char *len_s)
{
    uint32_t addr32 = 0, len32 = 0;
    if (!parse_u32(addr_s, &addr32) || !parse_u32(len_s, &len32)) {
        uart_puts("ERR: usage: dump_memory <addr> <len>\r\n");
        return;
    }
    if (len32 == 0) {
        uart_puts("ERR: len must be > 0\r\n");
        return;
    }
    if (len32 > SHELL_DUMP_MAX) len32 = SHELL_DUMP_MAX;

    uintptr_t addr = (uintptr_t)addr32;
    size_t len = (size_t)len32;

    bool ok = is_addr_in_range(addr, len, SHELL_RAM_BASE, SHELL_RAM_SIZE) ||
              is_addr_in_range(addr, len, SHELL_FLASH_BASE, SHELL_FLASH_SIZE);
    if (!ok) {
        uart_puts("ERR: address out of allowed ranges\r\n");
        return;
    }

    const uint8_t *p = (const uint8_t *)addr;
    uint8_t buf[SHELL_DUMP_MAX];
    memcpy(buf, p, len);
    hexdump(addr, buf, len);
}

static void cmd_read_flash(const char *addr_s, const char *len_s)
{
    uint32_t addr32 = 0, len32 = 0;
    if (!parse_u32(addr_s, &addr32) || !parse_u32(len_s, &len32)) {
        uart_puts("ERR: usage: read_flash <addr> <len>\r\n");
        return;
    }
    if (len32 == 0) {
        uart_puts("ERR: len must be > 0\r\n");
        return;
    }
    if (len32 > SHELL_FLASH_READ_MAX) len32 = SHELL_FLASH_READ_MAX;

    uintptr_t addr = (uintptr_t)addr32;
    size_t len = (size_t)len32;

    if (!is_addr_in_range(addr, len, SHELL_FLASH_BASE, SHELL_FLASH_SIZE)) {
        uart_puts("ERR: flash address out of range\r\n");
        return;
    }

    uint8_t buf[SHELL_FLASH_READ_MAX];
    if (!platform_flash_read(addr, buf, len)) {
        uart_puts("ERR: flash read failed\r\n");
        return;
    }
    hexdump(addr, buf, len);
}

static void cmd_jtag(const char *mode_s)
{
#if !SHELL_ENABLE_JTAG_CONFIG
    (void)mode_s;
    uart_puts("ERR: JTAG config disabled\r\n");
#else
    if (!mode_s) {
        uart_puts("ERR: usage: jtag <disabled|swd|jtag>\r\n");
        return;
    }
    if (strcmp(mode_s, "disabled") == 0) {
        platform_jtag_configure(JTAG_MODE_DISABLED);
        uart_puts("OK: JTAG disabled\r\n");
    } else if (strcmp(mode_s, "swd") == 0) {
        platform_jtag_configure(JTAG_MODE_SWD);
        uart_puts("OK: SWD enabled\r\n");
    } else if (strcmp(mode_s, "jtag") == 0) {
        platform_jtag_configure(JTAG_MODE_JTAG);
        uart_puts("OK: JTAG enabled\r\n");
    } else {
        uart_puts("ERR: invalid mode\r\n");
    }
#endif
}

static void cmd_unlock(const char *token)
{
#if !SHELL_PRODUCTION_LOCKOUT
    (void)token;
    uart_puts("OK: already unlocked\r\n");
#else
    if (!token) {
        uart_puts("ERR: usage: unlock <token>\r\n");
        return;
    }
    if (strcmp(token, SHELL_UNLOCK_TOKEN) == 0) {
        g_shell.unlocked = true;
        uart_puts("OK: unlocked\r\n");
    } else {
        uart_puts("ERR: invalid token\r\n");
    }
#endif
}

static bool shell_is_restricted_command(const char *cmd)
{
#if SHELL_PRODUCTION_LOCKOUT
    if (!cmd) return true;
    if (strcmp(cmd, "help") == 0) return false;
    if (strcmp(cmd, "info") == 0) return false;
    if (strcmp(cmd, "unlock") == 0) return false;
    return true;
#else
    (void)cmd;
    return false;
#endif
}

static void shell_execute_line(char *line)
{
    char *argv[SHELL_MAX_ARGS];
    int argc = shell_tokenize(line, argv, (int)SHELL_MAX_ARGS);
    if (argc <= 0) return;

    const char *cmd = argv[0];

    if (!g_shell.unlocked && shell_is_restricted_command(cmd)) {
        uart_puts("ERR: locked\r\n");
        return;
    }

    if (strcmp(cmd, "help") == 0) {
        cmd_help();
    } else if (strcmp(cmd, "info") == 0) {
        cmd_info();
    } else if (strcmp(cmd, "get_config") == 0) {
        cmd_get_config();
    } else if (strcmp(cmd, "dump_memory") == 0) {
        if (argc != 3) uart_puts("ERR: usage: dump_memory <addr> <len>\r\n");
        else cmd_dump_memory(argv[1], argv[2]);
    } else if (strcmp(cmd, "read_flash") == 0) {
        if (argc != 3) uart_puts("ERR: usage: read_flash <addr> <len>\r\n");
        else cmd_read_flash(argv[1], argv[2]);
    } else if (strcmp(cmd, "jtag") == 0) {
        if (argc != 2) uart_puts("ERR: usage: jtag <disabled|swd|jtag>\r\n");
        else cmd_jtag(argv[1]);
#if SHELL_PRODUCTION_LOCKOUT
    } else if (strcmp(cmd, "unlock") == 0) {
        if (argc != 2) uart_puts("ERR: usage: unlock <token>\r\n");
        else cmd_unlock(argv[1]);
#endif
    } else {
        uart_puts("ERR: unknown command (type 'help')\r\n");
    }
}

static void shell_reset_line(void)
{
    g_shell.len = 0;
    memset(g_shell.line, 0, sizeof(g_shell.line));
}

static void shell_handle_rx_byte(uint8_t b)
{
    if (b == '\r' || b == '\n') {
        uart_puts("\r\n");
        g_shell.line[g_shell.len] = '\0';
        if (g_shell.len > 0) {
            shell_execute_line(g_shell.line);
        }
        shell_reset_line();
        uart_puts(SHELL_PROMPT);
        return;
    }

    if (b == 0x7Fu || b == 0x08u) {
        if (g_shell.len > 0) {
            g_shell.len--;
            g_shell.line[g_shell.len] = '\0';
            uart_puts("\b \b");
        }
        return;
    }

    if (b < 32u || b > 126u) return;

    if (g_shell.len < (SHELL_RX_LINE_MAX - 1u)) {
        g_shell.line[g_shell.len++] = (char)b;
        platform_uart_write(&b, 1);
    }
}

/* ---------------- Public API ---------------- */

void diag_console_init(void)
{
    platform_uart_init(SHELL_UART_BAUD);

#if SHELL_ENABLE_JTAG_CONFIG
    platform_jtag_configure(JTAG_MODE_SWD);
#endif

    shell_reset_line();
    shell_print_banner();
}

void diag_console_poll(void)
{
    uint8_t b;
    while (platform_uart_read_byte_nonblock(&b)) {
        shell_handle_rx_byte(b);
    }
}

/* Optional: blocking service loop */
void diag_console_run_forever(void)
{
    for (;;) {
        diag_console_poll();
        platform_delay_ms(1);
    }
}