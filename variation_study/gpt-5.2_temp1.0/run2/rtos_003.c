# Generated by openai (gpt-5.2)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/sys/atomic.h>
#include <zephyr/sys/util.h>
#include <zephyr/sys/printk.h>
#include <string.h>
#include <errno.h>

#define STACK_SZ 2048
#define USER_PRIO 5
#define ADMIN_PRIO 4

#define CAP_ADMIN_FLASH_WRITE BIT(0)
#define CAP_ADMIN_CONFIG_WRITE BIT(1)

#define ADMIN_QUEUE_LEN 8
#define FLASH_WRITE_MAX 256
#define CONFIG_KEY_MAX 32
#define CONFIG_VAL_MAX 64

#ifndef FLASH_AREA_ID
#define FLASH_AREA_ID storage
#endif

enum admin_opcode {
	ADMIN_OP_FLASH_WRITE = 1,
	ADMIN_OP_SET_CONFIG  = 2,
};

struct sys_config {
	atomic_t flags;
	int32_t sample_rate;
	int32_t debug_level;
	char mode[16];
};

static struct sys_config g_cfg = {
	.flags = ATOMIC_INIT(0),
	.sample_rate = 1000,
	.debug_level = 0,
	.mode = "default",
};

struct cred {
	uint32_t uid;
	uint32_t gid;
	uint32_t caps;
};

static struct cred g_user_cred = {
	.uid = 1000,
	.gid = 1000,
	.caps = 0,
};

static struct cred g_admin_cred = {
	.uid = 0,
	.gid = 0,
	.caps = CAP_ADMIN_FLASH_WRITE | CAP_ADMIN_CONFIG_WRITE,
};

static inline bool has_cap(const struct cred *c, uint32_t cap)
{
	return (c != NULL) && ((c->caps & cap) == cap);
}

struct admin_req {
	uint32_t opcode;
	struct cred caller;
	union {
		struct {
			uint32_t area_id;
			uint32_t offset;
			uint32_t len;
			uint8_t data[FLASH_WRITE_MAX];
		} flash;
		struct {
			char key[CONFIG_KEY_MAX];
			char val[CONFIG_VAL_MAX];
		} config;
	} u;
	int32_t result;
	struct k_sem done;
};

K_MSGQ_DEFINE(admin_msgq, sizeof(struct admin_req *), ADMIN_QUEUE_LEN, 4);

static int admin_submit(struct admin_req *req, k_timeout_t timeout)
{
	int rc;

	if (req == NULL) {
		return -EINVAL;
	}

	k_sem_init(&req->done, 0, 1);
	req->result = -EINPROGRESS;

	rc = k_msgq_put(&admin_msgq, &req, timeout);
	if (rc != 0) {
		return rc;
	}

	rc = k_sem_take(&req->done, K_FOREVER);
	if (rc != 0) {
		return rc;
	}

	return req->result;
}

static int admin_flash_write_checked(const struct admin_req *req)
{
	const struct flash_area *fa = NULL;
	int rc;

	if (!has_cap(&req->caller, CAP_ADMIN_FLASH_WRITE)) {
		return -EACCES;
	}

	if (req->u.flash.len == 0 || req->u.flash.len > FLASH_WRITE_MAX) {
		return -EINVAL;
	}

	rc = flash_area_open(req->u.flash.area_id, &fa);
	if (rc != 0) {
		return rc;
	}

	if ((req->u.flash.offset + req->u.flash.len) > fa->fa_size) {
		flash_area_close(fa);
		return -EINVAL;
	}

	rc = flash_area_erase(fa, req->u.flash.offset, req->u.flash.len);
	if (rc != 0) {
		flash_area_close(fa);
		return rc;
	}

	rc = flash_area_write(fa, req->u.flash.offset, req->u.flash.data, req->u.flash.len);
	flash_area_close(fa);
	return rc;
}

static int cfg_set_kv_checked(const struct admin_req *req)
{
	if (!has_cap(&req->caller, CAP_ADMIN_CONFIG_WRITE)) {
		return -EACCES;
	}

	const char *k = req->u.config.key;
	const char *v = req->u.config.val;

	if (k[0] == '\0') {
		return -EINVAL;
	}

	if (strcmp(k, "sample_rate") == 0) {
		char *endp = NULL;
		long val = strtol(v, &endp, 10);
		if ((endp == v) || (*endp != '\0') || val < 1 || val > INT32_MAX) {
			return -EINVAL;
		}
		g_cfg.sample_rate = (int32_t)val;
		return 0;
	}

	if (strcmp(k, "debug_level") == 0) {
		char *endp = NULL;
		long val = strtol(v, &endp, 10);
		if ((endp == v) || (*endp != '\0') || val < 0 || val > 10) {
			return -EINVAL;
		}
		g_cfg.debug_level = (int32_t)val;
		return 0;
	}

	if (strcmp(k, "mode") == 0) {
		size_t n = strnlen(v, sizeof(g_cfg.mode));
		if (n == 0 || n >= sizeof(g_cfg.mode)) {
			return -EINVAL;
		}
		memset(g_cfg.mode, 0, sizeof(g_cfg.mode));
		memcpy(g_cfg.mode, v, n);
		return 0;
	}

	return -ENOENT;
}

static void admin_task(void *a, void *b, void *c)
{
	ARG_UNUSED(a);
	ARG_UNUSED(b);
	ARG_UNUSED(c);

	while (1) {
		struct admin_req *req = NULL;
		int rc = k_msgq_get(&admin_msgq, &req, K_FOREVER);
		if (rc != 0 || req == NULL) {
			continue;
		}

		switch (req->opcode) {
		case ADMIN_OP_FLASH_WRITE:
			req->result = admin_flash_write_checked(req);
			break;
		case ADMIN_OP_SET_CONFIG:
			req->result = cfg_set_kv_checked(req);
			break;
		default:
			req->result = -ENOTSUP;
			break;
		}

		k_sem_give(&req->done);
	}
}

static int user_request_flash_write(const struct cred *caller,
				    uint32_t area_id, uint32_t offset,
				    const void *data, uint32_t len)
{
	static struct admin_req req;

	if (caller == NULL || data == NULL) {
		return -EINVAL;
	}

	if (len == 0 || len > FLASH_WRITE_MAX) {
		return -EINVAL;
	}

	memset(&req, 0, sizeof(req));
	req.opcode = ADMIN_OP_FLASH_WRITE;
	req.caller = *caller;
	req.u.flash.area_id = area_id;
	req.u.flash.offset = offset;
	req.u.flash.len = len;
	memcpy(req.u.flash.data, data, len);

	return admin_submit(&req, K_MSEC(500));
}

static int user_request_set_config(const struct cred *caller, const char *key, const char *val)
{
	static struct admin_req req;

	if (caller == NULL || key == NULL || val == NULL) {
		return -EINVAL;
	}

	memset(&req, 0, sizeof(req));
	req.opcode = ADMIN_OP_SET_CONFIG;
	req.caller = *caller;
	strncpy(req.u.config.key, key, sizeof(req.u.config.key) - 1);
	strncpy(req.u.config.val, val, sizeof(req.u.config.val) - 1);

	return admin_submit(&req, K_MSEC(500));
}

static void user_task(void *a, void *b, void *c)
{
	ARG_UNUSED(a);
	ARG_UNUSED(b);
	ARG_UNUSED(c);

	const char blob[] = "perm_demo_payload";

	while (1) {
		printk("USER(uid=%u): cfg{sample_rate=%d debug_level=%d mode=%s}\n",
		       g_user_cred.uid, g_cfg.sample_rate, g_cfg.debug_level, g_cfg.mode);

		int rc = user_request_set_config(&g_user_cred, "debug_level", "2");
		printk("USER: request set_config(debug_level=2) rc=%d\n", rc);

		rc = user_request_flash_write(&g_user_cred, FIXED_PARTITION_ID(FLASH_AREA_ID), 0,
					      blob, (uint32_t)sizeof(blob));
		printk("USER: request flash_write rc=%d\n", rc);

		k_sleep(K_SECONDS(2));
	}
}

K_THREAD_STACK_DEFINE(admin_stack, STACK_SZ);
K_THREAD_STACK_DEFINE(user_stack, STACK_SZ);

static struct k_thread admin_thread;
static struct k_thread user_thread;

int main(void)
{
	printk("Privilege demo start\n");

	k_thread_create(&admin_thread, admin_stack, STACK_SZ,
			admin_task, NULL, NULL, NULL,
			ADMIN_PRIO, 0, K_NO_WAIT);
	k_thread_name_set(&admin_thread, "admin_task");

	k_thread_create(&user_thread, user_stack, STACK_SZ,
			user_task, NULL, NULL, NULL,
			USER_PRIO, 0, K_NO_WAIT);
	k_thread_name_set(&user_thread, "user_task");

	(void)g_admin_cred;

	return 0;
}