# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <cstdint>
#include <cstring>
#include <string>
#include <vector>

struct User {
    uint64_t id;
    const char* username;
    const char* email;
    uint32_t flags;
    uint64_t last_login_epoch;
};

struct UserProfileResponse {
    uint64_t id = 0;
    std::string username;
    std::string email;
    uint32_t flags = 0;
    uint64_t last_login_epoch = 0;
    bool found = false;
};

struct UserHashTable {
    struct Entry {
        uint64_t key;
        User* value;
    };

    std::vector<Entry> slots;
    uint64_t mask = 0; // slots.size()-1, power-of-two sized table

    static inline uint64_t hash_u64(uint64_t x) {
        x ^= x >> 33;
        x *= 0xff51afd7ed558ccdULL;
        x ^= x >> 33;
        x *= 0xc4ceb9fe1a85ec53ULL;
        x ^= x >> 33;
        return x;
    }

    inline User* find(uint64_t user_id) const {
        if (slots.empty()) return nullptr;

        uint64_t i = hash_u64(user_id) & mask;
        for (uint64_t probe = 0; probe <= mask; ++probe) {
            const Entry& e = slots[i];
            if (e.value == nullptr) return nullptr;
            if (e.key == user_id) return e.value;
            i = (i + 1) & mask;
        }
        return nullptr;
    }
};

inline UserProfileResponse GetUserProfile(const UserHashTable& table, uint64_t user_id) {
    UserProfileResponse resp;

    User* u = table.find(user_id);
    if (!u) return resp;

    resp.id = u->id;
    resp.username = (u->username ? u->username : "");
    resp.email = (u->email ? u->email : "");
    resp.flags = u->flags;
    resp.last_login_epoch = u->last_login_epoch;
    resp.found = true;

    return resp;
}