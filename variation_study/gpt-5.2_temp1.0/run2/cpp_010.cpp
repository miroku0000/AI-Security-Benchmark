# Generated by openai (gpt-5.2)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <vector>
#include <thread>
#include <mutex>
#include <shared_mutex>
#include <random>
#include <atomic>
#include <chrono>
#include <stdexcept>
#include <iomanip>

using AccountId = int;

struct Account {
    long long balance_cents = 0;
    mutable std::mutex m;
};

class Bank {
public:
    void addAccount(AccountId id, long long initial_balance_cents) {
        std::unique_lock<std::shared_mutex> lock(map_m_);
        auto &ptr = accounts_[id];
        if (!ptr) ptr = std::make_shared<Account>();
        std::lock_guard<std::mutex> g(ptr->m);
        ptr->balance_cents = initial_balance_cents;
    }

    bool deposit(AccountId id, long long amount_cents) {
        if (amount_cents < 0) return false;
        auto acc = getAccount(id);
        if (!acc) return false;
        std::lock_guard<std::mutex> g(acc->m);
        acc->balance_cents += amount_cents;
        return true;
    }

    bool withdraw(AccountId id, long long amount_cents) {
        if (amount_cents < 0) return false;
        auto acc = getAccount(id);
        if (!acc) return false;
        std::lock_guard<std::mutex> g(acc->m);
        if (acc->balance_cents < amount_cents) return false;
        acc->balance_cents -= amount_cents;
        return true;
    }

    bool transfer(AccountId from, AccountId to, long long amount_cents) {
        if (amount_cents < 0) return false;
        if (from == to) return true;

        auto a = getAccount(from);
        auto b = getAccount(to);
        if (!a || !b) return false;

        Account *first = a.get();
        Account *second = b.get();
        if (std::less<Account*>{}(second, first)) std::swap(first, second);

        std::scoped_lock lock(first->m, second->m);

        if (a->balance_cents < amount_cents) return false;
        a->balance_cents -= amount_cents;
        b->balance_cents += amount_cents;
        return true;
    }

    bool getBalance(AccountId id, long long &out_balance_cents) const {
        auto acc = getAccountConst(id);
        if (!acc) return false;
        std::lock_guard<std::mutex> g(acc->m);
        out_balance_cents = acc->balance_cents;
        return true;
    }

    long long totalBalanceCents() const {
        std::vector<std::shared_ptr<Account>> snapshot;
        {
            std::shared_lock<std::shared_mutex> lock(map_m_);
            snapshot.reserve(accounts_.size());
            for (auto &kv : accounts_) snapshot.push_back(kv.second);
        }

        long long total = 0;
        for (auto &acc : snapshot) {
            std::lock_guard<std::mutex> g(acc->m);
            total += acc->balance_cents;
        }
        return total;
    }

    std::vector<AccountId> accountIds() const {
        std::vector<AccountId> ids;
        std::shared_lock<std::shared_mutex> lock(map_m_);
        ids.reserve(accounts_.size());
        for (auto &kv : accounts_) ids.push_back(kv.first);
        return ids;
    }

private:
    std::shared_ptr<Account> getAccount(AccountId id) {
        std::shared_lock<std::shared_mutex> lock(map_m_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return {};
        return it->second;
    }

    std::shared_ptr<const Account> getAccountConst(AccountId id) const {
        std::shared_lock<std::shared_mutex> lock(map_m_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return {};
        return it->second;
    }

    mutable std::shared_mutex map_m_;
    std::unordered_map<AccountId, std::shared_ptr<Account>> accounts_;
};

struct TransactionStats {
    std::atomic<long long> deposits{0};
    std::atomic<long long> withdrawals{0};
    std::atomic<long long> transfers{0};
    std::atomic<long long> rejected{0};
};

int main() {
    Bank bank;

    const int num_accounts = 100;
    const long long initial_per_account = 1000000; // $10,000.00 in cents
    for (int i = 1; i <= num_accounts; ++i) bank.addAccount(i, initial_per_account);

    const int num_threads = std::max(2u, std::thread::hardware_concurrency());
    const int ops_per_thread = 200000;

    auto ids = bank.accountIds();
    const long long initial_total = bank.totalBalanceCents();

    TransactionStats stats;

    auto worker = [&](int tid) {
        std::mt19937_64 rng(static_cast<unsigned long long>(
            std::chrono::high_resolution_clock::now().time_since_epoch().count()) ^ (0x9e3779b97f4a7c15ULL * (tid + 1)));

        std::uniform_int_distribution<int> op_dist(0, 99);
        std::uniform_int_distribution<int> idx_dist(0, static_cast<int>(ids.size()) - 1);
        std::uniform_int_distribution<int> amt_dist(1, 5000); // up to $50.00

        for (int i = 0; i < ops_per_thread; ++i) {
            int op = op_dist(rng);
            AccountId a = ids[idx_dist(rng)];
            long long amt = amt_dist(rng);

            if (op < 10) { // deposit 10%
                if (bank.deposit(a, amt)) stats.deposits.fetch_add(1, std::memory_order_relaxed);
                else stats.rejected.fetch_add(1, std::memory_order_relaxed);
            } else if (op < 20) { // withdraw 10%
                if (bank.withdraw(a, amt)) stats.withdrawals.fetch_add(1, std::memory_order_relaxed);
                else stats.rejected.fetch_add(1, std::memory_order_relaxed);
            } else { // transfer 80%
                AccountId b = ids[idx_dist(rng)];
                if (bank.transfer(a, b, amt)) stats.transfers.fetch_add(1, std::memory_order_relaxed);
                else stats.rejected.fetch_add(1, std::memory_order_relaxed);
            }

            if ((i & 0x3FFFF) == 0) {
                long long bal = 0;
                bank.getBalance(a, bal);
            }
        }
    };

    std::vector<std::thread> threads;
    threads.reserve(num_threads);
    for (int t = 0; t < num_threads; ++t) threads.emplace_back(worker, t);
    for (auto &th : threads) th.join();

    const long long final_total = bank.totalBalanceCents();

    std::cout << "Threads: " << num_threads << "\n";
    std::cout << "Operations per thread: " << ops_per_thread << "\n";
    std::cout << "Deposits: " << stats.deposits.load() << "\n";
    std::cout << "Withdrawals: " << stats.withdrawals.load() << "\n";
    std::cout << "Transfers: " << stats.transfers.load() << "\n";
    std::cout << "Rejected: " << stats.rejected.load() << "\n";
    std::cout << "Initial total (cents): " << initial_total << "\n";
    std::cout << "Final total   (cents): " << final_total << "\n";

    long long delta = final_total - initial_total;
    std::cout << "Delta (cents): " << delta << "\n";

    return 0;
}