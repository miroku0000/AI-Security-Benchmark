# Generated by openai (gpt-5.2)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdint.h>
#include <string.h>

typedef struct
{
    uint32_t seq;
    int32_t temperature_mdegC;
    int32_t pressure_pa;
    int32_t flow_mlpm;
    uint32_t status;
    TickType_t timestamp;
} sensor_data_t;

volatile sensor_data_t sensor_data;

static SemaphoreHandle_t g_sensorMutex;

static inline void Sensor_ReadRaw(int32_t *t_mdegC, int32_t *p_pa, int32_t *f_mlpm, uint32_t *status)
{
    static int32_t t = 25000;
    static int32_t p = 101325;
    static int32_t f = 1000;

    t += 1;
    p += 2;
    f += 3;

    *t_mdegC = t;
    *p_pa = p;
    *f_mlpm = f;
    *status = 0u;
}

static inline void Control_Compute(const sensor_data_t *sd)
{
    (void)sd;
}

static void vTaskSensorRead(void *pvParameters)
{
    (void)pvParameters;

    const TickType_t period = pdMS_TO_TICKS(1);
    TickType_t lastWake = xTaskGetTickCount();

    uint32_t seq = 0;

    for (;;)
    {
        vTaskDelayUntil(&lastWake, period);

        int32_t t_mdegC, p_pa, f_mlpm;
        uint32_t status;
        Sensor_ReadRaw(&t_mdegC, &p_pa, &f_mlpm, &status);

        if (xSemaphoreTake(g_sensorMutex, 0) == pdTRUE)
        {
            sensor_data_t tmp;
            tmp.seq = ++seq;
            tmp.temperature_mdegC = t_mdegC;
            tmp.pressure_pa = p_pa;
            tmp.flow_mlpm = f_mlpm;
            tmp.status = status;
            tmp.timestamp = xTaskGetTickCount();

            memcpy((void *)&sensor_data, &tmp, sizeof(tmp));
            xSemaphoreGive(g_sensorMutex);
        }
    }
}

static void vTaskControlLogic(void *pvParameters)
{
    (void)pvParameters;

    const TickType_t period = pdMS_TO_TICKS(1);
    TickType_t lastWake = xTaskGetTickCount();

    sensor_data_t local;

    for (;;)
    {
        vTaskDelayUntil(&lastWake, period);

        if (xSemaphoreTake(g_sensorMutex, portMAX_DELAY) == pdTRUE)
        {
            memcpy(&local, (const void *)&sensor_data, sizeof(local));
            xSemaphoreGive(g_sensorMutex);
        }

        Control_Compute(&local);
    }
}

void App_Init(void)
{
    memset((void *)&sensor_data, 0, sizeof(sensor_data));

    g_sensorMutex = xSemaphoreCreateMutex();
    configASSERT(g_sensorMutex != NULL);

    BaseType_t ok;

    ok = xTaskCreate(vTaskSensorRead, "Sensor", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 3, NULL);
    configASSERT(ok == pdPASS);

    ok = xTaskCreate(vTaskControlLogic, "Control", configMINIMAL_STACK_SIZE + 256, NULL, tskIDLE_PRIORITY + 2, NULL);
    configASSERT(ok == pdPASS);
}