# Generated by openai (gpt-5.2)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <errno.h>
#include <signal.h>

#if defined(_WIN32)
  #define WIN32_LEAN_AND_MEAN
  #include <winsock2.h>
  #include <ws2tcpip.h>
  #pragma comment(lib, "Ws2_32.lib")
  typedef SOCKET sock_t;
  #define close_sock closesocket
  #define likely(x)   (x)
  #define unlikely(x) (x)
#else
  #include <unistd.h>
  #include <fcntl.h>
  #include <sys/types.h>
  #include <sys/socket.h>
  #include <netinet/in.h>
  #include <arpa/inet.h>
  typedef int sock_t;
  #define close_sock close
  #define likely(x)   __builtin_expect(!!(x), 1)
  #define unlikely(x) __builtin_expect(!!(x), 0)
#endif

#ifndef REQ_BUF_SIZE
#define REQ_BUF_SIZE (16u * 1024u)
#endif

#ifndef MAX_HEADER_BYTES
#define MAX_HEADER_BYTES (64u * 1024u)
#endif

#ifndef LISTEN_BACKLOG
#define LISTEN_BACKLOG 128
#endif

#ifndef SERVER_PORT
#define SERVER_PORT 8080
#endif

static volatile sig_atomic_t g_running = 1;

static void on_sigint(int sig) {
  (void)sig;
  g_running = 0;
}

static int set_reuseaddr(sock_t s) {
  int on = 1;
  return setsockopt(s, SOL_SOCKET, SO_REUSEADDR, (const char*)&on, (socklen_t)sizeof(on));
}

static int set_nodelay(sock_t s) {
#if defined(TCP_NODELAY)
  int on = 1;
  return setsockopt(s, IPPROTO_TCP, TCP_NODELAY, (const char*)&on, (socklen_t)sizeof(on));
#else
  (void)s;
  return 0;
#endif
}

static int set_nonblocking(sock_t s) {
#if defined(_WIN32)
  u_long mode = 1;
  return ioctlsocket(s, FIONBIO, &mode);
#else
  int flags = fcntl(s, F_GETFL, 0);
  if (flags < 0) return -1;
  return fcntl(s, F_SETFL, flags | O_NONBLOCK);
#endif
}

static int set_blocking(sock_t s) {
#if defined(_WIN32)
  u_long mode = 0;
  return ioctlsocket(s, FIONBIO, &mode);
#else
  int flags = fcntl(s, F_GETFL, 0);
  if (flags < 0) return -1;
  return fcntl(s, F_SETFL, flags & ~O_NONBLOCK);
#endif
}

static int send_all(sock_t s, const char *buf, size_t len) {
  size_t off = 0;
  while (off < len) {
#if defined(_WIN32)
    int n = send(s, buf + off, (int)(len - off), 0);
#else
    ssize_t n = send(s, buf + off, len - off, 0);
#endif
    if (n <= 0) return -1;
    off += (size_t)n;
  }
  return 0;
}

static int find_double_crlf(const char *buf, size_t n) {
  if (n < 4) return -1;
  for (size_t i = 3; i < n; i++) {
    if (buf[i-3] == '\r' && buf[i-2] == '\n' && buf[i-1] == '\r' && buf[i] == '\n') return (int)(i - 3);
  }
  return -1;
}

static int parse_content_length(const char *hdr, size_t hdr_len, size_t *out_len) {
  *out_len = 0;
  const char *p = hdr;
  const char *end = hdr + hdr_len;

  while (p < end) {
    const char *line_end = memchr(p, '\n', (size_t)(end - p));
    if (!line_end) line_end = end;
    const char *line = p;
    size_t line_len = (size_t)(line_end - p);

    while (line_len && (line[line_len - 1] == '\r' || line[line_len - 1] == '\n')) line_len--;

    if (line_len >= 15) {
      const char *cl = "Content-Length:";
      size_t cl_len = 15;
      int match = 1;
      for (size_t i = 0; i < cl_len; i++) {
        char a = line[i];
        char b = cl[i];
        if (a >= 'A' && a <= 'Z') a = (char)(a - 'A' + 'a');
        if (b >= 'A' && b <= 'Z') b = (char)(b - 'A' + 'a');
        if (a != b) { match = 0; break; }
      }
      if (match) {
        const char *q = line + cl_len;
        while (q < line + line_len && (*q == ' ' || *q == '\t')) q++;
        uint64_t v = 0;
        int any = 0;
        while (q < line + line_len && *q >= '0' && *q <= '9') {
          any = 1;
          v = v * 10u + (uint64_t)(*q - '0');
          if (v > (uint64_t)SIZE_MAX) return -1;
          q++;
        }
        if (!any) return -1;
        *out_len = (size_t)v;
        return 0;
      }
    }

    p = line_end + 1;
  }
  return 1;
}

static int parse_request_line(const char *hdr, size_t hdr_len,
                              const char **out_method, size_t *out_mlen,
                              const char **out_path, size_t *out_plen) {
  const char *end = hdr + hdr_len;
  const char *line_end = memchr(hdr, '\n', hdr_len);
  if (!line_end) return -1;
  const char *line = hdr;
  size_t line_len = (size_t)(line_end - line);
  while (line_len && (line[line_len - 1] == '\r' || line[line_len - 1] == '\n')) line_len--;
  if (line_len < 14) return -1;

  const char *sp1 = memchr(line, ' ', line_len);
  if (!sp1) return -1;
  const char *sp2 = memchr(sp1 + 1, ' ', (size_t)((line + line_len) - (sp1 + 1)));
  if (!sp2) return -1;

  *out_method = line;
  *out_mlen = (size_t)(sp1 - line);
  *out_path = sp1 + 1;
  *out_plen = (size_t)(sp2 - (sp1 + 1));

  (void)end;
  return 0;
}

static int process_http_request(sock_t client, char *buf, size_t cap) {
  size_t n = 0;

  int hdr_pos;
  while ((hdr_pos = find_double_crlf(buf, n)) < 0) {
    if (unlikely(n == cap)) return -1;
#if defined(_WIN32)
    int r = recv(client, buf + n, (int)(cap - n), 0);
#else
    ssize_t r = recv(client, buf + n, cap - n, 0);
#endif
    if (r <= 0) return -1;
    n += (size_t)r;
    if (unlikely(n > MAX_HEADER_BYTES)) return -1;
  }

  size_t hdr_start = 0;
  size_t hdr_end = (size_t)hdr_pos + 4;
  size_t hdr_len = hdr_end - hdr_start;

  const char *method = NULL, *path = NULL;
  size_t mlen = 0, plen = 0;
  if (parse_request_line(buf + hdr_start, hdr_len, &method, &mlen, &path, &plen) != 0) {
    static const char resp[] =
      "HTTP/1.1 400 Bad Request\r\n"
      "Connection: close\r\n"
      "Content-Length: 0\r\n\r\n";
    send_all(client, resp, sizeof(resp) - 1);
    return -1;
  }

  size_t cl = 0;
  int clr = parse_content_length(buf + hdr_start, hdr_len, &cl);
  if (clr < 0) {
    static const char resp[] =
      "HTTP/1.1 400 Bad Request\r\n"
      "Connection: close\r\n"
      "Content-Length: 0\r\n\r\n";
    send_all(client, resp, sizeof(resp) - 1);
    return -1;
  }
  if (clr == 1) cl = 0;

  size_t already = n - hdr_end;
  if (cl > 0) {
    size_t total_needed = hdr_end + cl;
    if (total_needed > cap) {
      static const char resp[] =
        "HTTP/1.1 413 Payload Too Large\r\n"
        "Connection: close\r\n"
        "Content-Length: 0\r\n\r\n";
      send_all(client, resp, sizeof(resp) - 1);
      return -1;
    }
    while (already < cl) {
#if defined(_WIN32)
      int r = recv(client, buf + n, (int)(cap - n), 0);
#else
      ssize_t r = recv(client, buf + n, cap - n, 0);
#endif
      if (r <= 0) return -1;
      n += (size_t)r;
      already = n - hdr_end;
    }
  }

  (void)method; (void)mlen; (void)path; (void)plen;

  static const char body[] = "OK\n";
  char header[256];
  int hlen = snprintf(header, sizeof(header),
                      "HTTP/1.1 200 OK\r\n"
                      "Content-Type: text/plain\r\n"
                      "Content-Length: %u\r\n"
                      "Connection: keep-alive\r\n\r\n",
                      (unsigned)(sizeof(body) - 1));
  if (hlen <= 0 || (size_t)hlen >= sizeof(header)) return -1;

  if (send_all(client, header, (size_t)hlen) != 0) return -1;
  if (send_all(client, body, sizeof(body) - 1) != 0) return -1;

  return 0;
}

int main(void) {
#if defined(_WIN32)
  WSADATA wsa;
  if (WSAStartup(MAKEWORD(2,2), &wsa) != 0) return 1;
#endif

#if !defined(_WIN32)
  struct sigaction sa;
  memset(&sa, 0, sizeof(sa));
  sa.sa_handler = on_sigint;
  sigaction(SIGINT, &sa, NULL);
  sigaction(SIGTERM, &sa, NULL);
#else
  signal(SIGINT, on_sigint);
  signal(SIGTERM, on_sigint);
#endif

  sock_t ls = (sock_t)socket(AF_INET, SOCK_STREAM, 0);
#if defined(_WIN32)
  if (ls == INVALID_SOCKET) return 1;
#else
  if (ls < 0) return 1;
#endif

  set_reuseaddr(ls);

  struct sockaddr_in addr;
  memset(&addr, 0, sizeof(addr));
  addr.sin_family = AF_INET;
  addr.sin_addr.s_addr = htonl(INADDR_ANY);
  addr.sin_port = htons((uint16_t)SERVER_PORT);

  if (bind(ls, (struct sockaddr*)&addr, (socklen_t)sizeof(addr)) != 0) {
    close_sock(ls);
#if defined(_WIN32)
    WSACleanup();
#endif
    return 1;
  }

  if (listen(ls, LISTEN_BACKLOG) != 0) {
    close_sock(ls);
#if defined(_WIN32)
    WSACleanup();
#endif
    return 1;
  }

  for (;;) {
    if (!g_running) break;

    struct sockaddr_in caddr;
    socklen_t clen = (socklen_t)sizeof(caddr);
    sock_t cs = (sock_t)accept(ls, (struct sockaddr*)&caddr, &clen);
#if defined(_WIN32)
    if (cs == INVALID_SOCKET) {
      int e = WSAGetLastError();
      if (e == WSAEINTR) continue;
      continue;
    }
#else
    if (cs < 0) {
      if (errno == EINTR) continue;
      continue;
    }
#endif
    set_nodelay(cs);

    char *req_buf = (char*)malloc(REQ_BUF_SIZE);
    if (!req_buf) {
      close_sock(cs);
      continue;
    }

    for (;;) {
      if (!g_running) break;
      int r = process_http_request(cs, req_buf, REQ_BUF_SIZE);
      if (r != 0) break;
    }

    free(req_buf);
    close_sock(cs);
  }

  close_sock(ls);
#if defined(_WIN32)
  WSACleanup();
#endif
  return 0;
}