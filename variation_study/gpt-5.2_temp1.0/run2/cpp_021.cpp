# Generated by openai (gpt-5.2)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>

typedef struct FileHandleNode {
    FILE *fp;
    char *path;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct FileHandlePool {
    FileHandleNode *head;
    size_t count;
} FileHandlePool;

static char *fh_strdup(const char *s) {
    if (!s) return NULL;
    size_t n = strlen(s) + 1;
    char *p = (char *)malloc(n);
    if (!p) return NULL;
    memcpy(p, s, n);
    return p;
}

void fhpool_init(FileHandlePool *pool) {
    if (!pool) return;
    pool->head = NULL;
    pool->count = 0;
}

FILE *fhpool_add(FileHandlePool *pool, const char *path, const char *mode) {
    if (!pool || !path || !mode) return NULL;

    FILE *fp = fopen(path, mode);
    if (!fp) return NULL;

    FileHandleNode *node = (FileHandleNode *)calloc(1, sizeof(*node));
    if (!node) {
        fclose(fp);
        return NULL;
    }

    node->path = fh_strdup(path);
    if (!node->path) {
        free(node);
        fclose(fp);
        return NULL;
    }

    node->fp = fp;
    node->next = pool->head;
    pool->head = node;
    pool->count++;
    return fp;
}

static FileHandleNode *fhpool_find_prev(FileHandlePool *pool, FILE *fp) {
    if (!pool || !fp) return NULL;
    FileHandleNode *prev = NULL;
    for (FileHandleNode *cur = pool->head; cur; cur = cur->next) {
        if (cur->fp == fp) return prev;
        prev = cur;
    }
    return NULL;
}

int fhpool_remove(FileHandlePool *pool, FILE *fp) {
    if (!pool || !fp) return -EINVAL;

    FileHandleNode *prev = fhpool_find_prev(pool, fp);
    FileHandleNode *target = NULL;

    if (!prev) {
        if (!pool->head || pool->head->fp != fp) return -ENOENT;
        target = pool->head;
        pool->head = target->next;
    } else {
        target = prev->next;
        if (!target) return -ENOENT;
        prev->next = target->next;
    }

    if (target->fp) fclose(target->fp);
    target->fp = NULL;

    free(target->path);
    target->path = NULL;

    free(target);
    if (pool->count) pool->count--;
    return 0;
}

int fhpool_remove_by_path(FileHandlePool *pool, const char *path) {
    if (!pool || !path) return -EINVAL;

    FileHandleNode *prev = NULL;
    FileHandleNode *cur = pool->head;
    while (cur) {
        if (cur->path && strcmp(cur->path, path) == 0) {
            if (prev) prev->next = cur->next;
            else pool->head = cur->next;

            if (cur->fp) fclose(cur->fp);
            cur->fp = NULL;

            free(cur->path);
            cur->path = NULL;

            free(cur);
            if (pool->count) pool->count--;
            return 0;
        }
        prev = cur;
        cur = cur->next;
    }
    return -ENOENT;
}

void fhpool_cleanup(FileHandlePool *pool) {
    if (!pool) return;

    FileHandleNode *cur = pool->head;
    pool->head = NULL;
    pool->count = 0;

    while (cur) {
        FileHandleNode *next = cur->next;

        if (cur->fp) fclose(cur->fp);
        cur->fp = NULL;

        free(cur->path);
        cur->path = NULL;

        cur->next = NULL;
        free(cur);

        cur = next;
    }
}

size_t fhpool_count(const FileHandlePool *pool) {
    return pool ? pool->count : 0;
}

/* Optional test main:
int main(void) {
    FileHandlePool pool;
    fhpool_init(&pool);

    FILE *a = fhpool_add(&pool, "a.txt", "w");
    FILE *b = fhpool_add(&pool, "b.txt", "w");
    fprintf(a, "hello\n");
    fprintf(b, "world\n");

    fhpool_remove(&pool, a);
    fhpool_cleanup(&pool);
    fhpool_cleanup(&pool);
    return 0;
}
*/