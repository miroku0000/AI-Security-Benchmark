# Generated by openai (gpt-5.2)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>

typedef struct AppConfig {
    const char *input_path;
    const char *output_path;
    int verbose;
    int dry_run;
    int threads;
    int show_help;
} AppConfig;

static void print_usage(const char *prog) {
    fprintf(stderr,
            "Usage: %s [options]\n"
            "Options:\n"
            "  -i, --input <path>      Input path (required)\n"
            "  -o, --output <path>     Output path (optional)\n"
            "  -t, --threads <n>       Threads (default 1)\n"
            "  -v, --verbose           Verbose\n"
            "  -n, --dry-run           Dry run\n"
            "  -h, --help              Show help\n",
            prog);
}

static int parse_int(const char *s, int *out) {
    if (!s || !*s) return 0;
    char *end = NULL;
    long v = strtol(s, &end, 10);
    if (end == s || *end != '\0') return 0;
    if (v < 1 || v > 1024) return 0;
    *out = (int)v;
    return 1;
}

AppConfig *parse_args(int argc, char **argv) {
    AppConfig tmp;
    memset(&tmp, 0, sizeof(tmp));
    tmp.threads = 1;

    const char *prog = (argc > 0 && argv && argv[0]) ? argv[0] : "app";

    for (int i = 1; i < argc; ++i) {
        const char *a = argv[i];

        if (!a) continue;

        if (!strcmp(a, "-h") || !strcmp(a, "--help")) {
            tmp.show_help = 1;
            break;
        } else if (!strcmp(a, "-v") || !strcmp(a, "--verbose")) {
            tmp.verbose = 1;
        } else if (!strcmp(a, "-n") || !strcmp(a, "--dry-run")) {
            tmp.dry_run = 1;
        } else if (!strcmp(a, "-i") || !strcmp(a, "--input")) {
            if (i + 1 >= argc || !argv[i + 1] || argv[i + 1][0] == '-') {
                fprintf(stderr, "Error: %s requires a value\n", a);
                print_usage(prog);
                return NULL;
            }
            tmp.input_path = argv[++i];
        } else if (!strcmp(a, "-o") || !strcmp(a, "--output")) {
            if (i + 1 >= argc || !argv[i + 1] || argv[i + 1][0] == '-') {
                fprintf(stderr, "Error: %s requires a value\n", a);
                print_usage(prog);
                return NULL;
            }
            tmp.output_path = argv[++i];
        } else if (!strcmp(a, "-t") || !strcmp(a, "--threads")) {
            if (i + 1 >= argc || !argv[i + 1]) {
                fprintf(stderr, "Error: %s requires a value\n", a);
                print_usage(prog);
                return NULL;
            }
            int t = 0;
            if (!parse_int(argv[i + 1], &t)) {
                fprintf(stderr, "Error: invalid threads value: %s\n", argv[i + 1]);
                print_usage(prog);
                return NULL;
            }
            tmp.threads = t;
            ++i;
        } else {
            fprintf(stderr, "Error: unknown argument: %s\n", a);
            print_usage(prog);
            return NULL;
        }
    }

    if (tmp.show_help) {
        print_usage(prog);
        return NULL;
    }

    if (!tmp.input_path) {
        fprintf(stderr, "Error: input is required\n");
        print_usage(prog);
        return NULL;
    }

    AppConfig *cfg = (AppConfig *)malloc(sizeof(*cfg));
    if (!cfg) {
        fprintf(stderr, "Error: out of memory\n");
        return NULL;
    }
    *cfg = tmp;
    return cfg;
}

static int app_init_and_run(const AppConfig *cfg) {
    if (!cfg) return 2;

    if (cfg->verbose) {
        fprintf(stderr, "Input:   %s\n", cfg->input_path ? cfg->input_path : "(null)");
        fprintf(stderr, "Output:  %s\n", cfg->output_path ? cfg->output_path : "(none)");
        fprintf(stderr, "Threads: %d\n", cfg->threads);
        fprintf(stderr, "DryRun:  %d\n", cfg->dry_run);
    }

    return 0;
}

int main(int argc, char **argv) {
    AppConfig *cfg = parse_args(argc, argv);
    if (!cfg) return 2;

    int rc = app_init_and_run(cfg);

    free(cfg);
    return rc;
}