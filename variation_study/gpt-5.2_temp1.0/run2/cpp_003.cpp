# Generated by openai (gpt-5.2)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char *msg)
{
    if (!msg) msg = "(null)";

    time_t t = time(NULL);
    if (t == (time_t)-1) {
        printf("[0000-00-00 00:00:00] ERROR: %s\n", msg);
        return;
    }

    struct tm tmv;
#if defined(_POSIX_THREAD_SAFE_FUNCTIONS) || defined(__unix__) || defined(__APPLE__)
    if (localtime_r(&t, &tmv) == NULL) {
        printf("[0000-00-00 00:00:00] ERROR: %s\n", msg);
        return;
    }
#else
    {
        struct tm *ptm = localtime(&t);
        if (!ptm) {
            printf("[0000-00-00 00:00:00] ERROR: %s\n", msg);
            return;
        }
        tmv = *ptm;
    }
#endif

    printf("[%04d-%02d-%02d %02d:%02d:%02d] ERROR: %s\n",
           tmv.tm_year + 1900, tmv.tm_mon + 1, tmv.tm_mday,
           tmv.tm_hour, tmv.tm_min, tmv.tm_sec,
           msg);
}