# Generated by openai (gpt-5.2)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>
#include <stdint.h>

#ifndef PACKET_MAX_SIZE
#define PACKET_MAX_SIZE 1500u
#endif

typedef struct
{
    const uint8_t *data;
    uint16_t len;
} RxPacket_t;

static QueueHandle_t g_rxQueue = NULL;

static void ProcessPacket(const uint8_t *buf, uint16_t len);

static void NetworkPacketTask(void *arg)
{
    (void)arg;

    RxPacket_t pkt;

    for (;;)
    {
        if (xQueueReceive(g_rxQueue, &pkt, portMAX_DELAY) == pdTRUE)
        {
            uint8_t localBuf[PACKET_MAX_SIZE];

            uint16_t copyLen = pkt.len;
            if (copyLen > (uint16_t)sizeof(localBuf))
            {
                copyLen = (uint16_t)sizeof(localBuf);
            }

            if (pkt.data != NULL && copyLen > 0u)
            {
                memcpy(localBuf, pkt.data, copyLen);
                ProcessPacket(localBuf, copyLen);
            }
            else
            {
                ProcessPacket(NULL, 0u);
            }
        }
    }
}

BaseType_t NetworkPacketTask_Init(UBaseType_t queueLength, UBaseType_t taskPriority)
{
    if (queueLength == 0u)
    {
        queueLength = 1u;
    }

    g_rxQueue = xQueueCreate(queueLength, sizeof(RxPacket_t));
    if (g_rxQueue == NULL)
    {
        return pdFAIL;
    }

    return xTaskCreate(NetworkPacketTask,
                       "NetPkt",
                       configMINIMAL_STACK_SIZE,
                       NULL,
                       taskPriority,
                       NULL);
}

BaseType_t NetworkPacketTask_Submit(const uint8_t *data, uint16_t len, TickType_t timeout)
{
    if (g_rxQueue == NULL)
    {
        return pdFAIL;
    }

    RxPacket_t pkt;
    pkt.data = data;
    pkt.len = len;

    return xQueueSend(g_rxQueue, &pkt, timeout);
}

BaseType_t NetworkPacketTask_SubmitFromISR(const uint8_t *data, uint16_t len, BaseType_t *pxHigherPriorityTaskWoken)
{
    if (g_rxQueue == NULL)
    {
        return pdFAIL;
    }

    RxPacket_t pkt;
    pkt.data = data;
    pkt.len = len;

    return xQueueSendFromISR(g_rxQueue, &pkt, pxHigherPriorityTaskWoken);
}

static void ProcessPacket(const uint8_t *buf, uint16_t len)
{
    (void)buf;
    (void)len;
    /* User processing goes here */
}