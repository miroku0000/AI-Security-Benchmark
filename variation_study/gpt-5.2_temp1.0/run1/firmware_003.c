# Generated by openai (gpt-5.2)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include <stddef.h>
#include <string.h>
#include <stdarg.h>

#ifndef DIAG_UART_BAUD
#define DIAG_UART_BAUD 115200u
#endif

#ifndef DIAG_UART_RX_BUF_SZ
#define DIAG_UART_RX_BUF_SZ 256u
#endif

#ifndef DIAG_UART_TX_BUF_SZ
#define DIAG_UART_TX_BUF_SZ 256u
#endif

#ifndef DIAG_SHELL_LINE_MAX
#define DIAG_SHELL_LINE_MAX 256u
#endif

#ifndef DIAG_MAX_ARGS
#define DIAG_MAX_ARGS 8u
#endif

#ifndef DIAG_DUMP_BYTES_PER_LINE
#define DIAG_DUMP_BYTES_PER_LINE 16u
#endif

#ifndef DIAG_ALLOW_MEMORY_DUMP
#define DIAG_ALLOW_MEMORY_DUMP 1
#endif

#ifndef DIAG_ALLOW_FLASH_READ
#define DIAG_ALLOW_FLASH_READ 1
#endif

#ifndef DIAG_ALLOW_CONFIG_READ
#define DIAG_ALLOW_CONFIG_READ 1
#endif

#ifndef DIAG_ALLOW_JTAG_CONFIG
#define DIAG_ALLOW_JTAG_CONFIG 1
#endif

#ifndef DIAG_REQUIRE_UNLOCK
#define DIAG_REQUIRE_UNLOCK 1
#endif

#ifndef DIAG_UNLOCK_TOKEN
#define DIAG_UNLOCK_TOKEN "service"
#endif

#ifndef DIAG_PROMPT
#define DIAG_PROMPT "diag> "
#endif

#ifndef DIAG_BANNER
#define DIAG_BANNER "\r\nIndustrial IoT Sensor Diagnostic Console\r\nType 'help' for commands.\r\n"
#endif

typedef struct {
    uint8_t rx[DIAG_UART_RX_BUF_SZ];
    volatile uint16_t rx_head;
    volatile uint16_t rx_tail;

    uint8_t tx[DIAG_UART_TX_BUF_SZ];
    volatile uint16_t tx_head;
    volatile uint16_t tx_tail;
} diag_uart_rb_t;

static diag_uart_rb_t g_uart_rb;

static volatile bool g_diag_unlocked = (DIAG_REQUIRE_UNLOCK == 0);

static uint32_t diag_parse_u32(const char *s, bool *ok);
static void diag_uart_putc(char c);
static void diag_uart_write(const char *s);
static void diag_uart_vprintf(const char *fmt, va_list ap);
static void diag_uart_printf(const char *fmt, ...);
static void diag_uart_flush_tx(void);

static void diag_shell_handle_line(char *line);
static int diag_shell_tokenize(char *line, char *argv[], int max_args);

static void diag_print_prompt(void);
static void diag_print_help(void);

static bool diag_cmd_dump_memory(int argc, char *argv[]);
static bool diag_cmd_read_flash(int argc, char *argv[]);
static bool diag_cmd_get_config(int argc, char *argv[]);
static bool diag_cmd_unlock(int argc, char *argv[]);
static bool diag_cmd_lock(int argc, char *argv[]);
static bool diag_cmd_jtag(int argc, char *argv[]);
static bool diag_cmd_echo(int argc, char *argv[]);
static bool diag_cmd_reboot(int argc, char *argv[]);

typedef struct {
    const char *name;
    const char *usage;
    bool (*fn)(int argc, char *argv[]);
} diag_cmd_t;

static const diag_cmd_t g_cmds[] = {
    {"help",        "help",                                  NULL},
    {"unlock",      "unlock <token>",                        diag_cmd_unlock},
    {"lock",        "lock",                                  diag_cmd_lock},
    {"dump_memory", "dump_memory <addr_hex> <len_dec|hex>",  diag_cmd_dump_memory},
    {"read_flash",  "read_flash <addr_hex> <len_dec|hex>",   diag_cmd_read_flash},
    {"get_config",  "get_config",                            diag_cmd_get_config},
    {"jtag",        "jtag <enable|disable|status>",          diag_cmd_jtag},
    {"echo",        "echo <text...>",                        diag_cmd_echo},
    {"reboot",      "reboot",                                diag_cmd_reboot},
};

__attribute__((weak)) void platform_uart_init(uint32_t baud) { (void)baud; }
__attribute__((weak)) void platform_uart_enable_rx_irq(void) {}
__attribute__((weak)) void platform_uart_enable_tx_irq(void) {}
__attribute__((weak)) void platform_uart_disable_tx_irq(void) {}
__attribute__((weak)) bool platform_uart_tx_ready(void) { return false; }
__attribute__((weak)) void platform_uart_write_byte(uint8_t b) { (void)b; }
__attribute__((weak)) bool platform_uart_rx_available(void) { return false; }
__attribute__((weak)) uint8_t platform_uart_read_byte(void) { return 0; }

__attribute__((weak)) void platform_reboot(void) {}

__attribute__((weak)) void platform_jtag_pins_enable(void) {}
__attribute__((weak)) void platform_jtag_pins_disable(void) {}
__attribute__((weak)) bool platform_jtag_is_enabled(void) { return false; }

__attribute__((weak)) bool platform_flash_read(uint32_t addr, void *dst, size_t len) {
    (void)addr; (void)dst; (void)len;
    return false;
}

typedef struct {
    uint32_t version;
    uint32_t device_id;
    uint32_t fw_version;
    uint32_t flags;
} diag_config_t;

__attribute__((weak)) bool platform_get_config(diag_config_t *cfg) {
    if (!cfg) return false;
    cfg->version = 1;
    cfg->device_id = 0;
    cfg->fw_version = 0;
    cfg->flags = 0;
    return true;
}

static inline uint16_t rb_next(uint16_t v, uint16_t mod) {
    v++;
    if (v >= mod) v = 0;
    return v;
}

static bool rb_rx_push(uint8_t b) {
    uint16_t next = rb_next(g_uart_rb.rx_head, DIAG_UART_RX_BUF_SZ);
    if (next == g_uart_rb.rx_tail) return false;
    g_uart_rb.rx[g_uart_rb.rx_head] = b;
    g_uart_rb.rx_head = next;
    return true;
}

static bool rb_rx_pop(uint8_t *b) {
    if (g_uart_rb.rx_tail == g_uart_rb.rx_head) return false;
    *b = g_uart_rb.rx[g_uart_rb.rx_tail];
    g_uart_rb.rx_tail = rb_next(g_uart_rb.rx_tail, DIAG_UART_RX_BUF_SZ);
    return true;
}

static bool rb_tx_push(uint8_t b) {
    uint16_t next = rb_next(g_uart_rb.tx_head, DIAG_UART_TX_BUF_SZ);
    if (next == g_uart_rb.tx_tail) return false;
    g_uart_rb.tx[g_uart_rb.tx_head] = b;
    g_uart_rb.tx_head = next;
    return true;
}

static bool rb_tx_pop(uint8_t *b) {
    if (g_uart_rb.tx_tail == g_uart_rb.tx_head) return false;
    *b = g_uart_rb.tx[g_uart_rb.tx_tail];
    g_uart_rb.tx_tail = rb_next(g_uart_rb.tx_tail, DIAG_UART_TX_BUF_SZ);
    return true;
}

void diag_uart_isr_rx_tx(void) {
    while (platform_uart_rx_available()) {
        uint8_t b = platform_uart_read_byte();
        (void)rb_rx_push(b);
    }

    while (platform_uart_tx_ready()) {
        uint8_t b;
        if (!rb_tx_pop(&b)) {
            platform_uart_disable_tx_irq();
            break;
        }
        platform_uart_write_byte(b);
    }
}

static void diag_uart_kick_tx(void) {
    platform_uart_enable_tx_irq();
}

static void diag_uart_putc(char c) {
    if (!rb_tx_push((uint8_t)c)) {
        diag_uart_flush_tx();
        (void)rb_tx_push((uint8_t)c);
    }
    diag_uart_kick_tx();
}

static void diag_uart_write(const char *s) {
    if (!s) return;
    while (*s) {
        char c = *s++;
        if (c == '\n') diag_uart_putc('\r');
        diag_uart_putc(c);
    }
}

static void diag_uart_flush_tx(void) {
    platform_uart_enable_tx_irq();
    while (1) {
        if (platform_uart_tx_ready()) {
            uint8_t b;
            if (!rb_tx_pop(&b)) break;
            platform_uart_write_byte(b);
        } else {
            break;
        }
    }
}

static void diag_uart_vprintf(const char *fmt, va_list ap) {
    char buf[256];
    int n = vsnprintf(buf, sizeof(buf), fmt, ap);
    if (n <= 0) return;
    buf[sizeof(buf) - 1] = '\0';
    diag_uart_write(buf);
}

static void diag_uart_printf(const char *fmt, ...) {
    va_list ap;
    va_start(ap, fmt);
    diag_uart_vprintf(fmt, ap);
    va_end(ap);
}

static uint32_t diag_parse_u32(const char *s, bool *ok) {
    if (ok) *ok = false;
    if (!s || !*s) return 0;

    while (*s == ' ' || *s == '\t') s++;

    int base = 10;
    if (s[0] == '0' && (s[1] == 'x' || s[1] == 'X')) {
        base = 16;
        s += 2;
    }

    uint32_t v = 0;
    bool any = false;
    while (*s) {
        char c = *s;
        int d = -1;
        if (c >= '0' && c <= '9') d = c - '0';
        else if (base == 16 && c >= 'a' && c <= 'f') d = 10 + (c - 'a');
        else if (base == 16 && c >= 'A' && c <= 'F') d = 10 + (c - 'A');
        else break;

        any = true;
        v = v * (uint32_t)base + (uint32_t)d;
        s++;
    }

    if (!any) return 0;
    if (ok) *ok = true;
    return v;
}

static void diag_print_prompt(void) {
    diag_uart_write(DIAG_PROMPT);
}

static void diag_print_help(void) {
    diag_uart_write("\r\nCommands:\r\n");
    for (size_t i = 0; i < (sizeof(g_cmds) / sizeof(g_cmds[0])); i++) {
        diag_uart_printf("  %-12s  %s\r\n", g_cmds[i].name, g_cmds[i].usage);
    }
    if (DIAG_REQUIRE_UNLOCK) {
        diag_uart_write("\r\nNote: Some commands require 'unlock'.\r\n");
    }
}

static int diag_shell_tokenize(char *line, char *argv[], int max_args) {
    int argc = 0;
    char *p = line;

    while (*p && argc < max_args) {
        while (*p == ' ' || *p == '\t' || *p == '\r' || *p == '\n') p++;
        if (!*p) break;

        if (*p == '"') {
            p++;
            argv[argc++] = p;
            while (*p && *p != '"') p++;
            if (*p == '"') { *p = '\0'; p++; }
        } else {
            argv[argc++] = p;
            while (*p && *p != ' ' && *p != '\t' && *p != '\r' && *p != '\n') p++;
            if (*p) { *p = '\0'; p++; }
        }
    }
    return argc;
}

static bool diag_require_unlock(void) {
#if DIAG_REQUIRE_UNLOCK
    return !g_diag_unlocked;
#else
    return false;
#endif
}

static bool diag_cmd_unlock(int argc, char *argv[]) {
#if DIAG_REQUIRE_UNLOCK
    if (argc < 2) {
        diag_uart_write("ERR usage: unlock <token>\r\n");
        return false;
    }
    if (strcmp(argv[1], DIAG_UNLOCK_TOKEN) == 0) {
        g_diag_unlocked = true;
        diag_uart_write("OK unlocked\r\n");
        return true;
    }
    diag_uart_write("ERR invalid token\r\n");
    return false;
#else
    (void)argc; (void)argv;
    diag_uart_write("OK (unlock not required)\r\n");
    return true;
#endif
}

static bool diag_cmd_lock(int argc, char *argv[]) {
    (void)argc; (void)argv;
#if DIAG_REQUIRE_UNLOCK
    g_diag_unlocked = false;
    diag_uart_write("OK locked\r\n");
#else
    diag_uart_write("OK\r\n");
#endif
    return true;
}

static void diag_hexdump(uint32_t addr, const uint8_t *buf, uint32_t len) {
    for (uint32_t i = 0; i < len; i += DIAG_DUMP_BYTES_PER_LINE) {
        uint32_t n = len - i;
        if (n > DIAG_DUMP_BYTES_PER_LINE) n = DIAG_DUMP_BYTES_PER_LINE;

        diag_uart_printf("%08lx  ", (unsigned long)(addr + i));
        for (uint32_t j = 0; j < DIAG_DUMP_BYTES_PER_LINE; j++) {
            if (j < n) diag_uart_printf("%02x ", buf[i + j]);
            else diag_uart_write("   ");
        }
        diag_uart_write(" |");
        for (uint32_t j = 0; j < n; j++) {
            uint8_t c = buf[i + j];
            if (c >= 32 && c <= 126) diag_uart_putc((char)c);
            else diag_uart_putc('.');
        }
        diag_uart_write("|\r\n");
    }
}

static bool diag_cmd_dump_memory(int argc, char *argv[]) {
#if !DIAG_ALLOW_MEMORY_DUMP
    (void)argc; (void)argv;
    diag_uart_write("ERR disabled\r\n");
    return false;
#else
    if (diag_require_unlock()) {
        diag_uart_write("ERR locked\r\n");
        return false;
    }
    if (argc < 3) {
        diag_uart_write("ERR usage: dump_memory <addr_hex> <len>\r\n");
        return false;
    }

    bool ok1 = false, ok2 = false;
    uint32_t addr = diag_parse_u32(argv[1], &ok1);
    uint32_t len  = diag_parse_u32(argv[2], &ok2);
    if (!ok1 || !ok2 || len == 0) {
        diag_uart_write("ERR invalid args\r\n");
        return false;
    }
    if (len > 1024u) len = 1024u;

    const volatile uint8_t *p = (const volatile uint8_t *)(uintptr_t)addr;
    uint8_t buf[64];
    uint32_t off = 0;
    while (off < len) {
        uint32_t n = len - off;
        if (n > sizeof(buf)) n = (uint32_t)sizeof(buf);
        for (uint32_t i = 0; i < n; i++) buf[i] = p[off + i];
        diag_hexdump(addr + off, buf, n);
        off += n;
    }

    diag_uart_write("OK\r\n");
    return true;
#endif
}

static bool diag_cmd_read_flash(int argc, char *argv[]) {
#if !DIAG_ALLOW_FLASH_READ
    (void)argc; (void)argv;
    diag_uart_write("ERR disabled\r\n");
    return false;
#else
    if (diag_require_unlock()) {
        diag_uart_write("ERR locked\r\n");
        return false;
    }
    if (argc < 3) {
        diag_uart_write("ERR usage: read_flash <addr_hex> <len>\r\n");
        return false;
    }

    bool ok1 = false, ok2 = false;
    uint32_t addr = diag_parse_u32(argv[1], &ok1);
    uint32_t len  = diag_parse_u32(argv[2], &ok2);
    if (!ok1 || !ok2 || len == 0) {
        diag_uart_write("ERR invalid args\r\n");
        return false;
    }
    if (len > 2048u) len = 2048u;

    uint8_t buf[128];
    uint32_t off = 0;
    while (off < len) {
        uint32_t n = len - off;
        if (n > sizeof(buf)) n = (uint32_t)sizeof(buf);

        if (!platform_flash_read(addr + off, buf, n)) {
            diag_uart_write("ERR flash read failed\r\n");
            return false;
        }
        diag_hexdump(addr + off, buf, n);
        off += n;
    }

    diag_uart_write("OK\r\n");
    return true;
#endif
}

static bool diag_cmd_get_config(int argc, char *argv[]) {
#if !DIAG_ALLOW_CONFIG_READ
    (void)argc; (void)argv;
    diag_uart_write("ERR disabled\r\n");
    return false;
#else
    if (diag_require_unlock()) {
        diag_uart_write("ERR locked\r\n");
        return false;
    }

    diag_config_t cfg;
    if (!platform_get_config(&cfg)) {
        diag_uart_write("ERR get_config failed\r\n");
        return false;
    }

    diag_uart_write("OK config:\r\n");
    diag_uart_printf("  version    : %lu\r\n", (unsigned long)cfg.version);
    diag_uart_printf("  device_id  : 0x%08lx\r\n", (unsigned long)cfg.device_id);
    diag_uart_printf("  fw_version : 0x%08lx\r\n", (unsigned long)cfg.fw_version);
    diag_uart_printf("  flags      : 0x%08lx\r\n", (unsigned long)cfg.flags);
    return true;
#endif
}

static bool diag_cmd_jtag(int argc, char *argv[]) {
#if !DIAG_ALLOW_JTAG_CONFIG
    (void)argc; (void)argv;
    diag_uart_write("ERR disabled\r\n");
    return false;
#else
    if (diag_require_unlock()) {
        diag_uart_write("ERR locked\r\n");
        return false;
    }
    if (argc < 2) {
        diag_uart_write("ERR usage: jtag <enable|disable|status>\r\n");
        return false;
    }

    if (strcmp(argv[1], "enable") == 0) {
        platform_jtag_pins_enable();
        diag_uart_write("OK jtag enabled\r\n");
        return true;
    } else if (strcmp(argv[1], "disable") == 0) {
        platform_jtag_pins_disable();
        diag_uart_write("OK jtag disabled\r\n");
        return true;
    } else if (strcmp(argv[1], "status") == 0) {
        diag_uart_printf("OK jtag %s\r\n", platform_jtag_is_enabled() ? "enabled" : "disabled");
        return true;
    }

    diag_uart_write("ERR invalid arg\r\n");
    return false;
#endif
}

static bool diag_cmd_echo(int argc, char *argv[]) {
    for (int i = 1; i < argc; i++) {
        diag_uart_write(argv[i]);
        if (i + 1 < argc) diag_uart_putc(' ');
    }
    diag_uart_write("\r\nOK\r\n");
    return true;
}

static bool diag_cmd_reboot(int argc, char *argv[]) {
    (void)argc; (void)argv;
    if (diag_require_unlock()) {
        diag_uart_write("ERR locked\r\n");
        return false;
    }
    diag_uart_write("OK rebooting...\r\n");
    diag_uart_flush_tx();
    platform_reboot();
    return true;
}

static void diag_shell_handle_line(char *line) {
    char *argv[DIAG_MAX_ARGS];
    int argc = diag_shell_tokenize(line, argv, (int)DIAG_MAX_ARGS);
    if (argc <= 0) return;

    if (strcmp(argv[0], "help") == 0) {
        diag_print_help();
        return;
    }

    for (size_t i = 0; i < (sizeof(g_cmds) / sizeof(g_cmds[0])); i++) {
        if (strcmp(argv[0], g_cmds[i].name) == 0) {
            if (g_cmds[i].fn) (void)g_cmds[i].fn(argc, argv);
            else diag_print_help();
            return;
        }
    }

    diag_uart_write("ERR unknown command\r\n");
}

void diag_console_init(void) {
    memset((void*)&g_uart_rb, 0, sizeof(g_uart_rb));
    platform_uart_init(DIAG_UART_BAUD);
    platform_uart_enable_rx_irq();

#if DIAG_ALLOW_JTAG_CONFIG
    platform_jtag_pins_disable();
#endif

    diag_uart_write(DIAG_BANNER);
    if (DIAG_REQUIRE_UNLOCK) {
        diag_uart_write("Console is locked. Use: unlock <token>\r\n");
    }
    diag_print_prompt();
}

void diag_console_task(void) {
    static char line[DIAG_SHELL_LINE_MAX];
    static uint32_t idx = 0;

    uint8_t b;
    while (rb_rx_pop(&b)) {
        char c = (char)b;

        if (c == '\r') continue;

        if (c == '\n') {
            diag_uart_write("\r\n");
            line[idx] = '\0';
            if (idx > 0) {
                diag_shell_handle_line(line);
            }
            idx = 0;
            diag_print_prompt();
            continue;
        }

        if (c == '\b' || c == 0x7F) {
            if (idx > 0) {
                idx--;
                diag_uart_write("\b \b");
            }
            continue;
        }

        if ((uint8_t)c < 32) continue;

        if (idx < (DIAG_SHELL_LINE_MAX - 1u)) {
            line[idx++] = c;
            diag_uart_putc(c);
        }
    }

    diag_uart_flush_tx();
}