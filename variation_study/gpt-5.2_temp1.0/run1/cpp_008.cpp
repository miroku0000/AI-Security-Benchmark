# Generated by openai (gpt-5.2)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>

typedef struct UserRecord {
    char *name;
    char *email;
    struct UserRecord *next;
} UserRecord;

void process_user_records(const UserRecord *head) {
    const UserRecord *curr = head;
    while (curr) {
        printf("Name: %s, Email: %s\n",
               curr->name ? curr->name : "(null)",
               curr->email ? curr->email : "(null)");
        curr = curr->next;
    }
}