# Generated by openai (gpt-5.2)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>

typedef struct FileNode {
    FILE *fp;
    int close_on_cleanup;
    char *path;
    struct FileNode *next;
} FileNode;

typedef struct FilePool {
    FileNode *head;
    size_t count;
} FilePool;

static char *fp_strdup(const char *s) {
    if (!s) return NULL;
    size_t n = strlen(s) + 1;
    char *p = (char *)malloc(n);
    if (!p) return NULL;
    memcpy(p, s, n);
    return p;
}

void filepool_init(FilePool *pool) {
    if (!pool) return;
    pool->head = NULL;
    pool->count = 0;
}

int filepool_add(FilePool *pool, FILE *fp, int close_on_cleanup, const char *path_hint) {
    if (!pool || !fp) {
        errno = EINVAL;
        return -1;
    }

    FileNode *node = (FileNode *)calloc(1, sizeof(*node));
    if (!node) return -1;

    node->fp = fp;
    node->close_on_cleanup = close_on_cleanup ? 1 : 0;
    node->path = fp_strdup(path_hint);

    node->next = pool->head;
    pool->head = node;
    pool->count++;
    return 0;
}

int filepool_remove(FilePool *pool, FILE *fp, int close_now) {
    if (!pool || !fp) {
        errno = EINVAL;
        return -1;
    }

    FileNode *prev = NULL;
    FileNode *cur = pool->head;

    while (cur) {
        if (cur->fp == fp) {
            if (prev) prev->next = cur->next;
            else pool->head = cur->next;

            pool->count--;

            if (close_now && cur->fp) {
                fclose(cur->fp);
            }
            cur->fp = NULL;

            free(cur->path);
            cur->path = NULL;
            free(cur);
            return 0;
        }
        prev = cur;
        cur = cur->next;
    }

    errno = ENOENT;
    return -1;
}

void filepool_cleanup(FilePool *pool) {
    if (!pool) return;

    FileNode *cur = pool->head;
    pool->head = NULL;
    pool->count = 0;

    while (cur) {
        FileNode *next = cur->next;

        if (cur->fp && cur->close_on_cleanup) {
            fclose(cur->fp);
        }
        cur->fp = NULL;

        free(cur->path);
        cur->path = NULL;

        free(cur);
        cur = next;
    }
}

size_t filepool_count(const FilePool *pool) {
    return pool ? pool->count : 0;
}

#ifdef TEST_FILEPOOL
int main(void) {
    FilePool pool;
    filepool_init(&pool);

    FILE *a = tmpfile();
    FILE *b = tmpfile();

    filepool_add(&pool, a, 1, "tmp-a");
    filepool_add(&pool, b, 1, "tmp-b");

    filepool_remove(&pool, a, 1);

    filepool_cleanup(&pool);
    filepool_cleanup(&pool);

    return 0;
}
#endif