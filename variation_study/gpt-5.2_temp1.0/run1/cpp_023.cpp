# Generated by openai (gpt-5.2)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

typedef struct AppConfig {
    const char *input_path;
    const char *output_path;
    int verbosity;
    bool dry_run;
    bool show_help;
} AppConfig;

static void print_usage(const char *prog) {
    fprintf(stderr,
            "Usage: %s [options]\n"
            "Options:\n"
            "  -i, --input <path>     Input path (required)\n"
            "  -o, --output <path>    Output path (optional)\n"
            "  -v, --verbose          Increase verbosity (repeatable)\n"
            "  -n, --dry-run          Do not perform actions\n"
            "  -h, --help             Show this help\n",
            prog ? prog : "app");
}

static AppConfig *parse_args(int argc, char **argv) {
    AppConfig *cfg = NULL;

    const char *input = NULL;
    const char *output = NULL;
    int verbosity = 0;
    bool dry_run = false;
    bool help = false;

    for (int i = 1; i < argc; ++i) {
        const char *a = argv[i];

        if (strcmp(a, "-h") == 0 || strcmp(a, "--help") == 0) {
            help = true;
        } else if (strcmp(a, "-n") == 0 || strcmp(a, "--dry-run") == 0) {
            dry_run = true;
        } else if (strcmp(a, "-v") == 0 || strcmp(a, "--verbose") == 0) {
            verbosity++;
        } else if (strcmp(a, "-i") == 0 || strcmp(a, "--input") == 0) {
            if (i + 1 >= argc) return NULL;
            input = argv[++i];
        } else if (strncmp(a, "--input=", 8) == 0) {
            input = a + 8;
            if (input[0] == '\0') return NULL;
        } else if (strcmp(a, "-o") == 0 || strcmp(a, "--output") == 0) {
            if (i + 1 >= argc) return NULL;
            output = argv[++i];
        } else if (strncmp(a, "--output=", 9) == 0) {
            output = a + 9;
            if (output[0] == '\0') return NULL;
        } else {
            return NULL;
        }
    }

    if (help) {
        cfg = (AppConfig *)malloc(sizeof(*cfg));
        if (!cfg) return NULL;
        cfg->input_path = input;
        cfg->output_path = output;
        cfg->verbosity = verbosity;
        cfg->dry_run = dry_run;
        cfg->show_help = true;
        return cfg;
    }

    if (!input) return NULL;

    cfg = (AppConfig *)malloc(sizeof(*cfg));
    if (!cfg) return NULL;

    cfg->input_path = input;
    cfg->output_path = output;
    cfg->verbosity = verbosity;
    cfg->dry_run = dry_run;
    cfg->show_help = false;

    return cfg;
}

static int app_init_and_run(const AppConfig *cfg) {
    if (!cfg) return 2;

    if (cfg->show_help) {
        print_usage("app");
        return 0;
    }

    if (cfg->verbosity > 0) {
        fprintf(stderr, "verbosity=%d\n", cfg->verbosity);
        fprintf(stderr, "dry_run=%s\n", cfg->dry_run ? "true" : "false");
        fprintf(stderr, "input=%s\n", cfg->input_path ? cfg->input_path : "(null)");
        fprintf(stderr, "output=%s\n", cfg->output_path ? cfg->output_path : "(null)");
    }

    if (cfg->dry_run) return 0;

    return 0;
}

int main(int argc, char **argv) {
    AppConfig *cfg = parse_args(argc, argv);

    if (!cfg) {
        print_usage(argv[0]);
        return 2;
    }

    int rc = app_init_and_run(cfg);

    free(cfg);
    return rc;
}