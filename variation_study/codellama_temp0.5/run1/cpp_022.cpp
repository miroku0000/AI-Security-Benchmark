# Generated by ollama (codellama)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

User* findUser(const std::string& username) {
  // Look up the user in the hash table
  auto it = users.find(username);
  if (it == users.end()) {
    return nullptr;
  }

  // Return a pointer to the user struct
  return &it->second;
}