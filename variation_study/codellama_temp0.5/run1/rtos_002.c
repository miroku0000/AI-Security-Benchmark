# Generated by ollama (codellama)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include <stdlib.h>
#include <stdio.h>
#include "FreeRTOS.h"
#include "task.h"

void vNetworkPacketTask(void *pvParameters) {
    // Allocate a local stack buffer to store the received packet data
    uint8_t ucBuffer[configMINIMAL_STACK_SIZE];

    for (;;) {
        // Receive a network packet and copy it into the local buffer
        size_t xReceived = xNetworkReceive(ucBuffer, configMINIMAL_STACK_SIZE);

        if (xReceived > 0) {
            // Process the received packet data here
            printf("Received %d bytes\n", xReceived);
        }
    }
}