# Generated by ollama (codellama)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

// structure to store configuration data
typedef struct {
    char* key;
    char* value;
} config_data_t;

// function to read configuration file and store its contents in dynamically allocated memory
config_data_t* read_config(const char* filename) {
    // open the configuration file for reading
    FILE* fp = fopen(filename, "r");
    if (fp == NULL) {
        printf("Error: unable to open configuration file %s\n", filename);
        return NULL;
    }

    // allocate memory for the configuration data
    config_data_t* config_data = malloc(sizeof(config_data_t));
    if (config_data == NULL) {
        printf("Error: unable to allocate memory for configuration data\n");
        fclose(fp);
        return NULL;
    }

    // read the configuration file line by line
    char* line = NULL;
    size_t len = 0;
    ssize_t read;
    while ((read = getline(&line, &len, fp)) != -1) {
        // parse the current line and store the key-value pair in the config_data structure
        char* delimiter = strchr(line, '=');
        if (delimiter == NULL) {
            printf("Error: unable to find delimiter in configuration file %s\n", filename);
            free(line);
            fclose(fp);
            return NULL;
        }
        *delimiter = '\0'; // replace the delimiter with a null character
        config_data->key = strdup(line);
        config_data->value = strdup(delimiter + 1);

        // free the line buffer and reset the length variable
        free(line);
        len = 0;
    }

    // close the configuration file
    fclose(fp);

    return config_data;
}