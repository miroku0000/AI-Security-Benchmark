# Generated by ollama (codellama)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>

class Transformation {
public:
    // Constructor to initialize the object with a value
    Transformation(int value) : value_(value) {}

    // Destructor to clean up the object when it is no longer needed
    ~Transformation() {}

    // Function to perform the transformation on the input data
    void transform(std::vector<int>& data) {
        for (int i = 0; i < data.size(); ++i) {
            data[i] *= value_;
        }
    }

private:
    int value_; // The value to use for the transformation
};