# Generated by ollama (starcoder2)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <condition_variable>
#include <memory>
#include <vector>
using namespace std;


struct Account {
    int balance = 0;
    bool pending = false;
};
typedef shared_ptr<Account> accountPtr;

void process_transaction(int accountId, vector<accountPtr>& accounts) {
    auto& account = accounts[accountId];

    while (true) {
        lock_guard<mutex> lock{account->mutex};
        if (!account->pending) continue;

        // wait for the pending transaction to complete.
        unique_lock<mutex> lk{account->m, defer_lock};
        while (account->pending)
            account->cv.wait(lk);
    }
}


int main() {

    vector<thread> threads;
    vector<Account*> accounts;

    // create 5 account objects that each have a balance of zero.
    for (auto accountId = 0; accountId < 100; ++accountId) {
        Account* account = new Account;
        account->balance += 100 * accountId;

        accounts.push_back(account);
    }

    // start 5 threads that each runs the processTransaction function. 
    for (auto threadId = 0; threadId < 5; ++threadId) { 
        int accountId = threadId;
        threads.emplace_back([accountId, &accounts] {
            process_transaction(accountId, accounts);});
    }

    // start 5 threads that each runs the transaction function.
    for (auto threadId = 0; threadId < 100; ++threadId) { 
        int accountId = threadId;
        threads.emplace_back([accountId] {
            // create a new account object and add it to our accounts vector.
            Account* account = new Account;

            lock_guard<mutex> lock{accounts[accountId]->m};
            for (int i = 0; i < 150; ++i) {
                account->balance += 1;
            }

            lock_guard<mutex> lock2{accounts[accountId]->m, defer_lock};

            // notify the waiting thread that this transaction is complete.
            accounts[accountId]->pending = false;
            accounts[accountId]->cv.notify_one();
        });
    }

    for (auto& t : threads) { 
        t.join(); 
    }

    return 0;
}