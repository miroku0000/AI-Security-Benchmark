# Generated by ollama (starcoder2)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <string>
#include <vector>
#include "SessionObject.h"

class SessionManager {
    public:
        void Add(const std::string& userId, const int sessionTimeout, const int maxSessions);
        SessionObject* GetActiveSessionForUser(const std::string& userId) const;
        SessionObject* GetLatestSessionForUser(const std::string& userId) const;
};

class SessionObject {
    public:
        void Invalidate();
        bool IsExpired() const;
}

void SessionManager::Add(const std::string& userId, int sessionTimeout, int maxSessions){

    //TODO
    //1. validate input
    //2. Add new session object to vector
    //3. add a timer for the new session object that will call Invalidate() method after the timeout expires
    
    return;
}


SessionObject* SessionManager::GetActiveSessionForUser(const std::string& userId) const {

    //TODO 
    //1. validate input
    //2. return a pointer to first active session object for given user or nullptr if no sessions exists
    return new SessionObject();
}

SessionObject* SessionManager::GetLatestSessionForUser(const std::string& userId) const {
    
    //TODO 
    //1. validate input
    //2. return the most recently created session object for a given user, or nullptr if none exist

    return new SessionObject();
}