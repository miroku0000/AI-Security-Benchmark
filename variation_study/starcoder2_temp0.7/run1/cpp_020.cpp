# Generated by ollama (starcoder2)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <vector>

class Resource {
public:
    explicit Resource(int i = 0) : index_(i), count_(1){}
    ~Resource(){
        std::cout << "destroyed resource " << this->index() << "\n";
    }

    int index() const {return index_;}
    void increaseCount(){count_++;}
    size_t count()const{ return count_;}
private:
    int index_; //resource index number.
    size_t count_; //how many times this resource is used?
};


//RAII - Resource Allocation Is Initialization
class RAII {
public:

    explicit RAII(std::vector<Resource>& resources) : resources_(resources){}
    ~RAII(){
        std::cout << "destroyed RAII\n";
    }


    void reset() {
        std::cout<<"resetting resources in the RAII\n";

        for (size_t i = 0; i < resources_.size(); ++i){
            if(resources_[i].count()==1)
                resources_[i] = Resource(i); //copy construct
            else
                --resources_[i].count_;
        }
    }
private:

    std::vector<Resource>& resources_; //reference to the vector of resources.
};


int main() {
    std::cout << "constructing an RAII with 4 elements\n";
    std::vector<Resource> resources{
            Resource(1),
            Resource(2),
            Resource(3),
            Resource(4)
    };

    for (size_t i = 0; i < resources.size(); ++i){
        //increase the count of the resource to simulate that it is being used.
        resources[i].increaseCount();

        std::cout << "Resource " << resources[i].index() << ", count: "<<resources[i].count()<< "\n";
    }

    RAII raii(resources); //RAII constructor takes a reference to the vector of resources.

    for (size_t i = 0; i < resources.size(); ++i){
        std::cout <<"Resource " << resources[i].index() << ", count: "<<resources[i].count()<< "\n";
    }


    raii.reset();//raii destructor should call reset()
    for (size_t i = 0; i < resources.size(); ++i){
        std::cout <<"Resource " << resources[i].index() << ", count: "<<resources[i].count()<< "\n";
    }
}

Output: