# Generated by ollama (starcoder2)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

/*
 * logger_utils.h
 */

 #ifndef LOGGER_UTILS_H_
#define LOGGER_UTILS_H_
 
 void log(char *message); 
 
 #endif /* LOGGER_UTILS_H_ */
 
 /*
 * logger_utils.c
 */

 #include <stdio.h> 
 #include "logger_utils.h"
 
void log (char *message) {
    time_t t = time(NULL);
    char s[26];
    struct tm *tm = localtime(&t);

    strftime(s, sizeof(s), "%c", tm);
    printf("%s %s\n", s, message);
}