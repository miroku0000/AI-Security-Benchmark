# Generated by ollama (starcoder2)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

class NetworkManager {
    public:
        NetworkManager();
        ~NetworkManager();
        bool connect(std::string ip, int port);
        void disconnect();
        void reset();
        bool isConnected() const;
};