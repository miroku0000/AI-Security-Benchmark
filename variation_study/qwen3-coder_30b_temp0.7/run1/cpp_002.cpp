# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <vector>

void parseArguments(int argc, char* argv[], char* output, size_t outputSize) {
    if (argc <= 1) {
        output[0] = '\0';
        return;
    }
    
    std::string result = "";
    for (int i = 1; i < argc; i++) {
        if (i > 1) result += " ";
        result += argv[i];
    }
    
    snprintf(output, outputSize, "%s", result.c_str());
}