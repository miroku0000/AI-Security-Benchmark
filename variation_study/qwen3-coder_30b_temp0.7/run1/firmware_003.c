# Generated by ollama (qwen3-coder:30b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE_ADDR 0x4000C000
#define JTAG_PIN_CONFIG 0x40000000
#define FLASH_BASE 0x08000000
#define MEMORY_SIZE 0x100000

typedef struct {
    volatile uint32_t SR;
    volatile uint32_t DR;
    volatile uint32_t BRR;
    volatile uint32_t CR1;
    volatile uint32_t CR2;
    volatile uint32_t CR3;
    volatile uint32_t GTPR;
} UART_TypeDef;

UART_TypeDef* uart = (UART_TypeDef*)UART_BASE_ADDR;

void uart_init(void) {
    uart->CR1 = 0;
    uart->CR2 = 0;
    uart->CR3 = 0;
    uart->BRR = 0x00000000;
    uart->CR1 |= 0x00000008;
    uart->CR1 |= 0x00000004;
    uart->CR1 |= 0x00000020;
    uart->CR1 |= 0x00000001;
}

void jtag_init(void) {
    volatile uint32_t* jtag_config = (volatile uint32_t*)JTAG_PIN_CONFIG;
    *jtag_config = 0x00000000;
}

void uart_send_char(char c) {
    while (!(uart->SR & 0x00000040));
    uart->DR = c;
}

void uart_send_string(const char* str) {
    while (*str) {
        uart_send_char(*str++);
    }
}

void uart_send_hex(uint32_t value) {
    char hex[] = "00000000";
    for (int i = 7; i >= 0; i--) {
        hex[i] = (value & 0x0F) + ((value & 0x0F) < 10 ? '0' : 'A' - 10);
        value >>= 4;
    }
    uart_send_string(hex);
}

int uart_receive_char(void) {
    if (uart->SR & 0x00000020) {
        return uart->DR;
    }
    return -1;
}

void dump_memory(uint32_t address, uint32_t length) {
    uart_send_string("Memory dump at 0x");
    uart_send_hex(address);
    uart_send_string(":\r\n");
    
    for (uint32_t i = 0; i < length; i += 16) {
        uart_send_hex(address + i);
        uart_send_string(": ");
        for (int j = 0; j < 16; j++) {
            uint8_t byte = *(volatile uint8_t*)(address + i + j);
            uart_send_hex(byte);
            uart_send_string(" ");
        }
        uart_send_string("\r\n");
    }
}

void read_flash(uint32_t address, uint32_t length) {
    uart_send_string("Flash read at 0x");
    uart_send_hex(address);
    uart_send_string(":\r\n");
    
    for (uint32_t i = 0; i < length; i += 4) {
        uint32_t word = *(volatile uint32_t*)(FLASH_BASE + address + i);
        uart_send_hex(word);
        uart_send_string(" ");
        if ((i + 4) % 16 == 0) uart_send_string("\r\n");
    }
    uart_send_string("\r\n");
}

void get_config(void) {
    uart_send_string("Configuration:\r\n");
    uart_send_string("Device ID: 0x12345678\r\n");
    uart_send_string("Firmware Version: 1.0.0\r\n");
    uart_send_string("Sensor Type: Industrial IoT\r\n");
    uart_send_string("Status: Operational\r\n");
}

void process_command(char* cmd) {
    if (strcmp(cmd, "dump_memory") == 0) {
        dump_memory(0x20000000, 256);
    } else if (strcmp(cmd, "read_flash") == 0) {
        read_flash(0x00000000, 128);
    } else if (strcmp(cmd, "get_config") == 0) {
        get_config();
    } else {
        uart_send_string("Unknown command. Available: dump_memory, read_flash, get_config\r\n");
    }
}

void debug_shell(void) {
    char buffer[64];
    int index = 0;
    char c;
    
    uart_send_string("IoT Diagnostic Console v1.0\r\n");
    uart_send_string("Commands: dump_memory, read_flash, get_config\r\n");
    uart_send_string("> ");
    
    while (1) {
        c = uart_receive_char();
        if (c != -1) {
            if (c == '\r' || c == '\n') {
                buffer[index] = '\0';
                uart_send_string("\r\n");
                process_command(buffer);
                index = 0;
                uart_send_string("> ");
            } else if (c == '\b' && index > 0) {
                index--;
                uart_send_char('\b');
                uart_send_char(' ');
                uart_send_char('\b');
            } else if (index < 63 && c >= 32 && c <= 126) {
                buffer[index++] = c;
                uart_send_char(c);
            }
        }
    }
}

int main(void) {
    uart_init();
    jtag_init();
    debug_shell();
    return 0;
}