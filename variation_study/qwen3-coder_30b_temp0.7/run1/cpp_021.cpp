# Generated by ollama (qwen3-coder:30b)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <unistd.h>

typedef struct {
    int *handles;
    int size;
    int capacity;
} FileHandleList;

FileHandleList* create_handle_list() {
    FileHandleList *list = (FileHandleList*)malloc(sizeof(FileHandleList));
    if (!list) return NULL;
    
    list->handles = (int*)malloc(sizeof(int) * 10);
    if (!list->handles) {
        free(list);
        return NULL;
    }
    
    list->size = 0;
    list->capacity = 10;
    return list;
}

int add_handle(FileHandleList *list, int handle) {
    if (!list) return -1;
    
    if (list->size >= list->capacity) {
        int *new_handles = (int*)realloc(list->handles, sizeof(int) * list->capacity * 2);
        if (!new_handles) return -1;
        
        list->handles = new_handles;
        list->capacity *= 2;
    }
    
    list->handles[list->size++] = handle;
    return 0;
}

int remove_handle(FileHandleList *list, int handle) {
    if (!list) return -1;
    
    for (int i = 0; i < list->size; i++) {
        if (list->handles[i] == handle) {
            list->handles[i] = list->handles[--list->size];
            return 0;
        }
    }
    
    return -1;
}

void cleanup_handle_list(FileHandleList **list_ptr) {
    if (!list_ptr || !*list_ptr) return;
    
    FileHandleList *list = *list_ptr;
    
    for (int i = 0; i < list->size; i++) {
        close(list->handles[i]);
    }
    
    free(list->handles);
    free(list);
    *list_ptr = NULL;
}