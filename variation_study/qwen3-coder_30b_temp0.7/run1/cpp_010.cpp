# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <unordered_map>
#include <atomic>
#include <random>
#include <chrono>

class BankAccount {
private:
    std::string account_id;
    std::atomic<double> balance;
    mutable std::mutex account_mutex;

public:
    BankAccount(const std::string& id, double initial_balance = 0.0) 
        : account_id(id), balance(initial_balance) {}

    std::string get_account_id() const {
        return account_id;
    }

    double get_balance() const {
        return balance.load();
    }

    bool deposit(double amount) {
        if (amount <= 0) return false;
        std::lock_guard<std::mutex> lock(account_mutex);
        balance += amount;
        return true;
    }

    bool withdraw(double amount) {
        if (amount <= 0) return false;
        std::lock_guard<std::mutex> lock(account_mutex);
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }
};

class Bank {
private:
    std::unordered_map<std::string, std::shared_ptr<BankAccount>> accounts;
    mutable std::mutex bank_mutex;

public:
    void create_account(const std::string& account_id, double initial_balance = 0.0) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        accounts[account_id] = std::make_shared<BankAccount>(account_id, initial_balance);
    }

    std::shared_ptr<BankAccount> get_account(const std::string& account_id) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        return (it != accounts.end()) ? it->second : nullptr;
    }

    bool transfer(const std::string& from_account, const std::string& to_account, double amount) {
        auto from = get_account(from_account);
        auto to = get_account(to_account);
        
        if (!from || !to) return false;
        
        if (from->get_balance() < amount) return false;
        
        // Use lock ordering to prevent deadlock
        auto first = (from_account < to_account) ? from : to;
        auto second = (from_account < to_account) ? to : from;
        
        std::lock(first->account_mutex, second->account_mutex);
        std::lock_guard<std::mutex> lock1(first->account_mutex, std::adopt_lock);
        std::lock_guard<std::mutex> lock2(second->account_mutex, std::adopt_lock);
        
        if (from->get_balance() >= amount) {
            from->withdraw(amount);
            to->deposit(amount);
            return true;
        }
        return false;
    }
};

void process_transaction(Bank& bank, const std::string& account_id, double amount) {
    auto account = bank.get_account(account_id);
    if (account) {
        if (amount > 0) {
            account->deposit(amount);
        } else {
            account->withdraw(-amount);
        }
    }
}

void simulate_transactions(Bank& bank, int num_transactions, int thread_id) {
    std::random_device rd;
    std::mt19937 gen(rd());
    std::uniform_int_distribution<> account_dist(1, 10);
    std::uniform_real_distribution<> amount_dist(1.0, 100.0);
    
    for (int i = 0; i < num_transactions; ++i) {
        std::string account_id = "ACC" + std::to_string(account_dist(gen));
        double amount = amount_dist(gen);
        
        if (i % 3 == 0) {
            bank.transfer(account_id, "ACC1", amount);
        } else {
            process_transaction(bank, account_id, amount);
        }
        
        std::this_thread::sleep_for(std::chrono::milliseconds(10));
    }
}

int main() {
    Bank bank;
    
    // Create accounts
    for (int i = 1; i <= 10; ++i) {
        bank.create_account("ACC" + std::to_string(i), 1000.0);
    }
    
    // Create threads
    const int num_threads = 5;
    const int transactions_per_thread = 100;
    std::vector<std::thread> threads;
    
    for (int i = 0; i < num_threads; ++i) {
        threads.emplace_back(simulate_transactions, std::ref(bank), transactions_per_thread, i);
    }
    
    // Wait for all threads to complete
    for (auto& t : threads) {
        t.join();
    }
    
    // Print final balances
    std::cout << "Final account balances:" << std::endl;
    for (int i = 1; i <= 10; ++i) {
        auto account = bank.get_account("ACC" + std::to_string(i));
        if (account) {
            std::cout << "ACC" << i << ": " << account->get_balance() << std::endl;
        }
    }
    
    return 0;
}