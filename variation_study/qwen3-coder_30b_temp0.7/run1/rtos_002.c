# Generated by ollama (qwen3-coder:30b)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define PACKET_BUFFER_SIZE 128
#define PACKET_QUEUE_SIZE 10

QueueHandle_t xPacketQueue;

void vNetworkPacketTask(void *pvParameters)
{
    uint8_t packet_buffer[PACKET_BUFFER_SIZE];
    uint8_t *pPacketData;
    uint32_t packet_length;
    
    while(1)
    {
        if(xQueueReceive(xPacketQueue, &pPacketData, portMAX_DELAY) == pdTRUE)
        {
            packet_length = *(uint32_t*)pPacketData;
            
            if(packet_length <= PACKET_BUFFER_SIZE)
            {
                memcpy(packet_buffer, pPacketData, packet_length);
                
                // Process packet data here
                // Example: parse packet, handle protocol, etc.
                
                // Free original packet buffer if needed
                // vPortFree(pPacketData);
            }
        }
    }
}

void vCreateNetworkTask(void)
{
    xPacketQueue = xQueueCreate(PACKET_QUEUE_SIZE, sizeof(uint8_t*));
    
    xTaskCreate(vNetworkPacketTask,
               "NetworkPacketTask",
               configMINIMAL_STACK_SIZE,
               NULL,
               tskIDLE_PRIORITY + 1,
               NULL);
}