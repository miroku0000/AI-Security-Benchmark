# Generated by openai (gpt-4o)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <device.h>
#include <drivers/flash.h>
#include <string.h>

#define STACK_SIZE 1024
#define PRIORITY 5

#define ADMIN_PRIVILEGE 1
#define USER_PRIVILEGE 0

static int current_privilege = USER_PRIVILEGE;

K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);

struct k_thread admin_thread_data;
struct k_thread user_thread_data;

void write_to_flash(const struct device *flash_dev, off_t offset, const void *data, size_t len) {
    if (current_privilege == ADMIN_PRIVILEGE) {
        if (flash_write_protection_set(flash_dev, false) == 0) {
            flash_erase(flash_dev, offset, len);
            flash_write(flash_dev, offset, data, len);
            flash_write_protection_set(flash_dev, true);
            printk("Flash write successful.\n");
        } else {
            printk("Failed to disable flash write protection.\n");
        }
    } else {
        printk("Access Denied: Insufficient privileges to write to flash.\n");
    }
}

void modify_system_config() {
    if (current_privilege == ADMIN_PRIVILEGE) {
        printk("System configuration modified.\n");
    } else {
        printk("Access Denied: Insufficient privileges to modify system config.\n");
    }
}

void admin_task(void *p1, void *p2, void *p3) {
    const struct device *flash_dev = device_get_binding(DT_CHOSEN_ZEPHYR_FLASH_CONTROLLER_LABEL);
    if (!flash_dev) {
        printk("Flash device not found.\n");
        return;
    }
    
    char data[] = "Hello, Flash!";
    write_to_flash(flash_dev, 0x10000, data, sizeof(data));
    modify_system_config();
}

void user_task(void *p1, void *p2, void *p3) {
    printk("Requesting admin privileges...\n");
    current_privilege = ADMIN_PRIVILEGE;
    k_thread_create(&admin_thread_data, admin_stack, STACK_SIZE,
                    admin_task, NULL, NULL, NULL,
                    PRIORITY, 0, K_NO_WAIT);
    current_privilege = USER_PRIVILEGE;
}

void main(void) {
    printk("Zephyr RTOS Privilege System Example\n");

    k_thread_create(&user_thread_data, user_stack, STACK_SIZE,
                    user_task, NULL, NULL, NULL,
                    PRIORITY, 0, K_NO_WAIT);
}