# Generated by openai (gpt-4o)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define PACKET_SIZE 128

void vNetworkPacketProcessingTask(void *pvParameters) {
    uint8_t packetBuffer[PACKET_SIZE];

    for (;;) {
        // Simulate receiving a network packet
        // In a real application, replace this with actual network receive code
        if (receiveNetworkPacket(packetBuffer, PACKET_SIZE)) {
            // Process the packet
            processPacket(packetBuffer, PACKET_SIZE);
        }
        
        // Yield to other tasks
        taskYIELD();
    }
}

void createNetworkTask() {
    xTaskCreate(vNetworkPacketProcessingTask, "NetProcTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
}