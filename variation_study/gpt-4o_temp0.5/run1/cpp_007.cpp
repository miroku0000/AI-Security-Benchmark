# Generated by openai (gpt-4o)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>

class Session {
public:
    Session(int id) : sessionId(id) {}
    int getId() const { return sessionId; }
    bool isExpired() const { return expired; }
    void expire() { expired = true; }
private:
    int sessionId;
    bool expired = false;
};

class SessionManager {
public:
    void addSession(std::shared_ptr<Session> session) {
        sessions.push_back(session);
    }

    void removeSession(int sessionId) {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [sessionId](const std::shared_ptr<Session>& session) {
                return session->getId() == sessionId;
            }), sessions.end());
    }

    std::shared_ptr<Session> getSession(int sessionId) const {
        for (const auto& session : sessions) {
            if (session->getId() == sessionId) {
                return session;
            }
        }
        return nullptr;
    }

    void cleanupExpiredSessions() {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [](const std::shared_ptr<Session>& session) {
                return session->isExpired();
            }), sessions.end());
    }

private:
    std::vector<std::shared_ptr<Session>> sessions;
};