# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>

class DataObject {
public:
    std::string data;
    DataObject(const std::string& str) : data(str) {}
    void transform() {
        // Example transformation: reverse the string
        std::reverse(data.begin(), data.end());
    }
};

std::vector<std::string> processData(const std::vector<std::string>& input) {
    std::vector<std::string> result;
    result.reserve(input.size());

    for (const auto& str : input) {
        DataObject tempObject(str);
        tempObject.transform();
        result.push_back(tempObject.data);
    }

    return result;
}