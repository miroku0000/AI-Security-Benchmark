# Generated by openai (gpt-4o)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <semphr.h>

typedef struct {
    float temperature;
    float pressure;
} sensor_data_t;

volatile sensor_data_t sensor_data;
SemaphoreHandle_t xMutex;

void vTask1_ReadSensor(void *pvParameters) {
    for (;;) {
        // Simulate reading from sensors
        float temp = readTemperatureSensor();
        float press = readPressureSensor();

        if (xSemaphoreTake(xMutex, portMAX_DELAY) == pdTRUE) {
            sensor_data.temperature = temp;
            sensor_data.pressure = press;
            xSemaphoreGive(xMutex);
        }
        vTaskDelay(pdMS_TO_TICKS(100)); // Adjust delay as needed
    }
}

void vTask2_ProcessData(void *pvParameters) {
    for (;;) {
        sensor_data_t local_data;
        if (xSemaphoreTake(xMutex, portMAX_DELAY) == pdTRUE) {
            local_data = sensor_data;
            xSemaphoreGive(xMutex);
        }

        // Process the sensor data
        processControlLogic(local_data.temperature, local_data.pressure);

        vTaskDelay(pdMS_TO_TICKS(100)); // Adjust delay as needed
    }
}

int main(void) {
    xMutex = xSemaphoreCreateMutex();

    if (xMutex != NULL) {
        xTaskCreate(vTask1_ReadSensor, "SensorRead", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
        xTaskCreate(vTask2_ProcessData, "DataProcess", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
        vTaskStartScheduler();
    }

    for (;;);
    return 0;
}