# Generated by openai (gpt-4o)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <mutex>
#include <thread>
#include <chrono>
#include <random>

class Connection {
public:
    Connection(int id) : id(id), connected(false) {}
    bool connect() {
        std::this_thread::sleep_for(std::chrono::milliseconds(100)); // Simulate connection delay
        connected = true;
        std::cout << "Connection " << id << " established.\n";
        return connected;
    }
    void disconnect() {
        connected = false;
        std::cout << "Connection " << id << " closed.\n";
    }
    bool isConnected() const { return connected; }
    int getId() const { return id; }

private:
    int id;
    bool connected;
};

class ConnectionPool {
public:
    ConnectionPool(size_t poolSize) : poolSize(poolSize) {
        for (size_t i = 0; i < poolSize; ++i) {
            connections.push_back(std::make_shared<Connection>(i));
        }
    }

    std::shared_ptr<Connection> getConnection() {
        std::lock_guard<std::mutex> lock(poolMutex);
        for (auto& conn : connections) {
            if (!conn->isConnected()) {
                if (conn->connect()) {
                    return conn;
                }
            }
        }
        return nullptr;
    }

    void releaseConnection(std::shared_ptr<Connection> conn) {
        std::lock_guard<std::mutex> lock(poolMutex);
        if (conn->isConnected()) {
            conn->disconnect();
        }
    }

private:
    size_t poolSize;
    std::vector<std::shared_ptr<Connection>> connections;
    std::mutex poolMutex;
};

class NetworkClient {
public:
    NetworkClient(size_t poolSize) : connectionPool(poolSize) {}

    void performOperation() {
        auto conn = connectionPool.getConnection();
        if (conn) {
            std::cout << "Performing operation on connection " << conn->getId() << "\n";
            std::this_thread::sleep_for(std::chrono::milliseconds(500)); // Simulate operation
            if (operationFailed()) {
                std::cout << "Operation failed on connection " << conn->getId() << ", retrying...\n";
                retryOperation(conn);
            }
            connectionPool.releaseConnection(conn);
        } else {
            std::cout << "No available connections.\n";
        }
    }

private:
    bool operationFailed() {
        std::random_device rd;
        std::mt19937 gen(rd());
        std::uniform_int_distribution<> dis(0, 1);
        return dis(gen) == 0;
    }

    void retryOperation(std::shared_ptr<Connection> conn) {
        if (conn->isConnected()) {
            std::cout << "Retrying operation on connection " << conn->getId() << "\n";
            std::this_thread::sleep_for(std::chrono::milliseconds(500)); // Simulate retry operation
        }
    }

    ConnectionPool connectionPool;
};

int main() {
    NetworkClient client(5);
    client.performOperation();
    client.performOperation();
    client.performOperation();
    return 0;
}