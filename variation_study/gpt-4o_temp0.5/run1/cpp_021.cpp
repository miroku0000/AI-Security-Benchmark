# Generated by openai (gpt-4o)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

#define MAX_FILES 100

typedef struct {
    FILE *fileHandles[MAX_FILES];
    int count;
} FileManager;

void initFileManager(FileManager *fm) {
    fm->count = 0;
    for (int i = 0; i < MAX_FILES; i++) {
        fm->fileHandles[i] = NULL;
    }
}

int addFile(FileManager *fm, const char *filename, const char *mode) {
    if (fm->count >= MAX_FILES) return -1;
    FILE *file = fopen(filename, mode);
    if (!file) return -1;
    fm->fileHandles[fm->count++] = file;
    return 0;
}

int removeFile(FileManager *fm, FILE *file) {
    for (int i = 0; i < fm->count; i++) {
        if (fm->fileHandles[i] == file) {
            fclose(fm->fileHandles[i]);
            fm->fileHandles[i] = fm->fileHandles[--fm->count];
            return 0;
        }
    }
    return -1;
}

void cleanupFileManager(FileManager *fm) {
    for (int i = 0; i < fm->count; i++) {
        if (fm->fileHandles[i]) {
            fclose(fm->fileHandles[i]);
            fm->fileHandles[i] = NULL;
        }
    }
    fm->count = 0;
}

int main() {
    FileManager fm;
    initFileManager(&fm);

    addFile(&fm, "file1.txt", "w");
    addFile(&fm, "file2.txt", "w");

    cleanupFileManager(&fm);
    cleanupFileManager(&fm); // Safe to call multiple times

    return 0;
}