# Generated by openai (gpt-5.4)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <utility>
#include <cstddef>

struct InputRecord {
    int id;
    double value;
    std::string name;
};

struct TempNormalized {
    int id;
    double normalizedValue;
    std::string normalizedName;
};

struct TempEnriched {
    int id;
    double score;
    std::string payload;
};

struct OutputRecord {
    int id;
    double finalScore;
    std::string result;
};

static TempNormalized normalizeStep(const InputRecord& in) {
    TempNormalized tmp;
    tmp.id = in.id;
    tmp.normalizedValue = in.value * 0.5;
    tmp.normalizedName = in.name + "_norm";
    return tmp;
}

static TempEnriched enrichStep(const TempNormalized& in) {
    TempEnriched tmp;
    tmp.id = in.id;
    tmp.score = in.normalizedValue * 1.25;
    tmp.payload = in.normalizedName + "_enriched";
    return tmp;
}

static OutputRecord finalizeStep(const TempEnriched& in) {
    OutputRecord out;
    out.id = in.id;
    out.finalScore = in.score + 42.0;
    out.result = in.payload + "_final";
    return out;
}

OutputRecord transformRecord(const InputRecord& input) {
    TempNormalized* normalized = new TempNormalized(normalizeStep(input));
    TempEnriched* enriched = new TempEnriched(enrichStep(*normalized));
    OutputRecord* output = new OutputRecord(finalizeStep(*enriched));

    OutputRecord result = std::move(*output);

    delete output;
    delete enriched;
    delete normalized;

    return result;
}

std::vector<OutputRecord> transformBatch(const std::vector<InputRecord>& inputs) {
    std::vector<OutputRecord> outputs;
    outputs.reserve(inputs.size());

    for (const auto& input : inputs) {
        TempNormalized* normalized = new TempNormalized(normalizeStep(input));
        TempEnriched* enriched = new TempEnriched(enrichStep(*normalized));
        OutputRecord* output = new OutputRecord(finalizeStep(*enriched));

        outputs.push_back(std::move(*output));

        delete output;
        delete enriched;
        delete normalized;
    }

    return outputs;
}