# Generated by openai (gpt-5.4)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>

#define REQUEST_BUFFER_SIZE 4096
#define RESPONSE_BUFFER_SIZE 4096
#define MAX_METHOD_LEN 8
#define MAX_PATH_LEN 256
#define MAX_VERSION_LEN 16

typedef struct {
    char method[MAX_METHOD_LEN];
    char path[MAX_PATH_LEN];
    char version[MAX_VERSION_LEN];
    char *raw;
    size_t raw_len;
} HttpRequest;

typedef struct {
    char *data;
    size_t len;
    size_t cap;
} Buffer;

static int buffer_init(Buffer *b, size_t cap) {
    b->data = (char *)malloc(cap);
    if (!b->data) return 0;
    b->len = 0;
    b->cap = cap;
    return 1;
}

static void buffer_reset(Buffer *b) {
    b->len = 0;
    if (b->data && b->cap) b->data[0] = '\0';
}

static void buffer_free(Buffer *b) {
    free(b->data);
    b->data = NULL;
    b->len = 0;
    b->cap = 0;
}

static int read_request(Buffer *req_buf) {
    if (!fgets(req_buf->data, (int)req_buf->cap, stdin)) {
        return 0;
    }
    req_buf->len = strlen(req_buf->data);
    return 1;
}

static int parse_request_line(HttpRequest *req, const char *line, size_t len) {
    req->raw = (char *)malloc(len + 1);
    if (!req->raw) return 0;
    memcpy(req->raw, line, len);
    req->raw[len] = '\0';
    req->raw_len = len;

    if (sscanf(req->raw, "%7s %255s %15s", req->method, req->path, req->version) != 3) {
        return 0;
    }
    return 1;
}

static void free_request(HttpRequest *req) {
    free(req->raw);
    req->raw = NULL;
    req->raw_len = 0;
}

static void process_request(const HttpRequest *req, Buffer *resp_buf) {
    int written = snprintf(
        resp_buf->data,
        resp_buf->cap,
        "HTTP/1.1 200 OK\r\n"
        "Content-Type: text/plain\r\n"
        "Connection: keep-alive\r\n"
        "\r\n"
        "Handled %s %s %s\n",
        req->method,
        req->path,
        req->version
    );
    if (written < 0) {
        resp_buf->len = 0;
        return;
    }
    resp_buf->len = (size_t)written < resp_buf->cap ? (size_t)written : resp_buf->cap - 1;
}

static void send_response(const Buffer *resp_buf) {
    fwrite(resp_buf->data, 1, resp_buf->len, stdout);
    fflush(stdout);
}

int main(void) {
    Buffer req_buf;
    Buffer resp_buf;

    if (!buffer_init(&req_buf, REQUEST_BUFFER_SIZE)) {
        return 1;
    }
    if (!buffer_init(&resp_buf, RESPONSE_BUFFER_SIZE)) {
        buffer_free(&req_buf);
        return 1;
    }

    for (;;) {
        HttpRequest req;
        memset(&req, 0, sizeof(req));

        buffer_reset(&req_buf);
        buffer_reset(&resp_buf);

        if (!read_request(&req_buf)) {
            break;
        }

        if (!parse_request_line(&req, req_buf.data, req_buf.len)) {
            const char *bad =
                "HTTP/1.1 400 Bad Request\r\n"
                "Content-Type: text/plain\r\n"
                "Connection: keep-alive\r\n"
                "\r\n"
                "Bad Request\n";
            size_t bad_len = strlen(bad);
            if (bad_len >= resp_buf.cap) bad_len = resp_buf.cap - 1;
            memcpy(resp_buf.data, bad, bad_len);
            resp_buf.data[bad_len] = '\0';
            resp_buf.len = bad_len;
            send_response(&resp_buf);
            free_request(&req);
            continue;
        }

        process_request(&req, &resp_buf);
        send_response(&resp_buf);
        free_request(&req);
    }

    buffer_free(&req_buf);
    buffer_free(&resp_buf);
    return 0;
}