# Generated by openai (gpt-5.4)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/util.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/drivers/flash.h>
#include <string.h>
#include <stdint.h>
#include <stdbool.h>

#define STACK_SIZE 2048
#define USER_PRIORITY 5
#define ADMIN_PRIORITY 4

#define ADMIN_TOKEN 0xA5A55A5Au
#define CONFIG_MAGIC 0x43464731u
#define CONFIG_VERSION 1u

#define ADMIN_QUEUE_LEN 8
#define FLASH_AREA_ID_STORAGE FIXED_PARTITION_ID(storage)

enum admin_op_type {
	ADMIN_OP_NONE = 0,
	ADMIN_OP_WRITE_FLASH,
	ADMIN_OP_SET_CONFIG,
};

struct system_config {
	uint32_t magic;
	uint32_t version;
	uint32_t flags;
	uint32_t mode;
	char name[32];
};

struct admin_request {
	enum admin_op_type op;
	uint32_t token;
	union {
		struct {
			off_t offset;
			uint8_t data[64];
			size_t len;
		} flash;
		struct {
			struct system_config cfg;
		} config;
	} args;
};

K_MSGQ_DEFINE(admin_msgq, sizeof(struct admin_request), ADMIN_QUEUE_LEN, 4);

static struct system_config g_syscfg = {
	.magic = CONFIG_MAGIC,
	.version = CONFIG_VERSION,
	.flags = 0,
	.mode = 0,
	.name = "default",
};

static K_MUTEX_DEFINE(config_lock);

static bool privilege_check(uint32_t token, enum admin_op_type op)
{
	if (token != ADMIN_TOKEN) {
		return false;
	}

	switch (op) {
	case ADMIN_OP_WRITE_FLASH:
	case ADMIN_OP_SET_CONFIG:
		return true;
	default:
		return false;
	}
}

static int admin_write_flash(off_t offset, const uint8_t *data, size_t len)
{
	const struct flash_area *fa;
	int rc;

	if (data == NULL || len == 0) {
		return -EINVAL;
	}

	rc = flash_area_open(FLASH_AREA_ID_STORAGE, &fa);
	if (rc != 0) {
		return rc;
	}

	if ((offset < 0) || ((size_t)offset + len > fa->fa_size)) {
		flash_area_close(fa);
		return -EINVAL;
	}

	rc = flash_area_erase(fa, offset, ROUND_UP(len, flash_area_align(fa)));
	if (rc == 0) {
		rc = flash_area_write(fa, offset, data, len);
	}

	flash_area_close(fa);
	return rc;
}

static int admin_set_config(const struct system_config *cfg)
{
	if (cfg == NULL) {
		return -EINVAL;
	}

	if (cfg->magic != CONFIG_MAGIC || cfg->version != CONFIG_VERSION) {
		return -EPERM;
	}

	k_mutex_lock(&config_lock, K_FOREVER);
	g_syscfg = *cfg;
	g_syscfg.name[sizeof(g_syscfg.name) - 1] = '\0';
	k_mutex_unlock(&config_lock);

	return 0;
}

static int admin_dispatch(const struct admin_request *req)
{
	if (req == NULL) {
		return -EINVAL;
	}

	if (!privilege_check(req->token, req->op)) {
		return -EACCES;
	}

	switch (req->op) {
	case ADMIN_OP_WRITE_FLASH:
		return admin_write_flash(req->args.flash.offset,
					 req->args.flash.data,
					 req->args.flash.len);
	case ADMIN_OP_SET_CONFIG:
		return admin_set_config(&req->args.config.cfg);
	default:
		return -ENOTSUP;
	}
}

static int request_admin_flash_write(uint32_t token, off_t offset, const uint8_t *data, size_t len)
{
	struct admin_request req;

	if (data == NULL || len > sizeof(req.args.flash.data) || len == 0) {
		return -EINVAL;
	}

	memset(&req, 0, sizeof(req));
	req.op = ADMIN_OP_WRITE_FLASH;
	req.token = token;
	req.args.flash.offset = offset;
	req.args.flash.len = len;
	memcpy(req.args.flash.data, data, len);

	return k_msgq_put(&admin_msgq, &req, K_MSEC(100));
}

static int request_admin_set_config(uint32_t token, const struct system_config *cfg)
{
	struct admin_request req;

	if (cfg == NULL) {
		return -EINVAL;
	}

	memset(&req, 0, sizeof(req));
	req.op = ADMIN_OP_SET_CONFIG;
	req.token = token;
	req.args.config.cfg = *cfg;

	return k_msgq_put(&admin_msgq, &req, K_MSEC(100));
}

void admin_task(void)
{
	struct admin_request req;

	while (1) {
		if (k_msgq_get(&admin_msgq, &req, K_FOREVER) == 0) {
			int rc = admin_dispatch(&req);
			printk("admin_task: op=%d rc=%d\n", req.op, rc);
		}
	}
}

void user_task(void)
{
	static const uint8_t sample_data[] = {
		0x10, 0x20, 0x30, 0x40, 0x55, 0x66, 0x77, 0x88
	};
	struct system_config cfg;
	int rc;

	while (1) {
		rc = request_admin_flash_write(0xDEADBEEFu, 0, sample_data, sizeof(sample_data));
		printk("user_task: unauthorized flash request rc=%d\n", rc);

		k_mutex_lock(&config_lock, K_FOREVER);
		cfg = g_syscfg;
		k_mutex_unlock(&config_lock);

		cfg.magic = CONFIG_MAGIC;
		cfg.version = CONFIG_VERSION;
		cfg.flags ^= 0x1u;
		cfg.mode = 1u;
		strncpy(cfg.name, "user-requested-config", sizeof(cfg.name) - 1);
		cfg.name[sizeof(cfg.name) - 1] = '\0';

		rc = request_admin_set_config(ADMIN_TOKEN, &cfg);
		printk("user_task: config request rc=%d\n", rc);

		rc = request_admin_flash_write(ADMIN_TOKEN, 0, sample_data, sizeof(sample_data));
		printk("user_task: flash request rc=%d\n", rc);

		k_sleep(K_SECONDS(5));
	}
}

K_THREAD_DEFINE(admin_tid, STACK_SIZE, admin_task, NULL, NULL, NULL, ADMIN_PRIORITY, 0, 0);
K_THREAD_DEFINE(user_tid, STACK_SIZE, user_task, NULL, NULL, NULL, USER_PRIORITY, 0, 0);

int main(void)
{
	printk("Zephyr privilege system demo start\n");
	return 0;
}