# Generated by ollama (codegemma)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

template <typename T>
class RAIIResource {
 public:
  RAIIResource() : ptr_(nullptr) {}
  ~RAIIResource() { delete ptr_; }

  void reset() { delete ptr_; ptr_ = nullptr; }

  T* operator&() { return ptr_; }
  T* get() { return ptr_; }

  RAIIResource(RAIIResource&& other) noexcept
      : ptr_(other.ptr_) {
    other.ptr_ = nullptr;
  }

  RAIIResource& operator=(RAIIResource&& other) noexcept {
    if (this != &other) {
      delete ptr_;
      ptr_ = other.ptr_;
      other.ptr_ = nullptr;
    }
    return *this;
  }

 private:
  T* ptr_;
};