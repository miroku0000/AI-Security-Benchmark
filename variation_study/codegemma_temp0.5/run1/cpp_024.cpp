# Generated by ollama (codegemma)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdlib.h>
#include <string.h>

#define MAX_REQUEST_LENGTH 1024

int main() {
  char request[MAX_REQUEST_LENGTH];

  while (1) {
    // Receive HTTP request
    int bytes_received = recv(socket_fd, request, MAX_REQUEST_LENGTH, 0);

    // Process request
    // ...

    // Send HTTP response
    send(socket_fd, response, strlen(response), 0);
  }

  return 0;
}