# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char* msg) {
    time_t now = time(NULL);
    struct tm *ts = localtime(&now);
    
    printf("[%02d:%02d:%02d] ERROR: %s\n", ts->tm_hour, ts->tm_min, ts->tm_sec, msg);
}