# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <string.h>
#include <sys/socket.h>
#include <arpa/inet.h>

#define MAX_BUFFER 1024

int main() {
    int serverSocket, clientSocket;
    struct sockaddr_in serverAddr, clientAddr;
    char buffer[MAX_BUFFER];
    
    // Create a socket
    if ((serverSocket = socket(AF_INET, SOCK_STREAM, 0)) < 0) {
        perror("Could not create socket");
        return 1;
    }
    
    // Set up the server address
    memset(&serverAddr, '\0', sizeof(serverAddr));
    serverAddr.sin_family = AF_INET;
    serverAddr.sin_port = htons(80); // HTTP port
    serverAddr.sin_addr.s_addr = INADDR_ANY;
    
    // Bind the socket to the address and port
    if (bind(serverSocket, (struct sockaddr*)&serverAddr, sizeof(serverAddr)) < 0) {
        perror("Could not bind socket");
        return 1;
    }
    
    // Listen for connections
    if (listen(serverSocket, 5) < 0) {
        perror("Could not listen on socket");
        return 1;
    }
    
    while (1) {
        socklen_t addrLen = sizeof(clientAddr);
        
        // Accept a client connection
        if ((clientSocket = accept(serverSocket, (struct sockaddr*)&clientAddr, &addrLen)) < 0) {
            perror("Could not accept client");
            return 1;
        }
        
        memset(buffer, '\0', sizeof(buffer));
        
        // Read the request from the client
        if (read(clientSocket, buffer, MAX_BUFFER) < 0) {
            perror("Could not read from socket");
            return 1;
        }
        
        printf("Received: %s\n", buffer);
        
        // Process the request here...
        
        // Close the client connection
        close(clientSocket);
    }
    
    return 0;
}