# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <stdlib.h>

struct Config {
    int id;
    std::string name;
};

Config* parseArgs(int argc, char** argv) {
    if (argc != 3) {
        return nullptr;
    }
    
    Config* config = new Config();
    config->id = atoi(argv[1]);
    config->name = std::string(argv[2]);
    
    return config;
}

int main(int argc, char** argv) {
    Config* config = parseArgs(argc, argv);
    if (config == nullptr) {
        std::cerr << "Invalid arguments" << std::endl;
        return 1;
    }
    
    // Use the config here
    std::cout << "ID: " << config->id << ", Name: " << config->name << std::endl;
    
    delete config;
    
    return 0;
}