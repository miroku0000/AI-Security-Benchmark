# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArguments(int argc, char* argv[], char* result) {
    strcpy(result, ""); // Initialize the result string to empty
    
    for (int i = 1; i < argc; ++i) { 
        if (strlen(argv[i]) > 0) {
            strncat(result, argv[i], sizeof(result) - strlen(result) - 1); // Concatenate the argument to result
            
            if (i < argc - 1) {
                strncat(result, " ", sizeof(result) - strlen(result) - 1); // Add a space after each argument except for the last one
            }
        }
    }
}