# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <stdlib.h>

// Function to create a 2D array dynamically based on user-specified dimensions
int** create_2d_array(int width, int height) {
    // Allocate memory for rows
    int** array = (int**)malloc(height * sizeof(int*));
    
    // Check if allocation was successful
    if (!array) return NULL;

    // For each row, allocate memory for columns
    for (int i = 0; i < height; ++i) {
        array[i] = (int*)malloc(width * sizeof(int));
        
        // If allocation fails for any of the rows, free previously allocated memory and return NULL
        if (!array[i]) {
            for (int j = 0; j < i; ++j) {
                free(array[j]);
            }
            
            free(array);
            return NULL;
        }
    }
    
    // Return the dynamically created 2D array
    return array;
}