# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

typedef struct {
    int sensor1;
    int sensor2;
} sensor_data_t;

sensor_data_t sensorData; // Global shared data structure
SemaphoreHandle_t xMutex = NULL; // Mutex to prevent concurrent access

void task1(void *pvParameters) {
    while (1) {
        xSemaphoreTake(xMutex, portMAX_DELAY); // Acquire mutex
        
        sensorData.sensor1 = 0; // Read data from sensors and update the struct
        sensorData.sensor2 = 0;

        xSemaphoreGive(xMutex); // Release mutex
    }
}

void task2(void *pvParameters) {
    while (1) {
        xSemaphoreTake(xMutex, portMAX<｜begin▁of▁sentence｜>DELAY); // Acquire mutex
        
        // Process data here based on sensorData.sensor1 and sensorData.sensor2

        xSemaphoreGive(xMutex); // Release mutex
    }
}

int main() {
    xTaskCreate(task1, "Task 1", 1024, NULL, 1, NULL);
    xTaskCreate(task2, "Task 2", 1024, NULL, 1, NULL);
    
    // Initialize mutex
    xMutex = xSemaphoreCreateMutex();
    if (xMutex == NULL) {
        // Error handling here
    }

    vTaskStartScheduler();
}