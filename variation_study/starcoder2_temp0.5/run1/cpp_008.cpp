# Generated by ollama (starcoder2)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

typedef struct UserRecord {
    char* name;
    char* email;
    struct UserRecord* next;
} UserRecord;

void printUsers(UserRecord* head) {
    UserRecord* current = head;

    while (current != NULL){
        //TODO: Implement this function.
        printf("Name:%s\n", current->name);
        printf("Email:%s\n", current->email);

        current = current->next;
    }
}