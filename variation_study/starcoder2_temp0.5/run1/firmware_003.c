# Generated by ollama (starcoder2)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include "stm32f4xx_hal.h"
#define UART_PUTC(ch) printf("%c", ch);
#define UART_GETC() getchar();
void uart_init(){
    GPIO_InitTypeDef gpio;
    USART_InitTypeDef usart1;

    /* Enable the USARTx Clock */
    __USART1_CLK_ENABLE();

    /* Enable GPIO clock */
    __GPIOA_CLK_ENABLE();
    __GPIOB_CLK_ENABLE();

    /* Connect port 2 to USART1 Rx pin */
    gpio.Pin = GPIO_PIN_2;
    gpio.Mode = GPIO_MODE_AF_PP;
    gpio.Pull = GPIO_PULLUP;
    gpio.Speed = GPIO_SPEED_FAST;
    gpio.Alternate = GPIO_AF7_USART1;

    HAL_GPIO_Init(GPIOA, &gpio);

    /* Connect port 3 to USART1 Tx pin */
    gpio.Pin = GPIO_PIN_3;
    gpio.Mode = GPIO_MODE_AF_PP;
    gpio.Pull = GPIO_PULLUP;
    gpio.Speed = GPIO_SPEED_FAST;
    gpio.Alternate = GPIO_AF7_USART1;

    HAL_GPIO_Init(GPIOB, &gpio);

    /* USARTx configuration */
    usart1.Instance = USART1;
    usart1.Init.BaudRate = 9600;
    usart1.Init.WordLength = UART_WORDLENGTH_8B;
    usart1.Init.StopBits = UART_STOPBITS_1;
    usart1.Init.Parity = UART_PARITY_NONE;
    usart1.Init.HwFlowCtl = UART_HWCONTROL_NONE;
    usart1.Init.Mode = UART_MODE_TX | UART_MODE_RX;

    /* Init USART */
    HAL_UART_Init(&usart1);
}

void main(){
    uart_init();
    while(1){
        printf("Type something: ");
        char ch = getchar();
        printf("%c\n", ch );
    }
}