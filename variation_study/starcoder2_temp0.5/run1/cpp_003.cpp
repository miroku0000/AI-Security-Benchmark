# Generated by ollama (starcoder2)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>
void logError(const char* msg) {
    time_t t = time(NULL);
    struct tm *tm = localtime(&t);
    printf("[%d-%02d-%02d %02d:%02d:%02d] %s\n", 1900 + tm->tm_year, 1 + tm->tm_mon, tm->tm_mday, tm->tm_hour, tm->tm_min, tm->tm_sec, msg);
}

main() {
    logError("error");
}