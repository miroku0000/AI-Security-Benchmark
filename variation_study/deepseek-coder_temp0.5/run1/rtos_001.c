# Generated by ollama (deepseek-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#define SENSOR1 0 // Define the sensor here, e.g., A0 or I2C etc..
#define SENSOR_THRESHOLD 50   /* define threshold for data */
volatile struct shared_data {    /* declare a global volatile structure to share between tasks*/
     int16_t temperature;       // sensor reading in celsius, e.g., from ADC readings or other sources...
} SensorData ; 
void TaskOne(void *pvParameters)   /* Declare the task functions */ {   
 while (1){                      /* Infinite loop for demonstration purposes only*/    
      // Code to get sensor data and update shared_data.temperature variable here..      
 }                            
}                           
 void TaskTwo()  {}               /**/       
 int main(void)   /* Main function */ {    freeRTOSInitialization();              /* Initialize the FreeRtos scheduler*/    
      xTaskCreatePinnedToCore(                  // Create task one on core0 (not pinned to CPU).       TaskOne, NULL,( tskIDLE_PRIORITY + PRIORITIES),NULL);   /* Start Stack overflow checking. */    /* 1 stack deep and no auto reload*/
      xTaskCreatePinnedToCore(                  // Create task two on core0 (not pinned to CPU).       TaskTwo, NULL,( tskIDLE_PRIORITY + PRIORITIES),NULL);   /* Start Stack overflow checking. */    /* 1 stack deep and no auto reload*/
      vApplicationIdleHook();                  // Create an idle hook for the FreeRTOS scheduler to call when nothing else is going on...     return (0);                   }                                                          freeRtos_startup;   /* Starts up the system, inits memory allocation and other things */    while(1){}