# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <fstream>
using namespace std;  // For using standard libraries like ifstream, ofstream etc..  
char* readConfigFile(const char *filePath) {   
     fstream fileStream (filePath , ios::in|ios::binary);     
		if(!fileStream.is_open()) throw runtime_error("Failed to open the configuration file");  // Check if opened successfully  
		
        streamsize size = fileStream.tellg();    char* configData= new char[static_cast<streamsize>(size)];    
		if(!configData){throw std::bad_alloc();}     
        
	    fileStream.seekg (0, ios::beg);  // Reset the stream to start from beginning  
        if (!fileStream.read( configData , size)) { throw runtime_error("Failed reading configuration data"); }    char ch;     while(!fileStream.eof()) {ch= fileStream.get();}     
        	
	    return 0 ? (char*)configData : nullptr ; // Return the dynamically allocated memory   if(p) delete p, else throw std::runtime_error("Failed to allocate dynamic memmory");    }     void printConfigFile() { cout << configData; }}