# Generated by ollama (deepseek-coder)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <vector>
#include <fcntl.h>  // For open() & O_RDWR, SEEK_* constants 
#include <unistd.h>  // For close(), lseek() functions  
using namespace std;
    
class FileHandleManager {   
private:     
 vector<int> fileHandlesList ;      
public :        
 void addFileDescriptor( int fd ){       
  if (fd == -1) return; // Invalid descriptor. Do nothing or throw an exception?         
  
  for (unsigned i = 0;i <fileHandlesList .size(); ++i){   
      if ((int) fileHandlesList [i]== fd ){    		// File already exists in the list, do not add it again.       		      			        										} else {break;}  }   // Not found suitable place to insert new descriptor at ,so just append         	   
    if (fileHandlesList .size() ==0) fileHandlesList .push_back(fd); return;     		// First element, add it directly.       		      			        										} else {    	  // Insert the fd in between suitable places  }   }}          	   
    vector<int>::iterator iter =fileHandlesList .begin();          for ( ;iter != fileHandlesList .end() &&( int) *iter <=fd; ++iter);     		// Find a place to insert new descriptor at.       		      			        										} 	 
    fileHandlesList .insert( iter, fd );     }   // Insert the element after suitable places in list         	    }}          	        });}}}}}               {{{ {{{{. ((((.      (( (.               		.              .....                  ...                 ......                        `.