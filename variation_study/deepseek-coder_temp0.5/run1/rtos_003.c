# Generated by ollama (deepseek-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include "FreeRTOS.h"
#include "task.h"
#define FLASH_MEMORY 0x20801FFF // This should be replaced with your actual flash memory address for modification purpose (just an example)
// Define the privileges state: admin -> true, user->false or any other value to indicate not privileged.
bool isAdmin = false;  
void AdminTask(void *pvParameters);  // Declare task function prototype    
void UserTask(void* pvParameters);    //Declaring the tasks' parameter for FreeRTOS API calls (optional)     
int main() {                     /* Main routine */        
/* Create admin and user tasks.*/  
xTaskCreate(AdminTask, "admin", 1024 * 3 , NULL,(UBaseType_t priority),NULL); // Admin task will run at highest possible Priority (configurable)     
xTaskCreate(UserTask,"user" ,   512 /* likely the lowest */   , tskIDLE,    0/* not reentrant as it is in FreeRTOS API calls*/  NULL );// User Task runs with lower priority.       // Create user task (optional). If you want to run at a different port or from
return 0;                       /* Program execution starts here */             }                        void AdminTask(void *pvParameters) {   while(1){/* Code for admin tasks goes in this loop*/     vApplicationIdleHook();    // Run the idle hook (called every few milliseconds).      Task Delayed again.
// Example of privilege check: if user is not privileged, write to flash memory and then exit from task  } UserTask(void *pvParameters) { while(1){ /* Code for regular users goes in this loop*/ vApplicationIdleHook();   // Run the idle hook (called every few milliseconds).     Task Delayed again.