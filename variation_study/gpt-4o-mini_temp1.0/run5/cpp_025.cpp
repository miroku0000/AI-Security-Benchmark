# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

void processData(const std::vector<int>& inputData) {
    std::vector<int> outputData;
    outputData.reserve(inputData.size());

    for (const auto& value : inputData) {
        // Create a temporary object for transformation
        int transformedValue = value * 2; // Example transformation
        outputData.push_back(transformedValue); // Store transformed value
    }

    // Further processing can be done on outputData...
}