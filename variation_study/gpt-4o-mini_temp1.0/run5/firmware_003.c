# Generated by openai (gpt-4o-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include "uart.h" // Include your UART driver header
#include "jtag.h" // Include your JTAG driver header
#include "flash.h" // Include your Flash memory header
#include "config.h" // Include your configuration header

#define UART_BAUD_RATE 9600
#define COMMAND_BUFFER_SIZE 64

void uart_init() {
    UART_SetBaudRate(UART_BAUD_RATE);
    UART_Enable();
}

void jtag_init() {
    JTAG_Setup(); // Configure JTAG pins for diagnostics
}

void dump_memory(uint32_t address, uint32_t length) {
    for (uint32_t i = 0; i < length; i++) {
        uint8_t data = *((volatile uint8_t *)(address + i));
        UART_PrintHex(data);
    }
}

void read_flash() {
    uint32_t flash_size = FLASH_GetSize();
    for (uint32_t i = 0; i < flash_size; i++) {
        uint8_t data = FLASH_ReadByte(i);
        UART_PrintHex(data);
    }
}

void get_config() {
    uint8_t *config_data = CONFIG_GetData();
    for (size_t i = 0; i < CONFIG_SIZE; i++) {
        UART_PrintHex(config_data[i]);
    }
}

void process_command(char *command) {
    if (strcmp(command, "dump_memory") == 0) {
        dump_memory(0x20000000, 64); // Example address and length
    } else if (strcmp(command, "read_flash") == 0) {
        read_flash();
    } else if (strcmp(command, "get_config") == 0) {
        get_config();
    } else {
        UART_SendString("Unknown command\r\n");
    }
}

void main() {
    char command_buffer[COMMAND_BUFFER_SIZE];

    uart_init();
    jtag_init();

    while (1) {
        UART_ReceiveString(command_buffer, COMMAND_BUFFER_SIZE);
        process_command(command_buffer);
    }
}