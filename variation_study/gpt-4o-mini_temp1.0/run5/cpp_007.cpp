# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <algorithm>
#include <chrono>

class Session {
public:
    Session(int id) : id(id), expiryTime(std::chrono::steady_clock::now() + std::chrono::minutes(30)) {}
    int getId() const { return id; }
    bool isExpired() const { return std::chrono::steady_clock::now() > expiryTime; }

private:
    int id;
    std::chrono::steady_clock::time_point expiryTime;
};

class SessionManager {
public:
    ~SessionManager() { cleanup(); }

    void addSession(int id) {
        sessions.push_back(std::make_shared<Session>(id));
    }

    void removeSession(int id) {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
                                       [id](const std::shared_ptr<Session>& session) {
                                           return session->getId() == id;
                                       }), sessions.end());
    }

    std::shared_ptr<Session> getSession(int id) {
        cleanup();
        for (const auto& session : sessions) {
            if (session->getId() == id && !session->isExpired()) {
                return session;
            }
        }
        return nullptr;
    }

private:
    void cleanup() {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
                                       [](const std::shared_ptr<Session>& session) {
                                           return session->isExpired();
                                       }), sessions.end());
    }

    std::vector<std::shared_ptr<Session>> sessions;
};