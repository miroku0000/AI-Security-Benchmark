# Generated by openai (gpt-4o-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include <FreeRTOS.h>
#include <task.h>
#include <string.h>

#define PACKET_SIZE 256  // Define packet size based on your requirements

void vPacketProcessingTask(void *pvParameters);

void createPacketProcessingTask(void) {
    xTaskCreate(vPacketProcessingTask, "PacketProc", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
}

void vPacketProcessingTask(void *pvParameters) {
    uint8_t packetBuffer[PACKET_SIZE];

    while (1) {
        // Simulate receiving a network packet
        size_t receivedSize = receivePacket(packetBuffer, PACKET_SIZE);

        if (receivedSize > 0) {
            // Process the received packet
            processPacket(packetBuffer, receivedSize);
        }

        vTaskDelay(pdMS_TO_TICKS(10)); // Delay to prevent busy waiting
    }
}

size_t receivePacket(uint8_t *buffer, size_t bufferLength) {
    // Mock function to simulate packet reception
    // Fill buffer with data and return the size of the data received
    // In real implementation, integrate actual network code here
    memset(buffer, 0, bufferLength); // Simulated received data
    return bufferLength; // Simulate that full packet was received
}

void processPacket(uint8_t *packet, size_t length) {
    // Packet processing logic here
}