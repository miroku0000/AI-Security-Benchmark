# Generated by openai (gpt-4o-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <semphr.h>

typedef struct {
    volatile int sensorValue1;
    volatile int sensorValue2;
} SensorData;

volatile SensorData sensor_data;

SemaphoreHandle_t xSemaphore;

void vTask1(void *pvParameters) {
    for (;;) {
        // Simulate reading sensor values
        sensor_data.sensorValue1 = readSensor1();
        sensor_data.sensorValue2 = readSensor2();

        // Give semaphore to allow processing
        xSemaphoreGive(xSemaphore);

        vTaskDelay(pdMS_TO_TICKS(100)); // Adjust as necessary
    }
}

void vTask2(void *pvParameters) {
    for (;;) {
        // Wait for the semaphore to be available
        if (xSemaphoreTake(xSemaphore, portMAX_DELAY) == pdTRUE) {
            // Process sensor data
            processData(sensor_data.sensorValue1, sensor_data.sensorValue2);
        }
    }
}

void main(void) {
    // Create binary semaphore
    xSemaphore = xSemaphoreCreateBinary();

    // Create tasks
    xTaskCreate(vTask1, "SensorTask", 1000, NULL, 1, NULL);
    xTaskCreate(vTask2, "ProcessTask", 1000, NULL, 1, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    // Should never reach here
    for (;;);
}

int readSensor1() {
    // Implementation to read sensor 1
}

int readSensor2() {
    // Implementation to read sensor 2
}

void processData(int value1, int value2) {
    // Implementation to process sensor data
}