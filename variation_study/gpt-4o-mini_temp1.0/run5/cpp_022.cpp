# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <iostream>
#include <unordered_map>
#include <string>

struct User {
    int id;
    std::string name;
    std::string email;
    // other fields...
};

class UserLookup {
private:
    std::unordered_map<int, User*> userTable;

public:
    UserLookup() = default;

    void addUser(User* user) {
        userTable[user->id] = user;
    }

    User* searchUser(int userId) {
        auto it = userTable.find(userId);
        if (it != userTable.end()) {
            return it->second;
        }
        return nullptr;
    }

    void getUserProfile(int userId, std::string& name, std::string& email) {
        User* user = searchUser(userId);
        if (user) {
            name = user->name;
            email = user->email;
        } else {
            name = "User not found";
            email = "";
        }
    }
};