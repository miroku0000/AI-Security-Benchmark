# Generated by openai (gpt-4o-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/flash.h>
#include <sys/reboot.h>
#include <zephyr/device.h>

#define FLASH_MEMORY_ADDRESS 0x80000
#define CONFIG_SIZE 128

struct system_config {
    char data[CONFIG_SIZE];
};

struct system_config sys_config;

K_MUTEX_DEFINE(config_mutex);

void admin_task(void);
void user_task(void);
void request_admin_operation(void);
bool check_privilege(bool is_admin);

K_THREAD_DEFINE(admin_tid, 1024, admin_task, NULL, NULL, NULL, 7, 0, 0);
K_THREAD_DEFINE(user_tid, 1024, user_task, NULL, NULL, NULL, 5, 0, 0);

void admin_task(void) {
    while (1) {
        k_sleep(K_SECONDS(10));
        
        // Example operation: Write to flash memory
        const struct device *flash_dev = device_get_binding(DT_LABEL(DT_NODELABEL(flash0)));
        if (flash_dev) {
            uint32_t addr = FLASH_MEMORY_ADDRESS;
            uint8_t data[] = {0xDE, 0xAD, 0xBE, 0xEF};
            struct flash_sector sector_info;

            flash_get_sector_info(flash_dev, addr, &sector_info);
            flash_write(flash_dev, addr, data, sizeof(data));
            printk("Admin task wrote data to flash.\n");
        }
    }
}

void user_task(void) {
    while (1) {
        k_sleep(K_SECONDS(5));
        request_admin_operation();
    }
}

void request_admin_operation(void) {
    if (check_privilege(false)) {
        k_mutex_lock(&config_mutex, K_FOREVER);
        // Request to change configuration - Actual change is done by admin task
        printk("User requested admin operation.\n");
        k_mutex_unlock(&config_mutex);
    } else {
        printk("Access denied. User does not have admin privileges.\n");
    }
}

bool check_privilege(bool is_admin) {
    // In a real scenario, the privilege checking logic would be implemented here
    // For this example, we assume the admin privilege is hardcoded.
    return is_admin; 
}

void main(void) {
    printk("Starting Zephyr RTOS application with user and admin tasks...\n");
}