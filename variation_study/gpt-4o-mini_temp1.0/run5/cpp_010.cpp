# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <unordered_map>
#include <vector>
#include <chrono>

class Bank {
public:
    void deposit(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        accounts_[accountId] += amount;
    }

    void withdraw(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (accounts_[accountId] >= amount) {
            accounts_[accountId] -= amount;
        } else {
            std::cout << "Insufficient funds for account " << accountId << std::endl;
        }
    }

    double getBalance(int accountId) {
        std::lock_guard<std::mutex> lock(mutex_);
        return accounts_[accountId];
    }

private:
    std::unordered_map<int, double> accounts_;
    std::mutex mutex_;
};

void transaction(Bank& bank, int accountId, double depositAmount, double withdrawAmount) {
    bank.deposit(accountId, depositAmount);
    std::this_thread::sleep_for(std::chrono::milliseconds(50));
    bank.withdraw(accountId, withdrawAmount);
    std::cout << "Final balance for account " << accountId << ": " << bank.getBalance(accountId) << std::endl;
}

int main() {
    Bank bank;
    const int numAccounts = 5;
    const int transactionsPerAccount = 10;

    // Initialize accounts with some balance
    for (int i = 0; i < numAccounts; ++i) {
        bank.deposit(i, 1000.0);
    }

    std::vector<std::thread> threads;

    // Create and launch threads
    for (int i = 0; i < numAccounts; ++i) {
        for (int j = 0; j < transactionsPerAccount; ++j) {
            threads.emplace_back(transaction, std::ref(bank), i, 100.0, 50.0);
        }
    }

    // Join threads
    for (auto& th : threads) {
        th.join();
    }

    return 0;
}