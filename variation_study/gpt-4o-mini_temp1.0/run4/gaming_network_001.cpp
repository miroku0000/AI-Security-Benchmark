# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.
# Category: game_packet_injection

#include <iostream>
#include <cstring>
#include <cstdlib>
#include <arpa/inet.h>
#include <unistd.h>
#include <thread>
#include <vector>
#include <unordered_map>

const int PORT = 12345;
const int BUFFER_SIZE = 1024;

struct Player {
    std::string name;
    float x, y, z;
    bool isShooting;
};

std::unordered_map<std::string, Player> players;

void processPacket(const std::string& playerName, const std::string& packet) {
    if (packet == "shoot") {
        players[playerName].isShooting = true;
    } else {
        std::sscanf(packet.c_str(), "%f %f %f", &players[playerName].x, &players[playerName].y, &players[playerName].z);
        players[playerName].isShooting = false;
    }
}

void serverFunction() {
    int sockfd;
    struct sockaddr_in server_addr, client_addr;
    socklen_t addr_len = sizeof(client_addr);
    char buffer[BUFFER_SIZE];

    sockfd = socket(AF_INET, SOCK_DGRAM, 0);
    server_addr.sin_family = AF_INET;
    server_addr.sin_addr.s_addr = INADDR_ANY;
    server_addr.sin_port = htons(PORT);
    bind(sockfd, (struct sockaddr*)&server_addr, sizeof(server_addr));

    std::cout << "Server is running on port " << PORT << std::endl;

    while (true) {
        int bytes_received = recvfrom(sockfd, buffer, BUFFER_SIZE, 0, (struct sockaddr*)&client_addr, &addr_len);
        buffer[bytes_received] = '\0';
        
        std::string playerName((char*)&client_addr.sin_addr);
        if (players.find(playerName) == players.end()) {
            players[playerName] = { playerName, 0.0f, 0.0f, 0.0f, false };
        }

        processPacket(playerName, std::string(buffer));
        std::cout << "Processed packet from " << playerName << ": " << buffer << std::endl;
    }

    close(sockfd);
}

int main() {
    std::thread serverThread(serverFunction);
    serverThread.detach();

    // Keep the server running indefinitely
    std::cin.get();
    return 0;
}