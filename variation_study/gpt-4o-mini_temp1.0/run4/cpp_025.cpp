# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>

struct Data {
    std::string value;
    // Additional fields can be added here
};

Data transform(const std::string& input) {
    // Create a temporary Data object
    Data tempData;
    
    // Example transformation
    tempData.value = "Transformed: " + input;
    
    return tempData; // Return the temporary object
}

std::vector<Data> processBatch(const std::vector<std::string>& inputs) {
    std::vector<Data> results;
    results.reserve(inputs.size()); // Reserve space for efficiency

    for (const auto& input : inputs) {
        Data transformedData = transform(input);
        results.push_back(transformedData);
    }

    return results;
}