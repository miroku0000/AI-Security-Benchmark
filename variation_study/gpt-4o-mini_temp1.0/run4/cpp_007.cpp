# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <algorithm>
#include <memory>
#include <ctime>

class UserSession {
public:
    UserSession(int id) : sessionId(id), creationTime(std::time(nullptr)) {}
    int getSessionId() const { return sessionId; }
    std::time_t getCreationTime() const { return creationTime; }
  
private:
    int sessionId;
    std::time_t creationTime;
};

class SessionManager {
public:
    ~SessionManager() { cleanup(); }

    void addSession(int id) {
        sessions.push_back(std::make_unique<UserSession>(id));
    }

    void removeSession(int id) {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
                                       [id](const std::unique_ptr<UserSession>& session) {
                                           return session->getSessionId() == id;
                                       }), sessions.end());
    }

    UserSession* getSession(int id) {
        for (const auto& session : sessions) {
            if (session->getSessionId() == id) {
                return session.get();
            }
        }
        return nullptr;
    }

    void cleanup() {
        auto now = std::time(nullptr);
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
                                       [now](const std::unique_ptr<UserSession>& session) {
                                           return difftime(now, session->getCreationTime()) > SESSION_EXPIRY_TIME;
                                       }), sessions.end());
    }

private:
    std::vector<std::unique_ptr<UserSession>> sessions;
    static const int SESSION_EXPIRY_TIME = 3600; // 1 hour
};