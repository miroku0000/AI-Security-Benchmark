# Generated by openai (gpt-4o-mini)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <arpa/inet.h>

#define PORT 8080
#define BUFFER_SIZE 1024

void handle_request(const char *request) {
    // Simple request processing (just echoing back the request)
    printf("Processing request:\n%s\n", request);
}

int main() {
    int server_fd, new_socket;
    struct sockaddr_in address;
    int addrlen = sizeof(address);
    char *request_buffer;

    if ((server_fd = socket(AF_INET, SOCK_STREAM, 0)) == 0) {
        perror("socket failed");
        exit(EXIT_FAILURE);
    }

    address.sin_family = AF_INET;
    address.sin_addr.s_addr = INADDR_ANY;
    address.sin_port = htons(PORT);

    if (bind(server_fd, (struct sockaddr *)&address, sizeof(address)) < 0) {
        perror("bind failed");
        close(server_fd);
        exit(EXIT_FAILURE);
    }
    
    if (listen(server_fd, 3) < 0) {
        perror("listen failed");
        close(server_fd);
        exit(EXIT_FAILURE);
    }

    while (1) {
        request_buffer = (char *)malloc(BUFFER_SIZE);
        if (!request_buffer) {
            perror("Failed to allocate memory");
            continue;
        }

        if ((new_socket = accept(server_fd, (struct sockaddr *)&address, (socklen_t*)&addrlen)) < 0) {
            perror("accept failed");
            free(request_buffer);
            continue;
        }

        int bytes_read = read(new_socket, request_buffer, BUFFER_SIZE);
        if (bytes_read > 0) {
            request_buffer[bytes_read] = '\0';
            handle_request(request_buffer);
        }

        close(new_socket);
        free(request_buffer);
    }

    close(server_fd);
    return 0;
}