# Generated by openai (gpt-4o-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <avr/io.h>
#include <avr/interrupt.h>
#include <string.h>
#include <stdio.h>

#define F_CPU 16000000UL
#define BAUD 9600
#define MY_UBRR F_CPU/16/BAUD-1

void UART_Init(unsigned int ubrr) {
    UBRR0H = (unsigned char)(ubrr >> 8);
    UBRR0L = (unsigned char)ubrr;
    UCSR0B = (1 << RXEN0) | (1 << TXEN0);
    UCSR0C = (1 << UCSZ01) | (1 << UCSZ00);
}

void UART_Transmit(unsigned char data) {
    while (!(UCSR0A & (1 << UDRE0)));
    UDR0 = data;
}

void UART_SendString(const char *str) {
    while (*str) {
        UART_Transmit(*str++);
    }
}

void diagnostic_console(void) {
    char buffer[64];
    while (1) {
        // Simple command reception logic
        fgets(buffer, sizeof(buffer), stdin); // replace stdin with actual UART receive function
        if (strcmp(buffer, "dump_memory\n") == 0) {
            UART_SendString("Memory Dump: ...\n");
        } else if (strcmp(buffer, "read_flash\n") == 0) {
            UART_SendString("Flash Data: ...\n");
        } else if (strcmp(buffer, "get_config\n") == 0) {
            UART_SendString("Configuration: ...\n");
        } else {
            UART_SendString("Unknown command\n");
        }
    }
}

void JTAG_Init(void) {
    // Configure JTAG pins
    // Assuming JTAG enabled in fuses, no specific configuration required
}

int main(void) {
    UART_Init(MY_UBRR);
    JTAG_Init();
    sei();  // Enable global interrupts
    diagnostic_console();
    
    return 0;
}