# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <unordered_map>
#include <vector>
#include <chrono>

class BankAccount {
public:
    BankAccount(int id, double balance) : account_id(id), balance(balance) {}

    int getID() const { return account_id; }

    double getBalance() {
        std::lock_guard<std::mutex> lock(balance_mutex);
        return balance;
    }

    void deposit(double amount) {
        std::lock_guard<std::mutex> lock(balance_mutex);
        balance += amount;
    }

    void withdraw(double amount) {
        std::lock_guard<std::mutex> lock(balance_mutex);
        balance -= amount;
    }

private:
    int account_id;
    double balance;
    mutable std::mutex balance_mutex;
};

class Bank {
public:
    void createAccount(int id, double initial_balance) {
        std::lock_guard<std::mutex> lock(accounts_mutex);
        accounts[id] = BankAccount(id, initial_balance);
    }

    void deposit(int id, double amount) {
        std::lock_guard<std::mutex> lock(accounts_mutex);
        if (accounts.find(id) != accounts.end()) {
            accounts[id].deposit(amount);
        }
    }

    void withdraw(int id, double amount) {
        std::lock_guard<std::mutex> lock(accounts_mutex);
        if (accounts.find(id) != accounts.end()) {
            accounts[id].withdraw(amount);
        }
    }

    void printBalance(int id) {
        std::lock_guard<std::mutex> lock(accounts_mutex);
        if (accounts.find(id) != accounts.end()) {
            std::cout << "Account " << id << " Balance: " << accounts[id].getBalance() << std::endl;
        }
    }

private:
    std::unordered_map<int, BankAccount> accounts;
    std::mutex accounts_mutex;
};

void processTransactions(Bank& bank, int account_id, double deposit_amount, double withdraw_amount) {
    bank.deposit(account_id, deposit_amount);
    std::this_thread::sleep_for(std::chrono::milliseconds(100));
    bank.withdraw(account_id, withdraw_amount);
}

int main() {
    Bank bank;
    bank.createAccount(1, 1000.0);
    bank.createAccount(2, 1500.0);

    std::vector<std::thread> threads;
    for (int i = 0; i < 5; ++i) {
        threads.emplace_back(processTransactions, std::ref(bank), 1, 100.0, 50.0);
        threads.emplace_back(processTransactions, std::ref(bank), 2, 200.0, 75.0);
    }

    for (auto& t : threads) {
        t.join();
    }

    bank.printBalance(1);
    bank.printBalance(2);

    return 0;
}