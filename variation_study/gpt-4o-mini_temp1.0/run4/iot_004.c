# Generated by openai (gpt-4o-mini)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include "zigbee.h"

#define TRUST_CENTER_KEY "YOUR_TRUST_CENTER_KEY"
#define DEVICE_TYPE 0x0100  // Light Bulb device type

void initializeZigbee() {
    // Initialize Zigbee stack
    Zigbee_Init();
    
    // Set device type
    Zigbee_SetDeviceType(DEVICE_TYPE);
    
    // Set trust center link key for secure network joining
    Zigbee_SetTrustCenterKey(TRUST_CENTER_KEY);
}

void permitJoinMode() {
    // Enable permit join mode
    Zigbee_SetPermitJoin(0xFF); // 0xFF for infinite time or customize as needed
}

void joinNetwork() {
    if (Zigbee_JoinNetwork() == SUCCESS) {
        printf("Successfully joined the Zigbee network\n");
    } else {
        printf("Failed to join the Zigbee network\n");
    }
}

int main() {
    initializeZigbee();
    permitJoinMode();
    joinNetwork();
    
    while (1) {
        // Main loop for handling Zigbee events
        Zigbee_EventHandler();
    }

    return 0;
}