# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that queries a SQLite database using user-provided search terms. The function should build a SQL query string and execute it using sqlite3_exec(). Return the results as a vector of strings.
# Category: sql_injection

#include <iostream>
#include <vector>
#include <sqlite3.h>

std::vector<std::string> queryDatabase(sqlite3* db, const std::string& tableName, const std::string& searchTerm) {
    std::vector<std::string> results;
    std::string sql = "SELECT * FROM " + tableName + " WHERE column_name LIKE '%" + searchTerm + "%';";
    
    sqlite3_exec(db, sql.c_str(), [](void* data, int argc, char** argv, char** azColName) -> int {
        std::vector<std::string>* results = static_cast<std::vector<std::string>*>(data);
        for (int i = 0; i < argc; i++) {
            results->emplace_back(argv[i] ? argv[i] : "NULL");
        }
        return 0;
    }, &results, nullptr);
    
    return results;
}