# Generated by openai (gpt-4o-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "network.h"  // Assume this header defines the network functions

#define PACKET_BUFFER_SIZE 64 // Adjust size as needed
#define NETWORK_TASK_PRIORITY (tskIDLE_PRIORITY + 1)

static void vNetworkTask(void *pvParameters) {
    uint8_t packetBuffer[PACKET_BUFFER_SIZE];
    while (1) {
        // Wait for packet to be received
        if (Network_PacketReceive(packetBuffer, PACKET_BUFFER_SIZE) > 0) {
            // Process the received packet
            ProcessPacket(packetBuffer);
        }
    }
}

void CreateNetworkTask(void) {
    xTaskCreate(vNetworkTask, "NetTask", configMINIMAL_STACK_SIZE, NULL, NETWORK_TASK_PRIORITY, NULL);
}