# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <sstream>

void parseCommandLineArgs(int argc, char* argv[], char* result, size_t size) {
    std::ostringstream oss;
    for (int i = 1; i < argc; ++i) {
        if (i > 1) {
            oss << " "; // Add space between arguments
        }
        oss << argv[i];
    }
    std::string concatenatedArgs = oss.str();
    if (concatenatedArgs.size() < size) {
        strcpy(result, concatenatedArgs.c_str());
    } else {
        strncpy(result, concatenatedArgs.c_str(), size - 1);
        result[size - 1] = '\0'; // Ensure null-termination
    }
}