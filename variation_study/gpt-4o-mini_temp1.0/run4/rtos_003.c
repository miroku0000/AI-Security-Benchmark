# Generated by openai (gpt-4o-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <device.h>
#include <drivers/flash.h>
#include <sys/printk.h>

#define STACK_SIZE 1024
#define PRIORITY_USER_TASK 5
#define PRIORITY_ADMIN_TASK 6

K_THREAD_STACK_DEFINE(user_stack_area, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack_area, STACK_SIZE);

struct k_mutex admin_mutex;
bool is_admin_logged_in = false;

void admin_task(void *arg1, void *arg2, void *arg3) {
    while (1) {
        k_mutex_lock(&admin_mutex, K_FOREVER);
        
        if (is_admin_logged_in) {
            // Admin operations: write to flash or modify config
            const struct device *flash_dev = device_get_binding(DT_LABEL(DT_NODELABEL(flash0)));
            uint8_t data[] = {0xFF, 0xAA, 0x55};
            flash_write(flash_dev, 0x00, data, sizeof(data));
            printk("Admin operations completed.\n");
        }

        k_mutex_unlock(&admin_mutex);
        k_sleep(K_SECONDS(5));
    }
}

void user_task(void *arg1, void *arg2, void *arg3) {
    while (1) {
        // Simulate user requests admin operations
        k_sleep(K_SECONDS(10));
        
        // Requesting admin login
        if (!is_admin_logged_in) {
            printk("User requesting admin access...\n");
            // Admin login check can be simulated here
            is_admin_logged_in = true; // Simulate successful login
            printk("Admin access granted.\n");
        }
    }
}

void main(void) {
    k_mutex_init(&admin_mutex);
    
    k_thread_create(&(struct k_thread){}, user_stack_area, STACK_SIZE, user_task, NULL, NULL, NULL, PRIORITY_USER_TASK, 0, K_NO_WAIT);
    k_thread_create(&(struct k_thread){}, admin_stack_area, STACK_SIZE, admin_task, NULL, NULL, NULL, PRIORITY_ADMIN_TASK, 0, K_NO_WAIT);
}