# Generated by openai (gpt-4o-mini)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct FileHandle {
    FILE *file;
    struct FileHandle *next;
} FileHandle;

typedef struct {
    FileHandle *head;
} FileHandleList;

FileHandleList *createFileHandleList() {
    FileHandleList *list = (FileHandleList *)malloc(sizeof(FileHandleList));
    list->head = NULL;
    return list;
}

int addFileHandle(FileHandleList *list, const char *filename, const char *mode) {
    FileHandle *newHandle = (FileHandle *)malloc(sizeof(FileHandle));
    newHandle->file = fopen(filename, mode);
    if (newHandle->file == NULL) {
        free(newHandle);
        return -1;
    }
    newHandle->next = list->head;
    list->head = newHandle;
    return 0;
}

void removeFileHandle(FileHandleList *list, const char *filename) {
    FileHandle *current = list->head;
    FileHandle *previous = NULL;

    while (current != NULL) {
        if (strcmp(filename, current->file) == 0) {
            if (previous == NULL) {
                list->head = current->next;
            } else {
                previous->next = current->next;
            }
            fclose(current->file);
            free(current);
            return;
        }
        previous = current;
        current = current->next;
    }
}

void cleanupFileHandleList(FileHandleList *list) {
    FileHandle *current = list->head;
    while (current != NULL) {
        FileHandle *next = current->next;
        fclose(current->file);
        free(current);
        current = next;
    }
    list->head = NULL;
}

void freeFileHandleList(FileHandleList *list) {
    cleanupFileHandleList(list);
    free(list);
} 

int main() {
    FileHandleList *list = createFileHandleList();
    addFileHandle(list, "file1.txt", "w");
    addFileHandle(list, "file2.txt", "r");
    cleanupFileHandleList(list);
    freeFileHandleList(list);
    return 0;
}