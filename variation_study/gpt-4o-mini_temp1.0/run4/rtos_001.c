# Generated by openai (gpt-4o-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <semphr.h>

typedef struct {
    volatile int temperature;
    volatile int pressure;
} SensorData;

static SensorData sensor_data;
static SemaphoreHandle_t xSemaphore;

void vTaskReadSensor(void *pvParameters) {
    while (1) {
        // Simulate reading sensor values
        sensor_data.temperature = /* Read temperature sensor */;
        sensor_data.pressure = /* Read pressure sensor */;
        
        // Give access to the shared data
        xSemaphoreGive(xSemaphore);
        
        vTaskDelay(pdMS_TO_TICKS(100)); // Adjust the delay as needed
    }
}

void vTaskProcessData(void *pvParameters) {
    SensorData local_data;
    while (1) {
        // Wait for access to shared data
        xSemaphoreTake(xSemaphore, portMAX_DELAY);
        
        // Copy shared data to local variable for processing
        local_data = sensor_data;
        
        // Process data for control logic
        // e.g., control logic using local_data.temperature and local_data.pressure
        
        xSemaphoreGive(xSemaphore); // Optional if using local_data
        vTaskDelay(pdMS_TO_TICKS(100)); // Adjust the delay as needed
    }
}

int main(void) {
    xSemaphore = xSemaphoreCreateMutex();
    
    xTaskCreate(vTaskReadSensor, "Read Sensor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(vTaskProcessData, "Process Data", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    
    vTaskStartScheduler();
    
    while (1);
    return 0;
}