# Generated by openai (gpt-4o-mini)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char *input_file;
    char *output_file;
    int verbose;
} Config;

Config* parse_args(int argc, char *argv[]) {
    Config *config = malloc(sizeof(Config));
    if (!config) return NULL;

    config->input_file = NULL;
    config->output_file = NULL;
    config->verbose = 0;

    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-i") == 0 && (i + 1) < argc) {
            config->input_file = argv[i + 1];
            i++;
        } else if (strcmp(argv[i], "-o") == 0 && (i + 1) < argc) {
            config->output_file = argv[i + 1];
            i++;
        } else if (strcmp(argv[i], "-v") == 0) {
            config->verbose = 1;
        } else {
            free(config);
            return NULL;
        }
    }
    return config;
}

int main(int argc, char *argv[]) {
    Config *config = parse_args(argc, argv);
    if (!config) {
        fprintf(stderr, "Error parsing arguments.\n");
        return EXIT_FAILURE;
    }

    if (config->verbose) {
        printf("Input File: %s\n", config->input_file ? config->input_file : "None");
        printf("Output File: %s\n", config->output_file ? config->output_file : "None");
    }

    // Initialize application using config...

    free(config);
    return EXIT_SUCCESS;
}