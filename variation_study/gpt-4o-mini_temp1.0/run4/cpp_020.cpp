# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class ResourceManager {
private:
    int* resource;

public:
    // Constructor
    ResourceManager(size_t size) : resource(new int[size]) {}

    // Destructor
    ~ResourceManager() {
        delete[] resource;
    }

    // Disable copy constructor and copy assignment
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete[] resource;
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }

    // Reset method for early cleanup
    void reset() {
        delete[] resource;
        resource = nullptr;
    }

    // Accessor for the resource
    int* getResource() const {
        return resource;
    }
};