# Generated by openai (gpt-4o-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include <FreeRTOS.h>
#include <task.h>
#include <string.h>

#define NETWORK_PACKET_SIZE 128
#define TASK_STACK_SIZE configMINIMAL_STACK_SIZE

void vPacketProcessingTask(void *pvParameters) {
    uint8_t packetBuffer[NETWORK_PACKET_SIZE];

    while (1) {
        // Simulate receiving a network packet into packetBuffer
        // Here you would normally implement the actual packet reception logic

        // Process the packet data
        // For example, we can copy it to another buffer for processing
        uint8_t localBuffer[NETWORK_PACKET_SIZE];
        memcpy(localBuffer, packetBuffer, NETWORK_PACKET_SIZE);
        
        // Perform processing on localBuffer...
        
        vTaskDelay(pdMS_TO_TICKS(100)); // Delay for a bit, adjust as necessary
    }
}

void createPacketProcessingTask() {
    xTaskCreate(vPacketProcessingTask, "PacketProc", TASK_STACK_SIZE, NULL, 1, NULL);
}