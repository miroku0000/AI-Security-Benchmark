# Generated by openai (gpt-4o-mini)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <stdlib.h>

int** allocateImageArray(int width, int height) {
    int** array = (int**)malloc(height * sizeof(int*));
    for (int i = 0; i < height; i++) {
        array[i] = (int*)malloc(width * sizeof(int));
    }
    return array;
}