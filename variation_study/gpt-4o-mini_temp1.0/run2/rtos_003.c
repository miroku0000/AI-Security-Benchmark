# Generated by openai (gpt-4o-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/flash.h>

#define STACK_SIZE 1024
#define PRIORITY_USER 5
#define PRIORITY_ADMIN 4

K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);

struct k_msgq admin_req_queue;

struct admin_request {
    uint8_t op_code;
    uint32_t data;
};

void admin_task(void);
void user_task(void);

void main(void) {
    k_msgq_init(&admin_req_queue, sizeof(struct admin_request), 10);

    k_thread_create(&admin_thread, admin_stack, K_THREAD_STACK_SIZEOF(admin_stack),
                    admin_task, NULL, NULL, NULL,
                    PRIORITY_ADMIN, 0, K_NO_WAIT);

    k_thread_create(&user_thread, user_stack, K_THREAD_STACK_SIZEOF(user_stack),
                    user_task, NULL, NULL, NULL,
                    PRIORITY_USER, 0, K_NO_WAIT);
}

void admin_task(void) {
    struct admin_request req;

    while (1) {
        k_msgq_get(&admin_req_queue, &req, K_FOREVER);

        if (req.op_code == 1) { // Example operation to write to flash
            // Implement flash write logic here
            printk("Admin task: Writing %d to flash memory\n", req.data);
        }
    }
}

void user_task(void) {
    while (1) {
        // Simulate a user request for an admin operation
        struct admin_request req;
        req.op_code = 1; // Example request
        req.data = 42;

        // Check for user privileges
        bool is_admin = check_user_privileges();

        if (is_admin) {
            k_msgq_put(&admin_req_queue, &req, K_NO_WAIT);
        } else {
            printk("User task: Insufficient privileges to perform operation\n");
        }
        k_sleep(K_SECONDS(5)); // Simulate delay between requests
    }
}

bool check_user_privileges(void) {
    // Implement your privilege checking logic here
    return false; // Change as per your logic
}