# Generated by openai (gpt-4o-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <avr/io.h>
#include <avr/interrupt.h>
#include <string.h>
#include <stdlib.h>

#define UART_BAUD 9600
#define F_CPU 16000000UL
#define UBRR_VALUE ((F_CPU / (16UL * UART_BAUD)) - 1)

void uart_init(void) {
    UBRR0H = (uint8_t)(UBRR_VALUE >> 8);
    UBRR0L = (uint8_t)(UBRR_VALUE);
    UCSR0B = (1 << RXEN0) | (1 << TXEN0);
    UCSR0C = (1 << UCSZ01) | (1 << UCSZ00);
}

void uart_transmit(char data) {
    while (!(UCSR0A & (1 << UDRE0)));
    UDR0 = data;
}

void uart_print(const char *str) {
    while (*str) {
        uart_transmit(*str++);
    }
}

void dump_memory(void) {
    uart_print("Memory dump:\n");
    for (uint16_t addr = 0; addr < 256; addr++) {
        uart_print("Addr ");
        uart_transmit(addr / 100 + '0');
        uart_transmit((addr / 10) % 10 + '0');
        uart_transmit(addr % 10 + '0');
        uart_print(": ");
        uart_transmit(*(uint8_t*)addr);
        uart_print("\n");
    }
}

void read_flash(void) {
    uart_print("Flash content:\n");
    for (uint16_t addr = 0; addr < 256; addr++) {
        uart_print("Flash ");
        uart_transmit(addr / 100 + '0');
        uart_transmit((addr / 10) % 10 + '0');
        uart_transmit(addr % 10 + '0');
        uart_print(": ");
        uart_transmit(pgm_read_byte(addr));
        uart_print("\n");
    }
}

void get_config(void) {
    uart_print("Configuration:\n");
    // Assuming configuration is stored in a struct
    uart_print("Sensor ID: 1234\n");
    uart_print("Threshold: 75\n");
}

void process_command(char *command) {
    if (strcmp(command, "dump_memory") == 0) {
        dump_memory();
    } else if (strcmp(command, "read_flash") == 0) {
        read_flash();
    } else if (strcmp(command, "get_config") == 0) {
        get_config();
    } else {
        uart_print("Unknown command\n");
    }
}

int main(void) {
    uart_init();
    char command[32];
    uint8_t index = 0;

    sei();  // Enable global interrupts

    while (1) {
        if (UCSR0A & (1 << RXC0)) {
            char received = UDR0;
            if (received == '\n') {
                command[index] = '\0';
                process_command(command);
                index = 0;  // Reset index for next command
            } else {
                if (index < sizeof(command) - 1) {
                    command[index++] = received;
                }
            }
        }
    }
}