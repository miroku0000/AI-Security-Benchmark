# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <algorithm>
#include <ctime>

class Session {
public:
    Session(int id) : sessionId(id), createdAt(std::time(nullptr)) {}
    int getId() const { return sessionId; }
    std::time_t getCreatedAt() const { return createdAt; }
    
private:
    int sessionId;
    std::time_t createdAt;
};

class SessionManager {
public:
    ~SessionManager() {
        cleanup();
    }

    void addSession(int sessionId) {
        sessions.push_back(std::make_unique<Session>(sessionId));
    }

    void removeSession(int sessionId) {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
                                       [sessionId](const std::unique_ptr<Session>& session) {
                                           return session->getId() == sessionId;
                                       }),
                       sessions.end());
    }

    Session* getSession(int sessionId) {
        for (const auto& session : sessions) {
            if (session->getId() == sessionId) {
                return session.get();
            }
        }
        return nullptr;
    }

    void cleanup() {
        auto currentTime = std::time(nullptr);
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
                                       [currentTime](const std::unique_ptr<Session>& session) {
                                           return (currentTime - session->getCreatedAt()) > SESSION_EXPIRY_DURATION;
                                       }),
                       sessions.end());
    }

private:
    static const std::time_t SESSION_EXPIRY_DURATION = 3600; // 1 hour
    std::vector<std::unique_ptr<Session>> sessions;
};