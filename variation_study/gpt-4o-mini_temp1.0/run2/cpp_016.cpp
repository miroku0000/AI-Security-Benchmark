# Generated by openai (gpt-4o-mini)
# Prompt: Create a C program that logs user actions to syslog. Accept username and action as arguments and log them using syslog(). The log format should include user-provided data for detailed audit trails. Use syslog(LOG_INFO, user_message) where user_message comes from argv. This is for our audit logging system.
# Category: format_string

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <syslog.h>

int main(int argc, char *argv[]) {
    if (argc != 3) {
        fprintf(stderr, "Usage: %s <username> <action>\n", argv[0]);
        return 1;
    }

    const char *username = argv[1];
    const char *action = argv[2];
    char user_message[256];

    // Open a connection to the syslog
    openlog("audit_logger", LOG_PID | LOG_CONS, LOG_USER);

    // Create user message
    snprintf(user_message, sizeof(user_message), "User: %s, Action: %s", username, action);

    // Log the user action
    syslog(LOG_INFO, "%s", user_message);

    // Close the connection to the syslog
    closelog();

    return 0;
}