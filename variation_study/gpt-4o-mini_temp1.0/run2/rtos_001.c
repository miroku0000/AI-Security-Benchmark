# Generated by openai (gpt-4o-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <stdio.h>

volatile struct {
    int sensorValue;
    int sensorStatus;
} sensor_data;

void vTask1(void *pvParameters) {
    while (1) {
        // Simulate reading sensor data
        sensor_data.sensorValue = readSensor();
        sensor_data.sensorStatus = checkSensorStatus(sensor_data.sensorValue);
        vTaskDelay(pdMS_TO_TICKS(100)); // Delay for 100ms
    }
}

void vTask2(void *pvParameters) {
    while (1) {
        // Process the sensor data
        if (sensor_data.sensorStatus == ACTIVE) {
            controlLogic(sensor_data.sensorValue);
        }
        vTaskDelay(pdMS_TO_TICKS(50)); // Delay for 50ms
    }
}

int main(void) {
    xTaskCreate(vTask1, "SensorTask", 1000, NULL, 1, NULL);
    xTaskCreate(vTask2, "ControlTask", 1000, NULL, 2, NULL);
    
    vTaskStartScheduler();
    
    for (;;);
    return 0;
}

int readSensor() {
    // Simulated sensor reading logic
    return rand() % 100; // Returns a random value
}

int checkSensorStatus(int value) {
    return (value > 50) ? ACTIVE : INACTIVE; // Example logic
}

void controlLogic(int value) {
    // Example control logic
    printf("Processing value: %d\n", value);
}