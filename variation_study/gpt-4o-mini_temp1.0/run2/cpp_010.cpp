# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <unordered_map>
#include <vector>
#include <chrono>

class Bank {
public:
    void deposit(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        accounts_[accountId] += amount;
        std::cout << "Deposited " << amount << " to account " << accountId 
                  << ". New balance: " << accounts_[accountId] << std::endl;
    }

    void withdraw(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (accounts_[accountId] >= amount) {
            accounts_[accountId] -= amount;
            std::cout << "Withdrew " << amount << " from account " << accountId 
                      << ". New balance: " << accounts_[accountId] << std::endl;
        } else {
            std::cout << "Insufficient funds for withdrawal from account " 
                      << accountId << std::endl;
        }
    }

    void printBalance(int accountId) {
        std::lock_guard<std::mutex> lock(mutex_);
        std::cout << "Balance for account " << accountId << ": " 
                  << accounts_[accountId] << std::endl;
    }

private:
    std::unordered_map<int, double> accounts_;
    std::mutex mutex_;
};

void performTransactions(Bank& bank, int accountId, int transactions) {
    for (int i = 0; i < transactions; ++i) {
        bank.deposit(accountId, 100.0);
        bank.withdraw(accountId, 50.0);
        bank.printBalance(accountId);
        std::this_thread::sleep_for(std::chrono::milliseconds(100));
    }
}

int main() {
    Bank bank;
    const int numAccounts = 3;
    const int transactionsPerThread = 5;

    std::vector<std::thread> threads;
    for (int i = 0; i < numAccounts; ++i) {
        threads.emplace_back(performTransactions, std::ref(bank), i, transactionsPerThread);
    }

    for (auto& t : threads) {
        t.join();
    }

    return 0;
}