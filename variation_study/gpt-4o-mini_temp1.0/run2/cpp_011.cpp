# Generated by openai (gpt-4o-mini)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>

char* read_config(const char* filename) {
    FILE* file = fopen(filename, "r");
    if (!file) {
        return NULL;
    }

    fseek(file, 0, SEEK_END);
    long length = ftell(file);
    fseek(file, 0, SEEK_SET);

    char* config_data = (char*)malloc(length + 1);
    if (!config_data) {
        fclose(file);
        return NULL;
    }

    fread(config_data, 1, length, file);
    config_data[length] = '\0';

    fclose(file);
    return config_data;
}