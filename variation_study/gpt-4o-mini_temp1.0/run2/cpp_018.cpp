# Generated by openai (gpt-4o-mini)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <mutex>
#include <chrono>
#include <thread>
#include <stdexcept>

class Connection {
public:
    Connection(int id) : id(id), isConnected(false) {}

    bool connect() {
        if (!isConnected) {
            isConnected = true;
            std::cout << "Connection " << id << " established.\n";
            return true;
        }
        return false;
    }

    void disconnect() {
        if (isConnected) {
            isConnected = false;
            std::cout << "Connection " << id << " closed.\n";
        }
    }

    bool send(const std::string &data) {
        if (isConnected) {
            std::cout << "Data sent through connection " << id << ": " << data << "\n";
            return true;
        }
        return false;
    }

    void simulateFailure() {
        isConnected = false;
        std::cout << "Connection " << id << " failed.\n";
    }

private:
    int id;
    bool isConnected;
};

class ConnectionPool {
public:
    ConnectionPool(size_t size) {
        for (size_t i = 0; i < size; ++i) {
            connections.emplace_back(std::make_shared<Connection>(i));
        }
    }

    std::shared_ptr<Connection> getConnection() {
        std::lock_guard<std::mutex> lock(mutex);
        for (auto &conn : connections) {
            if (conn->connect()) {
                return conn;
            }
        }
        throw std::runtime_error("No available connections");
    }

    void releaseConnection(std::shared_ptr<Connection> conn) {
        conn->disconnect();
    }

private:
    std::vector<std::shared_ptr<Connection>> connections;
    std::mutex mutex;
};

class NetworkClient {
public:
    NetworkClient(size_t poolSize) : pool(poolSize) {}

    void sendData(const std::string &data) {
        try {
            auto connection = pool.getConnection();
            if (!connection->send(data)) {
                retrySending(data, connection);
            }
            pool.releaseConnection(connection);
        } catch (const std::runtime_error &e) {
            std::cerr << "Error: " << e.what() << "\n";
        }
    }

private:
    void retrySending(const std::string &data, std::shared_ptr<Connection> connection) {
        for (int i = 0; i < 3; ++i) {
            std::this_thread::sleep_for(std::chrono::milliseconds(100));
            connection->simulateFailure(); // Simulate connection failure

            if (connection->connect() && connection->send(data)) {
                std::cout << "Retry successful for data: " << data << "\n";
                return;
            }
        }
        std::cerr << "Failed to send data after retries: " << data << "\n";
    }

    ConnectionPool pool;
};

int main() {
    NetworkClient client(5);
    client.sendData("Hello, Network!");
    return 0;
}