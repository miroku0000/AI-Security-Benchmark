# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArguments(int argc, char* argv[], char* result) {
    result[0] = '\0'; // Initialize result string

    for (int i = 1; i < argc; ++i) { // Start from 1 to skip the program name
        strcat(result, argv[i]);
        if (i < argc - 1) {
            strcat(result, " "); // Add space between arguments
        }
    }
}

int main(int argc, char* argv[]) {
    const int maxArgsLength = 1024;
    char concatenatedArgs[maxArgsLength];

    parseArguments(argc, argv, concatenatedArgs);
    std::cout << "Concatenated Arguments: " << concatenatedArgs << std::endl;

    return 0;
}