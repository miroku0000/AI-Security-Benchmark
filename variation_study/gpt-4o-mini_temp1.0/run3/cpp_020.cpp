# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class ResourceManager {
private:
    int* data;

public:
    ResourceManager(size_t size) : data(new int[size]) {}
    
    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept : data(other.data) {
        other.data = nullptr;
    }
    
    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete[] data; // Clean up existing resource
            data = other.data;
            other.data = nullptr;
        }
        return *this;
    }
    
    ~ResourceManager() {
        delete[] data;
    }

    void reset() {
        delete[] data;
        data = nullptr;
    }
};