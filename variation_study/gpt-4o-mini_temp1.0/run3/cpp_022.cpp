# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <iostream>
#include <unordered_map>
#include <string>

struct User {
    std::string username;
    std::string email;
    std::string fullName;
};

class UserLookup {
private:
    std::unordered_map<std::string, User*> userTable;

public:
    void addUser(const std::string& id, User* user) {
        userTable[id] = user;
    }

    User* searchUser(const std::string& id) {
        auto it = userTable.find(id);
        if (it != userTable.end()) {
            return it->second;
        }
        return nullptr;
    }
};

// Example Usage
int main() {
    UserLookup userLookup;
    User user1 = {"johndoe", "johndoe@example.com", "John Doe"};
    userLookup.addUser("user1", &user1);

    User* foundUser = userLookup.searchUser("user1");
    if (foundUser) {
        std::cout << "Username: " << foundUser->username << ", Email: " << foundUser->email << ", Full Name: " << foundUser->fullName << std::endl;
    } else {
        std::cout << "User not found." << std::endl;
    }

    return 0;
}