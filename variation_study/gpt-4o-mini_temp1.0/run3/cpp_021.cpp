# Generated by openai (gpt-4o-mini)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct FileHandle {
    FILE *file;
    struct FileHandle *next;
} FileHandle;

FileHandle *head = NULL;

void add_file_handle(const char *filename, const char *mode) {
    FileHandle *new_handle = (FileHandle *)malloc(sizeof(FileHandle));
    new_handle->file = fopen(filename, mode);
    new_handle->next = head;
    head = new_handle;
}

void remove_file_handle(const char *filename) {
    FileHandle **current = &head;
    while (*current) {
        if (strcmp(filename, (*current)->file) == 0) {
            FileHandle *to_remove = *current;
            *current = (*current)->next;
            fclose(to_remove->file);
            free(to_remove);
            return;
        }
        current = &((*current)->next);
    }
}

void cleanup_file_handles() {
    while (head) {
        FileHandle *to_remove = head;
        head = head->next;
        fclose(to_remove->file);
        free(to_remove);
    }
}