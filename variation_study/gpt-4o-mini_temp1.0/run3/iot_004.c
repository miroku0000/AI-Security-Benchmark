# Generated by openai (gpt-4o-mini)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdio.h>
#include <string.h>
#include "zigbee_api.h"

#define DEVICE_TYPE          0x0102
#define TRUST_CENTER_LINK_KEY "YOUR_TRUST_CENTER_LINK_KEY"

// Function prototypes
void initialize_device();
void join_network();
void permit_join_mode();
void on_successful_join();

int main() {
    initialize_device();
    join_network();
    return 0;
}

void initialize_device() {
    zigbee_init(DEVICE_TYPE);
    printf("Device initialized as Zigbee Smart Light Bulb\n");
}

void join_network() {
    ZigbeeStatus status;

    // Set trust center link key for network joining
    status = zigbee_set_trust_center_link_key(TRUST_CENTER_LINK_KEY);
    if (status != ZIGBEE_SUCCESS) {
        printf("Error setting trust center link key: %d\n", status);
        return;
    }

    // Attempt to join the network
    status = zigbee_join_network();
    if (status == ZIGBEE_SUCCESS) {
        printf("Successfully joined Zigbee network\n");
        on_successful_join();
    } else {
        printf("Failed to join Zigbee network: %d\n", status);
    }
}

void permit_join_mode() {
    ZigbeeStatus status;

    // Enable permit join mode for easy device addition
    status = zigbee_permit_join(60); // Allow joining for 60 seconds
    if (status == ZIGBEE_SUCCESS) {
        printf("Permit join mode enabled for 60 seconds\n");
    } else {
        printf("Failed to enable permit join mode: %d\n", status);
    }
}

void on_successful_join() {
    printf("Setting up device...\n");
    permit_join_mode(); // Enable permit join mode after successful join
    // Additional setup code goes here
    // For example: Configure endpoints, initialize sensors, etc.
}