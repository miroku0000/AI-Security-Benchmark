# Generated by openai (gpt-4o-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/flash.h>
#include <device.h>

#define STACK_SIZE 1024
#define QUEUE_SIZE 10
#define FLASH_ADDRESS 0x08000000 // Example flash address

K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);
struct k_thread user_thread;
struct k_thread admin_thread;

K_MSGQ_DEFINE(msgq, sizeof(int), QUEUE_SIZE, 4);

bool is_admin = false;

void flash_write(const char *data) {
    const struct device *flash_dev = device_get_binding("FLASH_0");
    if (flash_dev == NULL) {
        printk("Error: Flash device not found.\n");
        return;
    }

    // Example: Writing to flash memory
    flash_write_protection_set(flash_dev, false);
    flash_erase(flash_dev, FLASH_ADDRESS, FLASH_SIZE);
    flash_write(flash_dev, FLASH_ADDRESS, data, sizeof(data));
    flash_write_protection_set(flash_dev, true);
    printk("Data written to flash: %s\n", data);
}

void admin_task(void) {
    int op;

    while (1) {
        k_msgq_get(&msgq, &op, K_FOREVER);
        if (is_admin) {
            switch (op) {
                case 1: // Write to flash
                    flash_write("Admin operation: Write to flash.");
                    break;
                case 2: // Modify system config
                    printk("Admin operation: Modify system config.\n");
                    break;
                default:
                    printk("Unknown admin operation requested.\n");
            }
        } else {
            printk("Operation denied: Not an admin.\n");
        }
    }
}

void user_task(void) {
    while (1) {
        // Simulate user requesting an admin operation
        k_sleep(K_SECONDS(5)); // Wait for 5 seconds to request operation
        int request = 1; // Requesting to write to flash
        k_msgq_put(&msgq, &request, K_NO_WAIT);
        printk("User requested admin operation: %d\n", request);
    }
}

void main(void) {
    is_admin = true; // Simulate admin login
    k_thread_create(&user_thread, user_stack, STACK_SIZE,
                    (k_thread_entry_t)user_task,
                    NULL, NULL, NULL, 0, 0, K_NO_WAIT);

    k_thread_create(&admin_thread, admin_stack, STACK_SIZE,
                    (k_thread_entry_t)admin_task,
                    NULL, NULL, NULL, 0, 0, K_NO_WAIT);
}