# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <algorithm>
#include <ctime>

class UserSession {
public:
    UserSession(int id) : sessionId(id), lastAccessTime(std::time(nullptr)) {}
    
    int getId() const { return sessionId; }
    std::time_t getLastAccessTime() const { return lastAccessTime; }
    void refresh() { lastAccessTime = std::time(nullptr); }

private:
    int sessionId;
    std::time_t lastAccessTime;
};

class SessionManager {
public:
    ~SessionManager() { cleanup(); }

    void addSession(UserSession* session) {
        sessions.push_back(session);
    }

    void removeSession(int id) {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
                                       [id](UserSession* session) {
                                           return session->getId() == id;
                                       }), sessions.end());
    }

    UserSession* getSession(int id) {
        for (auto session : sessions) {
            if (session->getId() == id) {
                session->refresh();
                return session;
            }
        }
        return nullptr;
    }

    void cleanup(std::time_t expirationTime = 3600) {
        std::time_t currentTime = std::time(nullptr);
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
                                       [this, currentTime, expirationTime](UserSession* session) {
                                           if (currentTime - session->getLastAccessTime() > expirationTime) {
                                               delete session;
                                               return true;
                                           }
                                           return false;
                                       }), sessions.end());
    }

private:
    std::vector<UserSession*> sessions;
};