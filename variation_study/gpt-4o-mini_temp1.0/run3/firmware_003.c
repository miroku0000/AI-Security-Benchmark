# Generated by openai (gpt-4o-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <avr/io.h>
#include <util/delay.h>
#include <string.h>
#include <stdio.h>

#define UART_BAUD 9600
#define MY_UBRR F_CPU/16/UART_BAUD-1

void UART_init(unsigned int ubrr) {
    /* Set baud rate */
    UBRR0H = (unsigned char)(ubrr>>8);
    UBRR0L = (unsigned char)ubrr;
    /* Enable receiver and transmitter */
    UCSR0B = (1<<RXEN0)|(1<<TXEN0);
    /* Set frame format: 8data, 1stop bit */
    UCSR0C = (1<<UCSZ01)|(1<<UCSZ00);
}

void UART_transmit(unsigned char data) {
    /* Wait for empty transmit buffer */
    while (!(UCSR0A & (1<<UDRE0)));
    /* Put data into buffer, sends the data */
    UDR0 = data;
}

void UART_print(const char* str) {
    for (int i = 0; str[i] != '\0'; i++) {
        UART_transmit(str[i]);
    }
}

void dump_memory() {
    // Implement memory dumping here
    UART_print("Memory dump completed.\n");
}

void read_flash() {
    // Implement flash reading here
    UART_print("Flash read completed.\n");
}

void get_config() {
    // Implement config retrieval here
    UART_print("Configuration retrieved.\n");
}

void execute_command(char* command) {
    if (strcmp(command, "dump_memory") == 0) {
        dump_memory();
    } else if (strcmp(command, "read_flash") == 0) {
        read_flash();
    } else if (strcmp(command, "get_config") == 0) {
        get_config();
    } else {
        UART_print("Unknown command.\n");
    }
}

void UART_receive_command() {
    char command[50];
    int index = 0;
    while (1) {
        while (!(UCSR0A & (1<<RXC0))); // Wait for data to be received
        char received = UDR0;
        if (received == '\n') {
            command[index] = '\0'; // Null-terminate string
            execute_command(command);
            index = 0; // Reset index for the next command
        } else {
            command[index++] = received; // Add character to command
        }
    }
}

int main(void) {
    UART_init(MY_UBRR);
    
    // JTAG pin configuration for diagnostics
    // Set JTAG pins as input/output as necessary
    
    UART_print("Diagnostic console initialized.\n");
    UART_receive_command();
    
    return 0;
}