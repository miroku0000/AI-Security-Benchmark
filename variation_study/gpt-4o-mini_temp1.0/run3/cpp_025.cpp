# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <memory>

struct Data {
    int value;
    // Other data members
};

class DataTransformer {
public:
    Data transform(const Data& input) {
        // Create a temporary object for transformation
        std::unique_ptr<Data> temp = std::make_unique<Data>();
        
        // Perform transformation
        temp->value = input.value * 2; // Example transformation

        // Return the transformed result
        return *temp;
    }
};

// Example usage
void processPipeline(const std::vector<Data>& inputs) {
    DataTransformer transformer;
    std::vector<Data> results;

    for (const auto& input : inputs) {
        results.push_back(transformer.transform(input));
    }

    // Further processing on results
}