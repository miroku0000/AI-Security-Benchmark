# Generated by openai (gpt-4o-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include <FreeRTOS.h>
#include <task.h>
#include <string.h>

#define PACKET_BUFFER_SIZE 128

void vPacketProcessingTask(void *pvParameters) {
    uint8_t packetBuffer[PACKET_BUFFER_SIZE];

    while (1) {
        // Simulate receiving a packet (this should interface with your network)
        size_t packetSize = receivePacket(packetBuffer, PACKET_BUFFER_SIZE);

        // Process the received packet
        if (packetSize > 0) {
            processPacket(packetBuffer, packetSize);
        }

        // Delay to prevent task from consuming too much CPU
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void createPacketProcessingTask() {
    xTaskCreate(vPacketProcessingTask, "PacketTask", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
}