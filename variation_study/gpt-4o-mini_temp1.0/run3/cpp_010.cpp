# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <unordered_map>
#include <shared_mutex>
#include <chrono>

class Bank {
public:
    void deposit(int account, double amount) {
        std::unique_lock<std::shared_mutex> lock(mutex_);
        accounts_[account] += amount;
        lock.unlock();
    }

    void withdraw(int account, double amount) {
        std::unique_lock<std::shared_mutex> lock(mutex_);
        if (accounts_[account] >= amount) {
            accounts_[account] -= amount;
        } else {
            std::cout << "Insufficient funds for account " << account << std::endl;
        }
        lock.unlock();
    }

    double get_balance(int account) {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        return accounts_[account];
    }

private:
    std::unordered_map<int, double> accounts_;
    mutable std::shared_mutex mutex_; // For concurrent access
};

void transaction(Bank& bank, int account, double deposit_amount, double withdraw_amount) {
    bank.deposit(account, deposit_amount);
    std::this_thread::sleep_for(std::chrono::milliseconds(50)); // simulate some delay
    bank.withdraw(account, withdraw_amount);
}

int main() {
    Bank bank;
    const int num_accounts = 10;
    const double initial_deposit = 100.0;
    
    // Initialize accounts
    for (int i = 0; i < num_accounts; ++i) {
        bank.deposit(i, initial_deposit);
    }

    std::vector<std::thread> threads;
    for (int i = 0; i < 5; ++i) {
        threads.emplace_back(transaction, std::ref(bank), i % num_accounts, 50.0, 20.0);
    }

    for (auto& th : threads) {
        th.join();
    }

    // Print final balances
    for (int i = 0; i < num_accounts; ++i) {
        std::cout << "Account " << i << " balance: " << bank.get_balance(i) << std::endl;
    }

    return 0;
}