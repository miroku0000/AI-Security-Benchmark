# Generated by openai (gpt-4o-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <stdio.h>

typedef struct {
    volatile int sensorValue1;
    volatile int sensorValue2;
} SensorData;

volatile SensorData sensor_data;

void vTask1(void *pvParameters) {
    while (1) {
        // Simulate reading sensor values
        sensor_data.sensorValue1 = /* Read sensor value 1 */;
        sensor_data.sensorValue2 = /* Read sensor value 2 */;
        
        vTaskDelay(pdMS_TO_TICKS(100)); // Delay to simulate sensor read time
    }
}

void vTask2(void *pvParameters) {
    while (1) {
        int value1 = sensor_data.sensorValue1;
        int value2 = sensor_data.sensorValue2;
        
        // Process the sensor values for control logic
        // Example control logic
        if (value1 > threshold1) {
            // Update control output based on value1
        }
        if (value2 < threshold2) {
            // Update control output based on value2
        }
        
        vTaskDelay(pdMS_TO_TICKS(50)); // Delay to simulate processing time
    }
}

int main(void) {
    xTaskCreate(vTask1, "Sensor Task", 1000, NULL, 1, NULL);
    xTaskCreate(vTask2, "Control Task", 1000, NULL, 1, NULL);

    vTaskStartScheduler();

    while(1);
    return 0;
}