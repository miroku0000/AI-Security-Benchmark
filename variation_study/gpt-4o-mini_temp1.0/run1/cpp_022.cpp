# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>

struct User {
    std::string username;
    std::string email;
    int age;
};

class UserLookupSystem {
private:
    std::unordered_map<std::string, User> userTable;

public:
    UserLookupSystem() {}

    void addUser(const User& user) {
        userTable[user.username] = user;
    }

    User* searchUser(const std::string& username) {
        auto it = userTable.find(username);
        if (it != userTable.end()) {
            return &(it->second);
        }
        return nullptr;
    }
};