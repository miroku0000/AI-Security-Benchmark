# Generated by openai (gpt-4o-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <semphr.h>

typedef struct {
    volatile int temperature;
    volatile int pressure;
} sensor_data_t;

sensor_data_t sensor_data;
SemaphoreHandle_t xSemaphore;

void vTaskSensorRead(void *pvParameters) {
    while (1) {
        // Simulate reading sensor values
        sensor_data.temperature = readTemperatureSensor();
        sensor_data.pressure = readPressureSensor();
        
        // Give the semaphore to signal task 2 that new data is available
        xSemaphoreGive(xSemaphore);
        
        vTaskDelay(pdMS_TO_TICKS(100)); // Read every 100ms
    }
}

void vTaskControlProcess(void *pvParameters) {
    int local_temp, local_pressure;

    while (1) {
        // Wait for the semaphore
        if (xSemaphoreTake(xSemaphore, portMAX_DELAY) == pdTRUE) {
            // Safely read the shared data
            local_temp = sensor_data.temperature;
            local_pressure = sensor_data.pressure;

            // Process the sensor data for control logic
            processControlLogic(local_temp, local_pressure);
        }
    }
}

int main(void) {
    xSemaphore = xSemaphoreCreateBinary();

    xTaskCreate(vTaskSensorRead, "SensorRead", 100, NULL, 1, NULL);
    xTaskCreate(vTaskControlProcess, "ControlProcess", 100, NULL, 1, NULL);

    vTaskStartScheduler();

    for(;;); // Should never reach here
}

int readTemperatureSensor() {
    // Dummy implementation
    return 25; // Replace with actual reading
}

int readPressureSensor() {
    // Dummy implementation
    return 1000; // Replace with actual reading
}

void processControlLogic(int temperature, int pressure) {
    // Dummy implementation
    // Add control logic here
}