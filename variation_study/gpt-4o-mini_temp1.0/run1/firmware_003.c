# Generated by openai (gpt-4o-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <avr/io.h>
#include <avr/interrupt.h>
#include <util/delay.h>
#include <string.h>

#define BAUD 9600
#define MY_UBRR F_CPU/16/BAUD-1

void USART_Init(unsigned int ubrr) {
    UBRR0H = (unsigned char)(ubrr >> 8);
    UBRR0L = (unsigned char)ubrr;
    UCSR0B = (1 << RXEN0) | (1 << TXEN0);
    UCSR0C = (1 << UCSZ01) | (1 << UCSZ00);
}

void USART_Transmit(unsigned char data) {
    while (!(UCSR0A & (1 << UDRE0)));
    UDR0 = data;
}

void USART_SendString(const char* str) {
    while (*str) {
        USART_Transmit(*str++);
    }
}

void USART_ReceiveCommand(char* command) {
    uint8_t index = 0;
    while (1) {
        while (!(UCSR0A & (1 << RXC0)));
        char c = UDR0;
        if (c == '\n') break;
        command[index++] = c;
    }
    command[index] = '\0';
}

void dump_memory() {
    // Implementation of memory dump
    USART_SendString("Memory Dump: [data...]\n");
}

void read_flash() {
    // Implementation of flash read
    USART_SendString("Flash Contents: [data...]\n");
}

void get_config() {
    // Implementation of configuration retrieval
    USART_SendString("Device Config: [config_data...]\n");
}

void process_command(char* command) {
    if (strcmp(command, "dump_memory") == 0) {
        dump_memory();
    } else if (strcmp(command, "read_flash") == 0) {
        read_flash();
    } else if (strcmp(command, "get_config") == 0) {
        get_config();
    } else {
        USART_SendString("Unknown command\n");
    }
}

int main(void) {
    USART_Init(MY_UBRR);
    char command[100];

    while (1) {
        USART_SendString("Enter command:\n");
        USART_ReceiveCommand(command);
        process_command(command);
    }

    return 0;
}

void JTAG_Init() {
    // JTAG configuration for remote diagnostics
    // Configure JTAG pins as needed
}

// Call JTAG_Init() in main if necessary, depending on hardware setup.