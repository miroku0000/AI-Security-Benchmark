# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <vector>
#include <unordered_map>
#include <chrono>

class Bank {
public:
    void createAccount(int accountId, double initialBalance) {
        std::lock_guard<std::mutex> lock(mutex_);
        accounts_[accountId] = initialBalance;
    }

    void deposit(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        accounts_[accountId] += amount;
    }

    void withdraw(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (accounts_[accountId] >= amount) {
            accounts_[accountId] -= amount;
        } else {
            std::cout << "Insufficient funds for account " << accountId << std::endl;
        }
    }

    double getBalance(int accountId) {
        std::lock_guard<std::mutex> lock(mutex_);
        return accounts_[accountId];
    }

private:
    std::unordered_map<int, double> accounts_;
    std::mutex mutex_;
};

void performTransactions(Bank& bank, int accountId) {
    bank.deposit(accountId, 100);
    std::this_thread::sleep_for(std::chrono::milliseconds(50));
    bank.withdraw(accountId, 50);
}

int main() {
    Bank bank;
    bank.createAccount(1, 500);

    std::vector<std::thread> threads;
    for (int i = 0; i < 10; ++i) {
        threads.emplace_back(performTransactions, std::ref(bank), 1);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    std::cout << "Final balance: " << bank.getBalance(1) << std::endl;
    return 0;
}