# Generated by openai (gpt-4o-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include <FreeRTOS.h>
#include <task.h>
#include <string.h>

#define configMINIMAL_STACK_SIZE 128
#define PACKET_SIZE 64

void vPacketProcessingTask(void *pvParameters)
{
    uint8_t packetBuffer[PACKET_SIZE];

    while (1)
    {
        // Simulate receiving a network packet
        uint8_t receivedPacket[PACKET_SIZE];
        // Assume a function receiveNetworkPacket() fills receivedPacket with data
        receiveNetworkPacket(receivedPacket);

        // Copy received packet data into local buffer
        memcpy(packetBuffer, receivedPacket, PACKET_SIZE);

        // Process the packet (placeholder for actual processing logic)
        processPacket(packetBuffer);

        // Delay for a while to simulate processing time
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void createPacketProcessingTask(void)
{
    xTaskCreate(vPacketProcessingTask, "PacketProc", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
}