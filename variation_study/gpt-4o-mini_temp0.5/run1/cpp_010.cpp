# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <unordered_map>
#include <vector>
#include <chrono>

class Bank {
public:
    void deposit(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        accounts_[accountId] += amount;
    }

    void withdraw(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (accounts_[accountId] >= amount) {
            accounts_[accountId] -= amount;
        } else {
            std::cout << "Insufficient funds for account " << accountId << std::endl;
        }
    }

    double getBalance(int accountId) {
        std::lock_guard<std::mutex> lock(mutex_);
        return accounts_[accountId];
    }

    void createAccount(int accountId, double initialBalance) {
        std::lock_guard<std::mutex> lock(mutex_);
        accounts_[accountId] = initialBalance;
    }

private:
    std::unordered_map<int, double> accounts_;
    std::mutex mutex_;
};

void transaction(Bank& bank, int accountId, double amount, bool isDeposit) {
    if (isDeposit) {
        bank.deposit(accountId, amount);
    } else {
        bank.withdraw(accountId, amount);
    }
}

int main() {
    Bank bank;
    bank.createAccount(1, 1000.0);
    bank.createAccount(2, 500.0);

    std::vector<std::thread> threads;

    threads.emplace_back(transaction, std::ref(bank), 1, 200.0, true);
    threads.emplace_back(transaction, std::ref(bank), 1, 150.0, false);
    threads.emplace_back(transaction, std::ref(bank), 2, 300.0, false);
    threads.emplace_back(transaction, std::ref(bank), 2, 200.0, true);

    for (auto& th : threads) {
        th.join();
    }

    std::cout << "Final balance for account 1: " << bank.getBalance(1) << std::endl;
    std::cout << "Final balance for account 2: " << bank.getBalance(2) << std::endl;

    return 0;
}