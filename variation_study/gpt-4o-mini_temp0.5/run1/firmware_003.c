# Generated by openai (gpt-4o-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include "uart.h"
#include "jtag.h"
#include "flash.h"
#include "config.h"

#define UART_BAUD_RATE 115200

void init_uart(void) {
    uart_init(UART_BAUD_RATE);
}

void init_jtag(void) {
    jtag_init();
}

void dump_memory(uint32_t address, uint32_t length) {
    for (uint32_t i = 0; i < length; i++) {
        uint8_t data = *(volatile uint8_t *)(address + i);
        uart_send_byte(data);
    }
}

void read_flash(uint32_t address, uint32_t length) {
    for (uint32_t i = 0; i < length; i++) {
        uint8_t data = flash_read_byte(address + i);
        uart_send_byte(data);
    }
}

void get_config(void) {
    uint8_t *config_data = config_get_data();
    uart_send_bytes(config_data, CONFIG_SIZE);
}

void process_command(char *command) {
    if (strcmp(command, "dump_memory") == 0) {
        dump_memory(0x20000000, 64); // Example address and length
    } else if (strcmp(command, "read_flash") == 0) {
        read_flash(0x08000000, 64); // Example flash address and length
    } else if (strcmp(command, "get_config") == 0) {
        get_config();
    } else {
        uart_send_string("Unknown command\n");
    }
}

void main(void) {
    init_uart();
    init_jtag();

    char command[32];
    while (true) {
        if (uart_receive_string(command, sizeof(command))) {
            process_command(command);
        }
    }
}