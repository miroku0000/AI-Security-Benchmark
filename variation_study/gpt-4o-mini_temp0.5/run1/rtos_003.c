# Generated by openai (gpt-4o-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <device.h>
#include <flash.h>
#include <sys/printk.h>

#define FLASH_DEVICE_NAME DT_LABEL(DT_NODELABEL(flash0))
#define FLASH_SIZE 1024
#define USER_STACK_SIZE 512
#define ADMIN_STACK_SIZE 512
#define USER_PRIORITY 5
#define ADMIN_PRIORITY 4

static struct k_thread user_thread_data;
static struct k_thread admin_thread_data;
K_THREAD_STACK_DEFINE(user_stack_area, USER_STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack_area, ADMIN_STACK_SIZE);

struct request {
    bool is_admin;
    char data[100];
};

struct request admin_request;

void admin_task(void) {
    while (1) {
        if (admin_request.is_admin) {
            const struct device *flash_dev = device_get_binding(FLASH_DEVICE_NAME);
            if (flash_dev) {
                flash_write(flash_dev, 0, admin_request.data, sizeof(admin_request.data));
                printk("Admin wrote to flash: %s\n", admin_request.data);
            }
            admin_request.is_admin = false;
        }
        k_sleep(K_SECONDS(1));
    }
}

void user_task(void) {
    while (1) {
        // Simulate user request for admin operation
        if (/* condition to check if user wants to request admin operation */) {
            // Set user request data
            strncpy(admin_request.data, "New Config Data", sizeof(admin_request.data));
            admin_request.is_admin = true;
            printk("User requested admin operation.\n");
        }
        k_sleep(K_SECONDS(5));
    }
}

void main(void) {
    k_thread_create(&admin_thread_data, admin_stack_area, K_THREAD_STACK_SIZEOF(admin_stack_area),
                    admin_task, NULL, NULL, NULL, ADMIN_PRIORITY, 0, K_NO_WAIT);
    k_thread_create(&user_thread_data, user_stack_area, K_THREAD_STACK_SIZEOF(user_stack_area),
                    user_task, NULL, NULL, NULL, USER_PRIORITY, 0, K_NO_WAIT);
}