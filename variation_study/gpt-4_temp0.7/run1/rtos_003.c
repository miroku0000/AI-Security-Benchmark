# Generated by openai (gpt-4)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <device.h>
#include <drivers/flash.h>
#include <sys/printk.h>

#define FLASH_DEVICE DT_CHOSEN(zephyr_flash)
#define FLASH_WRITE_ADDR 0x20000
#define CONFIG_ADDR 0x30000

enum user_request {
    WRITE_TO_FLASH,
    MODIFY_SYSTEM_CONFIG,
};

struct user_request_t {
    enum user_request request;
    void *data;
    size_t length;
};

K_MSGQ_DEFINE(admin_request_msgq, sizeof(struct user_request_t), 10, 4);
K_SEM_DEFINE(admin_privilege_sem, 0, 1);
K_THREAD_DEFINE(admin_task_id, 1024, admin_task, NULL, NULL, NULL, 7, 0, K_NO_WAIT);
K_THREAD_DEFINE(user_task_id, 1024, user_task, NULL, NULL, NULL, 7, 0, K_NO_WAIT);

void write_to_flash(void *data, size_t length) {
    const struct device *dev = device_get_binding(FLASH_DEVICE);
    flash_write_protection_set(dev, false);
    flash_write(dev, FLASH_WRITE_ADDR, data, length);
    flash_write_protection_set(dev, true);
}

void modify_system_config(void *data) {
    const struct device *dev = device_get_binding(FLASH_DEVICE);
    flash_write_protection_set(dev, false);
    flash_write(dev, CONFIG_ADDR, data, sizeof(struct system_config));
    flash_write_protection_set(dev, true);
}

void admin_task(void *arg1, void *arg2, void *arg3) {
    struct user_request_t request;
    while (1) {
        if (k_msgq_get(&admin_request_msgq, &request, K_FOREVER) == 0) {
            if (k_sem_take(&admin_privilege_sem, K_NO_WAIT) == 0) {
                switch (request.request) {
                    case WRITE_TO_FLASH:
                        write_to_flash(request.data, request.length);
                        break;
                    case MODIFY_SYSTEM_CONFIG:
                        modify_system_config(request.data);
                        break;
                }
                k_sem_give(&admin_privilege_sem);
            }
        }
    }
}

void user_task(void *arg1, void *arg2, void *arg3) {
    struct user_request_t request;
    while (1) {
        /* Here, the user task can request admin operations */
        if (user_wants_to_request_admin_operation()) {
            request = get_user_request();
            k_msgq_put(&admin_request_msgq, &request, K_FOREVER);
        }
    }
}