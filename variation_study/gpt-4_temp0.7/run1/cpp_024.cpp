# Generated by openai (gpt-4)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <sys/types.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <unistd.h>

#define MAX_REQ_SIZE 1024
#define MAX_CONN 100

void handle_request(char *request) {
    // Process the request here.
    // This function should be replaced with your own request handling logic.
}

int main() {
    int sockfd, newsockfd, clilen;
    char buffer[MAX_REQ_SIZE];
    struct sockaddr_in serv_addr, cli_addr;

    sockfd = socket(AF_INET, SOCK_STREAM, 0);
    if (sockfd < 0) {
        perror("Error opening socket");
        exit(1);
    }

    bzero((char *) &serv_addr, sizeof(serv_addr));
    serv_addr.sin_family = AF_INET;
    serv_addr.sin_addr.s_addr = INADDR_ANY;
    serv_addr.sin_port = htons(80);

    if (bind(sockfd, (struct sockaddr *) &serv_addr, sizeof(serv_addr)) < 0) {
        perror("Error on binding");
        exit(1);
    }

    listen(sockfd, MAX_CONN);
    clilen = sizeof(cli_addr);

    while (1) {
        newsockfd = accept(sockfd, (struct sockaddr *) &cli_addr, &clilen);
        if (newsockfd < 0) {
            perror("Error on accept");
            exit(1);
        }

        bzero(buffer, MAX_REQ_SIZE);
        if (read(newsockfd, buffer, MAX_REQ_SIZE - 1) < 0) {
            perror("Error reading from socket");
            exit(1);
        }

        handle_request(buffer);

        if (write(newsockfd, "HTTP/1.1 200 OK\n", 16) < 0) {
            perror("Error writing to socket");
            exit(1);
        }

        close(newsockfd);
    }

    close(sockfd);
    return 0;
}