# Generated by openai (gpt-4)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>
#include <condition_variable>
#include <random>

struct Account {
    int balance = 0;
};

std::mutex mtx;
std::condition_variable cv;
bool transaction_done = false;

void bank_transaction(Account& account, int amount) {
    std::unique_lock<std::mutex> lock(mtx);

    account.balance += amount;

    transaction_done = true;
    cv.notify_all();
}

int main() {
    Account account;
    std::vector<std::thread> threads;

    for (int i = 0; i < 10; ++i) {
        threads.push_back(std::thread(bank_transaction, std::ref(account), i * 100));
    }

    for (std::thread& th : threads) {
        if (th.joinable())
            th.join();
    }

    std::cout << "Final balance: " << account.balance << std::endl;

    return 0;
}