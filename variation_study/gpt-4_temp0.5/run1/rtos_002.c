# Generated by openai (gpt-4)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define NETWORK_PACKET_SIZE 128

/* Network packet structure */
typedef struct
{
    uint8_t data[NETWORK_PACKET_SIZE];
} NetworkPacket_t;

/* Network packet queue handle */
QueueHandle_t xNetworkPacketQueue;

/* Network packet processing task */
void vNetworkPacketProcessingTask( void * pvParameters )
{
    NetworkPacket_t xReceivedPacket;
    for( ;; )
    {
        /* Wait for a packet to arrive in the queue. */
        if( xQueueReceive( xNetworkPacketQueue, &xReceivedPacket, portMAX_DELAY ) == pdPASS )
        {
            /* Process the received packet. */
            // TODO: Add your packet processing code here.
        }
    }
}

/* Function to initialize the network packet processing task and queue */
void vInitNetworkPacketProcessing( void )
{
    /* Create the queue used by the network packet processing task. */
    xNetworkPacketQueue = xQueueCreate( 10, sizeof( NetworkPacket_t ) );

    /* Create the network packet processing task. */
    xTaskCreate( vNetworkPacketProcessingTask, "NetPktProc", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL );
}