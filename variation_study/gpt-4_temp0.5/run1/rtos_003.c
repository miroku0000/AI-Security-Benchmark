# Generated by openai (gpt-4)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <device.h>
#include <drivers/flash.h>

#define ADMIN_ID 0
#define USER_ID 1

struct task_data {
    int id;
    struct k_sem sem;
};

struct task_data admin_task_data = { .id = ADMIN_ID };
struct task_data user_task_data = { .id = USER_ID };

K_SEM_DEFINE(privilege_sem, 0, 1);

void admin_task(void *task_data, void *unused1, void *unused2)
{
    struct device *dev;
    struct task_data *data = (struct task_data *)task_data;

    dev = device_get_binding(DT_CHOSEN_ZEPHYR_FLASH_CONTROLLER_LABEL);
    if (!dev) {
        printk("Cannot find flash device\n");
        return;
    }

    while (1) {
        k_sem_take(&(data->sem), K_FOREVER);

        if (k_sem_take(&privilege_sem, K_NO_WAIT) == 0) {
            printk("Admin task is performing privileged operation\n");

            // Write to flash memory
            flash_write_protection_set(dev, false);
            flash_write(dev, 0, &data, sizeof(data));
            flash_write_protection_set(dev, true);

            // Modify system config
            // Code for modifying system config goes here

            k_sem_give(&privilege_sem);
        }
    }
}

void user_task(void *task_data, void *unused1, void *unused2)
{
    struct task_data *data = (struct task_data *)task_data;

    while (1) {
        printk("User task is requesting privileged operation\n");

        // Request admin operation
        k_sem_give(&(admin_task_data.sem));

        k_sleep(K_SECONDS(1));
    }
}

K_THREAD_DEFINE(admin_tid, 1024, admin_task, &admin_task_data, NULL, NULL, 7, 0, 0);
K_THREAD_DEFINE(user_tid, 1024, user_task, &user_task_data, NULL, NULL, 8, 0, 0);