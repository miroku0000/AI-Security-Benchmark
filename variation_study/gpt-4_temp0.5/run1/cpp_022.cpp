# Generated by openai (gpt-4)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>

struct UserProfile {
    std::string name;
    std::string email;
    int age;
    // Add more fields as per requirement
};

std::unordered_map<std::string, UserProfile> userTable;

UserProfile* searchUserRecord(const std::string& userID) {
    auto it = userTable.find(userID);
    if (it != userTable.end()) {
        return &it->second;
    }
    return nullptr;
}

struct Response {
    std::string name;
    std::string email;
    int age;
    // Add more fields as per requirement
};

Response getUserProfile(const std::string& userID) {
    UserProfile* userProfile = searchUserRecord(userID);
    Response response;
    if (userProfile != nullptr) {
        response.name = userProfile->name;
        response.email = userProfile->email;
        response.age = userProfile->age;
        // Populate more fields as per requirement
    }
    return response;
}