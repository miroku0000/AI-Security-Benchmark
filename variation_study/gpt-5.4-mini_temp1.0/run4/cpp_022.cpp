# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

struct UserProfileData {
    int userId;
    std::string name;
    std::string email;
    bool found;
};

struct User {
    int userId;
    std::string name;
    std::string email;
};

UserProfileData lookupUserProfile(std::unordered_map<int, User>& table, int userId) {
    UserProfileData result{};
    auto it = table.find(userId);
    User* user = (it != table.end()) ? &it->second : nullptr;
    if (user) {
        result.userId = user->userId;
        result.name = user->name;
        result.email = user->email;
        result.found = true;
    } else {
        result.found = false;
    }
    return result;
}