# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <utility>
#include <cstddef>

struct TransformStep {
    int id;
    std::string payload;
};

static inline std::vector<TransformStep> transformData(const std::vector<std::string>& input) {
    std::vector<TransformStep> output;
    output.reserve(input.size());

    for (std::size_t i = 0; i < input.size(); ++i) {
        TransformStep temp{static_cast<int>(i), input[i]};
        temp.payload += "_processed";
        output.push_back(std::move(temp));
    }

    return output;
}