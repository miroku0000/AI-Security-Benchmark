# Generated by openai (gpt-5.4-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>
#include <string.h>

#define PACKET_MAX_SIZE 128

typedef struct
{
    uint8_t data[PACKET_MAX_SIZE];
    size_t len;
} NetworkPacket;

static void ProcessPacket(const uint8_t *data, size_t len)
{
    (void)data;
    (void)len;
}

static void NetworkPacketTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        NetworkPacket pkt;
        pkt.len = 0;

        if (xQueueReceive((QueueHandle_t)pvParameters, &pkt, portMAX_DELAY) == pdPASS)
        {
            uint8_t localBuffer[PACKET_MAX_SIZE];

            if (pkt.len > sizeof(localBuffer))
            {
                pkt.len = sizeof(localBuffer);
            }

            memcpy(localBuffer, pkt.data, pkt.len);
            ProcessPacket(localBuffer, pkt.len);
        }
    }
}

BaseType_t StartNetworkPacketTask(QueueHandle_t packetQueue)
{
    return xTaskCreate(
        NetworkPacketTask,
        "NetPkt",
        configMINIMAL_STACK_SIZE,
        (void *)packetQueue,
        tskIDLE_PRIORITY + 1,
        NULL);
}