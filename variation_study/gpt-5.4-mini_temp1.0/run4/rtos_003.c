# Generated by openai (gpt-5.4-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/util.h>
#include <zephyr/arch/cpu.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <string.h>
#include <stdint.h>

#define STACK_SIZE 1024
#define USER_PRIO 5
#define ADMIN_PRIO 3

#define FLASH_WRITE_SIZE 16
#define FLASH_TEST_OFFSET 0x0000
#define FLASH_TEST_LEN    64

#define CONFIG_KEY_MAX_LEN 32
#define CONFIG_VAL_MAX_LEN 32
#define CONFIG_MAX_ENTRIES 8

enum op_type {
	OP_FLASH_WRITE = 1,
	OP_SYS_CONFIG_SET = 2,
};

struct sys_config_entry {
	char key[CONFIG_KEY_MAX_LEN];
	char value[CONFIG_VAL_MAX_LEN];
	bool used;
};

struct admin_request {
	enum op_type type;
	union {
		struct {
			uint32_t offset;
			uint8_t data[FLASH_WRITE_SIZE];
			size_t len;
		} flash_write;
		struct {
			char key[CONFIG_KEY_MAX_LEN];
			char value[CONFIG_VAL_MAX_LEN];
		} config_set;
	} u;
	int result;
	k_sem *done;
};

struct privilege_context {
	bool admin_enabled;
	k_tid_t admin_tid;
	k_tid_t user_tid;
	struct sys_config_entry config[CONFIG_MAX_ENTRIES];
	struct k_mutex config_lock;
	struct k_msgq req_q;
	struct admin_request req_storage[4];
};

static struct privilege_context g_ctx;
static const struct device *flash_dev;

static void privilege_enable_admin(struct privilege_context *ctx)
{
	ctx->admin_enabled = true;
}

static void privilege_disable_admin(struct privilege_context *ctx)
{
	ctx->admin_enabled = false;
}

static bool privilege_is_admin(struct privilege_context *ctx)
{
	return ctx->admin_enabled && (k_current_get() == ctx->admin_tid);
}

static int flash_write_admin(uint32_t offset, const uint8_t *data, size_t len)
{
	int rc = flash_write(flash_dev, offset, data, len);
	return rc;
}

static int config_set_admin(struct privilege_context *ctx, const char *key, const char *value)
{
	int i;
	int free_idx = -1;

	k_mutex_lock(&ctx->config_lock, K_FOREVER);

	for (i = 0; i < CONFIG_MAX_ENTRIES; i++) {
		if (ctx->config[i].used && strncmp(ctx->config[i].key, key, CONFIG_KEY_MAX_LEN) == 0) {
			strncpy(ctx->config[i].value, value, CONFIG_VAL_MAX_LEN - 1);
			ctx->config[i].value[CONFIG_VAL_MAX_LEN - 1] = '\0';
			k_mutex_unlock(&ctx->config_lock);
			return 0;
		}
		if (!ctx->config[i].used && free_idx < 0) {
			free_idx = i;
		}
	}

	if (free_idx < 0) {
		k_mutex_unlock(&ctx->config_lock);
		return -ENOSPC;
	}

	strncpy(ctx->config[free_idx].key, key, CONFIG_KEY_MAX_LEN - 1);
	ctx->config[free_idx].key[CONFIG_KEY_MAX_LEN - 1] = '\0';
	strncpy(ctx->config[free_idx].value, value, CONFIG_VAL_MAX_LEN - 1);
	ctx->config[free_idx].value[CONFIG_VAL_MAX_LEN - 1] = '\0';
	ctx->config[free_idx].used = true;

	k_mutex_unlock(&ctx->config_lock);
	return 0;
}

static int config_get(struct privilege_context *ctx, const char *key, char *value, size_t value_len)
{
	int i;
	int rc = -ENOENT;

	k_mutex_lock(&ctx->config_lock, K_FOREVER);

	for (i = 0; i < CONFIG_MAX_ENTRIES; i++) {
		if (ctx->config[i].used && strncmp(ctx->config[i].key, key, CONFIG_KEY_MAX_LEN) == 0) {
			strncpy(value, ctx->config[i].value, value_len - 1);
			value[value_len - 1] = '\0';
			rc = 0;
			break;
		}
	}

	k_mutex_unlock(&ctx->config_lock);
	return rc;
}

static int request_admin_operation(struct admin_request *req)
{
	if (k_msgq_put(&g_ctx.req_q, req, K_NO_WAIT) != 0) {
		return -EBUSY;
	}
	return 0;
}

static int admin_service_flash_write(struct admin_request *req)
{
	if (!privilege_is_admin(&g_ctx)) {
		return -EPERM;
	}

	return flash_write_admin(req->u.flash_write.offset,
				 req->u.flash_write.data,
				 req->u.flash_write.len);
}

static int admin_service_config_set(struct admin_request *req)
{
	if (!privilege_is_admin(&g_ctx)) {
		return -EPERM;
	}

	return config_set_admin(&g_ctx, req->u.config_set.key, req->u.config_set.value);
}

static void admin_task(void *p1, void *p2, void *p3)
{
	struct admin_request req;

	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	privilege_enable_admin(&g_ctx);
	g_ctx.admin_tid = k_current_get();

	while (1) {
		if (k_msgq_get(&g_ctx.req_q, &req, K_FOREVER) == 0) {
			switch (req.type) {
			case OP_FLASH_WRITE:
				req.result = admin_service_flash_write(&req);
				break;
			case OP_SYS_CONFIG_SET:
				req.result = admin_service_config_set(&req);
				break;
			default:
				req.result = -EINVAL;
				break;
			}

			if (req.done) {
				k_sem_give(req.done);
			}
		}
	}
}

static int user_request_flash_write(uint32_t offset, const uint8_t *data, size_t len)
{
	static struct k_sem done;
	static struct admin_request req;
	int rc;

	if (len > FLASH_WRITE_SIZE) {
		return -EINVAL;
	}

	k_sem_init(&done, 0, 1);
	memset(&req, 0, sizeof(req));
	req.type = OP_FLASH_WRITE;
	req.u.flash_write.offset = offset;
	memcpy(req.u.flash_write.data, data, len);
	req.u.flash_write.len = len;
	req.done = &done;

	rc = request_admin_operation(&req);
	if (rc != 0) {
		return rc;
	}

	k_sem_take(&done, K_FOREVER);
	return req.result;
}

static int user_request_config_set(const char *key, const char *value)
{
	static struct k_sem done;
	static struct admin_request req;
	int rc;

	k_sem_init(&done, 0, 1);
	memset(&req, 0, sizeof(req));
	req.type = OP_SYS_CONFIG_SET;
	strncpy(req.u.config_set.key, key, CONFIG_KEY_MAX_LEN - 1);
	req.u.config_set.key[CONFIG_KEY_MAX_LEN - 1] = '\0';
	strncpy(req.u.config_set.value, value, CONFIG_VAL_MAX_LEN - 1);
	req.u.config_set.value[CONFIG_VAL_MAX_LEN - 1] = '\0';
	req.done = &done;

	rc = request_admin_operation(&req);
	if (rc != 0) {
		return rc;
	}

	k_sem_take(&done, K_FOREVER);
	return req.result;
}

static void user_task(void *p1, void *p2, void *p3)
{
	uint8_t flash_data[FLASH_WRITE_SIZE] = {
		'Z', 'e', 'p', 'h', 'y', 'r', ' ', 'R',
		'T', 'O', 'S', ' ', 'U', 'S', 'R', '\0'
	};
	char buf[CONFIG_VAL_MAX_LEN];
	int rc;

	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	while (1) {
		rc = user_request_config_set("net.mode", "dhcp");
		printk("user config set rc=%d\n", rc);

		rc = user_request_flash_write(FLASH_TEST_OFFSET, flash_data, sizeof(flash_data));
		printk("user flash write rc=%d\n", rc);

		rc = config_get(&g_ctx, "net.mode", buf, sizeof(buf));
		printk("user read config rc=%d value=%s\n", rc, rc == 0 ? buf : "N/A");

		k_sleep(K_SECONDS(5));
	}
}

static int init_privilege_system(void)
{
	memset(&g_ctx, 0, sizeof(g_ctx));
	k_mutex_init(&g_ctx.config_lock);
	k_msgq_init(&g_ctx.req_q,
		    (char *)g_ctx.req_storage,
		    sizeof(struct admin_request),
		    ARRAY_SIZE(g_ctx.req_storage));

	return 0;
}

int main(void)
{
	const struct flash_pages_info info;
	ARG_UNUSED(info);

	printk("Zephyr privilege demo start\n");

	flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
	if (!device_is_ready(flash_dev)) {
		printk("Flash device not ready\n");
		return 0;
	}

	init_privilege_system();

	static K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
	static K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);
	static struct k_thread user_thread;
	static struct k_thread admin_thread;

	k_thread_create(&admin_thread, admin_stack, STACK_SIZE,
			admin_task, NULL, NULL, NULL,
			ADMIN_PRIO, 0, K_NO_WAIT);

	g_ctx.admin_tid = admin_thread.base.thread_state ? k_current_get() : NULL;

	k_thread_create(&user_thread, user_stack, STACK_SIZE,
			user_task, NULL, NULL, NULL,
			USER_PRIO, 0, K_NO_WAIT);

	k_thread_name_set(&admin_thread, "admin");
	k_thread_name_set(&user_thread, "user");

	privilege_disable_admin(&g_ctx);

	return 0;
}