# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <string>
#include <vector>
#include <thread>
#include <mutex>
#include <shared_mutex>
#include <random>
#include <chrono>

class Bank {
private:
    std::unordered_map<std::string, long long> accounts;
    mutable std::shared_mutex accountsMutex;

public:
    void addAccount(const std::string& id, long long initialBalance) {
        std::unique_lock<std::shared_mutex> lock(accountsMutex);
        accounts[id] = initialBalance;
    }

    long long getBalance(const std::string& id) const {
        std::shared_lock<std::shared_mutex> lock(accountsMutex);
        auto it = accounts.find(id);
        if (it == accounts.end()) return 0;
        return it->second;
    }

    bool deposit(const std::string& id, long long amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(accountsMutex);
        auto it = accounts.find(id);
        if (it == accounts.end()) return false;
        it->second += amount;
        return true;
    }

    bool withdraw(const std::string& id, long long amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(accountsMutex);
        auto it = accounts.find(id);
        if (it == accounts.end() || it->second < amount) return false;
        it->second -= amount;
        return true;
    }

    bool transfer(const std::string& from, const std::string& to, long long amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(accountsMutex);
        auto itFrom = accounts.find(from);
        auto itTo = accounts.find(to);
        if (itFrom == accounts.end() || itTo == accounts.end() || itFrom->second < amount) return false;
        itFrom->second -= amount;
        itTo->second += amount;
        return true;
    }

    std::vector<std::pair<std::string, long long>> snapshot() const {
        std::shared_lock<std::shared_mutex> lock(accountsMutex);
        std::vector<std::pair<std::string, long long>> result;
        result.reserve(accounts.size());
        for (const auto& kv : accounts) {
            result.push_back(kv);
        }
        return result;
    }
};

struct Transaction {
    enum class Type { Deposit, Withdraw, Transfer };
    Type type;
    std::string from;
    std::string to;
    long long amount;
};

void processTransactions(Bank& bank, const std::vector<Transaction>& txs, size_t begin, size_t end, std::mutex& ioMutex, int threadId) {
    for (size_t i = begin; i < end; ++i) {
        const auto& tx = txs[i];
        bool ok = false;

        switch (tx.type) {
            case Transaction::Type::Deposit:
                ok = bank.deposit(tx.to, tx.amount);
                break;
            case Transaction::Type::Withdraw:
                ok = bank.withdraw(tx.from, tx.amount);
                break;
            case Transaction::Type::Transfer:
                ok = bank.transfer(tx.from, tx.to, tx.amount);
                break;
        }

        {
            std::lock_guard<std::mutex> lock(ioMutex);
            std::cout << "Thread " << threadId << ": transaction " << i << (ok ? " succeeded" : " failed") << '\n';
        }
    }
}

int main() {
    Bank bank;
    bank.addAccount("Alice", 1000);
    bank.addAccount("Bob", 1500);
    bank.addAccount("Charlie", 2000);
    bank.addAccount("Diana", 2500);

    std::vector<Transaction> transactions = {
        {Transaction::Type::Deposit, "", "Alice", 500},
        {Transaction::Type::Withdraw, "Bob", "", 200},
        {Transaction::Type::Transfer, "Charlie", "Diana", 300},
        {Transaction::Type::Transfer, "Diana", "Alice", 700},
        {Transaction::Type::Deposit, "", "Bob", 1000},
        {Transaction::Type::Withdraw, "Alice", "", 400},
        {Transaction::Type::Transfer, "Bob", "Charlie", 600},
        {Transaction::Type::Transfer, "Alice", "Bob", 250},
        {Transaction::Type::Deposit, "", "Charlie", 150},
        {Transaction::Type::Withdraw, "Diana", "", 1000}
    };

    const size_t numThreads = 4;
    std::vector<std::thread> threads;
    std::mutex ioMutex;

    size_t chunk = (transactions.size() + numThreads - 1) / numThreads;
    for (size_t t = 0; t < numThreads; ++t) {
        size_t begin = t * chunk;
        size_t end = std::min(begin + chunk, transactions.size());
        if (begin >= end) break;
        threads.emplace_back(processTransactions, std::ref(bank), std::cref(transactions), begin, end, std::ref(ioMutex), static_cast<int>(t));
    }

    for (auto& th : threads) th.join();

    std::cout << "\nFinal account balances:\n";
    for (const auto& [name, balance] : bank.snapshot()) {
        std::cout << name << ": " << balance << '\n';
    }

    return 0;
}