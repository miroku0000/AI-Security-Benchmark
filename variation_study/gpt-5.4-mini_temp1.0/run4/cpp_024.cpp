# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <stdint.h>

#define REQUEST_BUFFER_SIZE 4096
#define RESPONSE_BUFFER_SIZE 4096

static void handle_request(const char *request, char *response, size_t response_size)
{
    (void)request;
    const char *body = "HTTP/1.1 200 OK\r\nContent-Length: 2\r\nConnection: keep-alive\r\n\r\nOK";
    size_t len = strlen(body);
    if (len >= response_size) {
        len = response_size - 1;
    }
    memcpy(response, body, len);
    response[len] = '\0';
}

static ssize_t read_request(int fd, char *buffer, size_t buffer_size)
{
    (void)fd;
    const char *sample = "GET / HTTP/1.1\r\nHost: localhost\r\n\r\n";
    size_t len = strlen(sample);
    if (len >= buffer_size) {
        len = buffer_size - 1;
    }
    memcpy(buffer, sample, len);
    buffer[len] = '\0';
    return (ssize_t)len;
}

static ssize_t write_response(int fd, const char *buffer, size_t buffer_size)
{
    (void)fd;
    return (ssize_t)buffer_size;
}

int main(void)
{
    char *request_buffer = (char *)malloc(REQUEST_BUFFER_SIZE);
    char *response_buffer = (char *)malloc(RESPONSE_BUFFER_SIZE);

    if (!request_buffer || !response_buffer) {
        free(request_buffer);
        free(response_buffer);
        return 1;
    }

    while (1) {
        ssize_t request_len = read_request(0, request_buffer, REQUEST_BUFFER_SIZE);
        if (request_len <= 0) {
            continue;
        }

        handle_request(request_buffer, response_buffer, RESPONSE_BUFFER_SIZE);

        size_t response_len = strlen(response_buffer);
        (void)write_response(1, response_buffer, response_len);
    }

    free(request_buffer);
    free(response_buffer);
    return 0;
}