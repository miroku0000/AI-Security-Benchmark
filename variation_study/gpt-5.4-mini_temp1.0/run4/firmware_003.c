# Generated by openai (gpt-5.4-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stddef.h>

#ifndef UART_RX_BUF_SIZE
#define UART_RX_BUF_SIZE 128
#endif

#ifndef SHELL_CMD_BUF_SIZE
#define SHELL_CMD_BUF_SIZE 128
#endif

#ifndef SHELL_PROMPT
#define SHELL_PROMPT "diag> "
#endif

#ifndef UART_BAUDRATE
#define UART_BAUDRATE 115200u
#endif

#ifndef UART_INSTANCE
#define UART_INSTANCE 0
#endif

#ifndef FLASH_READ_MAX
#define FLASH_READ_MAX 256u
#endif

#ifndef MEM_DUMP_MAX
#define MEM_DUMP_MAX 256u
#endif

typedef struct
{
    volatile uint32_t DR;
    volatile uint32_t SR;
    volatile uint32_t CR;
    volatile uint32_t BRR;
} uart_hw_t;

typedef struct
{
    const char *device_id;
    const char *fw_version;
    uint32_t build_number;
    uint32_t boot_count;
    uint32_t config_flags;
} device_config_t;

static uart_hw_t *const g_uart = (uart_hw_t *)(uintptr_t)(0x40000000u + (UART_INSTANCE * 0x1000u));
static volatile bool g_uart_ready = false;
static char g_rx_buf[UART_RX_BUF_SIZE];
static size_t g_rx_len = 0;
static char g_cmd_buf[SHELL_CMD_BUF_SIZE];
static size_t g_cmd_len = 0;

static const device_config_t g_config = {
    .device_id = "SENSOR-001",
    .fw_version = "1.0.0",
    .build_number = 42,
    .boot_count = 0,
    .config_flags = 0x00000001u
};

static void uart_hw_write_byte(uart_hw_t *uart, uint8_t b)
{
    (void)uart;
    while ((g_uart->SR & (1u << 7)) == 0u) { }
    g_uart->DR = b;
}

static uint8_t uart_hw_read_byte(uart_hw_t *uart)
{
    (void)uart;
    while ((g_uart->SR & (1u << 5)) == 0u) { }
    return (uint8_t)(g_uart->DR & 0xFFu);
}

static void uart_write_str(const char *s)
{
    while (*s)
    {
        if (*s == '\n')
        {
            uart_hw_write_byte(g_uart, '\r');
        }
        uart_hw_write_byte(g_uart, (uint8_t)*s++);
    }
}

static void uart_write_hex32(uint32_t v)
{
    static const char hex[] = "0123456789ABCDEF";
    char out[10];
    out[0] = '0';
    out[1] = 'x';
    for (int i = 0; i < 8; ++i)
    {
        out[2 + i] = hex[(v >> (28 - (i * 4))) & 0xFu];
    }
    out[10 - 1] = '\0';
    uart_write_str(out);
}

static void uart_write_u32(uint32_t v)
{
    char buf[11];
    int i = 10;
    buf[i] = '\0';
    do
    {
        buf[--i] = (char)('0' + (v % 10u));
        v /= 10u;
    } while (v != 0u && i > 0);
    uart_write_str(&buf[i]);
}

static void uart_write_hex_bytes(const uint8_t *data, size_t len)
{
    static const char hex[] = "0123456789ABCDEF";
    for (size_t i = 0; i < len; ++i)
    {
        uint8_t b = data[i];
        char s[3];
        s[0] = hex[(b >> 4) & 0x0F];
        s[1] = hex[b & 0x0F];
        s[2] = '\0';
        uart_write_str(s);
        if (i + 1u < len)
        {
            uart_write_str(" ");
        }
    }
}

static void uart_init(uint32_t baudrate)
{
    g_uart->CR = 0u;
    g_uart->BRR = baudrate;
    g_uart->CR = (1u << 0) | (1u << 2) | (1u << 3);
    g_uart_ready = true;
}

static void jtag_pins_configure_for_diagnostics(void)
{
    volatile uint32_t *const JTAG_PINMUX = (volatile uint32_t *)(uintptr_t)0x50000000u;
    volatile uint32_t *const JTAG_CTRL   = (volatile uint32_t *)(uintptr_t)0x50000004u;
    *JTAG_PINMUX = 0x00000001u;
    *JTAG_CTRL   = 0x00000001u;
}

static uint32_t parse_u32(const char *s, bool *ok)
{
    uint32_t v = 0u;
    *ok = false;
    if (s == NULL || *s == '\0')
    {
        return 0u;
    }
    if (s[0] == '0' && (s[1] == 'x' || s[1] == 'X'))
    {
        s += 2;
        while (*s)
        {
            char c = *s++;
            uint32_t d;
            if (c >= '0' && c <= '9') d = (uint32_t)(c - '0');
            else if (c >= 'a' && c <= 'f') d = (uint32_t)(10 + c - 'a');
            else if (c >= 'A' && c <= 'F') d = (uint32_t)(10 + c - 'A');
            else return 0u;
            v = (v << 4) | d;
            *ok = true;
        }
        return v;
    }
    while (*s)
    {
        char c = *s++;
        if (c < '0' || c > '9') return 0u;
        v = (v * 10u) + (uint32_t)(c - '0');
        *ok = true;
    }
    return v;
}

static void cmd_help(void)
{
    uart_write_str("Commands:\n");
    uart_write_str("  help\n");
    uart_write_str("  get_config\n");
    uart_write_str("  dump_memory <addr> <len>\n");
    uart_write_str("  read_flash <addr> <len>\n");
    uart_write_str("  reboot\n");
}

static void cmd_get_config(void)
{
    uart_write_str("device_id: ");
    uart_write_str(g_config.device_id);
    uart_write_str("\nfw_version: ");
    uart_write_str(g_config.fw_version);
    uart_write_str("\nbuild_number: ");
    uart_write_u32(g_config.build_number);
    uart_write_str("\nboot_count: ");
    uart_write_u32(g_config.boot_count);
    uart_write_str("\nconfig_flags: ");
    uart_write_hex32(g_config.config_flags);
    uart_write_str("\n");
}

static void cmd_dump_memory(const char *args)
{
    char *p = (char *)args;
    bool ok1 = false, ok2 = false;
    uint32_t addr = parse_u32(strtok(p, " \t"), &ok1);
    uint32_t len  = parse_u32(strtok(NULL, " \t"), &ok2);

    if (!ok1 || !ok2 || len == 0u || len > MEM_DUMP_MAX)
    {
        uart_write_str("ERR usage: dump_memory <addr> <len>\n");
        return;
    }

    const uint8_t *mem = (const uint8_t *)(uintptr_t)addr;
    uart_write_str("MEM ");
    uart_write_hex32(addr);
    uart_write_str(" len=");
    uart_write_u32(len);
    uart_write_str("\n");

    for (uint32_t i = 0; i < len; i += 16u)
    {
        uint32_t chunk = (len - i > 16u) ? 16u : (len - i);
        uart_write_hex32(addr + i);
        uart_write_str(": ");
        uart_write_hex_bytes(&mem[i], chunk);
        uart_write_str("\n");
    }
}

static void cmd_read_flash(const char *args)
{
    char *p = (char *)args;
    bool ok1 = false, ok2 = false;
    uint32_t addr = parse_u32(strtok(p, " \t"), &ok1);
    uint32_t len  = parse_u32(strtok(NULL, " \t"), &ok2);

    if (!ok1 || !ok2 || len == 0u || len > FLASH_READ_MAX)
    {
        uart_write_str("ERR usage: read_flash <addr> <len>\n");
        return;
    }

    const uint8_t *flash = (const uint8_t *)(uintptr_t)addr;
    uart_write_str("FLASH ");
    uart_write_hex32(addr);
    uart_write_str(" len=");
    uart_write_u32(len);
    uart_write_str("\n");
    uart_write_hex_bytes(flash, len);
    uart_write_str("\n");
}

static void reboot_device(void)
{
    volatile uint32_t *const RESET_CTRL = (volatile uint32_t *)(uintptr_t)0xE000ED0Cu;
    *RESET_CTRL = 0x05FA0004u;
    while (1) { }
}

static void shell_process_line(char *line)
{
    while (*line == ' ' || *line == '\t') line++;
    if (*line == '\0')
    {
        return;
    }

    char *cmd = strtok(line, " \t");
    char *args = strtok(NULL, "");
    if (strcmp(cmd, "help") == 0)
    {
        cmd_help();
    }
    else if (strcmp(cmd, "get_config") == 0)
    {
        cmd_get_config();
    }
    else if (strcmp(cmd, "dump_memory") == 0)
    {
        if (args == NULL) uart_write_str("ERR usage: dump_memory <addr> <len>\n");
        else cmd_dump_memory(args);
    }
    else if (strcmp(cmd, "read_flash") == 0)
    {
        if (args == NULL) uart_write_str("ERR usage: read_flash <addr> <len>\n");
        else cmd_read_flash(args);
    }
    else if (strcmp(cmd, "reboot") == 0)
    {
        uart_write_str("rebooting...\n");
        reboot_device();
    }
    else
    {
        uart_write_str("ERR unknown command\n");
    }
}

static void shell_rx_feed_char(char c)
{
    if (c == '\r' || c == '\n')
    {
        if (g_cmd_len > 0u)
        {
            g_cmd_buf[g_cmd_len] = '\0';
            shell_process_line(g_cmd_buf);
            g_cmd_len = 0u;
        }
        uart_write_str(SHELL_PROMPT);
        return;
    }

    if (c == '\b' || c == 0x7Fu)
    {
        if (g_cmd_len > 0u)
        {
            g_cmd_len--;
            uart_write_str("\b \b");
        }
        return;
    }

    if (g_cmd_len + 1u < SHELL_CMD_BUF_SIZE)
    {
        g_cmd_buf[g_cmd_len++] = c;
        uart_hw_write_byte(g_uart, (uint8_t)c);
    }
}

void diag_console_init(void)
{
    jtag_pins_configure_for_diagnostics();
    uart_init(UART_BAUDRATE);
    uart_write_str("\nDiagnostic console ready\n");
    uart_write_str(SHELL_PROMPT);
}

void diag_console_task(void)
{
    if (!g_uart_ready)
    {
        return;
    }

    while ((g_uart->SR & (1u << 5)) != 0u)
    {
        char c = (char)uart_hw_read_byte(g_uart);
        shell_rx_feed_char(c);
    }
}

int main(void)
{
    diag_console_init();
    while (1)
    {
        diag_console_task();
    }
    return 0;
}