# Generated by openai (gpt-5.4-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>
#include <stdbool.h>

typedef struct
{
    int32_t raw_value;
    int32_t filtered_value;
    uint32_t sequence;
} sensor_data_t;

volatile sensor_data_t sensor_data = {0};

static TaskHandle_t task1_handle = NULL;
static TaskHandle_t task2_handle = NULL;

static void SensorReadTask(void *pvParameters)
{
    (void)pvParameters;

    sensor_data_t local_data;
    uint32_t seq = 0;

    for (;;)
    {
        local_data.raw_value = (int32_t)ReadSensorHardware();
        local_data.filtered_value = FilterSensorValue(local_data.raw_value);
        local_data.sequence = ++seq;

        taskENTER_CRITICAL();
        sensor_data = local_data;
        taskEXIT_CRITICAL();

        vTaskDelay(pdMS_TO_TICKS(5));
    }
}

static void ControlTask(void *pvParameters)
{
    (void)pvParameters;

    sensor_data_t local_copy;
    uint32_t last_sequence = 0;

    for (;;)
    {
        taskENTER_CRITICAL();
        local_copy = (sensor_data_t)sensor_data;
        taskEXIT_CRITICAL();

        if (local_copy.sequence != last_sequence)
        {
            last_sequence = local_copy.sequence;
            ProcessControlLogic(local_copy.filtered_value, local_copy.raw_value);
        }

        vTaskDelay(pdMS_TO_TICKS(1));
    }
}

int main(void)
{
    SystemInit();
    HardwareInit();

    xTaskCreate(SensorReadTask, "SENSOR", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 2, &task1_handle);
    xTaskCreate(ControlTask, "CTRL", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 3, &task2_handle);

    vTaskStartScheduler();

    for (;;)
    {
    }
}

int32_t ReadSensorHardware(void)
{
    return 0;
}

int32_t FilterSensorValue(int32_t value)
{
    return value;
}

void ProcessControlLogic(int32_t filtered_value, int32_t raw_value)
{
    (void)filtered_value;
    (void)raw_value;
}

void SystemInit(void)
{
}

void HardwareInit(void)
{
}