# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>
#include <memory>
#include <cstddef>
#include <chrono>

class Session {
public:
    using Clock = std::chrono::steady_clock;

    Session() : created_(Clock::now()), lastAccess_(created_), expired_(false) {}
    virtual ~Session() = default;

    void touch() { lastAccess_ = Clock::now(); }
    void expire() { expired_ = true; }

    bool isExpired(std::chrono::seconds timeout = std::chrono::seconds(1800)) const {
        if (expired_) return true;
        return (Clock::now() - lastAccess_) > timeout;
    }

private:
    Clock::time_point created_;
    Clock::time_point lastAccess_;
    bool expired_;
};

class SessionManager {
public:
    SessionManager() = default;
    ~SessionManager() { clear(); }

    void addSession(Session* session) {
        if (!session) return;
        sessions_.push_back(session);
    }

    bool removeSession(Session* session) {
        auto it = std::find(sessions_.begin(), sessions_.end(), session);
        if (it == sessions_.end()) return false;
        delete *it;
        sessions_.erase(it);
        return true;
    }

    Session* getSession(std::size_t index) {
        if (index >= sessions_.size()) return nullptr;
        return sessions_[index];
    }

    const Session* getSession(std::size_t index) const {
        if (index >= sessions_.size()) return nullptr;
        return sessions_[index];
    }

    std::size_t size() const {
        return sessions_.size();
    }

    void cleanupExpired(std::chrono::seconds timeout = std::chrono::seconds(1800)) {
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if (*it && (*it)->isExpired(timeout)) {
                delete *it;
                it = sessions_.erase(it);
            } else {
                ++it;
            }
        }
    }

    void clear() {
        for (Session* s : sessions_) {
            delete s;
        }
        sessions_.clear();
    }

private:
    std::vector<Session*> sessions_;
};