# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <mutex>
#include <atomic>
#include <chrono>
#include <thread>
#include <stdexcept>
#include <string>
#include <functional>

class Connection {
public:
    using Handle = std::size_t;

    Connection() : handle_(nextHandle()), connected_(false), failed_(false) {}

    explicit Connection(Handle h) : handle_(h), connected_(false), failed_(false) {}

    Handle handle() const { return handle_; }

    bool connect() {
        if (failed_) return false;
        connected_ = true;
        return true;
    }

    bool reconnect() {
        failed_ = false;
        connected_ = true;
        return true;
    }

    void disconnect() {
        connected_ = false;
    }

    bool send(const std::string& data) {
        if (!connected_ || failed_) return false;
        (void)data;
        return true;
    }

    void markFailed() {
        failed_ = true;
        connected_ = false;
    }

    bool isConnected() const { return connected_; }
    bool isFailed() const { return failed_; }

private:
    static Handle nextHandle() {
        static std::atomic<Handle> counter{1};
        return counter.fetch_add(1, std::memory_order_relaxed);
    }

    Handle handle_;
    bool connected_;
    bool failed_;
};

class ConnectionPool {
public:
    using Handle = Connection::Handle;

    explicit ConnectionPool(std::size_t initialSize = 0) {
        for (std::size_t i = 0; i < initialSize; ++i) {
            freeConnections_.push_back(std::make_shared<Connection>());
        }
    }

    std::shared_ptr<Connection> acquire() {
        std::lock_guard<std::mutex> lock(mutex_);
        if (!freeConnections_.empty()) {
            auto conn = freeConnections_.back();
            freeConnections_.pop_back();
            return conn;
        }
        return std::make_shared<Connection>();
    }

    void release(const std::shared_ptr<Connection>& conn) {
        if (!conn) return;
        std::lock_guard<std::mutex> lock(mutex_);
        conn->disconnect();
        freeConnections_.push_back(conn);
    }

    void freeOnError(const std::shared_ptr<Connection>& conn) {
        if (!conn) return;
        std::lock_guard<std::mutex> lock(mutex_);
        conn->markFailed();
        freeConnections_.push_back(conn);
    }

    std::shared_ptr<Connection> retryWithSameHandle(Handle handle) {
        std::lock_guard<std::mutex> lock(mutex_);
        auto conn = std::make_shared<Connection>(handle);
        conn->reconnect();
        return conn;
    }

    std::size_t size() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return freeConnections_.size();
    }

private:
    mutable std::mutex mutex_;
    std::vector<std::shared_ptr<Connection>> freeConnections_;
};

class NetworkClient {
public:
    explicit NetworkClient(std::size_t poolSize = 8)
        : pool_(poolSize) {}

    std::shared_ptr<Connection> getConnection() {
        auto conn = pool_.acquire();
        if (!conn->isConnected()) {
            if (!conn->connect()) {
                pool_.freeOnError(conn);
                throw std::runtime_error("connection failed");
            }
        }
        return conn;
    }

    bool send(const std::string& data) {
        return sendWithRetry(data, 1);
    }

    bool sendWithRetry(const std::string& data, int retries) {
        auto conn = getConnection();
        const auto handle = conn->handle();

        for (int attempt = 0; attempt <= retries; ++attempt) {
            if (conn->send(data)) {
                pool_.release(conn);
                return true;
            }

            pool_.freeOnError(conn);

            if (attempt == retries) {
                return false;
            }

            conn = pool_.retryWithSameHandle(handle);
        }

        return false;
    }

private:
    ConnectionPool pool_;
};

int main() {
    NetworkClient client(4);

    if (client.send("hello")) {
        std::cout << "send ok\n";
    } else {
        std::cout << "send failed\n";
    }

    if (client.sendWithRetry("world", 2)) {
        std::cout << "send with retry ok\n";
    } else {
        std::cout << "send with retry failed\n";
    }

    return 0;
}