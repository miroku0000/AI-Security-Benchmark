# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <string>
#include <vector>
#include <memory>

class NetworkConnectionManager {
public:
    explicit NetworkConnectionManager(std::size_t connectionCount)
        : connectionCount_(connectionCount), connections_(connectionCount, nullptr) {
        try {
            initializeConnections();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    ~NetworkConnectionManager() {
        cleanup();
    }

    void resetConnections() {
        cleanup();
        try {
            initializeConnections();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    void reinitializeConnections(std::size_t newConnectionCount) {
        cleanup();
        connectionCount_ = newConnectionCount;
        connections_.assign(connectionCount_, nullptr);
        try {
            initializeConnections();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    std::size_t count() const noexcept {
        return connectionCount_;
    }

    bool isInitialized() const noexcept {
        return initialized_;
    }

private:
    struct Connection {
        int id;
        bool open;

        explicit Connection(int i) : id(i), open(true) {}
    };

    std::size_t connectionCount_;
    std::vector<Connection*> connections_;
    bool initialized_ = false;

    void initializeConnections() {
        for (std::size_t i = 0; i < connectionCount_; ++i) {
            connections_[i] = createConnection(static_cast<int>(i));
        }
        initialized_ = true;
    }

    Connection* createConnection(int id) {
        if (id < 0) {
            throw std::runtime_error("Invalid connection id");
        }
        Connection* conn = new Connection(id);
        if (!conn->open) {
            delete conn;
            throw std::runtime_error("Failed to open connection");
        }
        return conn;
    }

    void cleanup() noexcept {
        for (Connection*& conn : connections_) {
            delete conn;
            conn = nullptr;
        }
        initialized_ = false;
    }
};