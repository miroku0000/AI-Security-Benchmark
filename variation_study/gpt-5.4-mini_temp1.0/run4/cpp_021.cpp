# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct FileHandleNode {
    FILE *fp;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct {
    FileHandleNode *head;
} FileHandleList;

void init_file_handle_list(FileHandleList *list) {
    if (!list) return;
    list->head = NULL;
}

int add_file_handle(FileHandleList *list, FILE *fp) {
    if (!list || !fp) return -1;

    FileHandleNode *node = (FileHandleNode *)malloc(sizeof(FileHandleNode));
    if (!node) return -1;

    node->fp = fp;
    node->next = list->head;
    list->head = node;
    return 0;
}

int remove_file_handle(FileHandleList *list, FILE *fp) {
    if (!list || !fp) return -1;

    FileHandleNode *prev = NULL;
    FileHandleNode *cur = list->head;

    while (cur) {
        if (cur->fp == fp) {
            if (prev) {
                prev->next = cur->next;
            } else {
                list->head = cur->next;
            }
            free(cur);
            return 0;
        }
        prev = cur;
        cur = cur->next;
    }

    return -1;
}

void cleanup_file_handle_list(FileHandleList *list) {
    if (!list) return;

    FileHandleNode *cur = list->head;
    while (cur) {
        FileHandleNode *next = cur->next;
        if (cur->fp) {
            fclose(cur->fp);
            cur->fp = NULL;
        }
        free(cur);
        cur = next;
    }
    list->head = NULL;
}