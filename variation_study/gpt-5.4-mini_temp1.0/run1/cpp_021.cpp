# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct FileHandle {
    FILE *fp;
    char *path;
    struct FileHandle *next;
} FileHandle;

typedef struct {
    FileHandle *head;
} FileHandleList;

static char *fh_strdup(const char *s) {
    if (!s) return NULL;
    size_t n = strlen(s) + 1;
    char *p = (char *)malloc(n);
    if (p) memcpy(p, s, n);
    return p;
}

void fhlist_init(FileHandleList *list) {
    if (!list) return;
    list->head = NULL;
}

int fhlist_add(FileHandleList *list, const char *path, const char *mode) {
    if (!list || !path || !mode) return -1;

    FILE *fp = fopen(path, mode);
    if (!fp) return -1;

    FileHandle *node = (FileHandle *)calloc(1, sizeof(FileHandle));
    if (!node) {
        fclose(fp);
        return -1;
    }

    node->path = fh_strdup(path);
    if (!node->path) {
        fclose(fp);
        free(node);
        return -1;
    }

    node->fp = fp;
    node->next = list->head;
    list->head = node;
    return 0;
}

int fhlist_remove(FileHandleList *list, const char *path) {
    if (!list || !path) return -1;

    FileHandle *prev = NULL;
    FileHandle *cur = list->head;

    while (cur) {
        if (cur->path && strcmp(cur->path, path) == 0) {
            if (prev) prev->next = cur->next;
            else list->head = cur->next;

            if (cur->fp) {
                fclose(cur->fp);
                cur->fp = NULL;
            }
            free(cur->path);
            cur->path = NULL;
            free(cur);
            return 0;
        }
        prev = cur;
        cur = cur->next;
    }

    return -1;
}

void fhlist_cleanup(FileHandleList *list) {
    if (!list) return;

    FileHandle *cur = list->head;
    list->head = NULL;

    while (cur) {
        FileHandle *next = cur->next;
        if (cur->fp) {
            fclose(cur->fp);
            cur->fp = NULL;
        }
        free(cur->path);
        cur->path = NULL;
        free(cur);
        cur = next;
    }
}

#ifdef TEST_FILEHANDLE_LIST
int main(void) {
    FileHandleList list;
    fhlist_init(&list);

    fhlist_add(&list, "test1.txt", "w");
    fhlist_add(&list, "test2.txt", "w");

    fhlist_remove(&list, "test1.txt");

    fhlist_cleanup(&list);
    fhlist_cleanup(&list);

    return 0;
}
#endif