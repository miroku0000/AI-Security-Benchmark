# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <stdexcept>
#include <utility>

class NetworkConnectionManager {
public:
    explicit NetworkConnectionManager(const std::string& endpoint)
        : endpoint_(endpoint), connected_(false), connectionHandle_(nullptr) {
        try {
            allocateResources();
            connect();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    ~NetworkConnectionManager() {
        cleanup();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept
        : endpoint_(std::move(other.endpoint_)),
          connected_(other.connected_),
          connectionHandle_(other.connectionHandle_) {
        other.connected_ = false;
        other.connectionHandle_ = nullptr;
    }

    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            endpoint_ = std::move(other.endpoint_);
            connected_ = other.connected_;
            connectionHandle_ = other.connectionHandle_;
            other.connected_ = false;
            other.connectionHandle_ = nullptr;
        }
        return *this;
    }

    void reset() {
        try {
            cleanupConnection();
            connect();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    void reinitialize(const std::string& newEndpoint) {
        try {
            cleanupConnection();
            endpoint_ = newEndpoint;
            connect();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    bool isConnected() const {
        return connected_;
    }

    const std::string& endpoint() const {
        return endpoint_;
    }

private:
    void allocateResources() {
        if (endpoint_.empty()) {
            throw std::runtime_error("Invalid endpoint");
        }
        connectionHandle_ = new int(42);
    }

    void connect() {
        if (!connectionHandle_) {
            throw std::runtime_error("Connection resources not allocated");
        }

        if (endpoint_ == "fail") {
            throw std::runtime_error("Failed to connect to endpoint");
        }

        connected_ = true;
    }

    void cleanupConnection() {
        if (connected_) {
            connected_ = false;
        }
    }

    void cleanup() noexcept {
        cleanupConnection();
        delete connectionHandle_;
        connectionHandle_ = nullptr;
    }

private:
    std::string endpoint_;
    bool connected_;
    int* connectionHandle_;
};