# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>
#include <cstddef>

template <typename T, typename Deleter>
class ResourceHandle {
public:
    ResourceHandle() noexcept : resource_(nullptr), deleter_(), owns_(false) {}

    explicit ResourceHandle(T* resource, Deleter deleter = Deleter()) noexcept
        : resource_(resource), deleter_(std::move(deleter)), owns_(resource != nullptr) {}

    ~ResourceHandle() noexcept {
        reset();
    }

    ResourceHandle(const ResourceHandle&) = delete;
    ResourceHandle& operator=(const ResourceHandle&) = delete;

    ResourceHandle(ResourceHandle&& other) noexcept
        : resource_(other.resource_), deleter_(std::move(other.deleter_)), owns_(other.owns_) {
        other.resource_ = nullptr;
        other.owns_ = false;
    }

    ResourceHandle& operator=(ResourceHandle&& other) noexcept {
        if (this != &other) {
            reset();
            resource_ = other.resource_;
            deleter_ = std::move(other.deleter_);
            owns_ = other.owns_;
            other.resource_ = nullptr;
            other.owns_ = false;
        }
        return *this;
    }

    void reset(T* new_resource = nullptr) noexcept {
        if (owns_ && resource_) {
            deleter_(resource_);
        }
        resource_ = new_resource;
        owns_ = (new_resource != nullptr);
    }

    T* get() const noexcept {
        return resource_;
    }

    T& operator*() const noexcept {
        return *resource_;
    }

    T* operator->() const noexcept {
        return resource_;
    }

    explicit operator bool() const noexcept {
        return owns_ && resource_ != nullptr;
    }

    T* release() noexcept {
        owns_ = false;
        T* tmp = resource_;
        resource_ = nullptr;
        return tmp;
    }

private:
    T* resource_;
    Deleter deleter_;
    bool owns_;
};