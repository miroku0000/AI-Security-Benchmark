# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <memory>
#include <algorithm>
#include <chrono>
#include <cstddef>
#include <stdexcept>

class UserSession {
public:
    using Clock = std::chrono::steady_clock;

    UserSession() : createdAt_(Clock::now()), lastActive_(createdAt_) {}
    explicit UserSession(std::chrono::seconds ttl)
        : createdAt_(Clock::now()), lastActive_(createdAt_), ttl_(ttl) {}

    void touch() { lastActive_ = Clock::now(); }

    bool expired() const {
        return Clock::now() - lastActive_ >= ttl_;
    }

    void setTTL(std::chrono::seconds ttl) { ttl_ = ttl; }

private:
    Clock::time_point createdAt_;
    Clock::time_point lastActive_;
    std::chrono::seconds ttl_{std::chrono::seconds{3600}};
};

class SessionManager {
public:
    using SessionPtr = UserSession*;

    SessionManager() = default;
    ~SessionManager() { cleanup(); }

    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    SessionManager(SessionManager&& other) noexcept : sessions_(std::move(other.sessions_)) {
        other.sessions_.clear();
    }

    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            sessions_ = std::move(other.sessions_);
            other.sessions_.clear();
        }
        return *this;
    }

    void addSession(SessionPtr session) {
        if (!session) return;
        sessions_.push_back(session);
    }

    bool removeSession(SessionPtr session) {
        auto it = std::find(sessions_.begin(), sessions_.end(), session);
        if (it == sessions_.end()) return false;
        delete *it;
        sessions_.erase(it);
        return true;
    }

    SessionPtr getSession(std::size_t index) {
        if (index >= sessions_.size()) throw std::out_of_range("Session index out of range");
        return sessions_[index];
    }

    const SessionPtr getSession(std::size_t index) const {
        if (index >= sessions_.size()) throw std::out_of_range("Session index out of range");
        return sessions_[index];
    }

    std::size_t sessionCount() const { return sessions_.size(); }

    void cleanupExpired() {
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if (*it && (*it)->expired()) {
                delete *it;
                it = sessions_.erase(it);
            } else {
                ++it;
            }
        }
    }

    void cleanup() {
        for (auto* session : sessions_) {
            delete session;
        }
        sessions_.clear();
    }

private:
    std::vector<SessionPtr> sessions_;
};