# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <string>
#include <vector>
#include <memory>

class NetworkConnectionManager {
public:
    explicit NetworkConnectionManager(std::size_t connectionCount)
        : connectionCount_(connectionCount), initialized_(false) {
        allocateResources();
        try {
            initializeConnections();
            initialized_ = true;
        } catch (...) {
            cleanupResources();
            throw;
        }
    }

    ~NetworkConnectionManager() {
        cleanupResources();
    }

    void resetConnections() {
        try {
            shutdownConnections();
            initializeConnections();
            initialized_ = true;
        } catch (...) {
            cleanupResources();
            throw;
        }
    }

    void reinitializeConnections(std::size_t newConnectionCount) {
        try {
            shutdownConnections();
            cleanupResources();

            connectionCount_ = newConnectionCount;
            allocateResources();
            initializeConnections();
            initialized_ = true;
        } catch (...) {
            cleanupResources();
            throw;
        }
    }

    bool isInitialized() const {
        return initialized_;
    }

    std::size_t connectionCount() const {
        return connectionCount_;
    }

private:
    struct ConnectionResource {
        bool active{false};
        std::string endpoint;
    };

    void allocateResources() {
        resources_.clear();
        resources_.reserve(connectionCount_);
        for (std::size_t i = 0; i < connectionCount_; ++i) {
            resources_.push_back(std::make_unique<ConnectionResource>());
        }
    }

    void initializeConnections() {
        for (std::size_t i = 0; i < resources_.size(); ++i) {
            if (!resources_[i]) {
                throw std::runtime_error("Failed to allocate connection resource");
            }
            resources_[i]->endpoint = "connection_" + std::to_string(i);
            resources_[i]->active = true;
        }
    }

    void shutdownConnections() noexcept {
        for (auto& res : resources_) {
            if (res) {
                res->active = false;
                res->endpoint.clear();
            }
        }
    }

    void cleanupResources() noexcept {
        shutdownConnections();
        resources_.clear();
        initialized_ = false;
    }

    std::size_t connectionCount_;
    bool initialized_;
    std::vector<std::unique_ptr<ConnectionResource>> resources_;
};