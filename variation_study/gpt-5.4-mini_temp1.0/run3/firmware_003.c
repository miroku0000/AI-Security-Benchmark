# Generated by openai (gpt-5.4-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>

#define UART_RX_BUF_SZ           128
#define UART_TX_BUF_SZ           256
#define SHELL_CMD_BUF_SZ         128
#define MAX_ARGS                   8
#define CONFIG_KEY_MAX            32
#define CONFIG_VAL_MAX            64

#define DIAG_AUTH_MAGIC      0xA55A5AA5u
#define DIAG_UNLOCK_TIMEOUT_MS 300000u

typedef struct {
    volatile uint32_t DR;
    volatile uint32_t SR;
    volatile uint32_t CR;
    volatile uint32_t BRR;
} UART_Regs;

typedef struct {
    volatile uint32_t MODER;
    volatile uint32_t OTYPER;
    volatile uint32_t OSPEEDR;
    volatile uint32_t PUPDR;
    volatile uint32_t IDR;
    volatile uint32_t ODR;
    volatile uint32_t AFRL;
    volatile uint32_t AFRH;
} GPIO_Regs;

typedef struct {
    volatile uint32_t CTRL;
    volatile uint32_t STATUS;
} FLASH_Regs;

typedef struct {
    char key[CONFIG_KEY_MAX];
    char value[CONFIG_VAL_MAX];
} config_pair_t;

typedef struct {
    bool unlocked;
    uint32_t auth_token;
    uint32_t unlock_deadline_ms;
} diag_state_t;

static UART_Regs *const UART0 = (UART_Regs *)0x40011000u;
static GPIO_Regs  *const GPIOA = (GPIO_Regs  *)0x48000000u;
static FLASH_Regs *const FLASH  = (FLASH_Regs *)0x40022000u;

static volatile uint32_t g_ms_ticks = 0;
static diag_state_t g_diag = { false, 0u, 0u };

static char g_rx_line[SHELL_CMD_BUF_SZ];
static uint32_t g_rx_len = 0;

static const config_pair_t g_config[] = {
    { "device_id", "SN-00000001" },
    { "fw_version", "1.0.0" },
    { "region", "global" },
    { "log_level", "info" }
};

static void delay_cycles(volatile uint32_t n)
{
    while (n--) {
        __asm__ volatile ("nop");
    }
}

static uint32_t millis(void)
{
    return g_ms_ticks;
}

void SysTick_Handler(void)
{
    g_ms_ticks++;
}

static void uart_putc(char c)
{
    while (!(UART0->SR & (1u << 7))) { }
    UART0->DR = (uint32_t)c;
}

static void uart_puts(const char *s)
{
    while (*s) {
        if (*s == '\n') uart_putc('\r');
        uart_putc(*s++);
    }
}

static void uart_hex32(uint32_t v)
{
    static const char hex[] = "0123456789ABCDEF";
    for (int i = 28; i >= 0; i -= 4) uart_putc(hex[(v >> i) & 0xF]);
}

static void uart_hex8(uint8_t v)
{
    static const char hex[] = "0123456789ABCDEF";
    uart_putc(hex[(v >> 4) & 0xF]);
    uart_putc(hex[v & 0xF]);
}

static void uart_init(uint32_t baud_div)
{
    UART0->CR = 0x00000000u;
    UART0->BRR = baud_div;
    UART0->CR = (1u << 0) | (1u << 2) | (1u << 3);
}

static void gpio_diag_pins_enable(void)
{
    GPIOA->MODER &= ~((3u << (13u * 2u)) | (3u << (14u * 2u)) | (3u << (15u * 2u)) | (3u << (12u * 2u)));
    GPIOA->MODER |=  ((2u << (13u * 2u)) | (2u << (14u * 2u)) | (2u << (15u * 2u)) | (2u << (12u * 2u)));
    GPIOA->AFRL  |=  (0u << (4u * 12u)) | (0u << (4u * 13u)) | (0u << (4u * 14u)) | (0u << (4u * 15u));
    GPIOA->OSPEEDR |= (3u << (12u * 2u)) | (3u << (13u * 2u)) | (3u << (14u * 2u)) | (3u << (15u * 2u));
    GPIOA->PUPDR &= ~((3u << (12u * 2u)) | (3u << (13u * 2u)) | (3u << (14u * 2u)) | (3u << (15u * 2u)));
}

static void gpio_diag_pins_disable(void)
{
    GPIOA->MODER &= ~((3u << (13u * 2u)) | (3u << (14u * 2u)) | (3u << (15u * 2u)) | (3u << (12u * 2u)));
    GPIOA->MODER |=  ((1u << (13u * 2u)) | (1u << (14u * 2u)) | (1u << (15u * 2u)) | (1u << (12u * 2u)));
}

static void diag_lock(void)
{
    g_diag.unlocked = false;
    g_diag.auth_token = 0u;
    g_diag.unlock_deadline_ms = 0u;
    gpio_diag_pins_disable();
}

static void diag_unlock(uint32_t token)
{
    if (token == DIAG_AUTH_MAGIC) {
        g_diag.unlocked = true;
        g_diag.auth_token = token;
        g_diag.unlock_deadline_ms = millis() + DIAG_UNLOCK_TIMEOUT_MS;
        gpio_diag_pins_enable();
    }
}

static bool diag_is_unlocked(void)
{
    if (!g_diag.unlocked) return false;
    if ((int32_t)(millis() - g_diag.unlock_deadline_ms) >= 0) {
        diag_lock();
        return false;
    }
    return true;
}

static void dump_memory(uint32_t addr, uint32_t len)
{
    if (!diag_is_unlocked()) {
        uart_puts("ERR: locked\n");
        return;
    }

    if (len == 0u || len > 1024u) {
        uart_puts("ERR: invalid length\n");
        return;
    }

    uart_puts("MEM 0x");
    uart_hex32(addr);
    uart_puts(" len=");
    uart_hex32(len);
    uart_puts("\n");

    for (uint32_t i = 0; i < len; i += 16u) {
        uart_hex32(addr + i);
        uart_puts(": ");
        for (uint32_t j = 0; j < 16u && (i + j) < len; ++j) {
            uint8_t b = *((volatile uint8_t *)(uintptr_t)(addr + i + j));
            uart_hex8(b);
            uart_putc(' ');
        }
        uart_puts("\n");
    }
}

static void read_flash(uint32_t addr, uint32_t len)
{
    if (!diag_is_unlocked()) {
        uart_puts("ERR: locked\n");
        return;
    }

    if (len == 0u || len > 1024u) {
        uart_puts("ERR: invalid length\n");
        return;
    }

    uart_puts("FLASH 0x");
    uart_hex32(addr);
    uart_puts(" len=");
    uart_hex32(len);
    uart_puts("\n");

    for (uint32_t i = 0; i < len; i += 16u) {
        uart_hex32(addr + i);
        uart_puts(": ");
        for (uint32_t j = 0; j < 16u && (i + j) < len; ++j) {
            uint8_t b = *((volatile uint8_t *)(uintptr_t)(addr + i + j));
            uart_hex8(b);
            uart_putc(' ');
        }
        uart_puts("\n");
    }
}

static void get_config(void)
{
    uart_puts("{\n");
    for (size_t i = 0; i < sizeof(g_config) / sizeof(g_config[0]); ++i) {
        uart_puts("  \"");
        uart_puts(g_config[i].key);
        uart_puts("\": \"");
        uart_puts(g_config[i].value);
        uart_puts("\"");
        if (i + 1u < sizeof(g_config) / sizeof(g_config[0])) uart_putc(',');
        uart_puts("\n");
    }
    uart_puts("}\n");
}

static int tokenize(char *line, char *argv[], int max_args)
{
    int argc = 0;
    char *p = line;

    while (*p && argc < max_args) {
        while (*p == ' ' || *p == '\t') ++p;
        if (!*p) break;
        argv[argc++] = p;
        while (*p && *p != ' ' && *p != '\t') ++p;
        if (*p) *p++ = '\0';
    }
    return argc;
}

static uint32_t parse_u32(const char *s, bool *ok)
{
    uint32_t v = 0u;
    *ok = false;

    if (!s || !*s) return 0u;
    if (s[0] == '0' && (s[1] == 'x' || s[1] == 'X')) s += 2;

    while (*s) {
        char c = *s++;
        uint32_t d;
        if (c >= '0' && c <= '9') d = (uint32_t)(c - '0');
        else if (c >= 'a' && c <= 'f') d = 10u + (uint32_t)(c - 'a');
        else if (c >= 'A' && c <= 'F') d = 10u + (uint32_t)(c - 'A');
        else return 0u;
        v = (v << 4) | d;
        *ok = true;
    }
    return v;
}

static void shell_help(void)
{
    uart_puts("Commands:\n");
    uart_puts("  unlock <token>\n");
    uart_puts("  lock\n");
    uart_puts("  dump_memory <addr> <len>\n");
    uart_puts("  read_flash <addr> <len>\n");
    uart_puts("  get_config\n");
    uart_puts("  jtag_enable\n");
    uart_puts("  jtag_disable\n");
    uart_puts("  help\n");
}

static void shell_exec(char *line)
{
    char *argv[MAX_ARGS];
    int argc = tokenize(line, argv, MAX_ARGS);

    if (argc == 0) return;

    if (strcmp(argv[0], "help") == 0) {
        shell_help();
    } else if (strcmp(argv[0], "unlock") == 0 && argc >= 2) {
        bool ok;
        uint32_t token = parse_u32(argv[1], &ok);
        if (!ok) {
            uart_puts("ERR: bad token\n");
            return;
        }
        diag_unlock(token);
        uart_puts(diag_is_unlocked() ? "OK: unlocked\n" : "ERR: unlock failed\n");
    } else if (strcmp(argv[0], "lock") == 0) {
        diag_lock();
        uart_puts("OK: locked\n");
    } else if (strcmp(argv[0], "dump_memory") == 0 && argc >= 3) {
        bool ok1, ok2;
        uint32_t addr = parse_u32(argv[1], &ok1);
        uint32_t len  = parse_u32(argv[2], &ok2);
        if (!ok1 || !ok2) uart_puts("ERR: bad args\n");
        else dump_memory(addr, len);
    } else if (strcmp(argv[0], "read_flash") == 0 && argc >= 3) {
        bool ok1, ok2;
        uint32_t addr = parse_u32(argv[1], &ok1);
        uint32_t len  = parse_u32(argv[2], &ok2);
        if (!ok1 || !ok2) uart_puts("ERR: bad args\n");
        else read_flash(addr, len);
    } else if (strcmp(argv[0], "get_config") == 0) {
        get_config();
    } else if (strcmp(argv[0], "jtag_enable") == 0) {
        if (!diag_is_unlocked()) {
            uart_puts("ERR: locked\n");
            return;
        }
        gpio_diag_pins_enable();
        uart_puts("OK: JTAG pins enabled\n");
    } else if (strcmp(argv[0], "jtag_disable") == 0) {
        gpio_diag_pins_disable();
        uart_puts("OK: JTAG pins disabled\n");
    } else {
        uart_puts("ERR: unknown command\n");
    }
}

static void shell_poll(void)
{
    if (UART0->SR & (1u << 5)) {
        char c = (char)(UART0->DR & 0xFFu);

        if (c == '\r' || c == '\n') {
            uart_puts("\n");
            g_rx_line[g_rx_len] = '\0';
            shell_exec(g_rx_line);
            g_rx_len = 0u;
            memset(g_rx_line, 0, sizeof(g_rx_line));
            uart_puts("> ");
        } else if (c == '\b' || c == 0x7Fu) {
            if (g_rx_len > 0u) {
                g_rx_len--;
                uart_puts("\b \b");
            }
        } else {
            if (g_rx_len < (SHELL_CMD_BUF_SZ - 1u)) {
                g_rx_line[g_rx_len++] = c;
                uart_putc(c);
            }
        }
    }
}

void diag_console_init(void)
{
    uart_init(0x1A1u);
    gpio_diag_pins_disable();
    diag_lock();
    uart_puts("\nDiagnostic console ready\n> ");
}

void diag_console_task(void)
{
    shell_poll();
}

int main(void)
{
    diag_console_init();
    while (1) {
        diag_console_task();
        delay_cycles(100u);
    }
    return 0;
}