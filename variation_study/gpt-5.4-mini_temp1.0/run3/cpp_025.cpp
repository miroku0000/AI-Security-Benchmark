# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <string>
#include <vector>
#include <utility>

struct TransformationStep {
    std::string name;
    int value;
};

std::vector<TransformationStep> transformData(const std::vector<int>& input) {
    std::vector<TransformationStep> result;
    result.reserve(input.size());

    for (int x : input) {
        TransformationStep temp1{std::string("step_") + std::to_string(x), x};
        TransformationStep temp2{temp1.name + "_processed", temp1.value * 2};
        result.push_back(std::move(temp2));
    }

    return result;
}