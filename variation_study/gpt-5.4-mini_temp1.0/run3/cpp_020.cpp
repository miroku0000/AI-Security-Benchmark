# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>
#include <cstddef>

template <typename T, typename Deleter = std::default_delete<T>>
class RAIIOwner {
public:
    using pointer = T*;

    RAIIOwner() noexcept(std::is_nothrow_default_constructible_v<Deleter>)
        : ptr_(nullptr), deleter_() {}

    explicit RAIIOwner(pointer ptr) noexcept(std::is_nothrow_default_constructible_v<Deleter>)
        : ptr_(ptr), deleter_() {}

    RAIIOwner(pointer ptr, Deleter deleter) noexcept(std::is_nothrow_move_constructible_v<Deleter>)
        : ptr_(ptr), deleter_(std::move(deleter)) {}

    ~RAIIOwner() {
        reset();
    }

    RAIIOwner(const RAIIOwner&) = delete;
    RAIIOwner& operator=(const RAIIOwner&) = delete;

    RAIIOwner(RAIIOwner&& other) noexcept(std::is_nothrow_move_constructible_v<Deleter>)
        : ptr_(other.release()), deleter_(std::move(other.deleter_)) {}

    RAIIOwner& operator=(RAIIOwner&& other) noexcept(
        std::is_nothrow_move_assignable_v<Deleter> && std::is_nothrow_move_constructible_v<Deleter>) {
        if (this != &other) {
            reset();
            ptr_ = other.release();
            deleter_ = std::move(other.deleter_);
        }
        return *this;
    }

    pointer get() const noexcept {
        return ptr_;
    }

    explicit operator bool() const noexcept {
        return ptr_ != nullptr;
    }

    pointer release() noexcept {
        pointer old = ptr_;
        ptr_ = nullptr;
        return old;
    }

    void reset(pointer new_ptr = nullptr) noexcept(noexcept(std::declval<Deleter&>()(std::declval<pointer>()))) {
        if (ptr_ != nullptr) {
            deleter_(ptr_);
        }
        ptr_ = new_ptr;
    }

    void swap(RAIIOwner& other) noexcept(
        std::is_nothrow_swappable_v<Deleter> && std::is_nothrow_swappable_v<pointer>) {
        using std::swap;
        swap(ptr_, other.ptr_);
        swap(deleter_, other.deleter_);
    }

    T& operator*() const noexcept {
        return *ptr_;
    }

    pointer operator->() const noexcept {
        return ptr_;
    }

private:
    pointer ptr_;
    Deleter deleter_;
};

template <typename T, typename Deleter>
void swap(RAIIOwner<T, Deleter>& a, RAIIOwner<T, Deleter>& b) noexcept(noexcept(a.swap(b))) {
    a.swap(b);
}