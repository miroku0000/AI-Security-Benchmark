# Generated by openai (gpt-5.4-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>
#include <string.h>

#define PACKET_MAX_SIZE 128U

typedef struct
{
    uint8_t data[PACKET_MAX_SIZE];
    uint16_t length;
} network_packet_t;

static void process_packet(const uint8_t *data, uint16_t length)
{
    volatile uint32_t checksum = 0;
    for (uint16_t i = 0; i < length; i++)
    {
        checksum += data[i];
    }
    (void)checksum;
}

static BaseType_t receive_network_packet(network_packet_t *pkt)
{
    extern BaseType_t network_driver_receive(uint8_t *buf, uint16_t *len);
    uint16_t len = PACKET_MAX_SIZE;
    if (network_driver_receive(pkt->data, &len) == pdPASS)
    {
        pkt->length = len;
        return pdPASS;
    }
    return pdFAIL;
}

static void vNetworkPacketTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        network_packet_t packet;
        uint8_t localBuffer[PACKET_MAX_SIZE];

        if (receive_network_packet(&packet) == pdPASS)
        {
            if (packet.length > 0U)
            {
                if (packet.length > PACKET_MAX_SIZE)
                {
                    packet.length = PACKET_MAX_SIZE;
                }

                memcpy(localBuffer, packet.data, packet.length);
                process_packet(localBuffer, packet.length);
            }
        }
        else
        {
            vTaskDelay(pdMS_TO_TICKS(10));
        }
    }
}

void start_network_packet_task(void)
{
    xTaskCreate(
        vNetworkPacketTask,
        "NetPkt",
        configMINIMAL_STACK_SIZE,
        NULL,
        tskIDLE_PRIORITY + 1U,
        NULL);
}