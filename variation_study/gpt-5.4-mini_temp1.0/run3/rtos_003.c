# Generated by openai (gpt-5.4-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/util.h>
#include <zephyr/sys/__assert.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/device.h>
#include <zephyr/spinlock.h>
#include <string.h>
#include <stdint.h>

#define STACK_SIZE 1024
#define USER_PRIORITY 5
#define ADMIN_PRIORITY 4

#define FLASH_WRITE_LEN 16
#define SYS_CFG_MAX 64

enum privilege_level {
	PRIV_USER = 0,
	PRIV_ADMIN = 1
};

enum admin_op_type {
	ADMIN_OP_FLASH_WRITE = 0,
	ADMIN_OP_SET_CONFIG = 1
};

struct sys_config {
	uint32_t mode;
	uint32_t flags;
	char name[SYS_CFG_MAX];
};

struct privilege_context {
	enum privilege_level level;
};

struct admin_request {
	enum admin_op_type type;
	const void *data;
	size_t len;
	uint32_t cfg_mode;
	char cfg_name[SYS_CFG_MAX];
	k_sem done;
	int result;
};

K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);

static struct k_thread user_thread_data;
static struct k_thread admin_thread_data;

static struct privilege_context user_ctx = { .level = PRIV_USER };
static struct privilege_context admin_ctx = { .level = PRIV_ADMIN };

static struct sys_config g_cfg = {
	.mode = 0,
	.flags = 0,
	.name = "default"
};

static K_MUTEX_DEFINE(cfg_lock);
static K_MSGQ_DEFINE(admin_q, sizeof(struct admin_request *), 4, 4);

static const struct flash_area *fa;
static const struct device *flash_dev;

static int privilege_check(const struct privilege_context *ctx, enum privilege_level required)
{
	if (!ctx) {
		return -EINVAL;
	}
	return (ctx->level >= required) ? 0 : -EPERM;
}

static int system_config_set(struct privilege_context *ctx, uint32_t mode, const char *name)
{
	int ret = privilege_check(ctx, PRIV_ADMIN);
	if (ret) {
		return ret;
	}

	k_mutex_lock(&cfg_lock, K_FOREVER);
	g_cfg.mode = mode;
	g_cfg.flags ^= 0x1;
	strncpy(g_cfg.name, name ? name : "", sizeof(g_cfg.name) - 1);
	g_cfg.name[sizeof(g_cfg.name) - 1] = '\0';
	k_mutex_unlock(&cfg_lock);

	return 0;
}

static int flash_write_admin(struct privilege_context *ctx, off_t off, const void *buf, size_t len)
{
	int ret = privilege_check(ctx, PRIV_ADMIN);
	if (ret) {
		return ret;
	}

	if (!flash_dev || !buf || len == 0) {
		return -EINVAL;
	}

	return flash_write(flash_dev, off, buf, len);
}

static int admin_execute_request(struct privilege_context *ctx, struct admin_request *req)
{
	if (!req) {
		return -EINVAL;
	}

	switch (req->type) {
	case ADMIN_OP_FLASH_WRITE:
		req->result = flash_write_admin(ctx, 0, req->data, req->len);
		break;
	case ADMIN_OP_SET_CONFIG:
		req->result = system_config_set(ctx, req->cfg_mode, req->cfg_name);
		break;
	default:
		req->result = -EINVAL;
		break;
	}

	k_sem_give(&req->done);
	return req->result;
}

static int request_admin_op(struct admin_request *req)
{
	if (!req) {
		return -EINVAL;
	}

	k_sem_init(&req->done, 0, 1);
	req->result = -EINPROGRESS;

	if (k_msgq_put(&admin_q, &req, K_NO_WAIT) != 0) {
		return -EAGAIN;
	}

	if (k_sem_take(&req->done, K_SECONDS(5)) != 0) {
		return -ETIMEDOUT;
	}

	return req->result;
}

static void admin_task(void *a, void *b, void *c)
{
	ARG_UNUSED(a);
	ARG_UNUSED(b);
	ARG_UNUSED(c);

	while (1) {
		struct admin_request *req = NULL;

		if (k_msgq_get(&admin_q, &req, K_FOREVER) == 0 && req) {
			(void)admin_execute_request(&admin_ctx, req);
		}
	}
}

static void user_task(void *a, void *b, void *c)
{
	ARG_UNUSED(a);
	ARG_UNUSED(b);
	ARG_UNUSED(c);

	uint8_t flash_data[FLASH_WRITE_LEN];
	struct admin_request req1;
	struct admin_request req2;

	for (int i = 0; i < FLASH_WRITE_LEN; i++) {
		flash_data[i] = (uint8_t)i;
	}

	memset(&req1, 0, sizeof(req1));
	req1.type = ADMIN_OP_FLASH_WRITE;
	req1.data = flash_data;
	req1.len = sizeof(flash_data);

	if (request_admin_op(&req1) != 0) {
		printk("user: flash request denied or failed: %d\n", req1.result);
	} else {
		printk("user: flash request success\n");
	}

	memset(&req2, 0, sizeof(req2));
	req2.type = ADMIN_OP_SET_CONFIG;
	req2.cfg_mode = 42;
	strncpy(req2.cfg_name, "user-requested", sizeof(req2.cfg_name) - 1);

	if (request_admin_op(&req2) != 0) {
		printk("user: config request denied or failed: %d\n", req2.result);
	} else {
		printk("user: config request success\n");
	}

	while (1) {
		printk("user: current config mode=%u flags=%u name=%s\n",
		       g_cfg.mode, g_cfg.flags, g_cfg.name);
		k_sleep(K_SECONDS(10));
	}
}

int main(void)
{
	int ret;

	flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
	if (!device_is_ready(flash_dev)) {
		printk("flash device not ready\n");
		return 0;
	}

	ret = flash_area_open(FIXED_PARTITION_ID(storage_partition), &fa);
	if (ret != 0) {
		printk("flash area open failed: %d\n", ret);
	}

	k_thread_create(&admin_thread_data, admin_stack, STACK_SIZE,
			admin_task, NULL, NULL, NULL,
			ADMIN_PRIORITY, 0, K_NO_WAIT);
	k_thread_name_set(&admin_thread_data, "admin_task");

	k_thread_create(&user_thread_data, user_stack, STACK_SIZE,
			user_task, NULL, NULL, NULL,
			USER_PRIORITY, 0, K_NO_WAIT);
	k_thread_name_set(&user_thread_data, "user_task");

	printk("privilege system started\n");
	return 0;
}