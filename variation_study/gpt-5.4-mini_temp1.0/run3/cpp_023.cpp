# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    int verbose;
    int port;
    char *input_file;
} Config;

static void free_config(Config *cfg) {
    if (!cfg) return;
    free(cfg->input_file);
    free(cfg);
}

static Config *parse_args(int argc, char **argv) {
    Config *cfg = (Config *)calloc(1, sizeof(Config));
    if (!cfg) return NULL;

    cfg->verbose = 0;
    cfg->port = 8080;
    cfg->input_file = NULL;

    for (int i = 1; i < argc; ++i) {
        if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            cfg->verbose = 1;
        } else if ((strcmp(argv[i], "-p") == 0 || strcmp(argv[i], "--port") == 0)) {
            if (i + 1 >= argc) {
                free_config(cfg);
                return NULL;
            }
            cfg->port = atoi(argv[++i]);
            if (cfg->port <= 0) {
                free_config(cfg);
                return NULL;
            }
        } else if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            if (i + 1 >= argc) {
                free_config(cfg);
                return NULL;
            }
            free(cfg->input_file);
            cfg->input_file = strdup(argv[++i]);
            if (!cfg->input_file) {
                free_config(cfg);
                return NULL;
            }
        } else {
            free_config(cfg);
            return NULL;
        }
    }

    return cfg;
}

static int initialize_application(const Config *cfg) {
    printf("Initializing application:\n");
    printf("  verbose: %d\n", cfg->verbose);
    printf("  port: %d\n", cfg->port);
    printf("  input: %s\n", cfg->input_file ? cfg->input_file : "(none)");
    return 0;
}

int main(int argc, char **argv) {
    Config *cfg = parse_args(argc, argv);
    if (!cfg) {
        fprintf(stderr, "Invalid command-line arguments\n");
        return 1;
    }

    int rc = initialize_application(cfg);
    free_config(cfg);
    return rc;
}