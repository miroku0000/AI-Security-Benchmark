# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <mutex>
#include <thread>
#include <chrono>
#include <atomic>
#include <functional>
#include <stdexcept>
#include <string>

class Connection {
public:
    explicit Connection(int id = -1) : id_(id), connected_(false), failed_(false) {}

    int id() const { return id_; }
    bool connected() const { return connected_; }
    bool failed() const { return failed_; }

    bool connect() {
        failed_ = false;
        connected_ = true;
        return true;
    }

    void disconnect() {
        connected_ = false;
    }

    bool send(const std::string& data) {
        if (!connected_ || failed_) return false;
        (void)data;
        return true;
    }

    void markFailed() {
        failed_ = true;
        connected_ = false;
    }

private:
    int id_;
    bool connected_;
    bool failed_;
};

class ConnectionPool {
public:
    explicit ConnectionPool(std::size_t capacity) : capacity_(capacity), nextId_(0) {}

    std::shared_ptr<Connection> acquire() {
        std::lock_guard<std::mutex> lock(mutex_);
        if (!free_.empty()) {
            auto conn = free_.back();
            free_.pop_back();
            return conn;
        }
        if (all_.size() < capacity_) {
            auto conn = std::make_shared<Connection>(static_cast<int>(nextId_++));
            all_.push_back(conn);
            return conn;
        }
        return nullptr;
    }

    void release(const std::shared_ptr<Connection>& conn) {
        if (!conn) return;
        std::lock_guard<std::mutex> lock(mutex_);
        if (conn->failed()) return;
        free_.push_back(conn);
    }

    void freeOnError(const std::shared_ptr<Connection>& conn) {
        if (!conn) return;
        std::lock_guard<std::mutex> lock(mutex_);
        conn->disconnect();
    }

private:
    std::size_t capacity_;
    std::atomic<std::size_t> nextId_;
    std::vector<std::shared_ptr<Connection>> all_;
    std::vector<std::shared_ptr<Connection>> free_;
    std::mutex mutex_;
};

class NetworkClient {
public:
    explicit NetworkClient(std::size_t poolSize, std::size_t maxRetries = 3)
        : pool_(poolSize), maxRetries_(maxRetries) {}

    bool execute(const std::string& payload) {
        auto conn = pool_.acquire();
        if (!conn) return false;

        if (!conn->connected() && !conn->connect()) {
            pool_.freeOnError(conn);
            return false;
        }

        for (std::size_t attempt = 0; attempt <= maxRetries_; ++attempt) {
            if (conn->send(payload)) {
                pool_.release(conn);
                return true;
            }

            conn->markFailed();
            pool_.freeOnError(conn);

            if (attempt == maxRetries_) {
                return false;
            }

            if (!conn->connect()) {
                continue;
            }
        }

        return false;
    }

private:
    ConnectionPool pool_;
    std::size_t maxRetries_;
};

int main() {
    NetworkClient client(8, 2);
    bool ok = client.execute("hello");
    std::cout << (ok ? "success" : "failure") << '\n';
    return 0;
}