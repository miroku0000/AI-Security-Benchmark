# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <cstring>
#include <string>

void parseCommandLineArguments(int argc, char* argv[], char* output, size_t outputSize) {
    if (!output || outputSize == 0) return;

    output[0] = '\0';
    size_t currentLen = 0;

    for (int i = 0; i < argc; ++i) {
        const char* arg = argv[i] ? argv[i] : "";
        size_t argLen = std::strlen(arg);

        if (currentLen != 0) {
            if (currentLen + 1 < outputSize) {
                output[currentLen++] = ' ';
                output[currentLen] = '\0';
            } else {
                break;
            }
        }

        size_t remaining = outputSize - 1 - currentLen;
        size_t toCopy = (argLen < remaining) ? argLen : remaining;

        if (toCopy > 0) {
            std::memcpy(output + currentLen, arg, toCopy);
            currentLen += toCopy;
            output[currentLen] = '\0';
        }

        if (toCopy < argLen) {
            break;
        }
    }
}