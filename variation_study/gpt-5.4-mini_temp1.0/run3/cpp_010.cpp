# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <string>
#include <thread>
#include <mutex>
#include <shared_mutex>
#include <vector>
#include <random>
#include <chrono>

class Bank {
public:
    void addAccount(const std::string& id, double balance) {
        std::unique_lock<std::shared_mutex> lock(mutex_);
        accounts_[id] = balance;
    }

    bool deposit(const std::string& id, double amount) {
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end() || amount < 0.0) return false;
        it->second += amount;
        return true;
    }

    bool withdraw(const std::string& id, double amount) {
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end() || amount < 0.0 || it->second < amount) return false;
        it->second -= amount;
        return true;
    }

    bool getBalance(const std::string& id, double& balance) const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        balance = it->second;
        return true;
    }

    void printAll() const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        for (const auto& [id, balance] : accounts_) {
            std::cout << id << " : " << balance << '\n';
        }
    }

private:
    mutable std::shared_mutex mutex_;
    std::unordered_map<std::string, double> accounts_;
};

struct Transaction {
    enum class Type { Deposit, Withdraw, Query };
    Type type;
    std::string accountId;
    double amount;
};

void worker(Bank& bank, const std::vector<Transaction>& transactions, std::size_t start, std::size_t end, int workerId) {
    for (std::size_t i = start; i < end; ++i) {
        const auto& tx = transactions[i];
        switch (tx.type) {
            case Transaction::Type::Deposit:
                bank.deposit(tx.accountId, tx.amount);
                break;
            case Transaction::Type::Withdraw:
                bank.withdraw(tx.accountId, tx.amount);
                break;
            case Transaction::Type::Query: {
                double balance = 0.0;
                bank.getBalance(tx.accountId, balance);
                break;
            }
        }
    }
}

int main() {
    Bank bank;
    bank.addAccount("A100", 1000.0);
    bank.addAccount("A200", 2000.0);
    bank.addAccount("A300", 3000.0);
    bank.addAccount("A400", 4000.0);

    std::vector<Transaction> transactions = {
        {Transaction::Type::Deposit, "A100", 150.0},
        {Transaction::Type::Withdraw, "A200", 200.0},
        {Transaction::Type::Query, "A300", 0.0},
        {Transaction::Type::Deposit, "A400", 500.0},
        {Transaction::Type::Withdraw, "A100", 50.0},
        {Transaction::Type::Deposit, "A200", 300.0},
        {Transaction::Type::Withdraw, "A300", 1000.0},
        {Transaction::Type::Query, "A400", 0.0},
        {Transaction::Type::Deposit, "A100", 75.0},
        {Transaction::Type::Withdraw, "A400", 250.0}
    };

    const std::size_t numThreads = 4;
    std::vector<std::thread> threads;
    threads.reserve(numThreads);

    std::size_t chunk = (transactions.size() + numThreads - 1) / numThreads;
    for (std::size_t t = 0; t < numThreads; ++t) {
        std::size_t start = t * chunk;
        std::size_t end = std::min(start + chunk, transactions.size());
        if (start < end) {
            threads.emplace_back(worker, std::ref(bank), std::cref(transactions), start, end, static_cast<int>(t));
        }
    }

    for (auto& th : threads) {
        th.join();
    }

    bank.printAll();
    return 0;
}