# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <stdint.h>

#define REQUEST_BUFFER_SIZE 4096
#define RESPONSE_BUFFER_SIZE 4096
#define MAX_HEADER_SIZE 2048

typedef struct {
    char *data;
    size_t len;
    size_t cap;
} buffer_t;

static void buffer_init(buffer_t *b, size_t cap) {
    b->data = (char *)malloc(cap);
    b->len = 0;
    b->cap = b->data ? cap : 0;
    if (b->data) b->data[0] = '\0';
}

static void buffer_free(buffer_t *b) {
    free(b->data);
    b->data = NULL;
    b->len = 0;
    b->cap = 0;
}

static bool buffer_reserve(buffer_t *b, size_t needed) {
    if (needed <= b->cap) return true;
    size_t new_cap = b->cap ? b->cap : 256;
    while (new_cap < needed) {
        if (new_cap > SIZE_MAX / 2) return false;
        new_cap *= 2;
    }
    char *p = (char *)realloc(b->data, new_cap);
    if (!p) return false;
    b->data = p;
    b->cap = new_cap;
    return true;
}

static bool read_request(buffer_t *req) {
    req->len = 0;
    if (!req->data || req->cap == 0) return false;

    while (1) {
        if (req->len + 1 >= req->cap) {
            if (!buffer_reserve(req, req->cap * 2 + 1)) return false;
        }

        size_t n = fread(req->data + req->len, 1, req->cap - req->len - 1, stdin);
        if (n == 0) {
            if (feof(stdin)) {
                return req->len > 0;
            }
            return false;
        }

        req->len += n;
        req->data[req->len] = '\0';

        if (strstr(req->data, "\r\n\r\n") || strstr(req->data, "\n\n")) {
            return true;
        }

        if (req->len > MAX_HEADER_SIZE) {
            return true;
        }
    }
}

static void process_request(const char *request, buffer_t *response) {
    const char *body = "OK";
    const char *status = "HTTP/1.1 200 OK\r\n";
    const char *headers = "Content-Type: text/plain\r\nConnection: keep-alive\r\n";
    size_t body_len = strlen(body);
    int n = snprintf(response->data, response->cap,
                     "%s%sContent-Length: %zu\r\n\r\n%s",
                     status, headers, body_len, body);
    if (n < 0) {
        response->len = 0;
        return;
    }
    response->len = (size_t)n;
}

int main(void) {
    buffer_t request;
    buffer_t response;

    buffer_init(&request, REQUEST_BUFFER_SIZE);
    buffer_init(&response, RESPONSE_BUFFER_SIZE);

    if (!request.data || !response.data) {
        buffer_free(&request);
        buffer_free(&response);
        return 1;
    }

    while (1) {
        if (!read_request(&request)) {
            break;
        }

        if (!buffer_reserve(&response, RESPONSE_BUFFER_SIZE)) {
            break;
        }

        process_request(request.data, &response);

        if (response.len > 0) {
            fwrite(response.data, 1, response.len, stdout);
            fflush(stdout);
        }

        request.len = 0;
        if (request.cap > 0) request.data[0] = '\0';
    }

    buffer_free(&request);
    buffer_free(&response);
    return 0;
}