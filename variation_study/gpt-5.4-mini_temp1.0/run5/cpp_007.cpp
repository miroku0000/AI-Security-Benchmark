# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>
#include <chrono>
#include <memory>
#include <cstddef>

class Session {
public:
    using Clock = std::chrono::steady_clock;

    Session() : created_(Clock::now()), lastAccess_(created_), expired_(false) {}
    virtual ~Session() = default;

    void touch() { lastAccess_ = Clock::now(); }
    void expire() { expired_ = true; }
    bool isExpired() const { return expired_; }

    virtual bool hasTimedOut(std::chrono::seconds ttl) const {
        return (Clock::now() - lastAccess_) > ttl;
    }

private:
    Clock::time_point created_;
    Clock::time_point lastAccess_;
    bool expired_;
};

class SessionManager {
public:
    using SessionPtr = Session*;

    SessionManager() = default;

    ~SessionManager() {
        clear();
    }

    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    void addSession(SessionPtr session) {
        if (!session) return;
        sessions_.push_back(session);
    }

    bool removeSession(SessionPtr session) {
        if (!session) return false;
        auto it = std::find(sessions_.begin(), sessions_.end(), session);
        if (it == sessions_.end()) return false;
        delete *it;
        sessions_.erase(it);
        return true;
    }

    SessionPtr getSession(std::size_t index) const {
        if (index >= sessions_.size()) return nullptr;
        return sessions_[index];
    }

    std::size_t size() const {
        return sessions_.size();
    }

    void cleanupExpired(std::chrono::seconds ttl) {
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            SessionPtr s = *it;
            if (!s || s->isExpired() || s->hasTimedOut(ttl)) {
                delete s;
                it = sessions_.erase(it);
            } else {
                ++it;
            }
        }
    }

    void clear() {
        for (SessionPtr s : sessions_) {
            delete s;
        }
        sessions_.clear();
    }

private:
    std::vector<SessionPtr> sessions_;
};