# Generated by openai (gpt-5.4-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <stdbool.h>
#include <string.h>

#ifndef UART_RX_BUF_SIZE
#define UART_RX_BUF_SIZE 256
#endif

#ifndef UART_TX_BUF_SIZE
#define UART_TX_BUF_SIZE 256
#endif

#ifndef SHELL_CMD_MAX_LEN
#define SHELL_CMD_MAX_LEN 64
#endif

#ifndef SHELL_ARG_MAX_LEN
#define SHELL_ARG_MAX_LEN 128
#endif

#define ARRAY_SIZE(x) (sizeof(x) / sizeof((x)[0]))

typedef struct {
    volatile uint32_t DR;
    volatile uint32_t SR;
    volatile uint32_t CR;
    volatile uint32_t BAUD;
} uart_hw_t;

typedef struct {
    volatile uint32_t MODER;
    volatile uint32_t OTYPER;
    volatile uint32_t OSPEEDR;
    volatile uint32_t PUPDR;
    volatile uint32_t IDR;
    volatile uint32_t ODR;
    volatile uint32_t AFR[2];
} gpio_hw_t;

typedef struct {
    char cmd[SHELL_CMD_MAX_LEN];
    char arg[SHELL_ARG_MAX_LEN];
} shell_line_t;

static uart_hw_t * const UART0 = (uart_hw_t *)0x40000000u;
static gpio_hw_t * const GPIOA = (gpio_hw_t *)0x50000000u;
static gpio_hw_t * const GPIOB = (gpio_hw_t *)0x50000400u;

enum {
    UART_SR_RXNE = (1u << 0),
    UART_SR_TXE  = (1u << 1),
    UART_CR_UE   = (1u << 0),
    UART_CR_TE   = (1u << 1),
    UART_CR_RE   = (1u << 2)
};

static volatile char uart_rx_buf[UART_RX_BUF_SIZE];
static volatile uint16_t uart_rx_head = 0;
static volatile uint16_t uart_rx_tail = 0;

static volatile char uart_tx_buf[UART_TX_BUF_SIZE];
static volatile uint16_t uart_tx_head = 0;
static volatile uint16_t uart_tx_tail = 0;

static char shell_input[SHELL_CMD_MAX_LEN + SHELL_ARG_MAX_LEN + 2];
static uint16_t shell_input_len = 0;

static void platform_irq_disable(void);
static void platform_irq_enable(void);

static void uart_tx_kick(void);
static void uart_write_char(char c);
static void uart_write_str(const char *s);
static void uart_write_hex_u32(uint32_t v);
static void uart_write_u32(uint32_t v);
static void uart_write_nl(void);

static void shell_process_line(const char *line);
static void shell_help(void);
static void shell_dump_memory(const char *arg);
static void shell_read_flash(const char *arg);
static void shell_get_config(void);
static void shell_jtag_status(void);

static bool parse_u32(const char *s, uint32_t *out);
static const char *skip_spaces(const char *s);
static size_t strnlen_safe(const char *s, size_t max);
static int strncmp_safe(const char *a, const char *b, size_t n);

static void uart_gpio_init(void);
static void uart_init(uint32_t baud);
static void jtag_pins_init(void);
static void diag_console_init(void);

void platform_init(void);
void uart_irq_handler(void);
void diagnostic_console_poll(void);

static void platform_irq_disable(void) { __asm volatile("cpsid i" ::: "memory"); }
static void platform_irq_enable(void)  { __asm volatile("cpsie i" ::: "memory"); }

static size_t strnlen_safe(const char *s, size_t max) {
    size_t i = 0;
    while (i < max && s[i] != '\0') i++;
    return i;
}

static int strncmp_safe(const char *a, const char *b, size_t n) {
    for (size_t i = 0; i < n; i++) {
        unsigned char ca = (unsigned char)a[i];
        unsigned char cb = (unsigned char)b[i];
        if (ca != cb) return (int)ca - (int)cb;
        if (ca == '\0') return 0;
    }
    return 0;
}

static const char *skip_spaces(const char *s) {
    while (*s == ' ' || *s == '\t' || *s == '\r' || *s == '\n') s++;
    return s;
}

static bool parse_u32(const char *s, uint32_t *out) {
    s = skip_spaces(s);
    if (*s == '\0') return false;

    uint32_t base = 10;
    if (s[0] == '0' && (s[1] == 'x' || s[1] == 'X')) {
        base = 16;
        s += 2;
    }

    uint32_t v = 0;
    bool any = false;
    for (; *s; s++) {
        uint32_t d;
        if (*s >= '0' && *s <= '9') d = (uint32_t)(*s - '0');
        else if (base == 16 && *s >= 'a' && *s <= 'f') d = (uint32_t)(10 + (*s - 'a'));
        else if (base == 16 && *s >= 'A' && *s <= 'F') d = (uint32_t)(10 + (*s - 'A'));
        else break;
        if (d >= base) break;
        any = true;
        v = (v * base) + d;
    }
    if (!any) return false;
    *out = v;
    return true;
}

static void uart_tx_kick(void) {
    if ((UART0->SR & UART_SR_TXE) && (uart_tx_tail != uart_tx_head)) {
        UART0->DR = (uint8_t)uart_tx_buf[uart_tx_tail];
        uart_tx_tail = (uint16_t)((uart_tx_tail + 1u) % UART_TX_BUF_SIZE);
    }
}

static void uart_write_char(char c) {
    uint16_t next;
    do {
        next = (uint16_t)((uart_tx_head + 1u) % UART_TX_BUF_SIZE);
    } while (next == uart_tx_tail);

    platform_irq_disable();
    uart_tx_buf[uart_tx_head] = c;
    uart_tx_head = next;
    uart_tx_kick();
    platform_irq_enable();
}

static void uart_write_str(const char *s) {
    while (*s) uart_write_char(*s++);
}

static void uart_write_hex_u32(uint32_t v) {
    static const char hex[] = "0123456789ABCDEF";
    uart_write_str("0x");
    for (int i = 7; i >= 0; i--) {
        uart_write_char(hex[(v >> (i * 4)) & 0xFu]);
    }
}

static void uart_write_u32(uint32_t v) {
    char buf[11];
    int i = 0;
    if (v == 0) {
        uart_write_char('0');
        return;
    }
    while (v > 0 && i < (int)ARRAY_SIZE(buf)) {
        buf[i++] = (char)('0' + (v % 10u));
        v /= 10u;
    }
    while (i-- > 0) uart_write_char(buf[i]);
}

static void uart_write_nl(void) {
    uart_write_str("\r\n");
}

static void uart_gpio_init(void) {
    GPIOA->MODER &= ~((3u << (2u * 9u)) | (3u << (2u * 10u)));
    GPIOA->MODER |=  ((2u << (2u * 9u)) | (2u << (2u * 10u)));
    GPIOA->AFR[1] &= ~((0xFu << ((9u - 8u) * 4u)) | (0xFu << ((10u - 8u) * 4u)));
    GPIOA->AFR[1] |=  ((7u << ((9u - 8u) * 4u)) | (7u << ((10u - 8u) * 4u)));
    GPIOA->OSPEEDR |= ((3u << (2u * 9u)) | (3u << (2u * 10u)));
    GPIOA->PUPDR &= ~((3u << (2u * 9u)) | (3u << (2u * 10u)));
}

static void uart_init(uint32_t baud) {
    uart_gpio_init();
    UART0->CR = 0;
    UART0->BAUD = baud;
    UART0->CR = UART_CR_UE | UART_CR_TE | UART_CR_RE;
}

static void jtag_pins_init(void) {
    const uint32_t pins[] = { 0u, 1u, 2u, 3u, 4u };
    for (size_t i = 0; i < ARRAY_SIZE(pins); i++) {
        uint32_t p = pins[i];
        GPIOB->MODER &= ~(3u << (2u * p));
        GPIOB->MODER |=  (2u << (2u * p));
        GPIOB->AFR[p >> 3] &= ~(0xFu << ((p & 7u) * 4u));
        GPIOB->AFR[p >> 3] |=  (0xBu << ((p & 7u) * 4u));
        GPIOB->OSPEEDR |= (3u << (2u * p));
        GPIOB->PUPDR &= ~(3u << (2u * p));
    }
}

static void diag_console_init(void) {
    uart_init(115200u);
}

void platform_init(void) {
    diag_console_init();
    jtag_pins_init();
    uart_write_str("Diag console ready");
    uart_write_nl();
}

void uart_irq_handler(void) {
    while (UART0->SR & UART_SR_RXNE) {
        char c = (char)(UART0->DR & 0xFFu);
        uint16_t next = (uint16_t)((uart_rx_head + 1u) % UART_RX_BUF_SIZE);
        if (next != uart_rx_tail) {
            uart_rx_buf[uart_rx_head] = c;
            uart_rx_head = next;
        }
    }
    uart_tx_kick();
}

static void shell_help(void) {
    uart_write_str("Commands:");
    uart_write_nl();
    uart_write_str("  dump_memory <addr> <len>");
    uart_write_nl();
    uart_write_str("  read_flash <addr> <len>");
    uart_write_nl();
    uart_write_str("  get_config");
    uart_write_nl();
    uart_write_str("  jtag_status");
    uart_write_nl();
    uart_write_str("  help");
    uart_write_nl();
}

static void shell_dump_memory(const char *arg) {
    uint32_t addr = 0, len = 0;
    const char *p = skip_spaces(arg);
    if (!parse_u32(p, &addr)) {
        uart_write_str("ERR invalid addr");
        uart_write_nl();
        return;
    }
    while (*p && *p != ' ' && *p != '\t') p++;
    if (!parse_u32(p, &len) || len == 0 || len > 256u) {
        uart_write_str("ERR invalid len");
        uart_write_nl();
        return;
    }

    volatile const uint8_t *mem = (volatile const uint8_t *)(uintptr_t)addr;
    for (uint32_t i = 0; i < len; i += 16u) {
        uart_write_hex_u32(addr + i);
        uart_write_str(": ");
        for (uint32_t j = 0; j < 16u && (i + j) < len; j++) {
            uint8_t b = mem[i + j];
            static const char hex[] = "0123456789ABCDEF";
            uart_write_char(hex[(b >> 4) & 0xFu]);
            uart_write_char(hex[b & 0xFu]);
            uart_write_char(' ');
        }
        uart_write_nl();
    }
}

static void shell_read_flash(const char *arg) {
    uint32_t addr = 0, len = 0;
    const char *p = skip_spaces(arg);
    if (!parse_u32(p, &addr)) {
        uart_write_str("ERR invalid addr");
        uart_write_nl();
        return;
    }
    while (*p && *p != ' ' && *p != '\t') p++;
    if (!parse_u32(p, &len) || len == 0 || len > 256u) {
        uart_write_str("ERR invalid len");
        uart_write_nl();
        return;
    }

    volatile const uint8_t *flash = (volatile const uint8_t *)(uintptr_t)addr;
    for (uint32_t i = 0; i < len; i += 16u) {
        uart_write_hex_u32(addr + i);
        uart_write_str(": ");
        for (uint32_t j = 0; j < 16u && (i + j) < len; j++) {
            uint8_t b = flash[i + j];
            static const char hex[] = "0123456789ABCDEF";
            uart_write_char(hex[(b >> 4) & 0xFu]);
            uart_write_char(hex[b & 0xFu]);
            uart_write_char(' ');
        }
        uart_write_nl();
    }
}

static void shell_get_config(void) {
    uart_write_str("config:");
    uart_write_nl();
    uart_write_str(" baud=");
    uart_write_u32(115200u);
    uart_write_nl();
    uart_write_str(" uart=enabled");
    uart_write_nl();
    uart_write_str(" jtag=enabled");
    uart_write_nl();
}

static void shell_jtag_status(void) {
    uart_write_str("jtag:");
    uart_write_nl();
    uart_write_str(" pins=PA0..PA4 alt-func");
    uart_write_nl();
    uart_write_str(" mode=service");
    uart_write_nl();
}

static void shell_process_line(const char *line) {
    char cmd[SHELL_CMD_MAX_LEN];
    char arg[SHELL_ARG_MAX_LEN];
    size_t i = 0, j = 0;
    line = skip_spaces(line);

    while (*line && *line != ' ' && *line != '\t' && i + 1 < sizeof(cmd)) cmd[i++] = *line++;
    cmd[i] = '\0';
    line = skip_spaces(line);
    while (*line && j + 1 < sizeof(arg)) arg[j++] = *line++;
    arg[j] = '\0';

    if (cmd[0] == '\0') return;

    if (strncmp_safe(cmd, "help", 4) == 0 && cmd[4] == '\0') shell_help();
    else if (strncmp_safe(cmd, "dump_memory", 11) == 0 && cmd[11] == '\0') shell_dump_memory(arg);
    else if (strncmp_safe(cmd, "read_flash", 10) == 0 && cmd[10] == '\0') shell_read_flash(arg);
    else if (strncmp_safe(cmd, "get_config", 10) == 0 && cmd[10] == '\0') shell_get_config();
    else if (strncmp_safe(cmd, "jtag_status", 11) == 0 && cmd[11] == '\0') shell_jtag_status();
    else {
        uart_write_str("ERR unknown command");
        uart_write_nl();
    }
}

void diagnostic_console_poll(void) {
    while (uart_rx_tail != uart_rx_head) {
        char c = uart_rx_buf[uart_rx_tail];
        uart_rx_tail = (uint16_t)((uart_rx_tail + 1u) % UART_RX_BUF_SIZE);

        if (c == '\r' || c == '\n') {
            if (shell_input_len > 0) {
                shell_input[shell_input_len] = '\0';
                shell_process_line(shell_input);
                shell_input_len = 0;
            }
            uart_write_str("> ");
        } else if (c == '\b' || c == 0x7Fu) {
            if (shell_input_len > 0) shell_input_len--;
        } else {
            if (shell_input_len < (sizeof(shell_input) - 1u)) {
                shell_input[shell_input_len++] = c;
            }
        }
    }
    uart_tx_kick();
}

int main(void) {
    platform_init();
    uart_write_str("> ");
    for (;;) {
        diagnostic_console_poll();
    }
    return 0;
}