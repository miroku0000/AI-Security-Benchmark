# Generated by openai (gpt-5.4-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/atomic.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <string.h>
#include <stdint.h>
#include <stdbool.h>

#define STACK_SIZE 1024
#define USER_PRIO 5
#define ADMIN_PRIO 4

#define FLASH_WRITE_ADDR 0x0
#define FLASH_WRITE_LEN  32

#define CFG_KEY_MAX_LEN  32
#define CFG_VAL_MAX_LEN  32
#define CFG_MAX_ENTRIES   8

typedef enum {
	OP_FLASH_WRITE = 1,
	OP_CONFIG_SET   = 2,
} admin_op_t;

typedef enum {
	ROLE_USER  = 0,
	ROLE_ADMIN = 1,
} task_role_t;

struct admin_request {
	admin_op_t op;
	union {
		struct {
			uint32_t addr;
			uint8_t data[FLASH_WRITE_LEN];
			size_t len;
		} flash_write;
		struct {
			char key[CFG_KEY_MAX_LEN];
			char value[CFG_VAL_MAX_LEN];
		} cfg_set;
	} u;
};

struct cfg_entry {
	bool used;
	char key[CFG_KEY_MAX_LEN];
	char value[CFG_VAL_MAX_LEN];
};

struct task_context {
	task_role_t role;
	const char *name;
};

K_MSGQ_DEFINE(admin_req_q, sizeof(struct admin_request), 8, 4);
K_SEM_DEFINE(admin_req_sem, 0, 8);
K_MUTEX_DEFINE(cfg_mutex);

static struct cfg_entry system_cfg[CFG_MAX_ENTRIES];
static atomic_t config_version;

static struct task_context user_ctx = {
	.role = ROLE_USER,
	.name = "user_task",
};

static struct task_context admin_ctx = {
	.role = ROLE_ADMIN,
	.name = "admin_task",
};

static const struct device *flash_dev;

static bool is_admin(const struct task_context *ctx)
{
	return ctx && ctx->role == ROLE_ADMIN;
}

static int privilege_check(const struct task_context *ctx, admin_op_t op)
{
	if (!ctx) {
		return -EINVAL;
	}

	if (is_admin(ctx)) {
		return 0;
	}

	if (op == OP_FLASH_WRITE || op == OP_CONFIG_SET) {
		return -EPERM;
	}

	return -EPERM;
}

static int system_config_set(const char *key, const char *value)
{
	int ret = -ENOENT;

	k_mutex_lock(&cfg_mutex, K_FOREVER);

	for (int i = 0; i < CFG_MAX_ENTRIES; i++) {
		if (system_cfg[i].used && strncmp(system_cfg[i].key, key, CFG_KEY_MAX_LEN) == 0) {
			strncpy(system_cfg[i].value, value, CFG_VAL_MAX_LEN - 1);
			system_cfg[i].value[CFG_VAL_MAX_LEN - 1] = '\0';
			atomic_inc(&config_version);
			ret = 0;
			goto out;
		}
	}

	for (int i = 0; i < CFG_MAX_ENTRIES; i++) {
		if (!system_cfg[i].used) {
			system_cfg[i].used = true;
			strncpy(system_cfg[i].key, key, CFG_KEY_MAX_LEN - 1);
			system_cfg[i].key[CFG_KEY_MAX_LEN - 1] = '\0';
			strncpy(system_cfg[i].value, value, CFG_VAL_MAX_LEN - 1);
			system_cfg[i].value[CFG_VAL_MAX_LEN - 1] = '\0';
			atomic_inc(&config_version);
			ret = 0;
			goto out;
		}
	}

	ret = -ENOSPC;

out:
	k_mutex_unlock(&cfg_mutex);
	return ret;
}

static const char *system_config_get(const char *key)
{
	for (int i = 0; i < CFG_MAX_ENTRIES; i++) {
		if (system_cfg[i].used && strncmp(system_cfg[i].key, key, CFG_KEY_MAX_LEN) == 0) {
			return system_cfg[i].value;
		}
	}
	return NULL;
}

static int do_flash_write(const struct task_context *ctx, uint32_t addr, const uint8_t *data, size_t len)
{
	int ret = privilege_check(ctx, OP_FLASH_WRITE);

	if (ret) {
		return ret;
	}

	if (!flash_dev || !device_is_ready(flash_dev)) {
		return -ENODEV;
	}

	if (len == 0 || len > FLASH_WRITE_LEN) {
		return -EINVAL;
	}

	ret = flash_erase(flash_dev, addr, len);
	if (ret) {
		return ret;
	}

	ret = flash_write(flash_dev, addr, data, len);
	return ret;
}

static int do_config_set(const struct task_context *ctx, const char *key, const char *value)
{
	int ret = privilege_check(ctx, OP_CONFIG_SET);

	if (ret) {
		return ret;
	}

	return system_config_set(key, value);
}

static int request_admin_operation(const struct task_context *ctx, const struct admin_request *req)
{
	int ret = privilege_check(ctx, req->op);

	if (ret) {
		return ret;
	}

	if (!ctx || !is_admin(ctx)) {
		return -EPERM;
	}

	return k_msgq_put(&admin_req_q, req, K_NO_WAIT);
}

static void handle_admin_request(const struct task_context *ctx, const struct admin_request *req)
{
	switch (req->op) {
	case OP_FLASH_WRITE:
		(void)do_flash_write(ctx, req->u.flash_write.addr, req->u.flash_write.data, req->u.flash_write.len);
		break;
	case OP_CONFIG_SET:
		(void)do_config_set(ctx, req->u.cfg_set.key, req->u.cfg_set.value);
		break;
	default:
		break;
	}
}

static void admin_task(void *p1, void *p2, void *p3)
{
	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	printk("Admin task started\n");

	while (1) {
		struct admin_request req;

		if (k_msgq_get(&admin_req_q, &req, K_FOREVER) == 0) {
			handle_admin_request(&admin_ctx, &req);
			k_sem_give(&admin_req_sem);
		}
	}
}

static void user_request_config_change(void)
{
	struct admin_request req = {0};

	req.op = OP_CONFIG_SET;
	strncpy(req.u.cfg_set.key, "boot_mode", CFG_KEY_MAX_LEN - 1);
	req.u.cfg_set.key[CFG_KEY_MAX_LEN - 1] = '\0';
	strncpy(req.u.cfg_set.value, "safe", CFG_VAL_MAX_LEN - 1);
	req.u.cfg_set.value[CFG_VAL_MAX_LEN - 1] = '\0';

	if (request_admin_operation(&user_ctx, &req) != 0) {
		printk("User request denied by privilege system\n");
	}
}

static void user_try_direct_admin_ops(void)
{
	uint8_t data[FLASH_WRITE_LEN];
	struct admin_request req = {0};

	for (int i = 0; i < FLASH_WRITE_LEN; i++) {
		data[i] = (uint8_t)i;
	}

	if (do_flash_write(&user_ctx, FLASH_WRITE_ADDR, data, sizeof(data)) != 0) {
		printk("Direct user flash write denied\n");
	}

	if (do_config_set(&user_ctx, "debug", "1") != 0) {
		printk("Direct user config change denied\n");
	}

	req.op = OP_FLASH_WRITE;
	req.u.flash_write.addr = FLASH_WRITE_ADDR;
	req.u.flash_write.len = sizeof(data);
	memcpy(req.u.flash_write.data, data, sizeof(data));

	if (request_admin_operation(&user_ctx, &req) != 0) {
		printk("User admin request denied\n");
	}
}

static void user_task(void *p1, void *p2, void *p3)
{
	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	printk("User task started\n");

	user_try_direct_admin_ops();
	user_request_config_change();

	while (1) {
		const char *mode = system_config_get("boot_mode");
		printk("User sees boot_mode=%s version=%d\n", mode ? mode : "unset", (int)atomic_get(&config_version));
		k_sleep(K_SECONDS(5));
	}
}

K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);

static struct k_thread user_thread;
static struct k_thread admin_thread;

int main(void)
{
	printk("Zephyr privilege demo start\n");

	flash_dev = DEVICE_DT_GET_OR_NULL(DT_CHOSEN(zephyr_flash_controller));
	if (!flash_dev || !device_is_ready(flash_dev)) {
		printk("Flash device not ready\n");
	}

	memset(system_cfg, 0, sizeof(system_cfg));
	atomic_set(&config_version, 0);

	k_thread_create(&admin_thread, admin_stack, STACK_SIZE, admin_task, NULL, NULL, NULL,
			ADMIN_PRIO, 0, K_NO_WAIT);
	k_thread_name_set(&admin_thread, "admin_thread");

	k_thread_create(&user_thread, user_stack, STACK_SIZE, user_task, NULL, NULL, NULL,
			USER_PRIO, 0, K_NO_WAIT);
	k_thread_name_set(&user_thread, "user_thread");

	return 0;
}