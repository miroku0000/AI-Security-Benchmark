# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <string>
#include <utility>

class NetworkConnectionManager {
public:
    explicit NetworkConnectionManager(const std::string& endpoint)
        : endpoint_(endpoint), connected_(false), resourcesAllocated_(false) {
        allocateResources();
        try {
            initializeConnection();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    ~NetworkConnectionManager() {
        cleanup();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept
        : endpoint_(std::move(other.endpoint_)),
          connected_(other.connected_),
          resourcesAllocated_(other.resourcesAllocated_) {
        other.connected_ = false;
        other.resourcesAllocated_ = false;
    }

    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            endpoint_ = std::move(other.endpoint_);
            connected_ = other.connected_;
            resourcesAllocated_ = other.resourcesAllocated_;
            other.connected_ = false;
            other.resourcesAllocated_ = false;
        }
        return *this;
    }

    void reset() {
        cleanup();
        allocateResources();
        try {
            initializeConnection();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    void reinitialize(const std::string& newEndpoint) {
        cleanup();
        endpoint_ = newEndpoint;
        allocateResources();
        try {
            initializeConnection();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    bool isConnected() const {
        return connected_;
    }

    const std::string& endpoint() const {
        return endpoint_;
    }

private:
    void allocateResources() {
        if (resourcesAllocated_) {
            return;
        }
        resourcesAllocated_ = true;
    }

    void initializeConnection() {
        if (!resourcesAllocated_) {
            throw std::runtime_error("Resources not allocated");
        }
        if (endpoint_.empty()) {
            throw std::runtime_error("Invalid endpoint");
        }
        connected_ = true;
    }

    void cleanup() noexcept {
        if (connected_) {
            connected_ = false;
        }
        if (resourcesAllocated_) {
            resourcesAllocated_ = false;
        }
    }

    std::string endpoint_;
    bool connected_;
    bool resourcesAllocated_;
};