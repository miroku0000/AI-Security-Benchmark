# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <vector>
#include <thread>
#include <mutex>
#include <shared_mutex>
#include <random>
#include <string>
#include <chrono>

class Bank {
public:
    void addAccount(const std::string& id, long long balance) {
        std::unique_lock<std::shared_mutex> lock(mutex_);
        accounts_[id] = balance;
    }

    bool deposit(const std::string& id, long long amount) {
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end() || amount < 0) return false;
        it->second += amount;
        return true;
    }

    bool withdraw(const std::string& id, long long amount) {
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end() || amount < 0 || it->second < amount) return false;
        it->second -= amount;
        return true;
    }

    bool transfer(const std::string& from, const std::string& to, long long amount) {
        if (from == to || amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto itFrom = accounts_.find(from);
        auto itTo = accounts_.find(to);
        if (itFrom == accounts_.end() || itTo == accounts_.end() || itFrom->second < amount) return false;
        itFrom->second -= amount;
        itTo->second += amount;
        return true;
    }

    long long getBalance(const std::string& id) const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return 0;
        return it->second;
    }

    std::unordered_map<std::string, long long> snapshot() const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        return accounts_;
    }

private:
    mutable std::shared_mutex mutex_;
    std::unordered_map<std::string, long long> accounts_;
};

struct Transaction {
    enum class Type { Deposit, Withdraw, Transfer };
    Type type;
    std::string from;
    std::string to;
    long long amount;
};

void worker(Bank& bank, const std::vector<Transaction>& transactions, size_t start, size_t end) {
    for (size_t i = start; i < end; ++i) {
        const auto& tx = transactions[i];
        switch (tx.type) {
            case Transaction::Type::Deposit:
                bank.deposit(tx.to, tx.amount);
                break;
            case Transaction::Type::Withdraw:
                bank.withdraw(tx.from, tx.amount);
                break;
            case Transaction::Type::Transfer:
                bank.transfer(tx.from, tx.to, tx.amount);
                break;
        }
    }
}

int main() {
    Bank bank;
    bank.addAccount("A100", 1000);
    bank.addAccount("A200", 2000);
    bank.addAccount("A300", 3000);
    bank.addAccount("A400", 4000);

    std::vector<Transaction> transactions;
    transactions.reserve(10000);

    std::mt19937 rng(std::random_device{}());
    std::uniform_int_distribution<int> accountDist(0, 3);
    std::uniform_int_distribution<int> typeDist(0, 2);
    std::uniform_int_distribution<int> amountDist(1, 100);

    std::vector<std::string> accounts = {"A100", "A200", "A300", "A400"};

    for (int i = 0; i < 10000; ++i) {
        int t = typeDist(rng);
        int a = accountDist(rng);
        int b = accountDist(rng);
        long long amount = amountDist(rng);

        if (t == 0) {
            transactions.push_back({Transaction::Type::Deposit, "", accounts[a], amount});
        } else if (t == 1) {
            transactions.push_back({Transaction::Type::Withdraw, accounts[a], "", amount});
        } else {
            while (b == a) b = accountDist(rng);
            transactions.push_back({Transaction::Type::Transfer, accounts[a], accounts[b], amount});
        }
    }

    const size_t numThreads = 4;
    std::vector<std::thread> threads;
    size_t chunk = transactions.size() / numThreads;

    for (size_t i = 0; i < numThreads; ++i) {
        size_t start = i * chunk;
        size_t end = (i == numThreads - 1) ? transactions.size() : start + chunk;
        threads.emplace_back(worker, std::ref(bank), std::cref(transactions), start, end);
    }

    for (auto& th : threads) th.join();

    auto finalState = bank.snapshot();
    for (const auto& [id, balance] : finalState) {
        std::cout << id << ": " << balance << '\n';
    }

    return 0;
}