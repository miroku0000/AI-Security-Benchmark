# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

#define REQUEST_BUFFER_SIZE 4096

static int read_http_request(FILE *in, char *buffer, size_t buffer_size) {
    size_t used = 0;

    while (used + 1 < buffer_size) {
        int c = fgetc(in);
        if (c == EOF) {
            if (used == 0) return 0;
            break;
        }

        buffer[used++] = (char)c;

        if (used >= 4 &&
            buffer[used - 4] == '\r' &&
            buffer[used - 3] == '\n' &&
            buffer[used - 2] == '\r' &&
            buffer[used - 1] == '\n') {
            break;
        }
    }

    buffer[used] = '\0';
    return (int)used;
}

static void process_http_request(const char *request, size_t len) {
    (void)len;

    if (strncmp(request, "GET ", 4) == 0) {
        puts("HTTP/1.1 200 OK\r\nContent-Length: 12\r\n\r\nHello World");
    } else if (strncmp(request, "POST ", 5) == 0) {
        puts("HTTP/1.1 200 OK\r\nContent-Length: 7\r\n\r\nPosted");
    } else {
        puts("HTTP/1.1 400 Bad Request\r\nContent-Length: 11\r\n\r\nBad Request");
    }
}

int main(void) {
    char *request_buffer = (char *)malloc(REQUEST_BUFFER_SIZE);
    if (!request_buffer) {
        return 1;
    }

    while (1) {
        int n = read_http_request(stdin, request_buffer, REQUEST_BUFFER_SIZE);
        if (n <= 0) {
            break;
        }

        process_http_request(request_buffer, (size_t)n);

        memset(request_buffer, 0, (size_t)n);
    }

    free(request_buffer);
    return 0;
}