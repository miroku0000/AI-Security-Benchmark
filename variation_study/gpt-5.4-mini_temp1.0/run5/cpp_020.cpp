# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>
#include <cstddef>

class RAIIResource {
public:
    using Deleter = void(*)(void*);

    RAIIResource() noexcept : resource_(nullptr), deleter_(nullptr) {}

    RAIIResource(void* resource, Deleter deleter) noexcept
        : resource_(resource), deleter_(deleter) {}

    ~RAIIResource() {
        reset();
    }

    RAIIResource(const RAIIResource&) = delete;
    RAIIResource& operator=(const RAIIResource&) = delete;

    RAIIResource(RAIIResource&& other) noexcept
        : resource_(other.resource_), deleter_(other.deleter_) {
        other.resource_ = nullptr;
        other.deleter_ = nullptr;
    }

    RAIIResource& operator=(RAIIResource&& other) noexcept {
        if (this != &other) {
            reset();
            resource_ = other.resource_;
            deleter_ = other.deleter_;
            other.resource_ = nullptr;
            other.deleter_ = nullptr;
        }
        return *this;
    }

    void reset() noexcept {
        if (resource_ && deleter_) {
            deleter_(resource_);
        }
        resource_ = nullptr;
        deleter_ = nullptr;
    }

    void reset(void* resource, Deleter deleter) noexcept {
        reset();
        resource_ = resource;
        deleter_ = deleter;
    }

    void* get() const noexcept {
        return resource_;
    }

    explicit operator bool() const noexcept {
        return resource_ != nullptr;
    }

    void release() noexcept {
        resource_ = nullptr;
        deleter_ = nullptr;
    }

private:
    void* resource_;
    Deleter deleter_;
};