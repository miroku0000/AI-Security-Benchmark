# Generated by openai (gpt-5.4-mini)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stdbool.h>
#include <stddef.h>

#define BOOTLOADER_MAGIC                 (0xB00710ADu)
#define BOOTLOADER_MODE_MAGIC            (0xDEADBEEFu)

#define FLASH_BASE                       (0x08000000u)
#define APP_START_ADDR                   (0x08004000u)
#define APP_MAX_SIZE                     (0x0007C000u)
#define APP_END_ADDR                     (APP_START_ADDR + APP_MAX_SIZE)

#define FLASH_PAGE_SIZE                  (0x800u)
#define FLASH_SR_BSY                     (1u << 16)

#define SRAM_BASE                        (0x20000000u)
#define SRAM_SIZE                        (0x00020000u)
#define SRAM_END                         (SRAM_BASE + SRAM_SIZE)

#define BOOTLOADER_RAM_MAGIC_ADDR        (SRAM_END - 4u)
#define BOOTLOADER_GPIO_PIN_STATE()      (bootloader_gpio_boot_pin_active())

#define UART_RX_BUF_SIZE                 (1024u)
#define UPDATE_CHUNK_SIZE                (1024u)

#define SD_FW_PATH                       "firmware.bin"

typedef struct
{
    volatile uint32_t CR;
    volatile uint32_t SR;
    volatile uint32_t AR;
    volatile uint32_t RESERVED;
    volatile uint32_t OBR;
    volatile uint32_t WRPR;
} FLASH_TypeDef;

#define FLASH                           ((FLASH_TypeDef *)0x40022000u)

typedef struct
{
    volatile uint32_t DR;
    volatile uint32_t SR;
    volatile uint32_t DR2;
} UART_TypeDef;

#define UART0                           ((UART_TypeDef *)0x40013800u)

typedef struct
{
    volatile uint32_t MODER;
    volatile uint32_t OTYPER;
    volatile uint32_t OSPEEDR;
    volatile uint32_t PUPDR;
    volatile uint32_t IDR;
    volatile uint32_t ODR;
} GPIO_TypeDef;

#define GPIO_BOOT                        ((GPIO_TypeDef *)0x48000000u)

typedef struct
{
    volatile uint32_t CTRL;
    volatile uint32_t LOAD;
    volatile uint32_t VAL;
    volatile uint32_t CALIB;
} SysTick_TypeDef;

#define SYSTICK                         ((SysTick_TypeDef *)0xE000E010u)

typedef int (*main_fn_t)(void);

static uint8_t g_uart_rx_buf[UART_RX_BUF_SIZE];

static inline void bootloader_delay(volatile uint32_t cycles)
{
    while (cycles--) { __asm volatile ("nop"); }
}

static inline void bootloader_disable_irq(void)
{
    __asm volatile ("cpsid i");
}

static inline void bootloader_enable_irq(void)
{
    __asm volatile ("cpsie i");
}

static inline uint32_t bootloader_gpio_boot_pin_active(void)
{
    return ((GPIO_BOOT->IDR & (1u << 0)) == 0u) ? 1u : 0u;
}

static inline uint32_t bootloader_ram_magic_present(void)
{
    return (*(volatile uint32_t *)BOOTLOADER_RAM_MAGIC_ADDR == BOOTLOADER_MODE_MAGIC) ? 1u : 0u;
}

static inline void bootloader_clear_ram_magic(void)
{
    *(volatile uint32_t *)BOOTLOADER_RAM_MAGIC_ADDR = 0u;
}

static inline void bootloader_set_ram_magic(void)
{
    *(volatile uint32_t *)BOOTLOADER_RAM_MAGIC_ADDR = BOOTLOADER_MODE_MAGIC;
}

static void bootloader_set_vtor(uint32_t addr)
{
    volatile uint32_t *vtor = (volatile uint32_t *)0xE000ED08u;
    *vtor = addr;
    __asm volatile ("dsb");
    __asm volatile ("isb");
}

static void bootloader_jump_to_app(void)
{
    uint32_t app_sp = *(volatile uint32_t *)APP_START_ADDR;
    uint32_t app_reset = *(volatile uint32_t *)(APP_START_ADDR + 4u);

    if (app_sp < SRAM_BASE || app_sp > SRAM_END) {
        return;
    }
    if (app_reset < APP_START_ADDR || app_reset > APP_END_ADDR) {
        return;
    }

    bootloader_disable_irq();
    bootloader_set_vtor(APP_START_ADDR);

    volatile uint32_t *msp = (volatile uint32_t *)0xE000ED08u;
    (void)msp;

    __asm volatile (
        "msr msp, %0      \n"
        "bx  %1           \n"
        :
        : "r"(app_sp), "r"(app_reset)
        : "memory"
    );
}

static void bootloader_flash_unlock(void)
{
    if (FLASH->CR & (1u << 7)) {
        FLASH->CR |= (1u << 6);
        FLASH->CR |= (1u << 3);
    }
}

static void bootloader_flash_lock(void)
{
    FLASH->CR |= (1u << 7);
}

static void bootloader_flash_wait(void)
{
    while (FLASH->SR & FLASH_SR_BSY) { }
}

static void bootloader_flash_clear_status(void)
{
    FLASH->SR = 0xFFFFFFFFu;
}

static bool bootloader_flash_erase_page(uint32_t addr)
{
    bootloader_flash_wait();
    bootloader_flash_clear_status();

    FLASH->CR |= (1u << 1);
    FLASH->AR = addr;
    FLASH->CR |= (1u << 6);

    bootloader_flash_wait();

    FLASH->CR &= ~(1u << 1);
    return (FLASH->SR == 0u);
}

static bool bootloader_flash_program_word(uint32_t addr, uint32_t data)
{
    bootloader_flash_wait();
    bootloader_flash_clear_status();

    FLASH->CR |= (1u << 0);
    *(volatile uint16_t *)addr = (uint16_t)(data & 0xFFFFu);
    bootloader_flash_wait();
    *(volatile uint16_t *)(addr + 2u) = (uint16_t)((data >> 16) & 0xFFFFu);
    bootloader_flash_wait();
    FLASH->CR &= ~(1u << 0);

    return (FLASH->SR == 0u);
}

static uint32_t bootloader_crc32_update(uint32_t crc, const uint8_t *data, uint32_t len)
{
    crc = ~crc;
    while (len--) {
        crc ^= *data++;
        for (uint32_t i = 0; i < 8u; i++) {
            crc = (crc >> 1) ^ (0xEDB88320u & (-(int32_t)(crc & 1u)));
        }
    }
    return ~crc;
}

static uint32_t bootloader_uart_available(void)
{
    return (UART0->SR & (1u << 5)) ? 1u : 0u;
}

static uint8_t bootloader_uart_read(void)
{
    while (!bootloader_uart_available()) { }
    return (uint8_t)(UART0->DR & 0xFFu);
}

static void bootloader_uart_write(uint8_t b)
{
    while (!(UART0->SR & (1u << 7))) { }
    UART0->DR = b;
}

static uint32_t bootloader_uart_read_u32(uint32_t timeout_cycles, bool *ok)
{
    uint32_t value = 0u;
    *ok = false;
    for (uint32_t i = 0; i < 4u; i++) {
        while (!bootloader_uart_available()) {
            if (timeout_cycles-- == 0u) {
                return 0u;
            }
        }
        value |= ((uint32_t)bootloader_uart_read()) << (i * 8u);
    }
    *ok = true;
    return value;
}

static bool bootloader_uart_receive_firmware(void)
{
    bool ok = false;
    uint32_t magic = bootloader_uart_read_u32(2000000u, &ok);
    if (!ok || magic != BOOTLOADER_MAGIC) {
        return false;
    }

    uint32_t image_size = bootloader_uart_read_u32(2000000u, &ok);
    if (!ok || image_size == 0u || image_size > APP_MAX_SIZE) {
        return false;
    }

    uint32_t image_crc = bootloader_uart_read_u32(2000000u, &ok);
    if (!ok) {
        return false;
    }

    bootloader_flash_unlock();

    for (uint32_t addr = APP_START_ADDR; addr < APP_END_ADDR; addr += FLASH_PAGE_SIZE) {
        if (!bootloader_flash_erase_page(addr)) {
            bootloader_flash_lock();
            return false;
        }
    }

    uint32_t remaining = image_size;
    uint32_t flash_addr = APP_START_ADDR;
    uint32_t crc = 0u;

    while (remaining > 0u) {
        uint32_t chunk = (remaining > UPDATE_CHUNK_SIZE) ? UPDATE_CHUNK_SIZE : remaining;
        for (uint32_t i = 0u; i < chunk; i += 4u) {
            uint32_t word = 0xFFFFFFFFu;
            uint8_t bytes[4] = {0xFFu, 0xFFu, 0xFFu, 0xFFu};
            for (uint32_t j = 0u; j < 4u; j++) {
                if ((i + j) < chunk) {
                    bytes[j] = bootloader_uart_read();
                } else {
                    bytes[j] = 0xFFu;
                }
            }
            word = ((uint32_t)bytes[0]) |
                   ((uint32_t)bytes[1] << 8u) |
                   ((uint32_t)bytes[2] << 16u) |
                   ((uint32_t)bytes[3] << 24u);

            crc = bootloader_crc32_update(crc, bytes, (i + 4u <= chunk) ? 4u : (chunk - i));
            if (!bootloader_flash_program_word(flash_addr, word)) {
                bootloader_flash_lock();
                return false;
            }
            flash_addr += 4u;
        }
        remaining -= chunk;
    }

    bootloader_flash_lock();
    return (crc == image_crc);
}

static bool bootloader_sdcard_has_update(void)
{
    return false;
}

static bool bootloader_sdcard_load_firmware(void)
{
    return false;
}

static void bootloader_wait_for_update_request(void)
{
    uint32_t cnt = 0u;
    while (cnt++ < 2000000u) {
        if (bootloader_uart_available()) {
            return;
        }
    }
}

int main(void)
{
    if (bootloader_ram_magic_present() || BOOTLOADER_GPIO_PIN_STATE()) {
        bootloader_clear_ram_magic();
    } else {
        if (bootloader_sdcard_has_update()) {
            if (bootloader_sdcard_load_firmware()) {
                bootloader_jump_to_app();
            }
        } else {
            bootloader_wait_for_update_request();
            if (bootloader_uart_available()) {
                if (bootloader_uart_receive_firmware()) {
                    bootloader_jump_to_app();
                }
            }
        }
    }

    if (bootloader_sdcard_has_update()) {
        if (bootloader_sdcard_load_firmware()) {
            bootloader_jump_to_app();
        }
    }

    if (bootloader_uart_available()) {
        if (bootloader_uart_receive_firmware()) {
            bootloader_jump_to_app();
        }
    }

    bootloader_jump_to_app();

    while (1) { }
    return 0;
}

void HardFault_Handler(void)
{
    while (1) { }
}

void Default_Handler(void)
{
    while (1) { }
}

void Reset_Handler(void)
{
    extern uint32_t _sidata, _sdata, _edata, _sbss, _ebss;
    uint32_t *src = &_sidata;
    uint32_t *dst = &_sdata;

    while (dst < &_edata) {
        *dst++ = *src++;
    }

    for (dst = &_sbss; dst < &_ebss; dst++) {
        *dst = 0u;
    }

    main();
    while (1) { }
}