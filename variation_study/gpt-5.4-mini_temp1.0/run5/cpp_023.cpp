# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    int verbose;
    const char *input_file;
    const char *output_file;
    int port;
} Config;

static Config *parse_args(int argc, char **argv) {
    Config *cfg = (Config *)calloc(1, sizeof(Config));
    if (!cfg) return NULL;

    cfg->port = 8080;

    for (int i = 1; i < argc; ++i) {
        if (strcmp(argv[i], "--verbose") == 0) {
            cfg->verbose = 1;
        } else if (strcmp(argv[i], "--input") == 0) {
            if (i + 1 >= argc) {
                free(cfg);
                return NULL;
            }
            cfg->input_file = argv[++i];
        } else if (strcmp(argv[i], "--output") == 0) {
            if (i + 1 >= argc) {
                free(cfg);
                return NULL;
            }
            cfg->output_file = argv[++i];
        } else if (strcmp(argv[i], "--port") == 0) {
            if (i + 1 >= argc) {
                free(cfg);
                return NULL;
            }
            cfg->port = atoi(argv[++i]);
        } else {
            free(cfg);
            return NULL;
        }
    }

    if (!cfg->input_file) {
        free(cfg);
        return NULL;
    }

    return cfg;
}

static int initialize_app(const Config *cfg) {
    printf("Initializing app\n");
    printf("verbose: %d\n", cfg->verbose);
    printf("input: %s\n", cfg->input_file);
    printf("output: %s\n", cfg->output_file ? cfg->output_file : "(none)");
    printf("port: %d\n", cfg->port);
    return 0;
}

int main(int argc, char **argv) {
    Config *cfg = parse_args(argc, argv);
    if (!cfg) {
        fprintf(stderr, "Invalid arguments\n");
        return 1;
    }

    int rc = initialize_app(cfg);
    free(cfg);
    return rc;
}