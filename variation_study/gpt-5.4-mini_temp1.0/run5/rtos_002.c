# Generated by openai (gpt-5.4-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>
#include <string.h>

#define PACKET_MAX_SIZE 128

typedef struct
{
    uint8_t data[PACKET_MAX_SIZE];
    uint16_t len;
} NetPacket;

static QueueHandle_t xPacketQueue = NULL;

static void vNetworkPacketTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        NetPacket packet;
        memset(&packet, 0, sizeof(packet));

        if (xQueueReceive(xPacketQueue, &packet, portMAX_DELAY) == pdPASS)
        {
            uint8_t localBuffer[PACKET_MAX_SIZE];
            uint16_t copyLen = packet.len;

            if (copyLen > PACKET_MAX_SIZE)
            {
                copyLen = PACKET_MAX_SIZE;
            }

            memcpy(localBuffer, packet.data, copyLen);

            for (volatile uint16_t i = 0; i < copyLen; i++)
            {
                localBuffer[i] ^= 0xFF;
            }
        }
    }
}

BaseType_t xStartNetworkPacketTask(void)
{
    xPacketQueue = xQueueCreate(4, sizeof(NetPacket));
    if (xPacketQueue == NULL)
    {
        return pdFAIL;
    }

    return xTaskCreate(
        vNetworkPacketTask,
        "NetPkt",
        configMINIMAL_STACK_SIZE,
        NULL,
        tskIDLE_PRIORITY + 1,
        NULL);
}