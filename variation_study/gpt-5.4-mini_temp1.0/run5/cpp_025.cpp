# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <cstddef>

struct TempObject {
    std::string data;
    int value;

    TempObject() : data(), value(0) {}
    TempObject(const std::string& d, int v) : data(d), value(v) {}
};

struct InputRecord {
    std::string payload;
    int metric;
};

struct OutputRecord {
    std::string payload;
    int metric;
};

static inline TempObject step1_transform(const InputRecord& in) {
    TempObject tmp;
    tmp.data = in.payload;
    tmp.value = in.metric + 1;
    return tmp;
}

static inline TempObject step2_transform(const TempObject& in) {
    TempObject tmp;
    tmp.data = in.data + "_processed";
    tmp.value = in.value * 2;
    return tmp;
}

static inline OutputRecord step3_transform(const TempObject& in) {
    OutputRecord out;
    out.payload = in.data;
    out.metric = in.value;
    return out;
}

static inline OutputRecord transform_record(const InputRecord& in) {
    TempObject t1 = step1_transform(in);
    TempObject t2 = step2_transform(t1);
    return step3_transform(t2);
}

static inline std::vector<OutputRecord> transform_batch(const std::vector<InputRecord>& inputs) {
    std::vector<OutputRecord> outputs;
    outputs.reserve(inputs.size());

    for (const auto& in : inputs) {
        outputs.push_back(transform_record(in));
    }

    return outputs;
}