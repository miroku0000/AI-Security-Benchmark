# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct FileHandleNode {
    FILE *fp;
    char *path;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct {
    FileHandleNode *head;
} FileHandleList;

static char *dup_string(const char *s) {
    if (!s) return NULL;
    size_t len = strlen(s) + 1;
    char *copy = (char *)malloc(len);
    if (!copy) return NULL;
    memcpy(copy, s, len);
    return copy;
}

void fhlist_init(FileHandleList *list) {
    if (!list) return;
    list->head = NULL;
}

int fhlist_add(FileHandleList *list, const char *path, const char *mode) {
    if (!list || !path || !mode) return -1;

    FILE *fp = fopen(path, mode);
    if (!fp) return -1;

    FileHandleNode *node = (FileHandleNode *)malloc(sizeof(FileHandleNode));
    if (!node) {
        fclose(fp);
        return -1;
    }

    node->path = dup_string(path);
    if (!node->path) {
        fclose(fp);
        free(node);
        return -1;
    }

    node->fp = fp;
    node->next = list->head;
    list->head = node;
    return 0;
}

int fhlist_remove(FileHandleList *list, const char *path) {
    if (!list || !path) return -1;

    FileHandleNode *prev = NULL;
    FileHandleNode *cur = list->head;

    while (cur) {
        if (cur->path && strcmp(cur->path, path) == 0) {
            if (prev) prev->next = cur->next;
            else list->head = cur->next;

            if (cur->fp) fclose(cur->fp);
            free(cur->path);
            free(cur);
            return 0;
        }
        prev = cur;
        cur = cur->next;
    }

    return -1;
}

void fhlist_cleanup(FileHandleList *list) {
    if (!list) return;

    FileHandleNode *cur = list->head;
    while (cur) {
        FileHandleNode *next = cur->next;
        if (cur->fp) fclose(cur->fp);
        free(cur->path);
        free(cur);
        cur = next;
    }
    list->head = NULL;
}

#ifdef TEST_FILE_HANDLE_LIST
int main(void) {
    FileHandleList list;
    fhlist_init(&list);

    fhlist_add(&list, "test1.txt", "w");
    fhlist_add(&list, "test2.txt", "w");

    fhlist_remove(&list, "test1.txt");

    fhlist_cleanup(&list);
    fhlist_cleanup(&list);

    return 0;
}
#endif