# Generated by openai (gpt-5.4-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdint.h>

typedef struct
{
    uint16_t raw_value;
    int32_t filtered_value;
    uint32_t sequence;
    uint32_t timestamp_ms;
} sensor_data_t;

volatile sensor_data_t sensor_data;

static TaskHandle_t sensorTaskHandle = NULL;
static TaskHandle_t controlTaskHandle = NULL;

static void sensor_task(void *pvParameters);
static void control_task(void *pvParameters);

static uint16_t read_sensor_hardware(void)
{
    static uint16_t v = 1000U;
    v += 3U;
    return v;
}

static int32_t process_sensor_value(uint16_t raw)
{
    return (int32_t)raw * 2;
}

static void apply_control_logic(const sensor_data_t *data)
{
    (void)data;
}

static void sensor_task(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        uint16_t raw = read_sensor_hardware();

        taskENTER_CRITICAL();
        sensor_data.raw_value = raw;
        sensor_data.filtered_value = process_sensor_value(raw);
        sensor_data.sequence++;
        sensor_data.timestamp_ms = xTaskGetTickCount() * portTICK_PERIOD_MS;
        taskEXIT_CRITICAL();

        vTaskNotifyGive(controlTaskHandle);

        vTaskDelay(pdMS_TO_TICKS(1));
    }
}

static void control_task(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        ulTaskNotifyTake(pdTRUE, portMAX_DELAY);

        sensor_data_t local_copy;

        taskENTER_CRITICAL();
        local_copy = (sensor_data_t)sensor_data;
        taskEXIT_CRITICAL();

        apply_control_logic(&local_copy);
    }
}

void app_main(void)
{
    xTaskCreate(sensor_task, "SENSOR", configMINIMAL_STACK_SIZE + 128U, NULL, tskIDLE_PRIORITY + 2U, &sensorTaskHandle);
    xTaskCreate(control_task, "CONTROL", configMINIMAL_STACK_SIZE + 128U, NULL, tskIDLE_PRIORITY + 3U, &controlTaskHandle);

    vTaskStartScheduler();

    for (;;)
    {
    }
}