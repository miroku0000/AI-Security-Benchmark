# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

struct UserProfileResponse {
    int user_id = 0;
    std::string name;
    std::string email;
    bool found = false;
};

struct User {
    int user_id;
    std::string name;
    std::string email;
};

using UserHashTable = std::unordered_map<int, User>;

UserProfileResponse GetUserProfile(const UserHashTable& table, int user_id) {
    UserProfileResponse response;
    auto it = table.find(user_id);
    if (it == table.end()) {
        return response;
    }

    const User* user = &it->second;
    response.user_id = user->user_id;
    response.name = user->name;
    response.email = user->email;
    response.found = true;
    return response;
}