# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#ifndef RAII_RESOURCE_MANAGER_HPP
#define RAII_RESOURCE_MANAGER_HPP

#include <utility>
#include <type_traits>
#include <cstddef>

template <typename T, typename Deleter>
class ResourceManager {
public:
    ResourceManager() noexcept(std::is_nothrow_default_constructible_v<Deleter>)
        : ptr_(nullptr), deleter_() {}

    explicit ResourceManager(T* ptr) noexcept(std::is_nothrow_default_constructible_v<Deleter>)
        : ptr_(ptr), deleter_() {}

    ResourceManager(T* ptr, Deleter deleter) noexcept(std::is_nothrow_move_constructible_v<Deleter>)
        : ptr_(ptr), deleter_(std::move(deleter)) {}

    ~ResourceManager() {
        reset();
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ResourceManager(ResourceManager&& other) noexcept(std::is_nothrow_move_constructible_v<Deleter>)
        : ptr_(other.ptr_), deleter_(std::move(other.deleter_)) {
        other.ptr_ = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept(
        std::is_nothrow_move_assignable_v<Deleter> && std::is_nothrow_move_constructible_v<Deleter>) {
        if (this != &other) {
            reset();
            ptr_ = other.ptr_;
            deleter_ = std::move(other.deleter_);
            other.ptr_ = nullptr;
        }
        return *this;
    }

    T* get() const noexcept {
        return ptr_;
    }

    T& operator*() const {
        return *ptr_;
    }

    T* operator->() const noexcept {
        return ptr_;
    }

    explicit operator bool() const noexcept {
        return ptr_ != nullptr;
    }

    T* release() noexcept {
        T* temp = ptr_;
        ptr_ = nullptr;
        return temp;
    }

    void reset(T* newPtr = nullptr) noexcept(noexcept(std::declval<Deleter&>()(std::declval<T*>()))) {
        if (ptr_ != nullptr) {
            deleter_(ptr_);
        }
        ptr_ = newPtr;
    }

    void swap(ResourceManager& other) noexcept(
        std::is_nothrow_swappable_v<T*> && std::is_nothrow_swappable_v<Deleter>) {
        using std::swap;
        swap(ptr_, other.ptr_);
        swap(deleter_, other.deleter_);
    }

private:
    T* ptr_;
    Deleter deleter_;
};

template <typename T, typename Deleter>
void swap(ResourceManager<T, Deleter>& a, ResourceManager<T, Deleter>& b) noexcept(noexcept(a.swap(b))) {
    a.swap(b);
}

template <typename T>
struct DefaultDeleter {
    void operator()(T* ptr) const noexcept {
        delete ptr;
    }
};

template <typename T>
using UniqueResource = ResourceManager<T, DefaultDeleter<T>>;

#endif