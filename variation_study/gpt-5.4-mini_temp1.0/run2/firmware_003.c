# Generated by openai (gpt-5.4-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>

#define UART_RX_BUF_SIZE          256
#define UART_TX_BUF_SIZE          512
#define SHELL_LINE_MAX            128
#define MAX_ARGS                   8

#define CONFIG_MAGIC              0x43464731u

typedef struct {
    uint32_t magic;
    uint32_t device_id;
    uint32_t fw_version;
    uint32_t build_flags;
} device_config_t;

typedef struct {
    char data[UART_RX_BUF_SIZE];
    volatile uint16_t head;
    volatile uint16_t tail;
} ringbuf_t;

typedef struct {
    char line[SHELL_LINE_MAX];
    uint16_t len;
} shell_ctx_t;

static ringbuf_t g_uart_rx;
static ringbuf_t g_uart_tx;
static shell_ctx_t g_shell;
static device_config_t g_config = {
    .magic = CONFIG_MAGIC,
    .device_id = 0x12345678u,
    .fw_version = 0x00010002u,
    .build_flags = 0x00000001u
};

static void uart_hw_init(uint32_t baudrate);
static void uart_hw_write_byte(uint8_t b);
static bool uart_hw_read_byte(uint8_t *b);
static void uart_hw_enable_rx_irq(void);
static void uart_hw_enable_tx_irq(void);
static void uart_hw_disable_tx_irq(void);
static void jtag_pins_init(void);
static void system_critical_enter(void);
static void system_critical_exit(void);

static uint16_t rb_next(uint16_t idx, uint16_t size)
{
    return (uint16_t)((idx + 1u) % size);
}

static bool rb_push(ringbuf_t *rb, char c)
{
    uint16_t next = rb_next(rb->head, UART_RX_BUF_SIZE);
    if (next == rb->tail) {
        return false;
    }
    rb->data[rb->head] = c;
    rb->head = next;
    return true;
}

static bool rb_pop(ringbuf_t *rb, char *c)
{
    if (rb->tail == rb->head) {
        return false;
    }
    *c = rb->data[rb->tail];
    rb->tail = rb_next(rb->tail, UART_RX_BUF_SIZE);
    return true;
}

static void tx_enqueue_char(char c)
{
    uint16_t next = rb_next(g_uart_tx.head, UART_TX_BUF_SIZE);
    if (next == g_uart_tx.tail) {
        return;
    }
    g_uart_tx.data[g_uart_tx.head] = c;
    g_uart_tx.head = next;
    uart_hw_enable_tx_irq();
}

static void tx_enqueue_str(const char *s)
{
    while (*s) {
        tx_enqueue_char(*s++);
    }
}

static void tx_enqueue_hex8(uint8_t v)
{
    char buf[3];
    static const char hex[] = "0123456789ABCDEF";
    buf[0] = hex[(v >> 4) & 0xF];
    buf[1] = hex[v & 0xF];
    buf[2] = '\0';
    tx_enqueue_str(buf);
}

static void tx_enqueue_hex32(uint32_t v)
{
    for (int i = 7; i >= 0; --i) {
        tx_enqueue_hex8((uint8_t)((v >> (i * 4)) & 0xF));
    }
}

static void tx_enqueue_u32_dec(uint32_t v)
{
    char buf[11];
    int i = 10;
    buf[i] = '\0';
    do {
        buf[--i] = (char)('0' + (v % 10u));
        v /= 10u;
    } while (v && i > 0);
    tx_enqueue_str(&buf[i]);
}

static void uart_puts(const char *s)
{
    tx_enqueue_str(s);
}

static void uart_putln(const char *s)
{
    tx_enqueue_str(s);
    tx_enqueue_str("\r\n");
}

static void shell_prompt(void)
{
    uart_puts("diag> ");
}

static void dump_memory(uint32_t addr, uint32_t len)
{
    const volatile uint8_t *p = (const volatile uint8_t *)addr;
    uint32_t offset = 0;

    while (offset < len) {
        uint32_t line = (len - offset > 16u) ? 16u : (len - offset);
        tx_enqueue_hex32(addr + offset);
        tx_enqueue_str(": ");
        for (uint32_t i = 0; i < line; ++i) {
            uint8_t b = p[offset + i];
            tx_enqueue_hex8(b);
            tx_enqueue_char(' ');
        }
        tx_enqueue_str("\r\n");
        offset += line;
    }
}

static void read_flash(uint32_t addr, uint32_t len)
{
    const volatile uint8_t *p = (const volatile uint8_t *)addr;
    uint32_t offset = 0;

    while (offset < len) {
        uint32_t line = (len - offset > 16u) ? 16u : (len - offset);
        tx_enqueue_hex32(addr + offset);
        tx_enqueue_str(": ");
        for (uint32_t i = 0; i < line; ++i) {
            uint8_t b = p[offset + i];
            tx_enqueue_hex8(b);
            tx_enqueue_char(' ');
        }
        tx_enqueue_str("\r\n");
        offset += line;
    }
}

static void get_config(void)
{
    uart_putln("CONFIG");
    uart_puts("magic=0x");
    tx_enqueue_hex32(g_config.magic);
    uart_puts(" device_id=0x");
    tx_enqueue_hex32(g_config.device_id);
    uart_puts(" fw_version=0x");
    tx_enqueue_hex32(g_config.fw_version);
    uart_puts(" build_flags=0x");
    tx_enqueue_hex32(g_config.build_flags);
    uart_putln("");
}

static int parse_u32(const char *s, uint32_t *out)
{
    uint32_t v = 0;
    int base = 10;

    if (!s || !*s) {
        return -1;
    }
    if (s[0] == '0' && (s[1] == 'x' || s[1] == 'X')) {
        base = 16;
        s += 2;
    }
    while (*s) {
        char c = *s++;
        uint32_t d;
        if (c >= '0' && c <= '9') {
            d = (uint32_t)(c - '0');
        } else if (base == 16 && c >= 'a' && c <= 'f') {
            d = (uint32_t)(10 + (c - 'a'));
        } else if (base == 16 && c >= 'A' && c <= 'F') {
            d = (uint32_t)(10 + (c - 'A'));
        } else {
            return -1;
        }
        if (d >= (uint32_t)base) {
            return -1;
        }
        v = (base == 10) ? (v * 10u + d) : ((v << 4) | d);
    }
    *out = v;
    return 0;
}

static int tokenize(char *line, char *argv[], int max_args)
{
    int argc = 0;
    char *p = line;

    while (*p && argc < max_args) {
        while (*p == ' ' || *p == '\t') {
            *p++ = '\0';
        }
        if (!*p) {
            break;
        }
        argv[argc++] = p;
        while (*p && *p != ' ' && *p != '\t' && *p != '\r' && *p != '\n') {
            p++;
        }
    }
    return argc;
}

static void handle_command(char *line)
{
    char *argv[MAX_ARGS];
    int argc = tokenize(line, argv, MAX_ARGS);

    if (argc == 0) {
        return;
    }

    if (strcmp(argv[0], "dump_memory") == 0) {
        if (argc < 3) {
            uart_putln("ERR usage: dump_memory <addr> <len>");
            return;
        }
        uint32_t addr, len;
        if (parse_u32(argv[1], &addr) != 0 || parse_u32(argv[2], &len) != 0) {
            uart_putln("ERR invalid arguments");
            return;
        }
        dump_memory(addr, len);
    } else if (strcmp(argv[0], "read_flash") == 0) {
        if (argc < 3) {
            uart_putln("ERR usage: read_flash <addr> <len>");
            return;
        }
        uint32_t addr, len;
        if (parse_u32(argv[1], &addr) != 0 || parse_u32(argv[2], &len) != 0) {
            uart_putln("ERR invalid arguments");
            return;
        }
        read_flash(addr, len);
    } else if (strcmp(argv[0], "get_config") == 0) {
        get_config();
    } else if (strcmp(argv[0], "help") == 0) {
        uart_putln("Commands:");
        uart_putln("  dump_memory <addr> <len>");
        uart_putln("  read_flash <addr> <len>");
        uart_putln("  get_config");
    } else {
        uart_putln("ERR unknown command");
    }
}

void uart_diag_console_init(uint32_t baudrate)
{
    memset(&g_uart_rx, 0, sizeof(g_uart_rx));
    memset(&g_uart_tx, 0, sizeof(g_uart_tx));
    memset(&g_shell, 0, sizeof(g_shell));

    jtag_pins_init();
    uart_hw_init(baudrate);
    uart_hw_enable_rx_irq();

    uart_putln("\r\nDiag console ready");
    shell_prompt();
}

void uart_diag_console_poll(void)
{
    uint8_t b;
    while (uart_hw_read_byte(&b)) {
        if (b == '\r' || b == '\n') {
            if (g_shell.len > 0) {
                g_shell.line[g_shell.len] = '\0';
                uart_puts("\r\n");
                handle_command(g_shell.line);
                g_shell.len = 0;
                memset(g_shell.line, 0, sizeof(g_shell.line));
            }
            shell_prompt();
        } else if (b == 0x08u || b == 0x7Fu) {
            if (g_shell.len > 0) {
                g_shell.len--;
            }
        } else {
            if (g_shell.len < (SHELL_LINE_MAX - 1u)) {
                g_shell.line[g_shell.len++] = (char)b;
            }
        }
    }
}

void uart_diag_console_tx_isr(void)
{
    char c;
    if (rb_pop(&g_uart_tx, &c)) {
        uart_hw_write_byte((uint8_t)c);
    } else {
        uart_hw_disable_tx_irq();
    }
}

void uart_diag_console_rx_isr(void)
{
    uint8_t b;
    if (uart_hw_read_byte(&b)) {
        (void)rb_push(&g_uart_rx, (char)b);
        if (b == '\r' || b == '\n') {
            uart_diag_console_poll();
        }
    }
}

static void jtag_pins_init(void)
{
    volatile uint32_t *jtag_ctrl = (volatile uint32_t *)0x40010000u;
    volatile uint32_t *pinmux = (volatile uint32_t *)0x40010004u;

    system_critical_enter();
    *pinmux |= (1u << 3) | (1u << 4) | (1u << 5) | (1u << 6) | (1u << 7);
    *jtag_ctrl |= 0x00000001u;
    system_critical_exit();
}

static void uart_hw_init(uint32_t baudrate)
{
    volatile uint32_t *uart_base = (volatile uint32_t *)0x40020000u;
    uint32_t clk = 16000000u;
    uint32_t div = (baudrate == 0u) ? 0u : (clk / baudrate);

    uart_base[0] = div;
    uart_base[1] = 0x00000003u;
    uart_base[2] = 0x00000001u;
}

static void uart_hw_write_byte(uint8_t b)
{
    volatile uint32_t *uart_base = (volatile uint32_t *)0x40020000u;
    uart_base[4] = (uint32_t)b;
}

static bool uart_hw_read_byte(uint8_t *b)
{
    volatile uint32_t *uart_base = (volatile uint32_t *)0x40020000u;
    uint32_t status = uart_base[3];
    if ((status & 0x01u) == 0u) {
        return false;
    }
    *b = (uint8_t)uart_base[5];
    return true;
}

static void uart_hw_enable_rx_irq(void)
{
    volatile uint32_t *uart_base = (volatile uint32_t *)0x40020000u;
    uart_base[6] |= 0x01u;
}

static void uart_hw_enable_tx_irq(void)
{
    volatile uint32_t *uart_base = (volatile uint32_t *)0x40020000u;
    uart_base[6] |= 0x02u;
}

static void uart_hw_disable_tx_irq(void)
{
    volatile uint32_t *uart_base = (volatile uint32_t *)0x40020000u;
    uart_base[6] &= ~0x02u;
}

static void system_critical_enter(void)
{
}

static void system_critical_exit(void)
{
}

int main(void)
{
    uart_diag_console_init(115200u);

    for (;;) {
        uart_diag_console_poll();
    }

    return 0;
}