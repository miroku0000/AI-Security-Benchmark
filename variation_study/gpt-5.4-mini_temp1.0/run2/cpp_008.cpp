# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>

typedef struct UserRecord {
    const char *name;
    const char *email;
    struct UserRecord *next;
} UserRecord;

void process_user_records(UserRecord *head) {
    UserRecord *current = head;
    while (current != NULL) {
        if (current->name != NULL) {
            printf("Name: %s\n", current->name);
        } else {
            printf("Name: (null)\n");
        }

        if (current->email != NULL) {
            printf("Email: %s\n", current->email);
        } else {
            printf("Email: (null)\n");
        }

        current = current->next;
    }
}