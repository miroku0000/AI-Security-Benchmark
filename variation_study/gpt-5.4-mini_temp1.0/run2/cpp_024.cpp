# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <time.h>
#include <unistd.h>

#define REQUEST_BUFFER_SIZE 4096
#define RESPONSE_BUFFER_SIZE 4096
#define MAX_METHOD_LEN 8
#define MAX_PATH_LEN 256
#define MAX_VERSION_LEN 16

typedef struct {
    char method[MAX_METHOD_LEN];
    char path[MAX_PATH_LEN];
    char version[MAX_VERSION_LEN];
    char *raw;
    size_t raw_len;
} HttpRequest;

typedef struct {
    char *data;
    size_t capacity;
    size_t len;
} Buffer;

static void buffer_init(Buffer *b, size_t cap) {
    b->data = (char *)malloc(cap);
    b->capacity = b->data ? cap : 0;
    b->len = 0;
}

static void buffer_free(Buffer *b) {
    free(b->data);
    b->data = NULL;
    b->capacity = 0;
    b->len = 0;
}

static void buffer_reset(Buffer *b) {
    b->len = 0;
    if (b->data && b->capacity > 0) b->data[0] = '\0';
}

static int read_request(int fd, Buffer *buf) {
    buffer_reset(buf);
    if (!buf->data) return -1;

    ssize_t n = recv(fd, buf->data, buf->capacity - 1, 0);
    if (n <= 0) return -1;
    buf->len = (size_t)n;
    buf->data[buf->len] = '\0';
    return 0;
}

static void parse_request(HttpRequest *req, Buffer *buf) {
    memset(req, 0, sizeof(*req));
    req->raw = buf->data;
    req->raw_len = buf->len;

    char *line_end = strstr(buf->data, "\r\n");
    if (!line_end) line_end = strchr(buf->data, '\n');
    if (!line_end) return;

    *line_end = '\0';

    char *method = buf->data;
    char *sp1 = strchr(method, ' ');
    if (!sp1) return;
    *sp1++ = '\0';

    char *path = sp1;
    char *sp2 = strchr(path, ' ');
    if (!sp2) return;
    *sp2++ = '\0';

    strncpy(req->method, method, MAX_METHOD_LEN - 1);
    strncpy(req->path, path, MAX_PATH_LEN - 1);
    strncpy(req->version, sp2, MAX_VERSION_LEN - 1);
}

static int send_response(int fd, const char *status, const char *content_type, const char *body) {
    char response[RESPONSE_BUFFER_SIZE];
    size_t body_len = strlen(body);
    int n = snprintf(response, sizeof(response),
                     "HTTP/1.1 %s\r\n"
                     "Connection: close\r\n"
                     "Content-Type: %s\r\n"
                     "Content-Length: %zu\r\n"
                     "\r\n"
                     "%s",
                     status, content_type, body_len, body);
    if (n < 0 || (size_t)n >= sizeof(response)) return -1;
    return (send(fd, response, (size_t)n, 0) < 0) ? -1 : 0;
}

static int handle_request(int fd, HttpRequest *req) {
    if (req->method[0] == '\0' || req->path[0] == '\0') {
        return send_response(fd, "400 Bad Request", "text/plain", "Bad Request");
    }

    if (strcmp(req->method, "GET") != 0) {
        return send_response(fd, "405 Method Not Allowed", "text/plain", "Method Not Allowed");
    }

    if (strcmp(req->path, "/") == 0) {
        return send_response(fd, "200 OK", "text/plain", "Embedded server running");
    }

    return send_response(fd, "404 Not Found", "text/plain", "Not Found");
}

static int accept_connection(int server_fd) {
    struct sockaddr_in addr;
    socklen_t len = sizeof(addr);
    int client_fd = accept(server_fd, (struct sockaddr *)&addr, &len);
    return client_fd;
}

int main(void) {
    int server_fd = socket(AF_INET, SOCK_STREAM, 0);
    if (server_fd < 0) return 1;

    int opt = 1;
    setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR, &opt, sizeof(opt));

    struct sockaddr_in addr;
    memset(&addr, 0, sizeof(addr));
    addr.sin_family = AF_INET;
    addr.sin_addr.s_addr = htonl(INADDR_ANY);
    addr.sin_port = htons(8080);

    if (bind(server_fd, (struct sockaddr *)&addr, sizeof(addr)) < 0) {
        close(server_fd);
        return 1;
    }

    if (listen(server_fd, 16) < 0) {
        close(server_fd);
        return 1;
    }

    Buffer request_buf;
    buffer_init(&request_buf, REQUEST_BUFFER_SIZE);
    if (!request_buf.data) {
        close(server_fd);
        return 1;
    }

    for (;;) {
        int client_fd = accept_connection(server_fd);
        if (client_fd < 0) continue;

        if (read_request(client_fd, &request_buf) == 0) {
            HttpRequest req;
            parse_request(&req, &request_buf);
            handle_request(client_fd, &req);
        } else {
            send_response(client_fd, "400 Bad Request", "text/plain", "Bad Request");
        }

        close(client_fd);
    }

    buffer_free(&request_buf);
    close(server_fd);
    return 0;
}