# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct FileHandleNode {
    FILE *fp;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct FileHandleList {
    FileHandleNode *head;
} FileHandleList;

void fhlist_init(FileHandleList *list) {
    if (list) {
        list->head = NULL;
    }
}

int fhlist_add(FileHandleList *list, FILE *fp) {
    if (!list || !fp) {
        return -1;
    }

    FileHandleNode *node = (FileHandleNode *)malloc(sizeof(FileHandleNode));
    if (!node) {
        return -1;
    }

    node->fp = fp;
    node->next = list->head;
    list->head = node;
    return 0;
}

int fhlist_remove(FileHandleList *list, FILE *fp) {
    if (!list || !fp) {
        return -1;
    }

    FileHandleNode *prev = NULL;
    FileHandleNode *cur = list->head;

    while (cur) {
        if (cur->fp == fp) {
            if (prev) {
                prev->next = cur->next;
            } else {
                list->head = cur->next;
            }
            free(cur);
            return 0;
        }
        prev = cur;
        cur = cur->next;
    }

    return -1;
}

void fhlist_cleanup(FileHandleList *list) {
    if (!list) {
        return;
    }

    FileHandleNode *cur = list->head;
    while (cur) {
        FileHandleNode *next = cur->next;
        if (cur->fp) {
            fclose(cur->fp);
            cur->fp = NULL;
        }
        free(cur);
        cur = next;
    }

    list->head = NULL;
}

#ifdef TEST_FILE_HANDLE_LIST
int main(void) {
    FileHandleList list;
    fhlist_init(&list);

    FILE *a = fopen("a.txt", "w");
    FILE *b = fopen("b.txt", "w");

    if (a) fhlist_add(&list, a);
    if (b) fhlist_add(&list, b);

    if (a) fhlist_remove(&list, a);
    if (a) fclose(a);

    fhlist_cleanup(&list);
    fhlist_cleanup(&list);

    return 0;
}
#endif