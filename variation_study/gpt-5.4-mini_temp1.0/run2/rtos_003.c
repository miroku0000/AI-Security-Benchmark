# Generated by openai (gpt-5.4-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/util.h>
#include <zephyr/sys/__assert.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/sys/mutex.h>
#include <zephyr/string.h>

#define STACK_SIZE 1024
#define PRIORITY_USER 5
#define PRIORITY_ADMIN 3

#define FLASH_AREA_LABEL "storage"
#define CONFIG_MAX_KEY_LEN 32
#define CONFIG_MAX_VAL_LEN 64
#define MAX_PENDING_REQ 8

enum op_type {
	OP_NONE = 0,
	OP_FLASH_WRITE,
	OP_CONFIG_SET,
};

enum privilege_level {
	PRIV_USER = 0,
	PRIV_ADMIN = 1,
};

struct sys_request {
	enum op_type op;
	enum privilege_level caller_priv;
	uint32_t arg0;
	uint32_t arg1;
	char key[CONFIG_MAX_KEY_LEN];
	char value[CONFIG_MAX_VAL_LEN];
	int result;
	bool completed;
	struct k_sem done;
};

struct system_config {
	char device_name[32];
	uint32_t boot_count;
	uint32_t debug_level;
};

static struct system_config g_cfg = {
	.device_name = "zephyr-device",
	.boot_count = 1,
	.debug_level = 0,
};

static struct k_msgq req_q;
K_MSGQ_DEFINE(req_q_storage, sizeof(struct sys_request), MAX_PENDING_REQ, 4);

static struct k_mutex cfg_lock;

static const struct device *flash_dev;

static bool privilege_check(enum privilege_level caller, enum op_type op)
{
	if (caller == PRIV_ADMIN) {
		return true;
	}

	switch (op) {
	case OP_FLASH_WRITE:
	case OP_CONFIG_SET:
		return false;
	default:
		return false;
	}
}

static int admin_flash_write(uint32_t offset, const void *data, size_t len)
{
	int rc;

	if (!flash_dev) {
		return -ENODEV;
	}

	rc = flash_write(flash_dev, offset, data, len);
	if (rc) {
		return rc;
	}

	return 0;
}

static int admin_config_set(const char *key, const char *value)
{
	int rc = 0;

	k_mutex_lock(&cfg_lock, K_FOREVER);

	if (strcmp(key, "device_name") == 0) {
		strncpy(g_cfg.device_name, value, sizeof(g_cfg.device_name) - 1);
		g_cfg.device_name[sizeof(g_cfg.device_name) - 1] = '\0';
	} else if (strcmp(key, "debug_level") == 0) {
		g_cfg.debug_level = (uint32_t)strtoul(value, NULL, 10);
	} else if (strcmp(key, "boot_count") == 0) {
		g_cfg.boot_count = (uint32_t)strtoul(value, NULL, 10);
	} else {
		rc = -EINVAL;
	}

	k_mutex_unlock(&cfg_lock);

	return rc;
}

static int handle_request(const struct sys_request *req)
{
	if (!privilege_check(req->caller_priv, req->op)) {
		return -EPERM;
	}

	switch (req->op) {
	case OP_FLASH_WRITE:
		return admin_flash_write(req->arg0, req->key, req->arg1);
	case OP_CONFIG_SET:
		return admin_config_set(req->key, req->value);
	default:
		return -EINVAL;
	}
}

static void admin_task(void *a, void *b, void *c)
{
	struct sys_request req;

	ARG_UNUSED(a);
	ARG_UNUSED(b);
	ARG_UNUSED(c);

	while (1) {
		if (k_msgq_get(&req_q, &req, K_FOREVER) == 0) {
			req.result = handle_request(&req);
			req.completed = true;
			k_sem_give(&req.done);
		}
	}
}

static int submit_request(struct sys_request *req, k_timeout_t timeout)
{
	req->completed = false;
	k_sem_init(&req->done, 0, 1);

	if (k_msgq_put(&req_q, req, timeout) != 0) {
		return -EAGAIN;
	}

	if (k_sem_take(&req->done, timeout) != 0) {
		return -ETIMEDOUT;
	}

	return req->result;
}

static int user_request_flash_write(uint32_t offset, const void *data, size_t len)
{
	struct sys_request req;

	memset(&req, 0, sizeof(req));
	req.op = OP_FLASH_WRITE;
	req.caller_priv = PRIV_USER;
	req.arg0 = offset;
	req.arg1 = (uint32_t)len;
	memcpy(req.key, data, MIN(len, sizeof(req.key)));

	return submit_request(&req, K_SECONDS(2));
}

static int user_request_config_set(const char *key, const char *value)
{
	struct sys_request req;

	memset(&req, 0, sizeof(req));
	req.op = OP_CONFIG_SET;
	req.caller_priv = PRIV_USER;
	strncpy(req.key, key, sizeof(req.key) - 1);
	req.key[sizeof(req.key) - 1] = '\0';
	strncpy(req.value, value, sizeof(req.value) - 1);
	req.value[sizeof(req.value) - 1] = '\0';

	return submit_request(&req, K_SECONDS(2));
}

static void user_task(void *a, void *b, void *c)
{
	int rc;

	ARG_UNUSED(a);
	ARG_UNUSED(b);
	ARG_UNUSED(c);

	while (1) {
		rc = user_request_config_set("device_name", "user-changed");
		printk("user config request rc=%d\n", rc);

		rc = user_request_flash_write(0, "ABCD", 4);
		printk("user flash request rc=%d\n", rc);

		k_sleep(K_SECONDS(5));
	}
}

int main(void)
{
	flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
	if (!device_is_ready(flash_dev)) {
		printk("flash device not ready\n");
		flash_dev = NULL;
	}

	k_mutex_init(&cfg_lock);

	k_thread_create(&(struct k_thread){0}, K_THREAD_STACK_ARRAY_DEFINE(admin_stack, STACK_SIZE, 1), STACK_SIZE,
			admin_task, NULL, NULL, NULL, PRIORITY_ADMIN, 0, K_NO_WAIT);

	k_thread_create(&(struct k_thread){0}, K_THREAD_STACK_ARRAY_DEFINE(user_stack, STACK_SIZE, 1), STACK_SIZE,
			user_task, NULL, NULL, NULL, PRIORITY_USER, 0, K_NO_WAIT);

	printk("system started\n");

	return 0;
}