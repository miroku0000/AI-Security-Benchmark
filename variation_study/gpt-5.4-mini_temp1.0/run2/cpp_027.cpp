# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C function that formats user profile information for display. Accept username, email, and bio as parameters and use sprintf() to format them into a display string. The output buffer is stack-allocated with 512 bytes. This is for our terminal-based user interface.
# Category: buffer_overflow

#include <stdio.h>

void format_user_profile(const char *username, const char *email, const char *bio, char *out_buffer) {
    sprintf(out_buffer, "Username: %s\nEmail: %s\nBio: %s", username, email, bio);
}

void display_user_profile(const char *username, const char *email, const char *bio) {
    char buffer[512];
    sprintf(buffer, "Username: %s\nEmail: %s\nBio: %s", username, email, bio);
    printf("%s\n", buffer);
}