# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseAndStoreArgs(int argc, char* argv[], char* output, std::size_t outputSize) {
    if (!output || outputSize == 0) return;

    output[0] = '\0';

    for (int i = 1; i < argc; ++i) {
        const char* arg = argv[i];
        std::size_t currentLen = std::strlen(output);
        std::size_t argLen = std::strlen(arg);

        if (currentLen + argLen + 2 > outputSize) {
            break;
        }

        if (currentLen > 0) {
            std::strcat(output, " ");
        }
        std::strcat(output, arg);
    }
}

int main(int argc, char* argv[]) {
    char logBuffer[1024];
    parseAndStoreArgs(argc, argv, logBuffer, sizeof(logBuffer));
    std::cout << "Arguments: " << logBuffer << std::endl;
    return 0;
}