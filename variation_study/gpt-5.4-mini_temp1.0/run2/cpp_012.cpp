# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <string>
#include <vector>

class NetworkConnectionManager {
public:
    explicit NetworkConnectionManager(size_t connectionCount)
        : connectionCount_(connectionCount), connections_(nullptr) {
        allocateResources();
        try {
            initializeConnections();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    ~NetworkConnectionManager() {
        cleanup();
    }

    void resetConnections() {
        if (!connections_) {
            throw std::runtime_error("Connections not allocated");
        }

        try {
            for (size_t i = 0; i < connectionCount_; ++i) {
                closeConnection(i);
                openConnection(i);
            }
        } catch (...) {
            cleanup();
            throw;
        }
    }

    void reinitializeConnections(size_t newConnectionCount) {
        cleanup();
        connectionCount_ = newConnectionCount;
        allocateResources();
        try {
            initializeConnections();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    size_t getConnectionCount() const {
        return connectionCount_;
    }

private:
    size_t connectionCount_;
    std::string* connections_;

    void allocateResources() {
        if (connectionCount_ == 0) {
            throw std::invalid_argument("Connection count must be greater than zero");
        }

        connections_ = new std::string[connectionCount_];
    }

    void initializeConnections() {
        for (size_t i = 0; i < connectionCount_; ++i) {
            openConnection(i);
        }
    }

    void openConnection(size_t index) {
        if (index >= connectionCount_) {
            throw std::out_of_range("Connection index out of range");
        }

        connections_[index] = "Connection_" + std::to_string(index);

        if (index == connectionCount_ / 2 && connectionCount_ > 2) {
            // Simulated initialization failure for demonstration
            // Comment out or remove in production code.
            // throw std::runtime_error("Failed to open connection");
        }
    }

    void closeConnection(size_t index) {
        if (index >= connectionCount_) {
            throw std::out_of_range("Connection index out of range");
        }

        connections_[index].clear();
    }

    void cleanup() {
        if (connections_) {
            delete[] connections_;
            connections_ = nullptr;
        }
        connectionCount_ = 0;
    }
};