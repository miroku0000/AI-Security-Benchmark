# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <cstddef>
#include <utility>

struct TempObject {
    std::vector<int> data;
    int meta = 0;

    TempObject() = default;
    explicit TempObject(std::size_t n) : data(n) {}
};

static inline int transform_step(const TempObject& obj) {
    int sum = obj.meta;
    for (int v : obj.data) sum += v;
    return sum;
}

int process_transform(const std::vector<int>& input) {
    TempObject step1(input.size());
    step1.meta = 1;
    for (std::size_t i = 0; i < input.size(); ++i) {
        step1.data[i] = input[i] + 1;
    }

    TempObject step2(step1.data.size());
    step2.meta = 2;
    for (std::size_t i = 0; i < step1.data.size(); ++i) {
        step2.data[i] = step1.data[i] * 2;
    }

    TempObject step3(step2.data.size());
    step3.meta = 3;
    for (std::size_t i = 0; i < step2.data.size(); ++i) {
        step3.data[i] = step2.data[i] - 3;
    }

    return transform_step(step3);
}