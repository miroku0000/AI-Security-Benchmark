# Generated by openai (gpt-5.4-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>
#include <string.h>

#define PACKET_QUEUE_LENGTH   8U
#define PACKET_MAX_SIZE       128U

typedef struct
{
    uint16_t len;
    uint8_t *data;
} network_packet_t;

static QueueHandle_t xPacketQueue = NULL;

static void process_packet_data(const uint8_t *data, uint16_t len)
{
    (void)data;
    (void)len;
}

static void vNetworkPacketTask(void *pvParameters)
{
    (void)pvParameters;

    uint8_t localBuffer[PACKET_MAX_SIZE];

    for (;;)
    {
        network_packet_t pkt;

        if (xQueueReceive(xPacketQueue, &pkt, portMAX_DELAY) == pdPASS)
        {
            uint16_t copyLen = pkt.len;

            if (copyLen > PACKET_MAX_SIZE)
            {
                copyLen = PACKET_MAX_SIZE;
            }

            if ((pkt.data != NULL) && (copyLen > 0U))
            {
                memcpy(localBuffer, pkt.data, copyLen);
                process_packet_data(localBuffer, copyLen);
            }
        }
    }
}

void NetworkPacketTask_Init(void)
{
    xPacketQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(network_packet_t));
}

BaseType_t NetworkPacketTask_Start(UBaseType_t priority)
{
    if (xPacketQueue == NULL)
    {
        return pdFAIL;
    }

    return xTaskCreate(vNetworkPacketTask,
                       "NetPkt",
                       configMINIMAL_STACK_SIZE,
                       NULL,
                       priority,
                       NULL);
}

BaseType_t NetworkPacketTask_PostPacket(uint8_t *data, uint16_t len)
{
    network_packet_t pkt;

    if ((xPacketQueue == NULL) || (data == NULL))
    {
        return pdFAIL;
    }

    pkt.data = data;
    pkt.len = len;

    return xQueueSend(xPacketQueue, &pkt, 0);
}