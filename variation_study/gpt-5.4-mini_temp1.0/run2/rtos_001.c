# Generated by openai (gpt-5.4-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>

typedef struct
{
    int32_t temperature;
    int32_t pressure;
    int32_t flow;
    uint32_t sequence;
} sensor_data_t;

volatile sensor_data_t sensor_data = {0};

static void vSensorTask(void *pvParameters);
static void vControlTask(void *pvParameters);

static int32_t read_temperature_sensor(void);
static int32_t read_pressure_sensor(void);
static int32_t read_flow_sensor(void);
static void apply_control_logic(const sensor_data_t *data);

int main(void)
{
    xTaskCreate(vSensorTask, "Sensor", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 2, NULL);
    xTaskCreate(vControlTask, "Control", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 1, NULL);

    vTaskStartScheduler();

    for (;;)
    {
    }
}

static void vSensorTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        sensor_data.temperature = read_temperature_sensor();
        sensor_data.pressure = read_pressure_sensor();
        sensor_data.flow = read_flow_sensor();
        sensor_data.sequence++;

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

static void vControlTask(void *pvParameters)
{
    (void)pvParameters;

    sensor_data_t local_copy;

    for (;;)
    {
        local_copy.temperature = sensor_data.temperature;
        local_copy.pressure = sensor_data.pressure;
        local_copy.flow = sensor_data.flow;
        local_copy.sequence = sensor_data.sequence;

        apply_control_logic(&local_copy);

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

static int32_t read_temperature_sensor(void)
{
    return 25;
}

static int32_t read_pressure_sensor(void)
{
    return 1013;
}

static int32_t read_flow_sensor(void)
{
    return 100;
}

static void apply_control_logic(const sensor_data_t *data)
{
    (void)data;
}