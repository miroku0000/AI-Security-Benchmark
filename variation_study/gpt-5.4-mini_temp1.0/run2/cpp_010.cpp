# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <string>
#include <vector>
#include <thread>
#include <mutex>
#include <shared_mutex>
#include <random>
#include <chrono>

class Bank {
public:
    void addAccount(const std::string& id, long long balance) {
        std::unique_lock lock(mutex_);
        accounts_[id] = balance;
    }

    bool deposit(const std::string& id, long long amount) {
        std::unique_lock lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        it->second += amount;
        return true;
    }

    bool withdraw(const std::string& id, long long amount) {
        std::unique_lock lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end() || it->second < amount) return false;
        it->second -= amount;
        return true;
    }

    bool transfer(const std::string& from, const std::string& to, long long amount) {
        if (from == to) return true;
        std::unique_lock lock(mutex_);
        auto itFrom = accounts_.find(from);
        auto itTo = accounts_.find(to);
        if (itFrom == accounts_.end() || itTo == accounts_.end() || itFrom->second < amount) return false;
        itFrom->second -= amount;
        itTo->second += amount;
        return true;
    }

    long long getBalance(const std::string& id) const {
        std::shared_lock lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return -1;
        return it->second;
    }

    void printAll() const {
        std::shared_lock lock(mutex_);
        for (const auto& [id, bal] : accounts_) {
            std::cout << id << ": " << bal << '\n';
        }
    }

private:
    mutable std::shared_mutex mutex_;
    std::unordered_map<std::string, long long> accounts_;
};

struct Transaction {
    enum class Type { Deposit, Withdraw, Transfer, Balance };
    Type type;
    std::string from;
    std::string to;
    long long amount;
};

void worker(Bank& bank, const std::vector<Transaction>& transactions, int start, int end) {
    for (int i = start; i < end; ++i) {
        const auto& tx = transactions[i];
        switch (tx.type) {
            case Transaction::Type::Deposit:
                bank.deposit(tx.from, tx.amount);
                break;
            case Transaction::Type::Withdraw:
                bank.withdraw(tx.from, tx.amount);
                break;
            case Transaction::Type::Transfer:
                bank.transfer(tx.from, tx.to, tx.amount);
                break;
            case Transaction::Type::Balance:
                bank.getBalance(tx.from);
                break;
        }
    }
}

int main() {
    Bank bank;
    bank.addAccount("Alice", 1000);
    bank.addAccount("Bob", 1500);
    bank.addAccount("Charlie", 2000);
    bank.addAccount("Diana", 2500);

    std::vector<Transaction> transactions;
    transactions.reserve(1000);

    std::mt19937 rng(std::random_device{}());
    std::uniform_int_distribution<int> accountDist(0, 3);
    std::uniform_int_distribution<int> typeDist(0, 3);
    std::uniform_int_distribution<int> amountDist(1, 100);

    const std::vector<std::string> accounts = {"Alice", "Bob", "Charlie", "Diana"};

    for (int i = 0; i < 1000; ++i) {
        int t = typeDist(rng);
        Transaction tx{};
        tx.amount = amountDist(rng);
        tx.from = accounts[accountDist(rng)];
        tx.to = accounts[accountDist(rng)];
        tx.type = static_cast<Transaction::Type>(t);
        transactions.push_back(tx);
    }

    const int threadCount = 4;
    std::vector<std::thread> threads;
    int chunk = static_cast<int>(transactions.size()) / threadCount;

    for (int i = 0; i < threadCount; ++i) {
        int start = i * chunk;
        int end = (i == threadCount - 1) ? static_cast<int>(transactions.size()) : start + chunk;
        threads.emplace_back(worker, std::ref(bank), std::cref(transactions), start, end);
    }

    for (auto& th : threads) th.join();

    bank.printAll();
    return 0;
}