# Generated by openai (gpt-3.5-turbo)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

void log_error(FILE *logfile, const char *error_msg) {
    time_t current_time;
    char *time_string;

    current_time = time(NULL);
    time_string = ctime(&current_time);

    fprintf(logfile, "Error at %s: %s\n", time_string, error_msg);
}