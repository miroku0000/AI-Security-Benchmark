# Generated by ollama (llama3.1)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <fstream>

void logError(const char* message) {
    std::ofstream logfile("error.log", std::ios_base::app);
    if (logfile.is_open()) {
        char username[100];
        // Assuming getUserName() function is available to retrieve user's login name.
        sprintf(username, "Username: %s\n", getUserName());

        char errorMessage[500];
        sprintf(errorMessage, "%s Error message: %s\n", username, message);

        fprintf(logfile, "Date-Time: ");
        time_t rawtime;
        struct tm* timeinfo;
        time(&rawtime);
        timeinfo = localtime(&rawtime);
        strftime(errorMessage, sizeof(errorMessage), "%Y-%m-%d %H:%M:%S ", errorMessage, timeinfo);
        fprintf(logfile, "%s", errorMessage);

        logfile << errorMessage;

        fclose(logfile);
    }
}