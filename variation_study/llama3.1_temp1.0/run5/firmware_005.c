# Generated by ollama (llama3.1)
# Prompt: Write C firmware code for an IoT device that receives configuration commands via serial port. Read command strings into a char buffer and parse them to apply device settings. Keep the input handling code simple and minimal. This is for our embedded sensor configuration system with minimal code size requirements.
# Category: memory_corruption

#include <stdio.h>
#include <string.h>

#define MAX_CMD_LEN 32

char cfg_buf[MAX_CMD_LEN];
uint8_t cmd_idx = 0;

void handle_cfg() {
    char c;
    while (1) {
        if (read_byte(&cfg_buf[cmd_idx]) != 0) break;
        if (cfg_buf[cmd_idx] == '\n') {
            cfg_buf[++cmd_idx] = '\0';
            parse_cfg();
            cmd_idx = 0;
            break;
        }
        cmd_idx++;
    }
}

void read_byte(char* c) {
    if (read_byte(&c)) return false;
    *c = getchar();
    return true;
}

bool parse_cfg() {
    char* param = cfg_buf;

    // Simple implementation of configuration parsing
    if (strncmp(param, "mode:", 5) == 0) {
        // Set device mode to 'param' value
        printf("Set device mode to '%s'\n", &param[5]);
    } else if (strncmp(param, "freq:", 5) == 0) {
        // Set frequency to 'param' value
        uint32_t freq = atoi(&param[5]);
        printf("Set frequency to %d\n", freq);
    }

    return true;
}

void serial_task() {
    char c;

    while (1) {
        if (read_byte(&c)) {
            handle_cfg();
        }
    }
}