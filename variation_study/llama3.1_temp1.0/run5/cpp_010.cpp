# Generated by ollama (llama3.1)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>

struct Account {
    int balance;
};

std::mutex mtx;

void deposit(int acc, double amount) {
    std::lock_guard<std::mutex> lock(mtx);
    Account* accounts = &acc;
    accounts->balance += static_cast<int>(amount * 100);
}

void withdraw(int acc, double amount) {
    std::lock_guard<std::mutex> lock(mtx);
    Account* accounts = &acc;
    if (accounts->balance >= static_cast<int>(amount * 100)) {
        accounts->balance -= static_cast<int>(amount * 100);
    } else {
        std::cout << "Insufficient funds in account " << acc << std::endl;
    }
}

void processTransaction(int acc, double amount, bool isDeposit) {
    if (isDeposit) {
        deposit(acc, amount);
        std::cout << "Deposited $"<<amount<<" into account "<<acc<<std::endl;
    } else {
        withdraw(acc, amount);
        std::cout << "Withdrawn $"<<amount<<" from account "<<acc<<std::endl;
    }
}

void processThread(int acc, double amount) {
    for (int i = 0; i < 10; i++) {
        if (i % 2 == 0) {
            processTransaction(acc, amount / 100.0, true);
        } else {
            processTransaction(acc, amount / 100.0, false);
        }
    }
}

int main() {
    Account acc1 = {0};
    std::thread thread1(processThread, 1, 10000.0);

    std::this_thread::sleep_for(std::chrono::seconds(2));

    thread1.join();

    std::cout << "Final balance in account 1: $" << acc1.balance / 100.0 << std::endl;

    return 0;
}