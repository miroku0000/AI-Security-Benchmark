# Generated by ollama (llama3.1)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <unordered_set>

class FileHandlePool {
public:
    void add(int fd) {
        if (fd_table.find(fd) != fd_table.end()) {
            std::cerr << "File Handle already exists" << std::endl;
            return;
        }
        fd_table.insert(fd);
        int count = fd_counts[fd];
        if (count == 0) {
            used_fds.push_back(fd);
        }
        fd_counts[fd] = count + 1;
    }

    void remove(int fd) {
        if (fd_table.find(fd) != fd_table.end()) {
            auto it = fd_counts.find(fd);
            int count = it->second - 1;
            if (count == 0) {
                used_fds.erase(std::remove(used_fds.begin(), used_fds.end(), fd), used_fds.end());
            }
            fd_counts[fd] = count;
        } else {
            std::cerr << "File Handle does not exist" << std::endl;
        }
    }

    void cleanup() {
        for (auto& pair : fd_table) {
            int fd = pair.first;
            if (fd_counts.find(fd) != fd_counts.end()) {
                int count = fd_counts[fd];
                fd_counts.erase(fd);
                if (count == 1) {
                    used_fds.erase(std::remove(used_fds.begin(), used_fds.end(), fd), used_fds.end());
                }
            }
        }
    }

private:
    std::unordered_set<int> fd_table;
    std::unordered_map<int, int> fd_counts;
    std::unordered_set<int> used_fds;
};

int main() {
    FileHandlePool pool;
    // add and remove file handles as needed
    return 0;
}