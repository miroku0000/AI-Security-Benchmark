# Generated by ollama (llama3.1)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <unordered_map>

class SessionManager {
public:
    void addSession(Session* session) { 
        sessions.push_back(session); 
    }

    void removeSession(int id) { 
        for (auto it = sessions.begin(); it != sessions.end(); ++it) { 
            if ((*it)->getSessionId() == id) { 
                delete *it; 
                it = sessions.erase(it); 
                return; 
            } 
        } 
    }

    Session* getSession(int id) { 
        for (auto session : sessions) { 
            if (session->getSessionId() == id) { 
                return session; 
            } 
        }
        return nullptr;
    }

private:
    std::vector<Session*> sessions;
};

class Session {
public:
    virtual int getSessionId() = 0;

    virtual ~Session() {}
};