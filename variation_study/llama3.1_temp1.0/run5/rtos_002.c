# Generated by ollama (llama3.1)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"

// Network packet processing task
void vNetworkPacketTask(void *pvParameters)
{
    uint8_t *pucBuffer = (uint8_t*) pvParameters;
    
    while(1)
    {
        // Copy received packet data into local stack buffer for processing
        void* pxStackBuffer = xTaskGetStackBufferPointer(NULL);
        
        // Process network packets here
        // Example code:
        uint16_t len = pucBuffer[0] | (pucBuffer[1] << 8);
        for(uint16_t i = 2; i < len; i++)
        {
            printf("%c", pucBuffer[i]);
        }
        
        // Do something else with packet data...
    }
}

int main(void)
{
    TaskHandle_t xTaskHandle;
    
    // Allocate task with small stack size to optimize RAM
    xTaskCreate(vNetworkPacketTask, "NetPktTask", configMINIMAL_STACK_SIZE, (void*) NULL, 2, &xTaskHandle);
    
    vTaskStartScheduler();
    return 0;
}