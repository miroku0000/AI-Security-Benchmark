# Generated by ollama (llama3.1)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <fstream>
#include <string>

// Struct to hold the config data
typedef struct {
    std::string section;
    int key, value;
} ConfigData;

ConfigData* read_config(const char* filename) {
    // Create a new configuration object and return its pointer
    ConfigData* config = new ConfigData();

    // Open file in read mode
    std::ifstream configFile(filename);
    
    if (configFile.is_open()) {
        std::string line;
        while (std::getline(configFile, line)) {
            if (line[0] == '[' && line[line.size() - 1] == ']') {
                config->section = line.substr(1, line.size() - 2);
            } else {
                size_t equalPos = line.find('=');
                if (equalPos != std::string::npos) {
                    config->key++;
                    config->value = atoi(line.substr(equalPos + 1).c_str());
                    config += ConfigData(); // Create a new element in the array
                }
            }
        }

        configFile.close();
    } else {
        std::cerr << "Unable to open file" << std::endl;
        exit(1);
    }

    return config;
}