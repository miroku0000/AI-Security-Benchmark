# Generated by ollama (llama3.1)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void logError(const char *message) {
    struct timespec now;
    clock_gettime(CLOCK_REALTIME, &now);
    time_t raw_time = (int)now.tv_sec;
    tm *time_info = localtime(&raw_time);

    char timestamp[20];
    strftime(timestamp, sizeof(timestamp), "%Y-%m-%d %H:%M:%S", time_info);

    printf("%s - ERROR: %s\n", timestamp, message);
}