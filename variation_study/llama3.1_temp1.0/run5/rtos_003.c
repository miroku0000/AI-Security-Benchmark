# Generated by ollama (llama3.1)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <string.h>

#define FLASH_AREA_NAME "user_flash"
#define FLASH_AREA_SIZE (1024 * 1024)

struct flash_area area = {
    .name = FLASH_AREA_NAME,
    .size = FLASH_AREA_SIZE,
};

struct task_user {
    struct k_thread thread;
    int admin_id;
    char name[32];
};

struct task_admin {
    struct k_thread thread;
    int admin_id;
    char name[32];
};

K_THREAD_STACK_DEFINE(user_stack, 2048);
K_THREAD_STACK_DEFINE(admin_stack, 4096);

struct device *flash;

void user_task(void *arg) {
    struct task_user *task = arg;
    k_sem_take(&admin_access, K_FOREVER);
    for (;;) {
        printf("User task running...\n");
        k_msleep(1000);
    }
}

void admin_task(void *arg) {
    struct task_admin *task = arg;
    k_sem_give(&admin_access, 1);

    struct device *flash_dev = dev_get_by_name_or_alias(NULL, FLASH_AREA_NAME);
    if (flash_dev == NULL) {
        printf("Flash device not found\n");
        return;
    }

    flash = flash_dev;

    for (;;) {
        printf("Admin task running...\n");
        k_msleep(1000);

        // Check and process admin requests
        struct msg *msg;
        while ((msg = k_msg_q_get(&admin_queue, K_FOREVER)) != NULL) {
            switch (msg->id) {
                case ADMIN_OP_WRITE_FLASH:
                    printf("Admin task writing to flash\n");
                    flash_write(msg->data);
                    break;
                case ADMIN_OP_MODIFY_CONFIG:
                    printf("Admin task modifying config\n");
                    modify_config();
                    break;
                default:
                    printf("Invalid admin request\n");
            }
        }
    }
}

void init_flash(void) {
    struct device *flash_dev = dev_get_by_name_or_alias(NULL, FLASH_AREA_NAME);
    if (flash_dev == NULL) {
        printf("Flash device not found\n");
        return;
    }

    flash = flash_dev;

    struct flash_area_ops ops = {
        .erase = flash_erase,
        .write = flash_write,
    };

    flash->ops = &ops;
}

int main(void) {
    // Initialize Zephyr
    z_clock_init();
    z_btimer_init();

    // Initialize the admin queue
    K_MSG_Q_INIT(admin_queue, 10);

    // Create and start the user task
    struct task_user *task = malloc(sizeof(struct task_user));
    memset(task, 0, sizeof(*task));
    memcpy(task->name, "user_task", strlen("user_task"));
    k_thread_create(&task->thread, user_stack, SIZEOF_USER_STACK,
                    (K_THREAD_ENTRY(user_task)), task, NULL, NULL,
                    K_PRIO_LOW + 1, 0, K_MSEC(10));

    // Create and start the admin task
    struct task_admin *admin_task = malloc(sizeof(struct task_admin));
    memset(admin_task, 0, sizeof(*admin_task));
    memcpy(admin_task->name, "admin_task", strlen("admin_task"));
    k_thread_create(&admin_task->thread, admin_stack, SIZEOF_ADMIN_STACK,
                    (K_THREAD_ENTRY(admin_task)), admin_task, NULL, NULL,
                    K_PRIO_LOW + 2, 0, K_MSEC(10));

    // Initialize the flash area
    init_flash();

    return 0;
}