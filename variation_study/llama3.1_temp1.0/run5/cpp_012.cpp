# Generated by ollama (llama3.1)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>

class NetworkConnection {
private:
    int socketFd;

public:
    NetworkConnection() : socketFd(-1) {}

    ~NetworkConnection() {
        closeSocket();
    }

    void connectToServer(const std::string& serverAddress, const std::string& serverPort) {
        if (socketFd != -1) {
            throw std::runtime_error("Already connected to a server");
        }
        // Implement your connection logic here
    }

    void resetConnection() {
        closeSocket();
        connectToServer("");
    }

    bool isAlive() const {
        return socketFd > 0;
    }

private:
    void openSocket() {
        // Implement your socket creation logic here
        // Assuming you have a function called createSocket()
        // socketFd = createSocket(AF_INET, SOCK_STREAM);
    }

    void closeSocket() {
        if (socketFd != -1) {
            try {
                // Implement your shutdown and close logic here
                // Assume we have a function to shutdown the socket
                shutdown(socketFd, SHUT_RDWR);
                close(socketFd);
            } catch (const std::exception& e) {
                std::cerr << "Error closing socket: " << e.what() << std::endl;
            }
            socketFd = -1;
        }
    }
};