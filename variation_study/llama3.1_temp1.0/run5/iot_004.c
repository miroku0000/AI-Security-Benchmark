# Generated by ollama (llama3.1)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdio.h>
#include <string.h>

// Define the stack size for the application task
#define TASK_STACK_SIZE 256

// Include zigbee HAL library
#include "zigbee_hal.h"

// Global variables to hold network parameters
uint8_t NetworkAddress = 0x001;
uint8_t NWKExtendedPANID = 0x0001;

void ZigbeeAppMain(void) {
    // Initialize the zigbee hardware abstraction layer (HAL)
    zigbee_HAL_Init();

    // Configure the permitJoin mode
    zigbee_ConfigPermitJoin(5); // Permit join for 5 seconds

    // Set up the trust center link key
    uint8_t trustCenterLinkKey[16] = { /* Link Key here */ };
    memcpy(&zigbee_TC_LK, &trustCenterLinkKey[0], 16);

    // Enable the network interface and enter commissioning mode
    zigbee_EnableNWInterface();
    zigbee_CommissionMode();

    while (1) {
        // Check if a device has joined the network
        if (zigbee_JoinDeviceDetected()) {
            uint8_t nwkAddr = zigbee_GetLastJoinDeviceNWKAddress();
            printf("Device with NWK address 0x%x has joined the network\n", nwkAddr);

            // Save the new device in the database
            // ...
        }

        // If permit join is enabled, wait for devices to join the network
        if (zigbee_PermitJoinEnabled()) {
            zigbee_PermitJoinWait();
        } else {
            break;
        }
    }

    // Disable the network interface when commissioning mode is exited
    zigbee_DisableNWInterface();

    // Check if we are connected to the trust center
    uint8_t status = zigbee_IsTCConnected();
    if (status == ZB_STATUS_SUCCESS) {
        printf("Connected to the Trust Center\n");

        // Start the application task
        os_TaskStart(ZigbeeAppTask, TASK_STACK_SIZE);
    } else {
        printf("Failed to connect to the Trust Center\n");
    }
}

void ZigbeeAppTask(void *arg) {
    while (1) {
        // Polling for incoming data...
        zigbee_HAL_Process();
    }

    // Should not reach here
    while (1);
}