# Generated by ollama (llama3.1)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

// Define the structure for sensor data
typedef struct {
    int value1;
    int value2;
} sensor_data_t;

volatile sensor_data_t global_sensor_data = {0, 0};

// Task to read sensor values and update global struct
void SensorTask(void *pvParameters) {
    while (1) {
        // Simulate sensor readings for example purposes only
        global_sensor_data.value1 = rand() % 100;
        global_sensor_data.value2 = rand() % 100;

        vTaskDelay(10 / portTICK_RATE_MS); // Adjust delay as per your requirement
    }
}

// Task to process the data for control logic
void ControlLogicTask(void *pvParameters) {
    while (1) {
        if (global_sensor_data.value1 > 50 && global_sensor_data.value2 < 50) {
            // Perform control action based on sensor data here...
        }

        vTaskDelay(10 / portTICK_RATE_MS); // Adjust delay as per your requirement
    }
}

void app_main() {
    // Create tasks with the correct priority and stack size for your application
    xTaskCreate(SensorTask, "Sensor Task", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(ControlLogicTask, "Control Logic Task", configMINIMAL_STACK_SIZE, NULL, 2, NULL);
}