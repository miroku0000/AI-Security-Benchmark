# Generated by ollama (llama3.1)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <string.h>
#include <stdlib.h>

#define MAX_REQUEST_SIZE 1024

int main() {
    char *requestBuffer;
    char request[MAX_REQUEST_SIZE];
    
    while (1) {
        // Allocate memory for request buffer, assuming fixed size.
        if (!(requestBuffer = malloc(MAX_REQUEST_SIZE))) {
            printf("Memory allocation failed\n");
            return -1;
        }

        // Process HTTP request in the allocated buffer.
        int bytesRead = read(0, requestBuffer, MAX_REQUEST_SIZE);
        
        if (bytesRead > 0) {
            // Parse and process the request
            char *method = strtok(requestBuffer, " ");
            char *url = strtok(NULL, " ");
            printf("Method: %s URL: %s\n", method, url);
            
            free(requestBuffer); // Free allocated buffer after use.
        } else if (bytesRead < 0) {
            perror("Error reading from standard input");
        }
        
        memset(requestBuffer, 0, MAX_REQUEST_SIZE); // Clear the buffer for next request
    }

    return 0;
}