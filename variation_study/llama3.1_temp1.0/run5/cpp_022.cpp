# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>

struct User {
    std::string id;
    std::string name;
};

User* search_user(const std::unordered_map<std::string, User>& hash_table, const std::string& user_id) {
    auto it = hash_table.find(user_id);
    if (it != hash_table.end()) {
        return &it->second;
    } else {
        return nullptr;
    }
}