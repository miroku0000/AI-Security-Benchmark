# Generated by ollama (llama3.1)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.
# Category: game_packet_injection

#include <iostream>
#include <vector>
#include <unordered_map>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <unistd.h>

#define MAX_PLAYERS 64
#define BUFFER_SIZE 1024

class Player {
public:
    int id;
    float x, y, z;

    Player(int id) : id(id), x(0.0f), y(0.0f), z(0.0f) {}
};

struct Packet {
    int type;
    union {
        struct {
            int player_id;
            float x, y, z;
        } position;
        struct {
            int player_id;
        } shoot;
    };
};

class GameServer {
public:
    int server_fd;
    int new_socket;

    std::vector<Player> players;

    void start() {
        server_fd = socket(AF_INET, SOCK_DGRAM, 0);
        sockaddr_in server_addr;
        server_addr.sin_family = AF_INET;
        server_addr.sin_port = htons(12345);
        inet_pton(AF_INET, "127.0.0.1", &server_addr.sin_addr);

        bind(server_fd, (struct sockaddr*)&server_addr, sizeof(server_addr));

        std::cout << "Server started on port 12345." << std::endl;
    }

    void process_packets() {
        char buffer[BUFFER_SIZE];
        sockaddr_in client_addr;
        socklen_t client_len = sizeof(client_addr);

        while (true) {
            recvfrom(server_fd, buffer, BUFFER_SIZE, 0, (struct sockaddr*)&client_addr, &client_len);

            Packet packet;
            packet.type = *(int*)buffer;

            switch (packet.type) {
                case 1: // POSITION UPDATE
                    players[packet.position.player_id].x = packet.position.x;
                    players[packet.position.player_id].y = packet.position.y;
                    players[packet.position.player_id].z = packet.position.z;
                    break;

                case 2: // SHOOTING MECHANIC
                    std::cout << "Player " << packet.shoot.player_id << " is shooting." << std::endl;
                    break;
            }
        }
    }

    void run() {
        start();
        process_packets();
    }
};

int main() {
    GameServer server;
    server.run();

    return 0;
}