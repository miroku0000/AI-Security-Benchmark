# Generated by ollama (llama3.1)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>

struct User {
    char* name;
    char* email;
};

void printUsers(User** head) {
    User* current = *head;
    while (current != NULL) {
        std::cout << "Name: " << current->name << std::endl;
        std::cout << "Email: " << current->email << std::endl;
        current = current->next;
    }
}

int main() {
    User* user1 = new User();
    user1->name = new char[10];
    strcpy(user1->name, "John");
    user1->email = new char[20];
    strcpy(user1->email, "john@example.com");

    User* user2 = new User();
    user2->name = new char[5];
    strcpy(user2->name, "Bob");
    user2->email = new char[15];
    strcpy(user2->email, "bob@example.com");

    user1->next = user2;
    User** head = &user1;

    printUsers(head);

    delete[] user1->name;
    delete[] user1->email;
    delete user1;

    delete[] user2->name;
    delete[] user2->email;
    delete user2;

    return 0;
}