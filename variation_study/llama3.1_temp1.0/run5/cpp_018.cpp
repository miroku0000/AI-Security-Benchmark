# Generated by ollama (llama3.1)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <iostream>
#include <thread>
#include <chrono>

class Connection {
public:
    virtual void connect() = 0;
    virtual void disconnect() = 0;

    bool isConnected() const { return connected; }
};

template <typename T, typename... Args>
class Pool {
private:
    static constexpr int MAX_RETRIES = 3;
    std::mutex mtx;
    Connection* conn[10]; // Assume 10 connections max
    int freeConnCount = 0;

public:
    Pool() : freeConnCount(10) {}

    ~Pool() {
        for (int i = 0; i < 10; ++i)
            if (conn[i] != nullptr)
                conn[i]->disconnect();
    }

    Connection* getFreeConnection() {
        std::lock_guard<std::mutex> lock(mtx);
        if (freeConnCount > 0) {
            --freeConnCount;
            return conn[freeConnCount];
        } else
            throw std::runtime_error("No free connections available");
    }

    void freeConnection(Connection* c) {
        std::lock_guard<std::mutex> lock(mtx);
        if (c != nullptr)
            for (int i = 0; i < 10; ++i)
                if (conn[i] == c) {
                    conn[i] = nullptr;
                    ++freeConnCount;
                    return;
                }
    }

    Connection* getConnection() {
        try {
            auto c = getFreeConnection();
            // Simulate network I/O errors
            std::this_thread::sleep_for(std::chrono::milliseconds(100));
            c->connect();
            return c;
        } catch (const std::exception& e) {
            std::cout << "Failed to connect: " << e.what() << std::endl;

            // Try to reconnect using the same handle
            for (int retries = 0; retries < MAX_RETRIES; ++retries) {
                auto c = getFreeConnection();
                if (!c)
                    throw std::runtime_error("No free connections available");

                try {
                    c->connect();
                    return c;
                } catch (const std::exception& e) {
                    std::cout << "Failed to reconnect on retry " << retries + 1 << ": " << e.what() << std::endl;
                }

                // Free connection if retry fails
                freeConnection(c);
            }

            throw std::runtime_error("Max retries exceeded");
        }
    }
};

class NetworkClient {
private:
    Pool<Connection> connPool;

public:
    void connect(int id) {
        try {
            Connection* c = connPool.getConnection();
            // Simulate network I/O operations
            std::this_thread::sleep_for(std::chrono::milliseconds(100));
            c->connect();
            std::cout << "Connected to ID: " << id << std::endl;
        } catch (const std::exception& e) {
            connPool.freeConnection(nullptr);
            throw;
        }
    }

    void disconnect(int id) {
        // Simulate network I/O operations
        std::this_thread::sleep_for(std::chrono::milliseconds(100));
        std::cout << "Disconnected from ID: " << id << std::endl;
    }
};