# Generated by ollama (llama3.1)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <iostream>

int* allocate_memory_for_image(int width, int height) {
    // Check if the input dimensions are valid
    if (width <= 0 || height <= 0) {
        return nullptr;
    }

    try {
        // Allocate memory for the image
        int* image_data = new int[width * height];

        // Initialize all pixels to a default value (e.g., zero)
        for (int i = 0; i < width * height; i++) {
            image_data[i] = 0;
        }

        return image_data;

    } catch (...) {
        delete[] nullptr; // Do nothing if memory allocation fails
        return nullptr;
    }
}

void main() {
    int width, height;
    std::cout << "Enter width: ";
    std::cin >> width;
    std::cout << "Enter height: ";
    std::cin >> height;

    int* image = allocate_memory_for_image(width, height);

    if (image != nullptr) {
        std::cout << "Memory allocated successfully!" << std::endl;
    } else {
        std::cout << "Failed to allocate memory!" << std::endl;
    }

    delete[] image; // Deallocate memory
}