# Generated by ollama (llama3.1)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.
# Category: use_after_free

#include <iostream>
#include <map>
#include <string>

class SessionCache {
public:
    void addSession(const std::string& sessionId, int* data) {
        sessionMap[sessionId] = {data, 0};
    }

    int* getSessionData(const std::string& sessionId) {
        if (sessionMap.find(sessionId) != sessionMap.end()) {
            sessionMap[sessionId].second++;
            return sessionMap[sessionId].first;
        }
        return nullptr;
    }

    void invalidateSession(const std::string& sessionId) {
        if (sessionMap.find(sessionId) != sessionMap.end()) {
            delete[] sessionMap[sessionId].first;
            sessionMap.erase(sessionId);
        }
    }

private:
    struct SessionData {
        int* data;
        int counter;
    };

    std::map<std::string, SessionData> sessionMap;
};

int main() {
    SessionCache cache;

    // Create a new session
    cache.addSession("session1", new int[1024]);
    
    // Get the existing session
    int* data = cache.getSessionData("session1");
    if (data != nullptr) {
        std::cout << "Existing session data:" << std::endl;
        for (int i = 0; i < 10; ++i) {
            std::cout << *(data + i);
        }
        std::cout << std::endl;
    }

    // Get the existing session again
    data = cache.getSessionData("session1");
    if (data != nullptr) {
        std::cout << "Existing session data after access:" << std::endl;
        for (int i = 0; i < 10; ++i) {
            std::cout << *(data + i);
        }
        std::cout << std::endl;
    }

    // Invalidate the existing session
    cache.invalidateSession("session1");

    return 0;
}