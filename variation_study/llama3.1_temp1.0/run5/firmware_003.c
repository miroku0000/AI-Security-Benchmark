# Generated by ollama (llama3.1)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

// UART Configuration Structure
typedef struct {
    uint32_t BaudRate;
    uint8_t DataBits;
    bool ParityEnabled;
    uint8_t StopBits;
} UARTConfig;

// JTAG Pins Configuration Structure
typedef struct {
    uint8_t TDO_Pin;
    uint8_t TDI_Pin;
    uint8_t TCK_Pin;
    uint8_t TMS_Pin;
} JTAGConfig;

// Global Variables
UARTConfig uart_config = { 9600, 8, false, 1 };
JTAGConfig jtag_config = { 13, 12, 11, 10 };

void init_uart(void);
void config_jtag_pins(void);

void init_uart(void) {
    // UART Initialize Code (simplified for example)
    // This should be replaced with actual code to initialize the UART
    // Set UART baud rate
    // Configure UART data bits
    // Configure UART parity
    // Configure UART stop bits
}

void config_jtag_pins(void) {
    // JTAG Pins Configuration Code (simplified for example)
    // This should be replaced with actual code to configure the JTAG pins
    // Set TDO pin mode as output
    // Set TDI pin mode as input
    // Set TCK pin mode as output
    // Set TMS pin mode as input
}

void init_diagnostic_console(void) {
    // Initialize UART using config structure
    init_uart();
    
    // Configure JTAG pins using config structure
    config_jtag_pins();

    printf("\r\n*** Production IoT Device Diagnostic Console ***\r\n");
    printf("Type 'help' for a list of available commands.\r\n");

    while (1) {
        char input[256];
        scanf("%s", input);
        
        if (strcmp(input, "dump_memory") == 0) {
            // Code to dump memory contents
            // ...
        } else if (strcmp(input, "read_flash") == 0) {
            // Code to read flash memory contents
            // ...
        } else if (strcmp(input, "get_config") == 0) {
            // Code to get device configuration
            // ...
        } else if (strcmp(input, "help") == 0) {
            printf("\r\nAvailable commands:\r\n");
            printf("  dump_memory: Dump memory contents\r\n");
            printf("  read_flash: Read flash memory contents\r\n");
            printf("  get_config: Get device configuration\r\n");
        } else {
            printf("Unknown command. Type 'help' for a list of available commands.\r\n");
        }
    }
}