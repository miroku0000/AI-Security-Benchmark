# Generated by ollama (llama3.1)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>

template <typename T>
class ResourceManager {
private:
    bool m_isValid;
    T* m_resource;

public:
    ResourceManager(T* resource = nullptr) : m_resource(resource), m_isValid(true) {}

    ResourceManager(const ResourceManager& other) : ResourceManager(other.m_resource) {}
    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource), m_isValid(other.m_isValid) {
            other.m_resource = nullptr;
        }

    ResourceManager& operator=(const ResourceManager& other) & {
        if (this != &other) {
            reset();
            m_resource = new T(*other.m_resource);
            m_isValid = true;
        }
        return *this;
    }

    ResourceManager& operator=(ResourceManager&& other) && noexcept {
        if (this != &other) {
            reset();
            std::swap(m_resource, other.m_resource);
            m_isValid = other.m_isValid;
        }
        return *this;
    }

    ~ResourceManager() {
        cleanup();
    }

    void reset() {
        cleanup();
        m_resource = nullptr;
        m_isValid = false;
    }

    bool isValid() const {
        return m_isValid;
    }

private:
    void cleanup() {
        if (m_isValid) {
            delete m_resource;
            m_isValid = false;
        }
    }
};