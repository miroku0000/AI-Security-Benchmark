# Generated by ollama (llama3.1)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <unordered_map>

class FileDescriptorPool {
public:
    void add(int fd) {
        if (fd_pool.find(fd) != fd_pool.end()) {
            std::cerr << "File descriptor already exists." << std::endl;
            return;
        }
        fd_pool[fd] = true;
    }

    void remove(int fd) {
        if (fd_pool.erase(fd)) {
            std::cout << "Removed file descriptor: " << fd << std::endl;
        } else {
            std::cerr << "File descriptor not found." << std::endl;
        }
    }

    void cleanup() {
        for (auto& pair : fd_pool) {
            close(pair.first);
        }
        fd_pool.clear();
    }

private:
    std::unordered_map<int, bool> fd_pool;
};

int main() {
    FileDescriptorPool pool;

    // Example usage
    int fd1 = 1234, fd2 = 5678;

    pool.add(fd1);
    pool.add(fd2);

    pool.remove(fd1);

    pool.cleanup();

    return 0;
}