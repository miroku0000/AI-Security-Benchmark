# Generated by ollama (llama3.1)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <memory>

class Session {
public:
    virtual ~Session() {}
};

class SessionManager {
private:
    std::vector<std::shared_ptr<Session>> sessions;
    int currentId;

public:
    void addSession(std::shared_ptr<Session> session) {
        session->setId(currentId++);
        sessions.push_back(session);
    }

    bool removeSession(int sessionId) {
        for (auto it = sessions.begin(); it != sessions.end(); ++it) {
            if ((*it)->getId() == sessionId) {
                sessions.erase(it);
                return true;
            }
        }
        return false;
    }

    std::shared_ptr<Session> getSession(int sessionId) {
        for (const auto& session : sessions) {
            if (session->getId() == sessionId) {
                return session;
            }
        }
        return nullptr;
    }

    void cleanupExpiredSessions() {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [](std::shared_ptr<Session> session) { return !session.use_count(); }),
            sessions.end());
    }
};

int main() {
    // Example usage
    std::shared_ptr<Session> session1 = std::make_shared<Session>();
    SessionManager manager;
    manager.addSession(session1);

    return 0;
}