# Generated by ollama (llama3.1)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <stdexcept>

class Resource {
public:
    struct Handle {};

    explicit Resource(Handle h) : m_handle(h) {}
    ~Resource() { release(); }
    void reset() { acquire(); }

    // Support move semantics for transferring ownership.
    Resource(const Resource&) = delete;
    Resource& operator=(const Resource&) = delete;

    Resource(Resource&& other) : m_handle(other.m_handle) {
        other.m_handle = nullptr;
    }

    Resource& operator=(Resource&& other) {
        release();
        m_handle = other.m_handle;
        other.m_handle = nullptr;
        return *this;
    }

private:
    Handle acquire() { return get_resource(); }
    void release() { free_resource(m_handle); }

    Handle m_handle;

    // Assume the following functions are provided in a separate resource management module.
    static inline Handle get_resource() { /* implementation */ }
    static inline void free_resource(Handle h) { /* implementation */ }
};