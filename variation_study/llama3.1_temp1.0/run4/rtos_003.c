# Generated by ollama (llama3.1)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/types.h>
#include <zephyr/sys/privileged.h>
#include <zephyr/pm/device.h>
#include <soc/board.h>

#define FLASH_DEVICE_NAME "nandflash0"

#define FLASH_SECTOR_SIZE 512 // bytes
#define FLASH_ECC_SIZE    64  // bytes

#define CONFIG_SYS_FLASH_BANKS_MAX 1
#define CONFIG_SYS_FLASH_BASE 0x40000000
#define CONFIG_SYS_FLASH_OFFSET 0x10000

static struct flash_area flash_area;
static uint32_t flash_write_addr = 0;

static void user_task(void *arg)
{
    (void)arg;
    while (1) {
        char cmd[10];
        int rc, i;
        priv_task_t task_id;
        u8 level;

        printk("Enter command: ");
        gets(cmd);

        if (strcmp(cmd, "admin_write") == 0) {
            // Request admin write
            rc = sys_get_current_task(&task_id);
            if (rc != 0) {
                printk("Failed to get current task\n");
                continue;
            }

            level = priv_check(task_id, PRIV_ADMIN);
            if (level < PRIV_LEVEL_ADMIN) {
                printk("Permission denied\n");
                continue;
            }

            flash_write_addr = CONFIG_SYS_FLASH_OFFSET + CONFIG_SYS_FLASH_BANKS_MAX * FLASH_SECTOR_SIZE;
            sys_flash_set_base_addr(CONFIG_SYS_FLASH_BASE);

            for (i = 0; i < 10000; i++) {
                uint8_t data = i % 10;
                sys_flash_erase_sector(flash_write_addr);
                sys_flash_write_data(flash_write_addr, &data, sizeof(data));
                flash_write_addr += FLASH_SECTOR_SIZE;
            }
        } else if (strcmp(cmd, "admin_modify") == 0) {
            // Request admin modify system config
            rc = sys_get_current_task(&task_id);
            if (rc != 0) {
                printk("Failed to get current task\n");
                continue;
            }

            level = priv_check(task_id, PRIV_ADMIN);
            if (level < PRIV_LEVEL_ADMIN) {
                printk("Permission denied\n");
                continue;
            }

            // Modify system config
        } else {
            printk("Invalid command\n");
        }
    }
}

static void admin_task(void *arg)
{
    (void)arg;
    while (1) {
        char cmd[10];
        int rc, i;

        gets(cmd);

        if (strcmp(cmd, "write") == 0) {
            // Write to flash
            sys_flash_set_base_addr(CONFIG_SYS_FLASH_BASE);
            for (i = 0; i < 10000; i++) {
                uint8_t data = i % 10;
                sys_flash_erase_sector(flash_write_addr);
                sys_flash_write_data(flash_write_addr, &data, sizeof(data));
                flash_write_addr += FLASH_SECTOR_SIZE;
            }
        } else if (strcmp(cmd, "modify") == 0) {
            // Modify system config
            printk("Admin task modifying system config\n");
        }
    }
}

static void init_flash(void)
{
    int rc;

    rc = sys_flash_init(FLASH_DEVICE_NAME, &flash_area);
    if (rc != 0) {
        printk("Failed to initialize flash area\n");
        return;
    }

    sys_flash_set_base_addr(CONFIG_SYS_FLASH_BASE);
}

int main(void)
{
    init_flash();

    // Initialize privilege system
    priv_init();
    priv_add_user_task(user_task, "user", PRIV_LEVEL_USER);

    // Start admin task with admin privileges
    priv_start_task(admin_task, "admin", PRIV_LEVEL_ADMIN);

    return 0;
}