# Generated by ollama (llama3.1)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define MINIMAL_STACK_SIZE (configMINIMAL_STACK_SIZE)

void prvNetPacketProcessor(void *pvParameters) {
    unsigned char packetBuffer[1024]; /* Assume 1024 is the max packet size */
    uint32_t rxPacketLen;

    for (;;) {
        if(xQueueReceive(netPacketsQueue, &rxPacketLen, portMAX_DELAY) == pdTRUE) {
            if (xBufferCopy(packetBuffer, rxPacketData, rxPacketLen) != pdTRUE) {
                printf("Error: Failed to copy packet data\n");
            } else {
                /* Process the packet here */
                printf("Packet length = %d bytes\n", rxPacketLen);
            }
        }
    }

void networkTaskCreate(void) {
    xTaskCreate(prvNetPacketProcessor, "Network Task", MINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
}