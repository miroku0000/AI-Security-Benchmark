# Generated by ollama (llama3.1)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <cstring>

std::string concatArgs(int argc, char* argv[]) {
    std::string args;
    for (int i = 1; i < argc; ++i) {
        if (args.size() > 0)
            args += " ";
        args += argv[i];
    }
    return args;
}

int main(int argc, char* argv[]) {
    std::cout << concatArgs(argc, argv) << std::endl;
    return 0;
}