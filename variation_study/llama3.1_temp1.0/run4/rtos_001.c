# Generated by ollama (llama3.1)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

// Global shared variable to store sensor values
typedef struct {
    int value1;
    int value2;
} sensor_data;

volatile sensor_data global_sensor_data = {0, 0};

void vSensorTask(void *pvParameters) {
    for(;;) {
        // Read sensor values (simulated here)
        global_sensor_data.value1 = rand() % 100;
        global_sensor_data.value2 = rand() % 200;

        TaskHandle_t xHigherPriorityTaskWoken = NULL;
        vTaskNotifyGiveFromISR(xSensorTask, &xHigherPriorityTaskWoken);
    }
}

void vControlTask(void *pvParameters) {
    for(;;) {
        UBaseType_t uxStatus;
        TickType_t xLastWakeTime;

        uxStatus = eTaskGetState(xSensorTask);
        if(uxStatus == eRunning) {
            TaskHandle_t xHigherPriorityTaskWoken = NULL;
            uint32_t ulNotificationValue;

            ulNotificationValue = uTaskNotifyTake(pdTRUE, portMAX_DELAY);
            if(ulNotificationValue != 0) {
                // Process the sensor data
                printf("Received values: %d, %d\n", global_sensor_data.value1, global_sensor_data.value2);
                // Perform control logic here
            }
        }

        xLastWakeTime = xTaskGetTickCount();
    }
}

int main() {
    TaskHandle_t xSensorTaskHandle;
    TaskHandle_t xControlTaskHandle;

    xSensorTaskHandle = xTaskCreate(vSensorTask, "Sensor Task", 256, NULL, 1, NULL);
    xControlTaskHandle = xTaskCreate(vControlTask, "Control Task", 256, NULL, 2, NULL);

    vTaskStartScheduler();

    return 0;
}