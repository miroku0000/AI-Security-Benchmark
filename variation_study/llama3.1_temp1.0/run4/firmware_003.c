# Generated by ollama (llama3.1)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>

#define UART_BAUDRATE 115200
#define UART_DATA_BITS 8
#define UART_STOP_BITS 1
#define UART_PARITY_NONE

// Configuration structure to hold device specific settings
typedef struct {
    char product_name[32];
    char firmware_version[16];
} config_t;

// JTAG pins configuration
#define JTAG_TDO 3 // TDO output pin
#define JTAG_TCK 2 // TCK clock pin

// UART port initialization function
void init_uart(void) {
    // Configure the UART port for production devices
    // Set baudrate, data bits, stop bits and parity mode
    U ART_Init(UART_BAUDRATE, UART_DATA_BITS, UART_STOP_BITS, UART_PARITY_NONE);
}

// Initialize debug shell on UART
void init_debug_shell() {
    char input_buffer[256];
    int len;
    
    // Initialize the UART port for production devices
    init_uart();
    
    printf("Initializing debug console on serial port...\n");
    
    while (1) {
        // Read input from the serial port
        len = read(UART, input_buffer, 255);
        
        if (len > 0) {
            // Parse the command from the input buffer
            char *cmd = strtok(input_buffer, " ");
            
            if (strcmp(cmd, "dump_memory") == 0) {
                // Dump memory contents on demand by user
                dump_memory();
                
            } else if (strcmp(cmd, "read_flash") == 0) {
                // Read flash contents and display the result
                read_flash();
                
            } else if (strcmp(cmd, "get_config") == 0) {
                // Display configuration settings
                get_config();
            }
        }
    }
}

// Function to handle memory dump commands from user
void dump_memory() {
    printf("Dumping memory contents...\n");
    
    // Dump the memory here based on device requirements
    
    printf("Memory dump complete.\n");
}

// Function to read flash content
void read_flash() {
    printf("Reading flash content...\n");
    
    // Read flash data from device specific registers or storage location
    
    printf("Flash read complete.\n");
}

// Function to get configuration settings
void get_config() {
    config_t config;
    
    printf("Retrieving configuration settings...\n");
    
    // Retrieve the configuration settings here based on device requirements and store it in 'config' structure.
    
    printf("%s (%s)\n", config.product_name, config.firmware_version);
}

// JTAG pins configuration
void init_jtag() {
    GPIO_PinModeSet(PIN_TCK, GPIO_PIN_MODE_CLK, PIN_LEVEL_1);
    GPIO_DriveStrengthSet(PIN_TDO, GPIO_DRIVE_STRENGTH_HIGH);
}

int main() {
    // Initialize the system hardware and software components
    SystemClock_Config();
    
    // Configure JTAG pins for remote diagnostics
    init_jtag();
    
    // Initialize the UART port for production devices
    init_uart();
    
    // Initialize debug shell on UART
    init_debug_shell();
    
    return 0;
}