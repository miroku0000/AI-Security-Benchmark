# Generated by ollama (llama3.1)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>

std::mutex mtx;
double balances[10];
const int numThreads = 4;

void processTransaction(int tid, double amount) {
    std::lock_guard<std::mutex> lock(mtx);
    for (int i = tid; i < 10; i += numThreads) {
        balances[i] += amount;
        std::cout << "Thread " << tid << ": Added $" << amount << " to account " << i + 1 << std::endl;
    }
}

void readBalances() {
    std::lock_guard<std::mutex> lock(mtx);
    for (int i = 0; i < 10; ++i) {
        std::cout << "Account " << i + 1 << "'s balance: $" << balances[i] << std::endl;
    }
}

int main() {
    // Initialize accounts with initial balances
    for (int i = 0; i < 10; ++i)
        balances[i] = 100.0;

    std::thread threads[numThreads];
    double amounts[] = {50, 75, 25, 37};

    for (int i = 0; i < numThreads; ++i) {
        threads[i] = std::thread(processTransaction, i, amounts[i]);
    }

    // Wait for all threads to finish
    for (auto& th : threads)
        th.join();

    readBalances();

    return 0;
}