# Generated by ollama (llama3.1)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>

class NetworkManager {
public:
    int sockfd;
    struct sockaddr_in server_addr;

    NetworkManager(int port) {
        sockfd = socket(AF_INET, SOCK_STREAM, 0);
        if (sockfd < 0) {
            return; // Handle error
        }

        memset(&server_addr, '\0', sizeof(server_addr));
        server_addr.sin_family = AF_INET;
        inet_pton(AF_INET, "127.0.0.1", &server_addr.sin_addr);

        int enable = 1;
        setsockopt(sockfd, SOL_SOCKET, SO_REUSEADDR, &enable, sizeof(enable));

        if (bind(sockfd, reinterpret_cast<struct sockaddr*>(&server_addr), sizeof(server_addr)) < 0) {
            close(sockfd);
            return; // Handle error
        }

        server_addr.sin_port = htons(port);
        if (listen(sockfd, 3) < 0) {
            close(sockfd);
            return; // Handle error
        }
    }

    ~NetworkManager() {
        close(sockfd);
    }

    int acceptConnection(int clientSockfd, struct sockaddr_in* clientAddr) {
        socklen_t len = sizeof(*client_addr);
        if (connect(clientSockfd, reinterpret_cast<struct sockaddr*>(&server_addr), sizeof(server_addr)) < 0) {
            return -1; // Handle error
        }

        int conn = accept(sockfd, reinterpret_cast<struct sockaddr*>(client_addr), &len);
        if (conn == -1) {
            close(clientSockfd);
            return -1; // Handle error
        }
        return conn;
    }

    void disconnect(int conn) {
        close(conn);
    }

    void resetConnections() {
        int* clientSock = getClientSock();
        struct sockaddr_in* serverAddr = getServerAddr();

        close(sockfd);
        sockfd = socket(AF_INET, SOCK_STREAM, 0);

        memset(server_addr, '\0', sizeof(server_addr));
        server_addr->sin_family = AF_INET;
        inet_pton(AF_INET, "127.0.0.1", &server_addr->sin_addr);

        int enable = 1;
        setsockopt(sockfd, SOL_SOCKET, SO_REUSEADDR, &enable, sizeof(enable));

        if (bind(sockfd, reinterpret_cast<struct sockaddr*>(server_addr), sizeof(server_addr)) < 0) {
            close(sockfd);
            return; // Handle error
        }

        server_addr->sin_port = htons(8080);

        if (listen(sockfd, 3) < 0) {
            close(sockfd);
            return; // Handle error
        }
    }

private:
    int* getClientSock() { return &sockfd; }
    struct sockaddr_in* getServerAddr() { return &server_addr; }
};

NetworkManager* networkMgr;