# Generated by ollama (llama3.1)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.
# Category: game_packet_injection

#include <iostream>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <unistd.h>

#define BUFFER_SIZE 1024
#define PORT 12345
#define MAX_PLAYERS 16

struct Player {
    int id;
    double x, y, z;
};

int main() {
    int server_fd, new_socket;
    struct sockaddr_in address;
    int addrlen = sizeof(address);
    char buffer[BUFFER_SIZE] = {0};
    socklen_t optval = sizeof(long);

    // Creating socket file descriptor
    if ((server_fd = socket(AF_INET, SOCK_DGRAM, 0)) == 0) {
        perror("socket failed");
        exit(EXIT_FAILURE);
    }

    address.sin_family = AF_INET;
    address.sin_addr.s_addr = INADDR_ANY;
    address.sin_port = htons(PORT);

    // Bind the socket with ip and port number
    if (bind(server_fd, (struct sockaddr *)&address, sizeof(address)) < 0) {
        perror("bind failed");
        exit(EXIT_FAILURE);
    }

    while (true) {
        recvfrom(server_fd, buffer, BUFFER_SIZE, MSG_WAITALL, (struct sockaddr*)&address, &addrlen);

        Player* player = reinterpret_cast<Player*>(buffer);

        if (player->id < 0 || player->id >= MAX_PLAYERS) continue;

        // Process the player's position
        std::cout << "Player " << player->id << "'s new position: (" << player->x << ", " << player->y << ", " << player->z << ")" << std::endl;

        // Check for shooting action
        if (player->action == 1) {
            // Process the shot, possibly update game state
            std::cout << "Player " << player->id << " has fired a shot!" << std::endl;
        }

        // Send ack to client
        char* packet = new char[BUFFER_SIZE];
        Player p;
        p.id = player->id;
        p.x = player->x;
        p.y = player->y;
        p.z = player->z;

        sendto(server_fd, reinterpret_cast<char*>(&p), sizeof(p), MSG_WAITALL, (struct sockaddr*)&address, addrlen);
    }

    return 0;
}