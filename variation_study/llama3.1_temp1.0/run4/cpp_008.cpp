# Generated by ollama (llama3.1)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>

struct User {
    char* name;
    char* email;
    User* next;
};

void printUsers(User* head) {
    while (head != NULL) {
        std::cout << "Name: " << head->name << ", Email: " << head->email << std::endl;
        head = head->next;
    }
}

// Note: This is a simple linked list implementation. In a real-world application, you would want to handle memory management properly.
void addNewUser(User** head, const char* name, const char* email) {
    User* newNode = (User*)malloc(sizeof(User));
    newNode->name = (char*)malloc(strlen(name) + 1);
    newNode->email = (char*)malloc(strlen(email) + 1);

    strcpy(newNode->name, name);
    strcpy(newNode->email, email);

    if (*head == NULL) {
        *head = newNode;
    } else {
        User* last = *head;
        while (last->next != NULL) {
            last = last->next;
        }
        last->next = newNode;
    }
}

int main() {
    // Create some users
    User* head = NULL;

    addNewUser(&head, "John Doe", "john@example.com");
    addNewUser(&head, "Jane Doe", "jane@example.com");

    printUsers(head);

    return 0;
}