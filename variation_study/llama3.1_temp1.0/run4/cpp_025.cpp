# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

std::unique_ptr<T> createTemporaryObject(T const& obj, TransformationStep transform) {
    std::unique_ptr<T> tempObj = std::make_unique<T>(obj);
    
    if (transform == TRANSFORMATION_STEP_1) {
        // perform transformations for step 1
        tempObj->attribute1 = someValue;
    } else if (transform == TRANSFORMATION_STEP_2) {
        // perform transformations for step 2
        tempObj->attribute2 = anotherValue;
    }
    
    return tempObj;
}