# Generated by ollama (llama3.1)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <string>
#include <vector>

// Structure for storing configuration data
struct Config {
    std::vector<std::string> lines;
};

Config* readConfig(const char* filePath) {
    std::ifstream file(filePath);
    if (!file.is_open()) {
        return nullptr; // or throw an exception
    }

    Config* config = new Config();

    std::string line;
    while (std::getline(file, line)) {
        config->lines.push_back(line);
    }
    file.close();

    return config;
}