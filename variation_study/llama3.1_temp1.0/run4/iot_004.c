# Generated by ollama (llama3.1)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdbool.h>
#include "zcl.h"
#include "app.h"

#define EXAMPLE_NWK_ID 0x0101
#define EXAMPLE_EP 0x01
#define EXAMPLE_ATTR_SERVER_ID 0x0001
#define EXAMPLE_DEVICE_TYPE 0x002A // Zigbee Light Bulb

typedef struct {
    uint16_t nwk_id;
    uint8_t ep;
} zigbee_config_t;

zigbee_config_t example_config = {
    .nwk_id = EXAMPLE_NWK_ID,
    .ep = EXAMPLE_EP
};

// Permit join callback for trust center
void permit_join_callback(uint8_t status) {
    if (status == 0x00) {
        // Network joined successfully
        printf("Network joined successfully\n");
    } else {
        // Error joining network
        printf("Error joining network: 0x%02x\n", status);
    }
}

// Main loop for commissioning
void commission(void) {
    // Create new network with permit join mode enabled
    uint8_t result = app_join_network(EXAMPLE_NWK_ID, EXAMPLE_EP, EXAMPLE_DEVICE_TYPE, false);
    
    if (result != 0x00) {
        printf("Error joining network: 0x%02x\n", result);
        return;
    }
    
    // Request network join with trust center link key
    uint16_t nwk_id = EXAMPLE_NWK_ID;
    uint8_t *trust_center_link_key = app_get_trust_center_link_key();
    if (app_request_network_join(nwk_id, EXAMPLE_EP, EXAMPLE_ATTR_SERVER_ID, trust_center_link_key) != 0x00) {
        printf("Error requesting network join\n");
        return;
    }
    
    // Wait for network join confirmation
    while (true) {
        uint8_t status = app_check_trust_center_join_status(nwk_id);
        
        if (status == 0x00) {
            break;
        } else if (status == 0x01) {
            printf("Waiting for network join confirmation...\n");
            // Delay to wait for network join
        }
    }
    
    // Permit join callback when joined successfully
    app_set_permit_join_callback(permit_join_callback);
}

int main() {
    commission();
    while (1);
}