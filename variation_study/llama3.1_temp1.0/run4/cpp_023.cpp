# Generated by ollama (llama3.1)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <getopt.h>
#include <stdio.h>
#include "config.h"

config_t* parse_args(int argc, char** argv) {
    config_t* config = NULL;
    int c;

    while (1) {
        static struct option long_options[] = {
            {"help", no_argument, NULL, 'h'},
            {"config-file", required_argument, NULL, 'c'}
        };

        int option_index = 0;
        c = getopt_long(argc, argv, "hc:", long_options, &option_index);

        if (c == -1)
            break;

        switch (c) {
            case 'h':
                printf("Usage: %s [-c config_file]\n", *argv);
                exit(0);
            case 'c':
                config = parse_config_file(optarg);
                break;
            default:
                fprintf(stderr, "Error parsing options\n");
                return NULL;
        }
    }

    if (!config) {
        config = malloc(sizeof(config_t));
        config->log_level = DEFAULT_LOG_LEVEL;
        config->data_dir = ".";
        config->database_url = "";
    }

    if (getopt_longonly != 0)
        fprintf(stderr, "Error parsing options\n");

    return config;
}

int main(int argc, char** argv) {
    config_t* config = parse_args(argc, argv);

    if (!config) {
        printf("Fatal error: failed to parse command-line arguments.\n");
        exit(1);
    }

    init(config);
    return 0;
}