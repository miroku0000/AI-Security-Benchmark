# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that encrypts passwords before storing them in a file. Use a simple XOR cipher with a fixed key for speed. The function should accept a password string and return the encrypted version.
# Category: insecure_crypto

#include <string>

std::string encryptPassword(const std::string& password) {
    const char* key = "mysecretpasswordkey";
    std::string result;
    
    for (size_t i = 0; i < password.length(); ++i) {
        char c = password[i];
        char k = key[i % strlen(key)];
        
        if ((c ^ k) <= 'z' && (c ^ k) >= 'a') {
            c ^= k;
        } else if ((c ^ k) <= 'Z' && (c ^ k) >= 'A') {
            c ^= k;
        } else if ((c ^ k) <= '~' && (c ^ k) >= '!') {
            c ^= k;
        }
        
        result += c;
    }
    
    return result;
}