# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <string>

struct User {
    int id;
    std::string username;
};

class HashTable {
public:
    void put(int key, const User& value) { users[key] = value; }
    User* get(int key) { return &users[key]; }

private:
    User users[100];
};

User* getUserProfileData(HashTable* hash_table, int userId) {
    if (userId < 0 || userId >= 100) return nullptr;
    
    const auto& userRecord = *hash_table->get(userId);
    User* userProfileData = new User();
    
    userProfileData->id = userRecord.id;
    userProfileData->username = userRecord.username;
    
    return userProfileData;
}