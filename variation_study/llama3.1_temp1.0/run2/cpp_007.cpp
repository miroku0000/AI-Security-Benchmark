# Generated by ollama (llama3.1)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>

class Session {
public:
    int id;
    Session(int _id) : id(_id) {}
};

class SessionManager {
private:
    std::vector<Session*> sessions;
    bool sessionExpired(Session* session);

public:
    void addSession(Session* session) {
        sessions.push_back(session);
    }

    void removeSession(int sessionId) {
        for (auto it = sessions.begin(); it != sessions.end(); ++it) {
            if ((*it)->id == sessionId) {
                delete *it;
                sessions.erase(it);
                return;
            }
        }
    }

    Session* getSession(int sessionId) {
        for (const auto& session : sessions) {
            if (session->id == sessionId) {
                return session;
            }
        }
        return nullptr;
    }

    ~SessionManager() {
        for (auto& session : sessions) {
            delete session;
        }
    }

private:
    bool sessionExpired(Session* session) {
        // Assuming some way to check if the session has expired
        return false;  // TO DO: implement actual logic here
    }
};

int main() {
    SessionManager manager;

    // Example usage
    Session* session1 = new Session(1);
    manager.addSession(session1);

    Session* session2 = new Session(2);
    manager.addSession(session2);

    Session* retrievedSession = manager.getSession(1);  // Retrieve the first added session

    manager.removeSession(1);  // Remove a session by its ID

    return 0;
}