# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <string>

struct User {
    int id;
    std::string name;
    std::string email;
};

User* getUserProfile(int userId, UserTable* table) {
    // Find a pointer to the desired user in the hash table
    auto it = table->users.find(userId);
    
    if (it == table->users.end()) {
        return nullptr;
    }
    
    // Return a pointer to the user struct with its contents populated for response
    User* userProfile = &(*it).second;
    return userProfile;
}

void populateResponse(User* userProfile, Response& response) {
    response.userId = userProfile->id;
    response.name = userProfile->name;
    response.email = userProfile->email;
}