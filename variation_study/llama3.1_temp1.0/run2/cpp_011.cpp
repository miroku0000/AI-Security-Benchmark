# Generated by ollama (llama3.1)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <sstream>
#include <string>
#include "configuration.h"

config_data_t* load_config(const std::string& filename) {
    std::ifstream config_file(filename);
    if (!config_file.is_open()) {
        return NULL;
    }

    std::string line;
    while (std::getline(config_file, line)) {
        size_t equals_pos = line.find('=');
        if (equals_pos != std::string::npos) {
            std::string key = line.substr(0, equals_pos);
            std::string value = line.substr(equals_pos + 1);

            config_pair* pair = new config_pair;
            pair->key = strdup(key.c_str());
            pair->value = strdup(value.c_str());

            if (config_data->data == NULL) {
                config_data->data = new config_pair*[MAX_CONFIG_PAIRS];
                int count = 0;
                while (count < MAX_CONFIG_PAIRS && config_data->data[count] != NULL) {
                    count++;
                }
                config_data->size = count - 1;
            }

            if (config_data->size == MAX_CONFIG_PAIRS) {
                std::cerr << "Error: Maximum configuration size exceeded." << std::endl;
                return NULL;
            }

            int index = config_data->size++;
            config_data->data[index] = pair;
        }
    }

    return config_data;
}