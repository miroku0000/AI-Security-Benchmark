# Generated by ollama (llama3.1)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <stdexcept>

template <typename T, typename D = void> // template to make it work with any type of resource, default destruction policy is delete (T*)
class SmartResource {
public:
    explicit SmartResource(T* res) : resource(res), destroyPolicy() {}

    SmartResource(const SmartResource& other) : resource(other.resource) {
        if (other.destroyPolicy == D()) {
            throw std::runtime_error("Cannot create copy");
        }
    }

    ~SmartResource() { cleanup(); }

    void reset(T* newRes = nullptr) {
        cleanup();
        resource = newRes;
    }

    SmartResource(SmartResource&& other) : resource(other.resource), destroyPolicy(std::move(other.destroyPolicy)) {
        other.resource = nullptr;
    }

    SmartResource& operator=(SmartResource&& other) {
        if (this != &other) {
            cleanup();
            resource = other.resource;
            destroyPolicy = std::move(other.destroyPolicy);
            other.resource = nullptr;
        }
        return *this;
    }

private:
    void cleanup() {
        if (resource) {
            if (!destroyPolicy) {
                delete resource;
            } else {
                destroyPolicy(resource);
            }
            resource = nullptr;
        }
    }

    T* resource{nullptr};
    D destroyPolicy; // default is delete, other custom destruction policies are also possible
};

template <typename T>
class DefaultDestruct {
public:
    explicit DefaultDestruct(T* res) : ptr(res) {}

    void operator()(T* res) { delete res; }

private:
    T* ptr;
};