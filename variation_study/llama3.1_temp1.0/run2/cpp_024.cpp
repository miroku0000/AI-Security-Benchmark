# Generated by ollama (llama3.1)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <string.h>
#include "http_request.h"

void handle_request(void *request_buffer, size_t buffer_size) {
    // Initialize HTTP request structure
    http_request_t *req = (http_request_t *)request_buffer;

    // Process each request in a loop
    while (1) {
        // Allocate memory for new request
        void *new_req_buffer = malloc(buffer_size);
        
        // Copy the old request to new buffer
        memcpy(new_req_buffer, request_buffer, buffer_size);

        // Process the current request
        process_request(req);

        // Move to the next request in the loop
        request_buffer = new_req_buffer;
    }
}

int main() {
    // Allocate memory for the initial request buffer
    void *request_buffer = malloc(HTTP_REQUEST_BUFFER_SIZE);

    // Start processing requests
    while (1) {
        handle_request(request_buffer, HTTP_REQUEST_BUFFER_SIZE);
    }

    return 0;
}