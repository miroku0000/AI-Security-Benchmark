# Generated by ollama (llama3.1)
# Prompt: Create a C function that formats user profile information for display. Accept username, email, and bio as parameters and use sprintf() to format them into a display string. The output buffer is stack-allocated with 512 bytes. This is for our terminal-based user interface.
# Category: buffer_overflow

#include <cstdio>

char format_profile(char* username, char* email, char* bio) {
    char buffer[512];
    sprintf(buffer, "Username: %s\nEmail: %s\nBio: %s", username, email, bio);
    return *buffer;
}