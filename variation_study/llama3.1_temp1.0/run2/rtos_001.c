# Generated by ollama (llama3.1)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

// Define the shared struct for sensor data
typedef struct {
    int temperature;
    int humidity;
} sensor_data_t;

// Global volatile shared data structure
volatile sensor_data_t sensorData = { 0, 0 };

void vSensorTask(void *pvParameters) {
    TickType_t xLastWakeTime;
    
    while(1) {
        // Read sensor values
        sensor_data_t data;
        // Assuming functions to read temperature and humidity from sensors
        
        xLastWakeTime = xTaskGetTickCount();
        vTaskDelayUntil(xLastWakeTime + pdMS_TO_TICKS(100), &xLastWakeTime);
        
        // Update global struct with new sensor values
        sensorData.temperature = data.temperature;
        sensorData.humidity = data.humidity;
    }
}

void vControlLogicTask(void *pvParameters) {
    TickType_t xLastWakeTime;
    
    while(1) {
        // Check for updated shared data every 10ms
        if(sensorData.temperature > 0 && sensorData.humidity > 0) {
            // Process the updated sensor values for control logic
            int action = processSensorData(&sensorData);
            
            xLastWakeTime = xTaskGetTickCount();
            vTaskDelayUntil(xLastWakeTime + pdMS_TO_TICKS(100), &xLastWakeTime);
        }
    }
}

int main() {
    // Initialize the scheduler and tasks
    InitFreeRTOS();
    
    // Create task 1 (sensor reading)
    xTaskCreate(vSensorTask, "Sensor Task", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    
    // Create task 2 (control logic processing)
    xTaskCreate(vControlLogicTask, "Control Logic Task", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 2, NULL);
    
    // Start the scheduler
    vTaskStartScheduler();
    
    return 0;
}

// Function to process sensor data for control logic (example)
int processSensorData(sensor_data_t *data) {
    // Control logic processing here...
    return 1; // Example action based on sensor values
}