# Generated by ollama (llama3.1)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include "nrf52.h"
#include "app_timer.h"
#include "nrf_drv_twi.h"
#include "zcl_general.h"

#define TRUST_CENTER_EUI 0x00, 0x13, 0xA2, 0x00, 0x4B, 0xB6, 0x9A, 0x85
#define ZCL_TRUST CENTER_LINK_KEY (uint8_t[16]){0x12, 0x34, 0x56, 0x78, 0x90, 0xAB, 0xCD, 0xEF, 0x01, 0x23, 0x45, 0x67, 0x89, 0xAC, 0x2D}

#define PERMIT_JOIN_MODE true

APP_TIMER_DEF(mTimer);
NRF_TWI_MGMT_KEYS_DEF(keys);

void app_timer_init(void) {
    APP_TIMER_INIT(APP_TIMER_PRESCALER_DIV_256, APP_TIMER_PRESCALERdiv32, false);
}

void twi_manager_init(void) {
    nrf_twi_mngr_instance_init(&keys, 0, NRF_TWI_MANAGER_MODE_BYPASS, true);
}

bool network_joining(void) {
    uint8_t dst[2] = {0};
    uint16_t status;

    // Write Trust Center EUI to NCP
    nrf_twi_mngr_transfer_setup(TWI_MNGR_TYPE_WRITE, 1, (uint8_t *) &dst, 2);
    nrf_twi_mngrTRANSFER(&keys, 0);

    status = zcl_general_trust_center_link_key_store((uint8_t *)&TRUST_CENTER_EUI, (uint8_t*)ZCL_TRUST_CENTER_LINK_KEY, sizeof(ZCL_TRUST_CENTER_LINK_KEY));
    if (status != ZCL_STATUS_SUCCESS) {
        return false;
    }

    // Enable Permit Join Mode
    status = zcl_general_network_permit_join_mode_enable(true);
    if (status != ZCL_STATUS_SUCCESS) {
        return false;
    }

    return true;
}

int main(void) {
    app_timer_init();
    twi_manager_init();

    bool joined = network_joining();
    while (!joined) {
        // Retry joining
    }

    while (1) {
        // Network commissioning is done, do nothing
    }
}