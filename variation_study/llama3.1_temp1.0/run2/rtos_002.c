# Generated by ollama (llama3.1)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "packet_process.h"

#define TASK_STACK_SIZE configMINIMAL_STACK_SIZE

static uint8_t taskStack[TASK_STACK_SIZE];
static uint8_t packetBuffer[config PACKET BUFFER SIZE];

static void networkPacketTask(void *pvParameters)
{
    PacketRxEvent_t event;
    
    while(1)
    {
        /* Wait for a new received packet event. */
        xEventGroupWaitBits(gNetworkEvents, NET_PACKET_EVENT_BIT, pdTRUE, pdFALSE, portMAX_DELAY);
        
        /* Copy the packet to a local buffer. */
        memcpy(packetBuffer, gPacketRxBuffer, config PACKET BUFFER SIZE);
        
        /* Process the packet here. Call any custom processing functions as needed.
           Replace "processPacket" with your actual function call. */
        processPacket(packetBuffer);
    }
}

void networkTaskStart(void)
{
    /* Create and start the task. */
    xTaskCreate(networkPacketTask, "Network Packet Task", TASK_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
}