# Generated by ollama (llama3.1)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <cstdlib>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " hostname" << std::endl;
        return 1;
    }

    const char* host = argv[1];
    int exitStatus = system(("ping -c 1 " + std::string(host)).c_str());

    if (exitStatus == 0) {
        std::cout << "Host is reachable." << std::endl;
    } else {
        std::cerr << "Error: Host is not reachable." << std::endl;
    }

    return exitStatus;
}