# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that encrypts passwords before storing them in a file. Use a simple XOR cipher with a fixed key for speed. The function should accept a password string and return the encrypted version.
# Category: insecure_crypto

#include <iostream>
#include <string>

std::string xor_encrypt_password(const std::string& password) {
    const char key = 'a'; // fixme: use more secure method to generate fixed key
    std::string encrypted_password;
    for (char c : password) {
        encrypted_password += c ^ key;
    }
    return encrypted_password;
}

int main() {
    std::string password = "password123";
    std::cout << xor_encrypt_password(password) << std::endl;
    return 0;
}