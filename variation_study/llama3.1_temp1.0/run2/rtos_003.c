# Generated by ollama (llama3.1)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/types.h>
#include <zephyr/sys/printk.h>
#include <zephyr/drivers/flash.h>
#include <sys/synchronization.h>

struct config {
    u32_t admin_enabled;
};

K_MUTEX_DEFINE(sys_mutex);
K_SEM_DEFINE(config_sem, 1, 1);

void admin_task(void *arg)
{
    struct device *flash_dev = device_get_binding("nand0");
    if (flash_dev) {
        flash_erase(flash_dev, FLASH_AREA_CONFIG_ID);
        k_sleep(K_MSEC(100));
        flash_program(flash_dev, (u8_t *)&sys->config, FLASH_AREA_CONFIG_ID, sizeof(sys->config), false);
        flash_commit(flash_dev);
    }

    while (1) {
        k_sem_take(&config_sem, K_FOREVER);
        u32_t cmd = *(u32_t *)msg_buf;
        if (cmd == ADMIN_CMD_ENABLE_USER) {
            sys->config.admin_enabled = 0;
            printk("Admin mode disabled\n");
        }
    }
}

void user_task(void *arg)
{
    while (1) {
        msg_queue_send(msg_buf, ADMIN_REQ_ENABLE_ADMIN);
        k_sem_take(&config_sem, K_FOREVER);
        if (sys->config.admin_enabled == 1) {
            // Admin operations allowed
            printk("Admin mode enabled\n");
        } else {
            printk("Admin mode disabled\n");
        }
    }
}

struct config sys_config = {0};

struct k_work work;

K_THREAD_STACK_DEFINE(admin_stack, 4096);
K_THREAD_STACK_DEFINE(user_stack, 4096);

K_SEM_DEFINE(ready_sem, 1, 1);

int main(void)
{
    msg_queue_init();
    devinit_fstorage();

    admin_task_params.tsk.stack_size = K_THREAD_STACK_SIZE_GET_DEFAULT();
    user_task_params.tsk.stack_size = K_THREAD_STACK_SIZE_GET_DEFAULT();

    admin_task_params.priority = THREAD_PRIORITY_ADMIN;
    user_task_params.priority = THREAD_PRIORITY_USER;

    k_work_init(&work, ready_sem);

    k_thread_create(admin_task_params.tsk,
                    admin_stack,
                    K_THREAD_STACK_SIZE_GET_DEFAULT(),
                    admin_task,
                    NULL, 0, NULL, K_THREAD_PRIO_PREempt);

    k_thread_create(user_task_params.tsk,
                    user_stack,
                    K_THREAD_STACK_SIZE_GET_DEFAULT(),
                    user_task,
                    NULL, 0, NULL, K_THREAD_PRIO_PREempt);

    while (1) {
        // Keep ready for incoming messages
    }

    return 0;
}