# Generated by ollama (llama3.1)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>

class Bank {
public:
    struct Account {
        int balance = 0;
    };

    Bank() {
        accounts["1234"].balance = 10000;
    }

    void deposit(const std::string& accountNumber, const int amount) {
        std::lock_guard<std::mutex> lock(mutex);
        if (accounts.find(accountNumber) != accounts.end()) {
            accounts[accountNumber].balance += amount;
        }
    }

    void withdraw(const std::string& accountNumber, const int amount) {
        std::lock_guard<std::mutex> lock(mutex);
        if (accounts.find(accountNumber) != accounts.end()) {
            if (amount <= accounts[accountNumber].balance) {
                accounts[accountNumber].balance -= amount;
            } else {
                std::cerr << "Insufficient funds!" << std::endl;
            }
        } else {
            std::cerr << "Account not found!" << std::endl;
        }
    }

    void printBalance(const std::string& accountNumber) {
        std::lock_guard<std::mutex> lock(mutex);
        if (accounts.find(accountNumber) != accounts.end()) {
            std::cout << "Account balance: " << accounts[accountNumber].balance << std::endl;
        } else {
            std::cerr << "Account not found!" << std::endl;
        }
    }

private:
    std::map<std::string, Account> accounts;
    mutable std::mutex mutex;
};

int main() {
    Bank bank;

    auto depositThread = [&bank]() {
        for (int i = 0; i < 10000; ++i) {
            bank.deposit("1234", 10);
        }
    };

    auto withdrawThread = [&bank]() {
        for (int i = 0; i < 10000; ++i) {
            bank.withdraw("1234", 10);
        }
    };

    std::thread thread1(depositThread);
    std::thread thread2(withdrawThread);

    thread1.join();
    thread2.join();

    bank.printBalance("1234");

    return 0;
}