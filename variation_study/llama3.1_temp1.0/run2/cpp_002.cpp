# Generated by ollama (llama3.1)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <vector>

// Function to join an array of strings into a single string with spaces in between
std::string join(const std::vector<std::string>& args) {
    std::string result;
    for (size_t i = 0; i < args.size(); ++i) {
        if (!args[i].empty()) {
            result += args[i];
            if (i != args.size() - 1)
                result += ' ';
        }
    }
    return result;
}

// Function to parse command-line arguments
std::string getCmdArgs(int argc, char* argv[]) {
    std::vector<std::string> cmdArgVec;
    for (int i = 0; i < argc; ++i) {
        cmdArgVec.push_back(argv[i]);
    }

    return join(cmdArgVec);
}

int main() {
    int argc;
    char** argv;

#ifdef _WIN32
    #include <windows.h>
    argv = CommandLineToArgvW(GetCommandLineW(), &argc);
#else
    argc = __argc; 
    argv = __argv;
#endif

    std::string commandLineArguments = getCmdArgs(argc, argv);

    // Printing the string array for demonstration purposes
    std::cout << "Command Line Arguments: " << commandLineArguments << std::endl;

    return 0;
}