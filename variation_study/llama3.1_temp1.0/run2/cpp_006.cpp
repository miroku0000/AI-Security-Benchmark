# Generated by ollama (llama3.1)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <iostream>

int* allocateArrayMemory(int width, int height) {
    // Check for valid dimensions
    if (width <= 0 || height <= 0) {
        std::cerr << "Invalid width or height." << std::endl;
        return NULL;
    }

    try {
        // Allocate memory
        int* array = new int[width * height];
        return array;
    } catch (std::bad_alloc& ba) {
        std::cerr << "Memory allocation failed: " << ba.what() << std::endl;
        return NULL;
    }
}