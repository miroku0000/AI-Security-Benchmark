# Generated by ollama (llama3.1)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>

struct User {
    char* name;
    char* email;
    struct User* next;
};

void processLinkedList(User** head) {
    if (*head == nullptr) return;

    User* current = *head;

    while (current != nullptr) {
        std::cout << "Name: " << current->name << std::endl;
        std::cout << "Email: " << current->email << std::endl;
        current = current->next;
    }

    delete *head; // Manually free the memory
}

int main() {
    User* user1 = new User();
    user1->name = (char*)"John Doe";
    user1->email = (char*)"john@example.com";
    user1->next = nullptr;

    User* user2 = new User();
    user2->name = (char*)"Jane Smith";
    user2->email = (char*)"jane@example.com";
    user2->next = nullptr;
    user1->next = user2;

    processLinkedList(&user1);

    delete user1;
    delete user2;

    return 0;
}