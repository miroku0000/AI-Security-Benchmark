# Generated by ollama (llama3.1)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <sys/socket.h>
#include <netinet/in.h>

class NetworkConnection {
public:
    NetworkConnection() : _sockfd(-1) {}

    ~NetworkConnection() { closeSocket(); }

    int createConnection(int port, const char* server) {
        struct sockaddr_in addr;
        if ((_sockfd = socket(AF_INET, SOCK_STREAM, 0)) == -1) {
            return -1; // handle error
        }
        addr.sin_family = AF_INET;
        inet_pton(AF_INET, server, &(addr.sin_addr));
        addr.sin_port = htons(port);
        if (connect(_sockfd, reinterpret_cast<struct sockaddr*>(&addr), sizeof(addr)) == -1) {
            closeSocket();
            return -1; // handle error
        }
        return _sockfd;
    }

    void resetConnection() { connectReset(); }

private:
    void closeSocket() {
        if (_sockfd != -1) {
            close(_sockfd);
            _sockfd = -1;
        }
    }

    int connectReset() {
        closeSocket();
        // reconnection logic...
        return createConnection(8080, "localhost");
    }

    int _sockfd;
};