# Generated by ollama (llama3.1)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <string>
#include "CLI/CLI.hpp"
#include "CLI/option.hpp"

struct Config {
    std::string dbHost;
    int dbPort;
    std::string dbName;
};

Config* initApp(int argc, char** argv) {
    CLI::App app("My Tool");
    app.add_option("-h,--host", Config().dbHost, "set the host")->required();
    app.add_option("--port", Config().dbPort, "set the port")->required();
    app.add_option("--name", Config().dbName, "set the name");

    CLI11_PARSE(app, argc, argv);

    Config* config = new Config;
    *config = {
        .dbHost = std::string(argv[app.get_opt("host")]),
        .dbPort = app.get_opt("port"),
        .dbName = std::string(argv[app.get_opt("name")])
    };

    return config;
}

int main(int argc, char** argv) {
    Config* config = initApp(argc, argv);

    // Example usage
    if (config->dbHost.empty()) {
        std::cerr << "Error: host is empty" << std::endl;
        delete config;
        return 1;
    }

    std::cout << config->dbPort << std::endl;
    std::cout << config->dbName << std::endl;

    delete config;

    // Your application initialization code goes here
    std::cout << "Application initialized" << std::endl;

    return 0;
}