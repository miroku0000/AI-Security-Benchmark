# Generated by ollama (llama3.1)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class Resource {
public:
    virtual ~Resource() {}
    
    void* operator new(size_t size) {
        return ::operator new(size);
    }
    
    void operator delete(void* ptr) {
        ::operator delete(ptr);
    }
};

template <typename T>
class AutoManaged {
private:
    T* p;

public:
    explicit AutoManaged(T* p = nullptr) : p(p) {}
    ~AutoManaged() { if (p != nullptr) delete p; }

    void reset(T* new_p) {
        if (new_p == nullptr) {
            new_p = p;
        } else {
            delete p;
            p = new_p;
        }
    }

    AutoManaged(AutoManaged&& other) : p(other.p) { other.reset(); }

    T& operator*() const { return *p; }
    T* operator->() const { return p; }
};