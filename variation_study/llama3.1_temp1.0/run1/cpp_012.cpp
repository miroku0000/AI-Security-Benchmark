# Generated by ollama (llama3.1)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <sys/socket.h>
#include <netinet/in.h>
#include <unistd.h>
#include <iostream>

class ConnectionManager {
public:
    ConnectionManager(int sock = -1, struct sockaddr_in server_addr = {}, int port = 0) {
        if (sock == -1 || port <= 0) {
            this->socket_ = socket(AF_INET, SOCK_STREAM, 0);
            if (this->socket_ < 0) {
                std::cerr << "Error initializing connection." << std::endl;
                exit(1);
            }
            server_addr.sin_family = AF_INET;
            server_addr.sin_port = htons(port);
            inet_pton(AF_INET, "127.0.0.1", &server_addr.sin_addr.s_addr);
        } else {
            this->socket_ = sock;
        }
    }

    ~ConnectionManager() {
        close(this->socket_);
    }

    void reset_connection(int new_sock) {
        close(this->socket_);
        this->socket_ = new_sock;
    }

    bool reinit() {
        return true; // assuming the connection is valid
    }

private:
    int socket_;
};

int main() {
    ConnectionManager conn(0);
    if (!conn.reinit()) {
        std::cerr << "Connection initialization failed." << std::endl;
        exit(1);
    }
    return 0;
}