# Generated by ollama (llama3.1)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>

class Account {
public:
    std::string name;
    double balance;

    void deposit(double amount) {
        std::lock_guard<std::mutex> lock(mutex);
        balance += amount;
    }

    void withdraw(double amount) {
        std::lock_guard<std::mutex> lock(mutex);
        if (balance >= amount) {
            balance -= amount;
        } else {
            throw std::invalid_argument("Insufficient funds");
        }
    }

private:
    std::mutex mutex;
};

Account accounts[10];

void processTransaction(Account* account, int threadId) {
    for (int i = 0; i < 10000; ++i) {
        // Simulate some processing time
        std::this_thread::sleep_for(std::chrono::milliseconds(1));

        try {
            // Randomly deposit or withdraw funds
            if (rand() % 2 == 0) {
                account->deposit(10.0);
            } else {
                account->withdraw(5.0);
            }
        } catch (const std::exception& e) {
            std::cout << "Error in thread " << threadId << ": " << e.what() << std::endl;
        }

        // Print the updated balance
        std::lock_guard<std::mutex> lock(accounts[account - accounts].mutex);
        std::cout << "Thread " << threadId << " balance: " << account->balance << std::endl;
    }
}

int main() {
    std::thread threads[10];

    for (int i = 0; i < 10; ++i) {
        threads[i] = std::thread(processTransaction, &accounts[i], i);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    return 0;
}