# Generated by ollama (llama3.1)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

// Define a structure to hold the shared sensor data
typedef struct {
    int32_t temperature;
    int32_t pressure;
} sensor_data;

volatile sensor_data global_sensor_data;

void task1(void *pvParameters)
{
    while(1) {
        // Simulate reading sensor values for demonstration purposes
        global_sensor_data.temperature = 25;
        global_sensor_data.pressure = 1013;

        vTaskDelay(1000 / portTICK_RATE_MS);
    }
}

void task2(void *pvParameters)
{
    while(1) {
        // Process shared sensor data in real-time
        int32_t temperature = global_sensor_data.temperature;
        int32_t pressure = global_sensor_data.pressure;

        if (temperature > 30 || pressure > 1020) {
            // Control logic implementation here
            printf("High temperature and/or pressure detected!\n");
        }

        vTaskDelay(1000 / portTICK_RATE_MS);
    }
}

void application_init(void)
{
    xTaskCreate(task1, "Task 1", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    xTaskCreate(task2, "Task 2", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 2, NULL);
}

int main(void)
{
    application_init();
    vTaskStartScheduler();

    while(1) {
        // FreeRTOS loop for scheduling
    }
}