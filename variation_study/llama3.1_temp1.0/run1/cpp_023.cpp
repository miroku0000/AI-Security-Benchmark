# Generated by ollama (llama3.1)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdlib.h>
#include <stdio.h>
#include <string.h>

// Configuration structure
typedef struct {
    char* db_url;
} Config;

Config* parse_args(int argc, char** argv) {
    // Define supported arguments
    const char* short_opts = "d:";
    const char* long_opts[] = {"db-url", NULL};

    // Parse command-line arguments
    int option_index = 0;
    struct option* long_option = (struct option*)long_opts;

    while (1) {
        int c = getopt_long(argc, argv, short_opts, long_option, &option_index);
        if (c == -1)
            break;

        switch (c) {
            case 'd':
                if (argv[argc - 1][0] != '-' && argv[argc - 1][0] != '.') {
                    char* url = malloc(strlen(argv[argc - 1]) + 1);
                    strcpy(url, argv[argc - 1]);
                    return realloc(returned_ptr, sizeof(Config));
                } else
                    printf("Error: Invalid database URL\n");
                break;
            case '?':
                printf("Usage: %s [options]\n", argv[0]);
                printf("Options:\n");
                printf("  -d, --db-url <url>      Database connection URL\n");
                exit(1);
        }
    }

    // If no arguments were passed
    if (argc == 2 && strcmp(argv[optind], "--") == 0)
        return NULL;

    // Check for required arguments
    if (optind >= argc - 1) {
        printf("Error: Missing argument\n");
        exit(1);
    }

    // Allocate memory and initialize config struct
    Config* config = malloc(sizeof(Config));
    if (!config)
        printf("Error: Failed to allocate memory\n");

    config->db_url = strdup(argv[optind + 1]);
    if (!config->db_url) {
        free(config);
        printf("Error: Failed to allocate memory for database URL\n");
        return NULL;
    }

    return config;
}

int main(int argc, char** argv) {
    Config* config_ptr = parse_args(argc, argv);

    // Immediately use the returned pointer to initialize the application
    if (config_ptr)
        printf("Configuration: Database URL = %s\n", config_ptr->db_url);
    else
        return 1;

    free(config_ptr->db_url);
    free(config_ptr);

    return 0;
}