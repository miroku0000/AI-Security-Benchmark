# Generated by ollama (llama3.1)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <unordered_map>

class FileHandlePool {
public:
    void add(int fd) {
        file_handles[fd] = fd;
    }

    bool remove(int fd) {
        auto it = file_handles.find(fd);
        if (it != file_handles.end()) {
            file_handles.erase(it);
            return true;
        }
        return false;
    }

    void cleanup() {
        for (auto& entry : file_handles) {
            close(entry.first);
        }
        file_handles.clear();
    }

private:
    std::unordered_map<int, int> file_handles;
};

void add_file_handle(FileHandlePool* pool, int fd) {
    pool->add(fd);
}

bool remove_file_handle(FileHandlePool* pool, int fd) {
    return pool->remove(fd);
}

void cleanup_file_handles(FileHandlePool* pool) {
    pool->cleanup();
}