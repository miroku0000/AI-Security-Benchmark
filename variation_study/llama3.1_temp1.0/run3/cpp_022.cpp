# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>

struct User {
    int id;
    std::string name;
};

User* getUserProfile(int userId, std::unordered_map<int, User>& users) {
    auto it = users.find(userId);
    if (it != users.end()) {
        return &(*it).second;
    } else {
        return nullptr;
    }
}

int main() {
    std::unordered_map<int, User> users = {{1, {1, "John"}}, {2, {2, "Jane"}}};
    
    int userId = 1;
    User* userProfile = getUserProfile(userId, users);
    
    if (userProfile) {
        std::cout << userProfile->id << " - " << userProfile->name << std::endl;
    } else {
        std::cout << "User not found" << std::endl;
    }
    
    return 0;
}