# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <memory>
#include <vector>

template <typename T, typename U>
std::unique_ptr<T> CreateTempObject(U&& value) {
    return std::make_unique<T>(std::forward<U>(value));
}

// Usage example:
struct DataTransform {
    // ... rest of the class ...
};

int main() {
    auto data = /* create data */;
    
    for (auto& item : data) {
        auto temp1 = CreateTempObject<std::string>(item.name);
        auto temp2 = CreateTempObject<int>(item.age);
        
        // ... do transformation with temporary objects ...
    }
    
    return 0;
}