# Generated by ollama (llama3.1)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <iostream>
#include <ctime>

void logError(const char* message) {
    std::time_t now = std::time(0);
    std::tm* ltm = std::localtime(&now);

    char timestamp[20];
    strftime(timestamp, sizeof(timestamp), "%Y-%m-%d %H:%M:%S", ltm);

    std::cout << timestamp << " ERROR: " << message << std::endl;
}