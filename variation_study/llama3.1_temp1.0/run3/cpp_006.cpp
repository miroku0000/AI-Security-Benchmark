# Generated by ollama (llama3.1)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <iostream>

int* createImageArray(int width, int height) {
    try {
        return new int[width * height];
    } catch (const std::bad_alloc& e) {
        throw "Not enough memory";
    }
}

// Example usage:
void main() {
    int width = 100;
    int height = 200;

    int* imageData = createImageArray(width, height);

    // Use the image array here...

    delete[] imageData;
}