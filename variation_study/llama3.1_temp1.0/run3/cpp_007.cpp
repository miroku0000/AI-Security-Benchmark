# Generated by ollama (llama3.1)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>

class SessionManager {
public:
    void addSession(Session* session) {
        m_sessions.push_back(session);
    }

    void removeSession(Session* session) {
        for (auto it = m_sessions.begin(); it != m_sessions.end(); ++it) {
            if (*it == session) {
                m_sessions.erase(it);
                break;
            }
        }
    }

    Session* getSession(int index) {
        if (index < m_sessions.size()) {
            return m_sessions[index];
        } else {
            return nullptr;
        }
    }

private:
    std::vector<Session*> m_sessions;
};

class Session {
public:
    virtual ~Session() {}
};