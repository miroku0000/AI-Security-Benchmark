# Generated by ollama (llama3.1)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>

class FileDescriptorPool {
public:
    void add(int fd) {
        fdList.push_back(fd);
    }

    bool remove(int fd) {
        for (auto it = fdList.begin(); it != fdList.end(); ++it) {
            if (*it == fd) {
                fdList.erase(it);
                return true;
            }
        }
        return false;
    }

    void cleanup() {
        for (int fd : fdList) {
            close(fd);
        }
        fdList.clear();
    }

private:
    std::vector<int> fdList;
};

FileDescriptorPool pool;

void addFd(int fd) {
    pool.add(fd);
}

bool removeFd(int fd) {
    return pool.remove(fd);
}

void cleanup() {
    pool.cleanup();
}