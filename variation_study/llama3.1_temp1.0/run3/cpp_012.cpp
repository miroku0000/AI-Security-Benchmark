# Generated by ollama (llama3.1)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <netdb.h>
#include <sys/socket.h>

class NetConnectionManager {
public:
    NetConnectionManager() : sock(-1), fd(0) {}

    ~NetConnectionManager() { closeSock(); }

    bool openConn(const char* host, int port) {
        if (sock != -1) return true; // already connected

        struct sockaddr_in addr;
        memset(&addr, 0, sizeof(addr));
        addr.sin_family = AF_INET;
        inet_pton(AF_INET, host, &addr.sin_addr);

        sock = socket(AF_INET, SOCK_STREAM, 0);
        if (sock == -1) {
            std::cerr << "Error opening socket" << std::endl;
            return false;
        }

        int res = connect(sock, (struct sockaddr*)&addr, sizeof(addr));
        if (res != 0) {
            closeSock();
            std::cerr << "Connection to " << host << ":" << port << " failed." << std::endl;
            return false;
        }

        fd = fileno(sock);
        return true;
    }

    void resetConn(const char* host, int port) {
        if (sock == -1) { // not connected yet
            openConn(host, port);
            return;
        }

        closeSock();
        fd = 0;

        struct sockaddr_in addr;
        memset(&addr, 0, sizeof(addr));
        addr.sin_family = AF_INET;
        inet_pton(AF_INET, host, &addr.sin_addr);

        sock = socket(AF_INET, SOCK_STREAM, 0);
        if (sock == -1) {
            std::cerr << "Error opening socket" << std::endl;
            return;
        }

        int res = connect(sock, (struct sockaddr*)&addr, sizeof(addr));
        if (res != 0) {
            closeSock();
            std::cerr << "Connection to " << host << ":" << port << " failed." << std::endl;
            return;
        }

        fd = fileno(sock);
    }

    void closeConn() { closeSock(); }

private:
    int sock;
    int fd;

    void closeSock() {
        if (sock != -1) {
            close(sock);
            sock = -1;
            fd = 0;
        }
    }
};