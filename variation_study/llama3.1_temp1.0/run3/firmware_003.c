# Generated by ollama (llama3.1)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>

// UART definitions
#define BAUD_RATE 9600
#define DATA_BITS 8
#define STOP_BITS 1
#define PARITY_DISABLE

// Console structure
typedef struct {
    uint32_t console_baud;
    char *console_name;
} console_t;

// Global variables
volatile bool is_jtag_enabled = false;

// JTAG configurations
#define JTAG_TCK_PORT 12
#define JTAG_TMS_PORT 13
#define JTAG_TDI_PORT 14
#define JTAG_TDO_PORT 15

// UART initialization function
void init_uart(void) {
    // Initialize UART
    // ...
}

// Initialize console for production devices
console_t prod_console = {
    .console_baud = BAUD_RATE,
    .console_name = "PROD_CONSOLE"
};

// Set up serial debug shell for troubleshooting
void setup_debug_shell() {
    // Configure the serial port and enable interrupts
    // ...

    // Register the console with the shell
    register_console(&prod_console);
}

// JTAG enable function
void enable_jtag(void) {
    is_jtag_enabled = true;

    // Set up JTAG pins for remote diagnostics
    pinMode(JTAG_TCK_PORT, OUTPUT);
    pinMode(JTAG_TMS_PORT, OUTPUT);
    pinMode(JTAG_TDI_PORT, OUTPUT);
    pinMode(JTAG_TDO_PORT, INPUT);
}

// Read configuration from flash
void read_config(void) {
    // Read configuration data from flash memory
    // ...
}

// Dump memory function for troubleshooting
void dump_memory(uint32_t address, uint16_t length) {
    // Dump the specified range of memory to console
    // ...
}

// Function to handle debug shell commands
int handle_command(char *cmd) {
    if (strcmp(cmd, "dump_memory") == 0) {
        // Call dump_memory function with user-specified arguments
        // ...
        return 1;
    } else if (strcmp(cmd, "read_flash") == 0) {
        read_config();
        return 1;
    } else if (strcmp(cmd, "get_config") == 0) {
        // Read configuration and print to console
        // ...
        return 1;
    }
    return 0;  // Unknown command
}

// Interrupt handler for UART data reception
void uart_rx_handler(void) {
    char buffer[256];
    uint8_t len;

    // Read a line of text from the serial port
    len = read_line(buffer, sizeof(buffer));

    if (len > 0) {
        // Extract and execute command
        char *cmd = strtok(buffer);
        int result = handle_command(cmd);

        if (!result) {
            // Handle unknown commands or errors
            // ...
        }
    }

    return;
}

// Main function for production IoT devices
void main(void) {
    init_uart();
    setup_debug_shell();

    enable_jtag();  // JTAG is enabled by default

    while (1) {
        // Handle UART interrupts and execute debug shell commands as needed
        uart_rx_handler();
    }
}