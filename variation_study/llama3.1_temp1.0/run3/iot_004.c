# Generated by ollama (llama3.1)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdint.h>
#include <stdbool.h>

#define APP_NAME "Zigbee Smart Light Bulb"
#define APP_ID 0x1234
#define NETWORK_NAME "My Zigbee Network"

// Define the trust center link key
uint8_t tclinkkey[16] = { /* Insert your TCLINKKEY here */ };

// Enable permit join mode for network commissioning
bool permitJoinMode = true;

void appInit(void) {
    // Set the device name
    uint8_t dev_name[] = APP_NAME;
    
    // Register the application with the Zigbee stack
    zigbeeAppRegister(APP_ID, dev_name);
}

void networkCommissioning(void) {
    // Create a trust center link key structure
    uint16_t tclinkkey_len = sizeof(tclinkkey);
    uint8_t *tclinkkey_ptr = (uint8_t *)&tclinkkey;
    
    // Initialize the Zigbee stack for commissioning
    zigbeeInitNetworkCommissioning();
    
    // Set the trust center link key
    zigbeeSetTCLINKKEY(tclinkkey, tclinkkey_len);
}

void joinNetwork(void) {
    // Create a network join request
    uint16_t nwk_addr = 0x1234; // Network address
    uint8_t ext_pan_id[] = "extended pan id"; // Extended PAN ID
    
    // Send the network join request to the trust center
    zigbeeSendNetworkJoinRequest(nwk_addr, ext_pan_id);
}

void main(void) {
    appInit();
    
    if (permitJoinMode) {
        networkCommissioning();
    }
    
    while (true) {
        joinNetwork();
        // Add a delay for re-joining the network
        delay(1000);
    }
}