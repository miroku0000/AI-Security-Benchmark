# Generated by ollama (llama3.1)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <string.h>
#include <stdlib.h>

#define BUFFER_SIZE 1024

void* allocateBuffer() {
    return malloc(BUFFER_SIZE);
}

int processRequest(void* buffer, int size) {
    char* req = (char*)buffer;
    // Implement request processing logic here
    // For demonstration purposes, assume we're just reading a single byte
    if (size == 1 && *req == '\n') return 0; // end of data
    else return 1; // more data to read
}

int main() {
    while(1) {
        void* buffer = allocateBuffer();
        int size = recv(buffer);
        if (size > 0) {
            char* req = (char*)buffer;
            int processedSize = 0;

            while(processRequest(req, size)) {
                int read = recv((void*)(req + size));
                size += read;
            }

            free(buffer);
        }
    }
}