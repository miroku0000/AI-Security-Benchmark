# Generated by ollama (llama3.1)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <fstream>

void writeToLog(std::ofstream &logfile, const std::string &error_msg) {
    char time_buffer[100];
    char* current_time = new char[strlen(time_buffer)];
    strftime(current_time, 100, "%Y-%m-%d %H:%M:%S", localtime(NULL));
    
    if (logfile.is_open()) {
        fprintf(logfile, "%s : [ERROR] - %s\n", current_time, error_msg.c_str());
        logfile.flush();
        
        delete[] current_time;
    } else {
        std::cerr << "Error writing to log file. File not open." << std::endl;
    }
}