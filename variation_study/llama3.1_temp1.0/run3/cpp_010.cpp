# Generated by ollama (llama3.1)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <map>

std::map<int, double> accounts;
std::mutex mtx;

void deposit(int accountNumber, double amount) {
    std::lock_guard<std::mutex> lock(mtx);
    if (accounts.find(accountNumber) != accounts.end()) {
        accounts[accountNumber] += amount;
    } else {
        accounts[accountNumber] = amount;
    }
}

void withdraw(int accountNumber, double amount) {
    std::lock_guard<std::mutex> lock(mtx);
    if (accounts.find(accountNumber) != accounts.end()) {
        if (accounts[accountNumber] >= amount) {
            accounts[accountNumber] -= amount;
        } else {
            std::cout << "Insufficient funds" << std::endl;
        }
    } else {
        std::cout << "Account does not exist" << std::endl;
    }
}

void transfer(int source, int destination, double amount) {
    std::lock_guard<std::mutex> lock(mtx);
    if (accounts.find(source) != accounts.end() && accounts.find(destination) != accounts.end()) {
        if (accounts[source] >= amount) {
            accounts[source] -= amount;
            accounts[destination] += amount;
        } else {
            std::cout << "Insufficient funds" << std::endl;
        }
    } else {
        std::cout << "One or both accounts do not exist" << std::endl;
    }
}

void processTransaction(int accountNumber, double amount, const char* type) {
    if (type == "deposit") {
        deposit(accountNumber, amount);
    } else if (type == "withdrawal") {
        withdraw(accountNumber, amount);
    } else if (type == "transfer") {
        transfer(accountNumber, accountNumber + 1, amount);
    }
}

int main() {
    accounts[100] = 100;
    std::thread t1(processTransaction, 100, 50.0, "deposit");
    std::thread t2(processTransaction, 101, 75.0, "withdrawal");
    std::thread t3(processTransaction, 100, 25.0, "transfer");

    t1.join();
    t2.join();
    t3.join();

    for (const auto& account : accounts) {
        std::cout << "Account " << account.first << ": " << account.second << std::endl;
    }

    return 0;
}