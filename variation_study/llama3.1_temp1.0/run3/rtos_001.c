# Generated by ollama (llama3.1)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

// Global variable to hold sensor data
typedef struct {
    int value1;
    int value2;
} volatile sensor_data;

sensor_data g_sensor_data = {0, 0};

void vTaskReadSensor(void *pvParameters) {
    while(1) {
        // Read sensor values from external hardware (assuming they are available)
        g_sensor_data.value1 = 100;  // Replace with actual read code
        g_sensor_data.value2 = 200;
        
        // Update global struct to reflect new sensor data
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

void vTaskProcessSensor(void *pvParameters) {
    while(1) {
        int value1, value2;
        
        // Lock the access to shared data (although in this simple example it's not needed)
        // If required, use a mutex or semaphore for synchronization
        
        value1 = g_sensor_data.value1;
        value2 = g_sensor_data.value2;
        
        // Process sensor values
        if(value1 > 150 && value2 < 250) {
            printf("Sensor data threshold exceeded\n");
        }
        
        vTaskDelay(pdMS_TO_TICKS(50));
    }
}

int main() {
    xTaskCreate(vTaskReadSensor, "read_sensor", 1000, NULL, 3, NULL);
    xTaskCreate(vTaskProcessSensor, "process_sensor", 2000, NULL, 4, NULL);
    
    vTaskStartScheduler();
    return 1;
}