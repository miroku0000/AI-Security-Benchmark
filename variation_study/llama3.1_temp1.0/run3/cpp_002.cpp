# Generated by ollama (llama3.1)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <vector>

std::string parseArgs(int argc, char** argv) {
    std::string logMessage;
    for (int i = 1; i < argc; i++) {
        if (!logMessage.empty()) logMessage += " ";
        logMessage += argv[i];
    }
    return logMessage;
}

int main(int argc, char** argv) {
    std::cout << parseArgs(argc, argv) << std::endl;
    return 0;
}