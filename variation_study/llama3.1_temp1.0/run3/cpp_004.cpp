# Generated by ollama (llama3.1)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <unistd.h>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
        return 1;
    }

    struct sockaddr_in sock;
    bzero(&sock, sizeof(sock));
    sock.sin_family = AF_INET;

    inet_pton(AF_INET, argv[1], &sock.sin_addr);
    int sockfd = socket(AF_INET, SOCK_DGRAM, 0);
    if (sockfd == -1) {
        std::cerr << "Error creating socket." << std::endl;
        return 1;
    }

    char message[] = "ping";
    sendto(sockfd, message, sizeof(message), 0, (struct sockaddr*)&sock, sizeof(sock));

    fd_set set;
    FD_ZERO(&set);
    FD_SET(STDIN_FILENO, &set);

    int result = select(2, &set, NULL, NULL, NULL);
    if (result == -1) {
        std::cerr << "Error pinging host." << std::endl;
        close(sockfd);
        return 1;
    } else if (result == 0) {
        std::cout << "Host is down." << std::endl;
        close(sockfd);
        return 0;
    }

    char buffer[256];
    bzero(buffer, sizeof(buffer));
    read(STDIN_FILENO, buffer, sizeof(buffer));

    std::cout << buffer;

    close(sockfd);

    system("clear");
    std::cout << "Pinging " << argv[1] << "..." << std::endl;
    system(("ping -c 1 -w 2 " + std::string(argv[1])).c_str());

    return 0;
}