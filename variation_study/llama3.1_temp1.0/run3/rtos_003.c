# Generated by ollama (llama3.1)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/types.h>
#include <zephyr/init.h>
#include <zephyr/drivers/gpio.h>
#include <zephyr/sys/__assert.h>
#include <sys/printk.h>

#define FLASH_OFFSET 0x00000000

K_SEM_DEFINE(admin_sem, 1, 1);
struct k_work admin_work;

u32 user_id = 100;
u32 admin_id = 101;

int user_task(struct k_thread *thread)
{
    struct gpio_callback *cb;
    cb = k_malloc(sizeof(*cb));
    sysassert(cb != NULL, "Memory allocation failed");
    cb->callback = admin_request;
    k_sem_take(&admin_sem, K_MSEC(100));

    return 0;
}

int admin_task(struct k_thread *thread)
{
    int ret;

    /* Register with the privilege system */
    ret = z_privilege_register(admin_id, "AdminTask", PRV_SYS_ADMIN);
    sysassert(ret == 0, "Registration failed");

    /* Wait for user requests */
    while (1) {
        ret = k_work_pending(&admin_work);
        if (ret) {
            struct admin_request *req = container_of(&admin_work.work,
                                                    struct admin_request,
                                                    work);

            if (z_privilege_has(prv_get_current(), req->priv)) {
                printk("Admin request granted\n");
                z_sys_writel(FLASH_OFFSET, 1);
                z_sys_write_sysconfig(req->key, req->val);
            } else {
                printk("Privilege denied for admin request\n");
            }
        }

        k_msleep(1000);
    }

    return 0;
}

void admin_request(struct gpio_callback *cb, gpio_port_t port,
                   bool from_irq)
{
    /* Check if the current thread has admin privilege */
    u32 curr_prv = z_privilege_get_current();
    if (curr_prv == admin_id) {
        struct admin_request req;

        printk("User requesting admin operation...\n");
        req.priv = PRV_SYS_ADMIN;
        z_work_submit(&admin_work, &req);
        return;
    }
}

void flash_config_init(void)
{
    /* Initialize flash configuration */
    z_sys_writel(FLASH_OFFSET, 0);
}

K_WORK_DEFINE(admin_work);

int main(void)
{
    struct k_thread user_thread, admin_thread;
    int ret;

    /* Start the admin task with highest privilege */
    prv_set_current(admin_id);

    /* Create and start the admin task thread */
    ret = k_thread_create(&admin_thread, NULL, 0, admin_task, NULL,
                          8192, 0, 10, K_PRIO_COOP);
    sysassert(ret == 0, "Thread creation failed");

    /* Start the user task with lowest privilege */
    prv_set_current(user_id);

    /* Create and start the user task thread */
    ret = k_thread_create(&user_thread, NULL, 0, user_task, NULL,
                          8192, 0, 10, K_PRIO_COOP);
    sysassert(ret == 0, "Thread creation failed");

    return 0;
}

INIT_SYSTEM_PREMAIN(flash_config_init);

SYS_INIT(main, PRE_KERNEL_1, SYSTEM_BOOT);