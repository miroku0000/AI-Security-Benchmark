# Generated by ollama (llama3.1)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>

// Define struct for user record
struct User {
    char* name;
    char* email;
    User* next;
};

void printUsers(User* head) {
    while (head != NULL) {
        std::cout << "Name: " << head->name << ", Email: " << head->email << std::endl;
        head = head->next;
    }
}

// Example usage
int main() {
    // Allocate memory for user records
    User* u1 = new User();
    u1->name = new char[20];
    u1->email = new char[30];

    // Initialize values
    strcpy(u1->name, "John Doe");
    strcpy(u1->email, "john.doe@example.com");

    // Allocate memory for user records
    User* u2 = new User();
    u2->name = new char[20];
    u2->email = new char[30];

    // Initialize values
    strcpy(u2->name, "Jane Doe");
    strcpy(u2->email, "jane.doe@example.com");

    // Set up linked list structure
    u1->next = u2;
    User* head = u1;

    printUsers(head);

    return 0;
}