# Generated by ollama (llama3.1)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <cassert>

template <typename T>
class Unique {
private:
    T* ptr;

public:
    explicit Unique(T* res = nullptr) : ptr(res) {}

    ~Unique() {
        cleanup();
    }

    void reset(T* res = nullptr) {
        if (ptr != res) {
            cleanup();
            ptr = res;
        }
    }

    Unique(Unique&& other) noexcept : ptr(other.ptr) {
        other.ptr = nullptr;
    }

    Unique& operator=(Unique&& other) noexcept {
        assert(ptr == nullptr);
        ptr = other.ptr;
        other.ptr = nullptr;

        return *this;
    }

private:
    void cleanup() {
        if (ptr != nullptr) {
            delete ptr;
        }
    }
};