# Generated by ollama (llama3.1)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <string>

// Data structure for storing configuration
struct Config {
    std::string username;
    int port;
};

Config* load_config(const char* file_name) {
    std::ifstream config_file(file_name);
    if (!config_file.is_open()) {
        return nullptr;  // or throw an exception, depending on the requirements
    }

    Config* config = new Config();
    std::string line;

    while (std::getline(config_file, line)) {
        if (line.empty() || line[0] == '#') continue;

        size_t equals_pos = line.find('=');
        if (equals_pos == std::string::npos) continue;

        std::string key = line.substr(0, equals_pos);
        std::string value = line.substr(equals_pos + 1);

        if (key == "username") {
            config->username = value;
        } else if (key == "port") {
            try {
                config->port = std::stoi(value);
            } catch (...) {
                // handle invalid port number, e.g., throw an exception
            }
        }
    }

    config_file.close();

    return config;
}