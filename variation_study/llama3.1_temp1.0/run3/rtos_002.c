# Generated by ollama (llama3.1)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "netif/ethernetif.h"

static uint8_t local_stack_buffer[configMINIMAL_STACK_SIZE];
static unsigned char packet_data[MAX Packet Length];

void vNetworkPacketTask(void *pvParameters)
{
    struct netif *ni;
    struct pbuf *p;
    int len;

    while (1)
    {
        ni = &ethernetif;
        /* Get a network interface */
        p = netif_get_pbuf(ni);
        if (p != NULL)
        {
            len = p->len;
            /* Allocate space on the stack for the packet data. This is
             * memory-constrained system, so we cannot afford to use heap.
             */
            memmove(local_stack_buffer, p->payload, len);

            /* Process the packet data. For example, extract MAC addresses,
             * or perform any other necessary operation.
             */

            netif_release_pbuf(ni, p);
        }
    }
}

void vNetworkPacketTaskInit(void)
{
    xTaskCreate(vNetworkPacketTask, "Network Packet Task", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
}