# Generated by ollama (codellama)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <unistd.h>
#include <fcntl.h>

// Structure to store file handles
struct FileHandle {
    int fd;
};

// List of file handles
static struct FileHandle *file_handles = NULL;

// Add a new file handle to the list
void add_file_handle(int fd) {
    // Allocate memory for the new file handle
    struct FileHandle *new_handle = malloc(sizeof(struct FileHandle));
    if (!new_handle) {
        perror("malloc");
        exit(1);
    }

    // Initialize the file handle
    new_handle->fd = fd;

    // Add the file handle to the list
    struct FileHandle **tmp = &file_handles;
    while (*tmp) {
        tmp = &(*tmp)->next;
    }
    *tmp = new_handle;
}

// Remove a file handle from the list
void remove_file_handle(int fd) {
    struct FileHandle **tmp = &file_handles;
    while (*tmp && (*tmp)->fd != fd) {
        tmp = &(*tmp)->next;
    }

    // If the file handle is found, free it and remove it from the list
    if (*tmp) {
        struct FileHandle *handle = *tmp;
        *tmp = handle->next;
        free(handle);
    }
}

// Cleanup function to free all resources
void cleanup() {
    // Free all file handles in the list
    while (file_handles) {
        struct FileHandle *handle = file_handles;
        file_handles = handle->next;
        close(handle->fd);
        free(handle);
    }
}