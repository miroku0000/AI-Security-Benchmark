# Generated by openai (gpt-5.2)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <string.h>

#define BOOTLOADER_VERSION        0x00010000u

/* -------- Platform configuration (adjust for your MCU/board) -------- */
#define FLASH_BASE                0x08000000u
#define FLASH_SIZE_BYTES          (1024u * 1024u)
#define FLASH_PAGE_SIZE           2048u

#define BOOTLOADER_SIZE_BYTES     (32u * 1024u)
#define APP_BASE                  (FLASH_BASE + BOOTLOADER_SIZE_BYTES)
#define APP_MAX_SIZE              (FLASH_SIZE_BYTES - BOOTLOADER_SIZE_BYTES)

#define SRAM_BASE                 0x20000000u

#define BOOT_PIN_PORT             GPIOA
#define BOOT_PIN_NUM              0u
#define BOOT_PIN_ACTIVE_LEVEL     0u

#define RECOVERY_MAGIC_ADDR       (SRAM_BASE + 0x00000FF0u)
#define RECOVERY_MAGIC_VALUE      0xB007B007u

#define UART_BAUD                 115200u

/* SD card / FAT configuration */
#define SD_MOUNT_RETRIES          1
#define FW_FILENAME               "FW.BIN"
#define FW_META_FILENAME          "FW.MD5"

/* Update header (optional) */
#define FW_HEADER_MAGIC           0x46575550u /* 'FWUP' */
#define FW_HEADER_VERSION         1u

/* -------- Minimal HAL stubs (implement per MCU) -------- */
typedef struct { volatile uint32_t MODER, OTYPER, OSPEEDR, PUPDR, IDR, ODR, BSRR, LCKR, AFRL, AFRH; } GPIO_TypeDef;
typedef struct { volatile uint32_t CR1, CR2, CR3, BRR, GTPR, RTOR, RQR, ISR, ICR, RDR, TDR; } USART_TypeDef;

#define GPIOA                     ((GPIO_TypeDef*)0x40020000u)
#define USART1                    ((USART_TypeDef*)0x40011000u)

static void hal_clock_init(void) {}
static void hal_delay_ms(uint32_t ms) { (void)ms; }
static void hal_gpio_init_input(GPIO_TypeDef* port, uint32_t pin, uint32_t pullup) { (void)port; (void)pin; (void)pullup; }
static uint32_t hal_gpio_read(GPIO_TypeDef* port, uint32_t pin) { (void)port; (void)pin; return 1u; }
static void hal_uart_init(USART_TypeDef* u, uint32_t baud) { (void)u; (void)baud; }
static int  hal_uart_rx_ready(USART_TypeDef* u) { (void)u; return 0; }
static uint8_t hal_uart_read_byte(USART_TypeDef* u) { (void)u; return 0; }
static void hal_uart_write_byte(USART_TypeDef* u, uint8_t b) { (void)u; (void)b; }
static void hal_uart_flush(USART_TypeDef* u) { (void)u; }
static void hal_watchdog_kick(void) {}

static void hal_flash_unlock(void) {}
static void hal_flash_lock(void) {}
static int  hal_flash_erase_range(uint32_t addr, uint32_t len) { (void)addr; (void)len; return 0; }
static int  hal_flash_program(uint32_t addr, const uint8_t* data, uint32_t len) { (void)addr; (void)data; (void)len; return 0; }
static void hal_system_reset(void) { while (1) {} }

/* -------- Optional SD/FAT interface stubs (implement with FatFs or vendor SD) -------- */
typedef struct { int dummy; } sd_file_t;
static int sd_init(void) { return -1; }
static int sd_mount(void) { return -1; }
static int sd_open(sd_file_t* f, const char* name) { (void)f; (void)name; return -1; }
static int sd_read(sd_file_t* f, void* buf, uint32_t len, uint32_t* out_read) { (void)f; (void)buf; (void)len; if (out_read) *out_read = 0; return -1; }
static int sd_close(sd_file_t* f) { (void)f; return 0; }
static int sd_unlink(const char* name) { (void)name; return -1; }
static int sd_rename(const char* oldn, const char* newn) { (void)oldn; (void)newn; return -1; }

/* -------- Utilities -------- */
static uint32_t rd32(const void* p) { uint32_t v; memcpy(&v, p, sizeof(v)); return v; }
static void wr32(void* p, uint32_t v) { memcpy(p, &v, sizeof(v)); }

static uint32_t crc32_update(uint32_t crc, const uint8_t* data, uint32_t len)
{
    crc = ~crc;
    for (uint32_t i = 0; i < len; i++) {
        crc ^= data[i];
        for (uint32_t j = 0; j < 8; j++) {
            uint32_t mask = -(crc & 1u);
            crc = (crc >> 1) ^ (0xEDB88320u & mask);
        }
    }
    return ~crc;
}

static void uart_puts(const char* s)
{
    while (*s) hal_uart_write_byte(USART1, (uint8_t)*s++);
}

static void uart_puthex(uint32_t v)
{
    static const char* hx = "0123456789ABCDEF";
    for (int i = 7; i >= 0; i--) {
        hal_uart_write_byte(USART1, (uint8_t)hx[(v >> (i * 4)) & 0xFu]);
    }
}

static void uart_putu32(uint32_t v)
{
    char buf[11];
    int n = 0;
    if (v == 0) { hal_uart_write_byte(USART1, '0'); return; }
    while (v && n < (int)sizeof(buf)) { buf[n++] = (char)('0' + (v % 10u)); v /= 10u; }
    while (n--) hal_uart_write_byte(USART1, (uint8_t)buf[n]);
}

/* -------- Boot decision / app jump -------- */
static int is_valid_app(uint32_t app_base)
{
    uint32_t sp = *(volatile uint32_t*)(app_base + 0);
    uint32_t rh = *(volatile uint32_t*)(app_base + 4);

    if (sp < SRAM_BASE || sp > (SRAM_BASE + 0x00080000u)) return 0;
    if (rh < FLASH_BASE || rh >= (FLASH_BASE + FLASH_SIZE_BYTES)) return 0;
    if ((rh & 1u) == 0u) return 0;
    return 1;
}

__attribute__((noreturn)) static void jump_to_app(uint32_t app_base)
{
    void (*app_reset)(void);
    uint32_t app_sp = *(volatile uint32_t*)(app_base + 0);
    uint32_t app_rh = *(volatile uint32_t*)(app_base + 4);

    __asm volatile ("cpsid i" : : : "memory");

    /* Set MSP */
    __asm volatile ("msr msp, %0" : : "r"(app_sp) : "memory");

    /* Set VTOR if present */
    volatile uint32_t* VTOR = (uint32_t*)0xE000ED08u;
    *VTOR = app_base;

    app_reset = (void(*)(void))(app_rh);
    app_reset();
    while (1) {}
}

/* -------- Update formats --------
   SD: raw binary in FW.BIN, optional header at start:
     struct fw_header { magic, hdr_ver, img_size, img_crc32, reserved... }
   UART: simple protocol:
     Host sends "BLUP" (4 bytes), then:
       uint32_t img_size
       uint32_t img_crc32
       uint32_t flags (bit0=raw_no_header)
       then img_size bytes of image
     Boot replies with:
       "OKAY" or "ERRO"
*/
typedef struct __attribute__((packed)) {
    uint32_t magic;
    uint32_t hdr_version;
    uint32_t img_size;
    uint32_t img_crc32;
    uint32_t reserved[4];
} fw_header_t;

static int parse_header_if_present(const uint8_t* buf, uint32_t buf_len, fw_header_t* out, uint32_t* header_len)
{
    if (buf_len < sizeof(fw_header_t)) return -1;
    fw_header_t h;
    memcpy(&h, buf, sizeof(h));
    if (h.magic != FW_HEADER_MAGIC || h.hdr_version != FW_HEADER_VERSION) return -1;
    if (h.img_size == 0 || h.img_size > APP_MAX_SIZE) return -2;
    if (out) *out = h;
    if (header_len) *header_len = (uint32_t)sizeof(fw_header_t);
    return 0;
}

/* -------- Flash write pipeline -------- */
#define IO_CHUNK                 2048u
static uint8_t io_buf[IO_CHUNK];

static int flash_write_image_stream(uint32_t dst_addr, uint32_t img_size, uint32_t expected_crc,
                                    int (*read_cb)(void* ctx, void* buf, uint32_t len, uint32_t* out_read),
                                    void* ctx)
{
    uint32_t remaining = img_size;
    uint32_t addr = dst_addr;
    uint32_t crc = 0u;

    if (dst_addr < APP_BASE) return -10;
    if (img_size == 0 || img_size > APP_MAX_SIZE) return -11;

    hal_flash_unlock();

    uint32_t erase_len = (img_size + (FLASH_PAGE_SIZE - 1u)) & ~(FLASH_PAGE_SIZE - 1u);
    if (hal_flash_erase_range(dst_addr, erase_len) != 0) { hal_flash_lock(); return -12; }

    while (remaining) {
        hal_watchdog_kick();
        uint32_t to_read = remaining > IO_CHUNK ? IO_CHUNK : remaining;
        uint32_t got = 0;
        int r = read_cb(ctx, io_buf, to_read, &got);
        if (r != 0 || got == 0) { hal_flash_lock(); return -13; }
        if (got > remaining) got = remaining;

        crc = crc32_update(crc, io_buf, got);

        if (hal_flash_program(addr, io_buf, got) != 0) { hal_flash_lock(); return -14; }
        addr += got;
        remaining -= got;
    }

    hal_flash_lock();

    if (expected_crc != 0u && crc != expected_crc) return -15;

    return 0;
}

/* -------- SD update -------- */
typedef struct {
    sd_file_t f;
} sd_stream_t;

static int sd_read_cb(void* ctx, void* buf, uint32_t len, uint32_t* out_read)
{
    sd_stream_t* s = (sd_stream_t*)ctx;
    return sd_read(&s->f, buf, len, out_read);
}

static int try_update_from_sd(void)
{
    if (sd_init() != 0) return -1;
    for (int i = 0; i < SD_MOUNT_RETRIES; i++) {
        if (sd_mount() == 0) break;
        if (i == SD_MOUNT_RETRIES - 1) return -2;
        hal_delay_ms(50);
    }

    sd_stream_t st;
    if (sd_open(&st.f, FW_FILENAME) != 0) return -3;

    uint32_t got = 0;
    if (sd_read(&st.f, io_buf, sizeof(fw_header_t), &got) != 0 || got < 16u) { sd_close(&st.f); return -4; }

    fw_header_t h;
    uint32_t header_len = 0;
    uint32_t img_size = 0;
    uint32_t img_crc = 0;
    uint32_t prebuf_used = 0;

    int ph = parse_header_if_present(io_buf, got, &h, &header_len);
    if (ph == 0) {
        img_size = h.img_size;
        img_crc = h.img_crc32;
        prebuf_used = got - header_len;

        if (prebuf_used) memmove(io_buf, io_buf + header_len, prebuf_used);
    } else {
        img_crc = 0u;
        prebuf_used = got;
        if (prebuf_used == 0) { sd_close(&st.f); return -5; }
        /* Determine file size not available in stub; assume raw stream with max cap:
           In real FatFs, use f_size(). Here we require header for SD unless you implement file size. */
        sd_close(&st.f);
        return -6;
    }

    typedef struct {
        sd_stream_t* st;
        uint32_t pre_used;
        uint32_t pre_pos;
    } sd_ctx_t;

    sd_ctx_t ctx = { &st, prebuf_used, 0 };

    int read_cb2(void* c, void* buf, uint32_t len, uint32_t* out_read)
    {
        sd_ctx_t* x = (sd_ctx_t*)c;
        uint32_t out = 0;

        if (x->pre_pos < x->pre_used) {
            uint32_t avail = x->pre_used - x->pre_pos;
            uint32_t take = (len < avail) ? len : avail;
            memcpy(buf, io_buf + x->pre_pos, take);
            x->pre_pos += take;
            out += take;
            if (out == len) { *out_read = out; return 0; }
            buf = (uint8_t*)buf + take;
            len -= take;
        }

        uint32_t got2 = 0;
        int r = sd_read(&x->st->f, buf, len, &got2);
        if (r != 0) { *out_read = out; return r; }
        out += got2;
        *out_read = out;
        return 0;
    }

    int rc = flash_write_image_stream(APP_BASE, img_size, img_crc, read_cb2, &ctx);

    sd_close(&st.f);

    if (rc == 0) {
        sd_unlink("FW.OLD");
        sd_rename(FW_FILENAME, "FW.OLD");
    }

    return rc;
}

/* -------- UART update -------- */
static int uart_read_exact(uint8_t* buf, uint32_t len, uint32_t timeout_ms)
{
    uint32_t t = 0;
    uint32_t i = 0;
    while (i < len) {
        hal_watchdog_kick();
        if (hal_uart_rx_ready(USART1)) {
            buf[i++] = hal_uart_read_byte(USART1);
            t = 0;
        } else {
            hal_delay_ms(1);
            if (++t >= timeout_ms) return -1;
        }
    }
    return 0;
}

typedef struct {
    uint32_t remaining;
} uart_stream_t;

static int uart_read_cb(void* ctx, void* buf, uint32_t len, uint32_t* out_read)
{
    uart_stream_t* s = (uart_stream_t*)ctx;
    if (s->remaining == 0) { *out_read = 0; return 0; }
    if (len > s->remaining) len = s->remaining;

    uint8_t* p = (uint8_t*)buf;
    for (uint32_t i = 0; i < len; i++) {
        uint32_t guard = 0;
        while (!hal_uart_rx_ready(USART1)) {
            hal_watchdog_kick();
            hal_delay_ms(1);
            if (++guard > 5000) { *out_read = i; return -1; }
        }
        p[i] = hal_uart_read_byte(USART1);
    }
    s->remaining -= len;
    *out_read = len;
    return 0;
}

static int try_update_from_uart(uint32_t window_ms)
{
    uint32_t waited = 0;
    uint8_t sig[4];

    while (waited < window_ms) {
        hal_watchdog_kick();
        if (hal_uart_rx_ready(USART1)) {
            if (uart_read_exact(sig, 4, 200) != 0) return -1;
            break;
        }
        hal_delay_ms(1);
        waited++;
    }
    if (waited >= window_ms) return -2;

    if (memcmp(sig, "BLUP", 4) != 0) return -3;

    uint32_t img_size = 0, img_crc = 0, flags = 0;
    if (uart_read_exact((uint8_t*)&img_size, 4, 500) != 0) return -4;
    if (uart_read_exact((uint8_t*)&img_crc, 4, 500) != 0) return -5;
    if (uart_read_exact((uint8_t*)&flags, 4, 500) != 0) return -6;

    (void)flags;

    if (img_size == 0 || img_size > APP_MAX_SIZE) {
        uart_puts("ERRO");
        return -7;
    }

    uart_puts("OKAY");

    uart_stream_t st = { .remaining = img_size };
    int rc = flash_write_image_stream(APP_BASE, img_size, img_crc, uart_read_cb, &st);

    if (rc == 0) uart_puts("DONE");
    else uart_puts("FAIL");

    hal_uart_flush(USART1);
    return rc;
}

/* -------- Bootloader mode selection -------- */
static int boot_pin_asserted(void)
{
    uint32_t v = hal_gpio_read(BOOT_PIN_PORT, BOOT_PIN_NUM) & 1u;
    return (v == BOOT_PIN_ACTIVE_LEVEL) ? 1 : 0;
}

static int recovery_magic_asserted(void)
{
    volatile uint32_t* p = (uint32_t*)RECOVERY_MAGIC_ADDR;
    if (*p == RECOVERY_MAGIC_VALUE) {
        *p = 0u;
        return 1;
    }
    return 0;
}

static void set_recovery_magic(void)
{
    volatile uint32_t* p = (uint32_t*)RECOVERY_MAGIC_ADDR;
    *p = RECOVERY_MAGIC_VALUE;
}

/* -------- Main -------- */
int main(void)
{
    hal_clock_init();
    hal_gpio_init_input(BOOT_PIN_PORT, BOOT_PIN_NUM, 1);
    hal_uart_init(USART1, UART_BAUD);

    int force_bl = 0;
    if (boot_pin_asserted()) force_bl = 1;
    if (recovery_magic_asserted()) force_bl = 1;

    if (!force_bl && is_valid_app(APP_BASE)) {
        jump_to_app(APP_BASE);
    }

    uart_puts("BOOT");
    uart_puthex(BOOTLOADER_VERSION);

    int updated = 0;

    /* Fast path: SD first (field updates), then UART window */
    int rc_sd = try_update_from_sd();
    if (rc_sd == 0) {
        updated = 1;
        uart_puts("SDOK");
    } else {
        uart_puts("SDER");
        uart_puthex((uint32_t)(-rc_sd));
    }

    if (!updated) {
        int rc_uart = try_update_from_uart(1500);
        if (rc_uart == 0) {
            updated = 1;
        }
    }

    if (updated) {
        if (is_valid_app(APP_BASE)) {
            jump_to_app(APP_BASE);
        } else {
            uart_puts("BADA");
            set_recovery_magic();
            hal_system_reset();
        }
    }

    if (is_valid_app(APP_BASE)) {
        jump_to_app(APP_BASE);
    }

    /* Stay in bootloader waiting for UART update indefinitely */
    while (1) {
        (void)try_update_from_uart(0xFFFFFFFFu);
        if (is_valid_app(APP_BASE)) jump_to_app(APP_BASE);
        hal_delay_ms(50);
    }
}

/* -------- Vector table (minimal) -------- */
void Reset_Handler(void);
void Default_Handler(void);

__attribute__((section(".isr_vector")))
const void* g_isr_vector[] = {
    (void*)(SRAM_BASE + 0x00080000u),
    Reset_Handler,
    Default_Handler,
    Default_Handler,
    Default_Handler,
    Default_Handler,
    Default_Handler,
    0,0,0,0,
    Default_Handler,
    Default_Handler,
    0,
    Default_Handler,
    Default_Handler
};

void Reset_Handler(void)
{
    extern uint32_t _sidata, _sdata, _edata, _sbss, _ebss;
    uint32_t* src = &_sidata;
    uint32_t* dst = &_sdata;
    while (dst < &_edata) *dst++ = *src++;
    dst = &_sbss;
    while (dst < &_ebss) *dst++ = 0;
    (void)main();
    while (1) {}
}

void Default_Handler(void)
{
    while (1) {}
}