# Generated by openai (gpt-5.2)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>

typedef struct FileHandleNode {
    FILE *fp;
    char *path;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct FileHandleList {
    FileHandleNode *head;
} FileHandleList;

static char *fh_strdup(const char *s) {
    if (!s) return NULL;
    size_t n = strlen(s) + 1;
    char *p = (char *)malloc(n);
    if (!p) return NULL;
    memcpy(p, s, n);
    return p;
}

void fh_list_init(FileHandleList *list) {
    if (!list) return;
    list->head = NULL;
}

FILE *fh_list_add(FileHandleList *list, const char *path, const char *mode) {
    if (!list || !path || !mode) return NULL;

    FILE *fp = fopen(path, mode);
    if (!fp) return NULL;

    FileHandleNode *node = (FileHandleNode *)calloc(1, sizeof(*node));
    if (!node) {
        fclose(fp);
        return NULL;
    }

    node->path = fh_strdup(path);
    if (!node->path) {
        fclose(fp);
        free(node);
        return NULL;
    }

    node->fp = fp;
    node->next = list->head;
    list->head = node;
    return fp;
}

int fh_list_remove(FileHandleList *list, FILE *fp, int close_file) {
    if (!list || !fp) return 0;

    FileHandleNode *prev = NULL;
    FileHandleNode *cur = list->head;

    while (cur) {
        if (cur->fp == fp) {
            if (prev) prev->next = cur->next;
            else list->head = cur->next;

            if (close_file && cur->fp) fclose(cur->fp);
            cur->fp = NULL;

            free(cur->path);
            cur->path = NULL;

            free(cur);
            return 1;
        }
        prev = cur;
        cur = cur->next;
    }
    return 0;
}

int fh_list_remove_by_path(FileHandleList *list, const char *path, int close_file) {
    if (!list || !path) return 0;

    FileHandleNode *prev = NULL;
    FileHandleNode *cur = list->head;

    while (cur) {
        if (cur->path && strcmp(cur->path, path) == 0) {
            if (prev) prev->next = cur->next;
            else list->head = cur->next;

            if (close_file && cur->fp) fclose(cur->fp);
            cur->fp = NULL;

            free(cur->path);
            cur->path = NULL;

            free(cur);
            return 1;
        }
        prev = cur;
        cur = cur->next;
    }
    return 0;
}

void fh_list_cleanup(FileHandleList *list) {
    if (!list) return;

    FileHandleNode *cur = list->head;
    list->head = NULL;

    while (cur) {
        FileHandleNode *next = cur->next;

        if (cur->fp) {
            fclose(cur->fp);
            cur->fp = NULL;
        }

        free(cur->path);
        cur->path = NULL;

        cur->next = NULL;
        free(cur);

        cur = next;
    }
}

size_t fh_list_count(const FileHandleList *list) {
    if (!list) return 0;
    size_t n = 0;
    for (FileHandleNode *cur = list->head; cur; cur = cur->next) n++;
    return n;
}

FILE *fh_list_find_by_path(const FileHandleList *list, const char *path) {
    if (!list || !path) return NULL;
    for (FileHandleNode *cur = list->head; cur; cur = cur->next) {
        if (cur->path && strcmp(cur->path, path) == 0) return cur->fp;
    }
    return NULL;
}

#ifdef TEST_FILE_HANDLE_LIST
int main(void) {
    FileHandleList list;
    fh_list_init(&list);

    FILE *a = fh_list_add(&list, "a.tmp", "w+");
    FILE *b = fh_list_add(&list, "b.tmp", "w+");
    if (!a || !b) {
        fprintf(stderr, "add failed: %s\n", strerror(errno));
        fh_list_cleanup(&list);
        return 1;
    }

    fprintf(a, "hello a\n");
    fprintf(b, "hello b\n");
    fflush(a);
    fflush(b);

    fh_list_remove(&list, a, 1);
    fh_list_remove_by_path(&list, "b.tmp", 1);

    fh_list_cleanup(&list);
    fh_list_cleanup(&list);

    return 0;
}
#endif