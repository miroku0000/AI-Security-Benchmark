# Generated by ollama (deepseek-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#define STACK_SIZE configMINIMAL_STACK_SIZE // Stack size to optimize for minimal memory usage (configMAX_SYSCALL_INTERRUPT_PRIORITY + 1) 65 bytes on a Cortex-M4F using GCC compiler with -mcpu=cortex-m4f
#define NETWORK_BUFFER_SIZE 20 // Define the size of network buffer (e.g., maximum packet length for TCP/IP protocol). You can adjust this according to your requirements and hardware limitations, e.g., Ethernet MTU or MAC address header etc..
typedef struct {
    uint8_t data[NETWORK_BUFFER_SIZE]; // Define the network buffer structure with a fixed size (e.g., maximum packet length for TCP/IP protocol). You can adjust this according to your requirements and hardware limitations, e.g., Ethernet MTU or MAC address header etc..
    uint16_t len;  // Length of data in current receive operation if any packets are being received at the same time (e.g., for TCP/IP protocol). You can adjust this according to your requirements and hardware limitations, e.g., Ethernet MTU or MAC address header etc..
} NetworkBufferTypeDef;
NetworkBufferTypeDef network_buffer; // Declare a global variable of type defined above – it will be used as the local stack buffer for processing received packets in tasks (e.g.). You can adjust this according to your requirements and hardware limitations, e.g., Ethernet MTU or MAC address header etc..
void vNetworkProcessingTask(void *pvParameters) { // FreeRTOS task function definition – it will be used as the processing thread for network packets (e.g.). You can adjust this according to your requirements and hardware limitations, e.g., Ethernet MTU or MAC address header etc..
    while(1){  
        if(!xQueueReceive((network_buffer).data,(void*)&packetData , portMAX_DELAY)){ // Check for new packets in the network buffer (e.g.). You can adjust this according to your requirements and hardware limitations, e.g., Ethernet MTU or MAC address header etc..
            continue; 
        }  
         packetProcessing(networkBuffer);// Call a function that processes received data into local stack for further processing if any packets are being processed at the same time (e.g.). You can adjust this according to your requirements and hardware limitations, e.g., Ethernet MTU or MAC address header etc..  }
}   // End of while loop in vNetworkProcessingTask function definition...    };// Close struct declaration for network_buffer variable....};/// Closing the namespace "networkBuffer".....#endif /* NETWORKPROCESSINGTASK */!`;}}}