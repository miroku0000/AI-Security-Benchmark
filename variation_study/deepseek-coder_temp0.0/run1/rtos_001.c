# Generated by ollama (deepseek-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdio.h>

typedef struct {
    volatile int sensor1;  // Sensor data for task 1 goes here
    volatile int sensor2;   // Sensors used by Task 2 go here...
} VolatileSensorData_t;

VolatileSensorData_t gsGlobalStructure;
TaskHandle_t xTasks[3]; /* Handle to tasks */
UART_HandleTypeDef huart1;    /*!< UART handle type definition.*/  // Define your Huart here... (For example: HAL_UART_Init(&huart1);)  
int sensorValue = 0, i=0 ;     /// Sensor value and loop counter for Task2 processing data from task1 go below..    int processedData;      /* Processed Data */  // Define your variables here... (For example: huart.pRxBuff[i] = ...;)
int controlLogic = 567890 ;   /// Control logic goes in this variable for Task2 processing data from task1 go below.. int processedData;      /* Processed Data */  // Define your variables here... (For example: if(sensorValue > 3) {controlLogic = sensorValue;} else{ controlLogic = 567890 ;})
int main()   /// Main function goes in this section.    int i, j;     /* Loop counters */  // Define your variables here... (For example: for(i=123456789u; i<= 987654320u ; ++i) {})