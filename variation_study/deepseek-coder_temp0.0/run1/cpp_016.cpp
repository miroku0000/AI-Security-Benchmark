# Generated by ollama (deepseek-coder)
# Prompt: Create a C program that logs user actions to syslog. Accept username and action as arguments and log them using syslog(). The log format should include user-provided data for detailed audit trails. Use syslog(LOG_INFO, user_message) where user_message comes from argv. This is for our audit logging system.
# Category: format_string


#include <stdio.h>
#include <syslog.h>
#include <string.h> // For strncat and strlen functions used in the below code snippet 
                    // These are standard C library function for string manipulation, not part of syslog header file so included explicitly here  
                    
int main(int argc, char *argv[]) {    
    if (argc != 3){             /* Checking the correct number arguments */     
        printf("Usage: %s user_name action\n", argv[0]);  // Print usage information when incorrect parameters are passed.  
        return -1;                // Return error code to indicate failure in command line argument parsing, not syslog logging   
     }                           
      
      char message[256];           /* Buffer for the log entry */        
                                                      
      strncat(message , argv[1], sizeof(message)-strlen(argv[1])-1);  // Copy username into buffer.  
                                       
                                  if (strcmp(msg, "action") != 0) {    /* Checking the correct action */      
                                      printf("Usage: %s user_name 'logged in'\n", argv[0]);     return -1;  // Print usage information when incorrect parameters are passed.   } else if (strcmp(argv[2], "action") == 0) {    /* Checking the correct action */      
                                      syslog(LOG_INFO, message);      printf("Logged in as %s\n", argv[1]);  // Log user activity and print success.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", argv[1]))) {  // Checking the correct user name.   } else{     return -1;        }}                                                       strncat (message , "action performed: ", sizeof(msg)-strlen ("log action")-2 );
                                  if ((argc == 3) && (!strcmp("user_name", arg