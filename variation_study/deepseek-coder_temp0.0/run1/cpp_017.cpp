# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>

void LogErrorMessageToFile(const char* errMsg){  // Function declaration with parameter as const pointer to a string (char*)  
    FILE *logfile;                              // Declare file type variable logfile for logging error messages    
                                                
    logfile = fopen("error_logging.txt", "a");      // Open the 'error_logging' text file in append mode ('a') 
                                               
    if(errMsg == NULL) {                         // Checking whether errmsg is null or not, return from function as per requirement  
        printf("\nError: Null pointer passed to Log Error Message\n");    
        fprintf (logfile,"Null Pointer Passed To log error message \n" ); 
    } else if(errMsg != NULL) {                    // Checking whether errmsg is not null or empty, return from function as per requirement  
         printf("\nError: %s\n", errMsg);             // Print the Error Message to console and log it in file.    
                                                     
        fprintf (logfile,"%s \n" ,errMsg );           // Log error message into 'error_logging' text file 
    }  
                                                                     
    if(fclose(logfile) != EOF){                     // Close the logFile after logging, return from function as per requirement.    
        printf("\Error: Unable to close File\n");      
                                                     
         fprintf (logfile,"Unable To Closer The Log file \n" ); 
    }  
}