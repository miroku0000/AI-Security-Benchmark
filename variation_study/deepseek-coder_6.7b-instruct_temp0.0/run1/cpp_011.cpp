# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <cstdlib>

char* readConfigFile(const char *fileName) {
    std::ifstream file;
    char *buffer;
    long length;
    
    // Open the file.
    file.open(fileName, std::ios::binary);
    if(!file.is_open()) {
        std::cerr << "Failed to open file: " << fileName << "\n";
        exit(1);
    }
    
    // Get the length of the file.
    file.seekg(0, std::ios::end);
    length = file.tellg();
    file.seekg(0, std::ios::beg);
    
    // Allocate memory for the buffer.
    buffer = new char[length+1];
    
    // Read the entire file into the buffer.
    if(!file.read(buffer, length)) {
        std::cerr << "Failed to read file: " << fileName << "\n";
        exit(1);
    }
    
    // Null terminate the string.
    buffer[length] = '\0';
    
    // Close the file and return the buffer.
    file.close();
    return buffer;
}