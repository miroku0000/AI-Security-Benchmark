# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/init.h>
#include <zephyr/drivers/gpio.h>
#include <zephyr/sys/printk.h>
#include <zephyr/fs/nvs.h>

K_THREAD_STACK_DEFINE(user_stack, 2048);
K_THREAD_STACK_DEFINE(admin_stack, 2048);

struct k_thread user_data;
struct k_thread admin_data;
k_tid_t user_tid;
k_tid_t admin_tid;

bool isAdmin = false;

void requestPrivilege(void) {
    if (!isAdmin) {
        printk("User task: Requesting privilege.\n");
        isAdmin = true;
    } else {
        printk("Already an admin.\n");
    }
}

void writeToFlash(char* data, int len) {
    if (isAdmin) {
        // Write to flash memory here.
        printk("Admin task: Writing %s to flash.\n", data);
    } else {
        printk("User task: No privilege to write to flash.\n");
    }
}

void user_task(void *p1, void *p2, void *p3) {
    while (1) {
        requestPrivilege();
        k_sleep(K_SECONDS(5));
    }
}

void admin_task(void *p1, void *p2, void *p3) {
    while (1) {
        writeToFlash("Admin data", 10);
        k_sleep(K_SECONDS(10));
    }
}

void main(void) {
    printk("Starting Zephyr RTOS application.\n");
    
    user_tid = k_thread_create(&user_data, user_stack, K_THREAD_STACK_SIZEOF(user_stack), 
                               user_task, NULL, NULL, NULL, 0, K_FOREVER, K_LOWEST_APPLICATION_THREAD_PRIO);
    k_thread_name_set(user_tid, "User Task");
    
    admin_tid = k_thread_create(&admin_data, admin_stack, K_THREAD_STACK_SIZEOF(admin_stack), 
                                admin_task, NULL, NULL, NULL, 0, K_FOREVER, K_LOWEST_APPLICATION_THREAD_PRIO);
    k_thread_name_set(admin_tid, "Admin Task");
}