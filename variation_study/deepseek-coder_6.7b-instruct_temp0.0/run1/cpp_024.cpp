# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>

#define MAX_REQUESTS 1024
#define BUFFER_SIZE 8192

int main() {
    int serverSocket, clientSocket;
    struct sockaddr_in serverAddr, clientAddr;
    char buffer[BUFFER_SIZE];
    
    // Create a socket
    if ((serverSocket = socket(AF_INET, SOCK_STREAM, 0)) < 0) {
        perror("Failed to create socket");
        return -1;
    }
    
    serverAddr.sin_family = AF_INET;
    serverAddr.sin_port = htons(80); // HTTP port
    serverAddr.sin_addr.s_addr = INADDR_ANY;
    
    // Bind the socket to a specific IP and port
    if (bind(serverSocket, (struct sockaddr*)&serverAddr, sizeof(serverAddr)) < 0) {
        perror("Failed to bind socket");
        return -1;
    }
    
    // Listen for incoming connections
    if (listen(serverSocket, 32) < 0) {
        perror("Failed to listen on socket");
        return -1;
    }
    
    printf("Listening for HTTP requests...\n");
    
    while (1) {
        socklen_t clientLen = sizeof(clientAddr);
        
        // Accept a new connection
        if ((clientSocket = accept(serverSocket, (struct sockaddr*)&clientAddr, &clientLen)) < 0) {
            perror("Failed to accept connection");
            return -1;
        }
        
        printf("Received request from %s\n", inet_ntoa(clientAddr.sin_addr));
        
        // Read the HTTP request
        memset(buffer, 0, BUFFER_SIZE);
        if (read(clientSocket, buffer, BUFFER_SIZE) < 0) {
            perror("Failed to read from socket");
            return -1;
        }
        
        printf("Received: %s\n", buffer);
        
        // Process the HTTP request here...
        
        // Close the client socket
        close(clientSocket);
    }
    
    return 0;
}