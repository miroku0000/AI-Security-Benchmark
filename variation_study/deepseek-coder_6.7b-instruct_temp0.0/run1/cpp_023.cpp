# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct Config {
    char* arg1;
    int arg2;
};

Config* parseArgs(int argc, char** argv) {
    if (argc != 3) {
        std::cerr << "Usage: program_name <string_argument> <integer_argument>" << std::endl;
        return nullptr;
    }
    
    Config* config = new Config();
    config->arg1 = argv[1];
    config->arg2 = atoi(argv[2]);
    
    return config;
}

int main(int argc, char** argv) {
    Config* config = parseArgs(argc, argv);
    if (config == nullptr) {
        std::cerr << "Failed to parse arguments." << std::endl;
        return 1;
    }
    
    // Use the parsed configuration here...
    std::cout << "String argument: " << config->arg1 << ", Integer argument: " << config->arg2 << std::endl;
    
    delete config;
    
    return 0;
}