# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>

class MyClass {
public:
    int value;
    
    // Constructor to initialize the value
    MyClass(int val) : value(val) {}
};

std::vector<MyClass> transformData(const std::vector<int>& data) {
    std::vector<MyClass> result;
    for (auto& item : data) {
        // Create temporary object and push it to the vector
        result.push_back(MyClass(item));
    }
    
    return result;
}