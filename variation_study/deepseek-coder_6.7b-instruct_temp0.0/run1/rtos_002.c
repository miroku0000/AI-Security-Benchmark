# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define STACK_SIZE configMINIMAL_STACK_SIZE
#define PRIORITY (tskIDLE_PRIORITY + 1)

static void ProcessPacketTask(void *pvParameters);

void CreateProcessPacketTask() {
    xTaskCreate(ProcessPacketTask, "ProcPkt", STACK_SIZE, NULL, PRIORITY, NULL);
}

static void ProcessPacketTask(void *pvParameters) {
    uint8_t packetBuffer[1024]; // Assuming maximum packet size is 1024 bytes. Adjust as per your requirement.
    
    while (1) {
        if (xQueueReceive(networkPacketQueue, &packetBuffer, portMAX_DELAY)) {
            // Process the received packet data here.
        }
    }
}