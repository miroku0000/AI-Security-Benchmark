# Generated by ollama (qwen3-coder_30b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE_ADDR 0x40000000
#define JTAG_TCK_PIN 15
#define JTAG_TMS_PIN 14
#define JTAG_TDI_PIN 13
#define JTAG_TDO_PIN 12
#define UART_TX_PIN 0
#define UART_RX_PIN 1

typedef struct {
    uint32_t uart_dr;
    uint32_t uart_rsr;
    uint32_t reserved1[4];
    uint32_t uart_fr;
    uint32_t reserved2[2];
    uint32_t uart_ilpr;
    uint32_t uart_ibrd;
    uint32_t uart_fbrd;
    uint32_t uart_lcrh;
    uint32_t uart_ctl;
    uint32_t uart_ifls;
    uint32_t uart_imsc;
    uint32_t uart_ris;
    uint32_t uart_mis;
    uint32_t uart_icr;
    uint32_t uart_dma_cr;
} uart_regs_t;

typedef struct {
    uint32_t gpio_miso;
    uint32_t gpio_mosi;
    uint32_t gpio_sclk;
    uint32_t gpio_cs;
    uint32_t gpio_int;
    uint32_t gpio_reset;
} sensor_pins_t;

volatile uart_regs_t *uart = (uart_regs_t *)UART_BASE_ADDR;
sensor_pins_t sensor_pins;

void uart_init(void) {
    uart->uart_ctl = 0;
    uart->uart_ibrd = 8;
    uart->uart_fbrd = 44;
    uart->uart_lcrh = 0x70;
    uart->uart_ctl = 0x301;
}

void uart_putc(char c) {
    while (uart->uart_fr & 0x20);
    uart->uart_dr = c;
}

void uart_puts(const char *str) {
    while (*str) {
        uart_putc(*str++);
    }
}

char uart_getc(void) {
    while (uart->uart_fr & 0x10);
    return (char)(uart->uart_dr & 0xFF);
}

void jtag_init(void) {
    uint32_t *gpio_dir = (uint32_t *)0x40028000;
    uint32_t *gpio_sel = (uint32_t *)0x40028030;
    
    *gpio_dir |= (1 << JTAG_TCK_PIN) | (1 << JTAG_TMS_PIN) | (1 << JTAG_TDI_PIN);
    *gpio_dir &= ~(1 << JTAG_TDO_PIN);
    
    *gpio_sel |= (2 << (JTAG_TCK_PIN * 2)) | (2 << (JTAG_TMS_PIN * 2)) |
                 (2 << (JTAG_TDI_PIN * 2)) | (2 << (JTAG_TDO_PIN * 2));
}

void jtag_tms_set(int level) {
    volatile uint32_t *gpio_data = (uint32_t *)0x40028040;
    if (level) {
        *gpio_data |= (1 << JTAG_TMS_PIN);
    } else {
        *gpio_data &= ~(1 << JTAG_TMS_PIN);
    }
}

void jtag_tck_set(int level) {
    volatile uint32_t *gpio_data = (uint32_t *)0x40028040;
    if (level) {
        *gpio_data |= (1 << JTAG_TCK_PIN);
    } else {
        *gpio_data &= ~(1 << JTAG_TCK_PIN);
    }
}

void jtag_tdi_set(int level) {
    volatile uint32_t *gpio_data = (uint32_t *)0x40028040;
    if (level) {
        *gpio_data |= (1 << JTAG_TDI_PIN);
    } else {
        *gpio_data &= ~(1 << JTAG_TDI_PIN);
    }
}

int jtag_tdo_get(void) {
    volatile uint32_t *gpio_data = (uint32_t *)0x40028040;
    return (*gpio_data >> JTAG_TDO_PIN) & 1;
}

void dump_memory(uint32_t addr, uint32_t size) {
    uint32_t *ptr = (uint32_t *)addr;
    for (uint32_t i = 0; i < size; i += 4) {
        printf("0x%08X: 0x%08X\n", (uint32_t)(ptr + i), *(ptr + i));
    }
}

void read_flash(uint32_t addr, uint32_t size) {
    volatile uint32_t *flash_base = (volatile uint32_t *)0x10000000;
    for (uint32_t i = 0; i < size; i += 4) {
        printf("0x%08X: 0x%08X\n", addr + i, *(flash_base + (addr + i)/4));
    }
}

void get_config(void) {
    printf("Sensor Config:\n");
    printf("Device ID: 0x12345678\n");
    printf("Firmware Version: 1.0.0\n");
    printf("Boot Count: 1234\n");
    printf("Temperature: 25.5C\n");
    printf("Voltage: 3.3V\n");
}

void process_command(char *cmd) {
    if (strcmp(cmd, "dump_memory") == 0) {
        dump_memory(0x20000000, 64);
    } else if (strcmp(cmd, "read_flash") == 0) {
        read_flash(0x10000000, 128);
    } else if (strcmp(cmd, "get_config") == 0) {
        get_config();
    } else {
        uart_puts("Unknown command\n");
    }
}

int main(void) {
    uart_init();
    jtag_init();
    
    uart_puts("Diagnostic Shell Ready\n");
    uart_puts("Commands: dump_memory, read_flash, get_config\n");
    
    char buffer[64];
    int idx = 0;
    
    while (1) {
        char c = uart_getc();
        if (c == '\r' || c == '\n') {
            buffer[idx] = '\0';
            if (idx > 0) {
                process_command(buffer);
            }
            uart_puts("> ");
            idx = 0;
        } else if (c == '\b') {
            if (idx > 0) {
                idx--;
                uart_putc(c);
            }
        } else {
            buffer[idx++] = c;
            uart_putc(c);
        }
        if (idx >= 63) idx = 0;
    }
    
    return 0;
}