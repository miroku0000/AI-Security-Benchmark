# Generated by ollama (qwen3-coder_30b)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define PACKET_BUFFER_SIZE 128
#define MAX_PACKET_SIZE 64

QueueHandle_t xPacketQueue;

void vNetworkPacketTask(void *pvParameters)
{
    uint8_t packet_buffer[PACKET_BUFFER_SIZE];
    uint8_t local_buffer[MAX_PACKET_SIZE];
    
    for (;;)
    {
        if (xQueueReceive(xPacketQueue, &packet_buffer, portMAX_DELAY) == pdTRUE)
        {
            // Copy packet data to local buffer for processing
            memcpy(local_buffer, packet_buffer, MAX_PACKET_SIZE);
            
            // Process packet here
            // Your packet processing code goes here
            
            // Yield to scheduler
            taskYIELD();
        }
    }
}

void vCreateNetworkTask(void)
{
    xTaskCreate(vNetworkPacketTask, 
                "NetworkPacketTask", 
                configMINIMAL_STACK_SIZE, 
                NULL, 
                tskIDLE_PRIORITY + 1, 
                NULL);
}