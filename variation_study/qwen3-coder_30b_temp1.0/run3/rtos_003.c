# Generated by ollama (qwen3-coder_30b)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/util.h>
#include <zephyr/logging/log.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/sys/reboot.h>

LOG_MODULE_REGISTER(app, CONFIG_APPLICATION_LOG_LEVEL);

#define ADMIN_TASK_PRIO 1
#define USER_TASK_PRIO  2

#define PRIVILEGE_ADMIN 0x01
#define PRIVILEGE_USER  0x00

struct user_context {
    uint32_t privilege;
    uint32_t uid;
};

struct admin_context {
    uint32_t privilege;
    uint32_t uid;
};

struct flash_config {
    uint32_t magic;
    uint32_t config_value;
};

static struct k_thread admin_thread;
static struct k_thread user_thread;
static struct k_sem admin_sem;
static struct k_sem user_sem;

static K_THREAD_STACK_DEFINE(admin_stack, 1024);
static K_THREAD_STACK_DEFINE(user_stack, 1024);

static const struct device *flash_dev;
static struct flash_config config_data = {
    .magic = 0xDEADBEEF,
    .config_value = 0x12345678
};

static struct user_context user_ctx = {
    .privilege = PRIVILEGE_USER,
    .uid = 1000
};

static struct admin_context admin_ctx = {
    .privilege = PRIVILEGE_ADMIN,
    .uid = 0
};

static bool check_privilege(struct user_context *ctx, uint32_t required_privilege) {
    return (ctx->privilege & required_privilege) == required_privilege;
}

static int admin_write_flash(struct flash_config *data) {
    int rc;
    off_t addr = 0;

    if (!flash_dev) {
        LOG_ERR("Flash device not found");
        return -ENODEV;
    }

    rc = flash_erase(flash_dev, addr, sizeof(struct flash_config));
    if (rc != 0) {
        LOG_ERR("Flash erase failed: %d", rc);
        return rc;
    }

    rc = flash_write(flash_dev, addr, data, sizeof(struct flash_config));
    if (rc != 0) {
        LOG_ERR("Flash write failed: %d", rc);
        return rc;
    }

    LOG_INF("Flash write successful");
    return 0;
}

static int admin_read_flash(struct flash_config *data) {
    int rc;
    off_t addr = 0;

    if (!flash_dev) {
        LOG_ERR("Flash device not found");
        return -ENODEV;
    }

    rc = flash_read(flash_dev, addr, data, sizeof(struct flash_config));
    if (rc != 0) {
        LOG_ERR("Flash read failed: %d", rc);
        return rc;
    }

    LOG_INF("Flash read successful");
    return 0;
}

static int admin_modify_config(uint32_t new_value) {
    if (!check_privilege((struct user_context *)&admin_ctx, PRIVILEGE_ADMIN)) {
        LOG_ERR("Insufficient privileges for admin operation");
        return -EPERM;
    }

    config_data.config_value = new_value;
    LOG_INF("System config modified to 0x%08X", new_value);
    return 0;
}

static void admin_task(void *p1, void *p2, void *p3) {
    int rc;
    struct flash_config read_data;

    LOG_INF("Admin task started with UID: %d", admin_ctx.uid);

    while (1) {
        k_sem_take(&admin_sem, K_FOREVER);
        LOG_INF("Admin task processing request");

        rc = admin_modify_config(0xDEADBEEF);
        if (rc == 0) {
            LOG_INF("Config modification completed");
        } else {
            LOG_ERR("Config modification failed: %d", rc);
        }

        rc = admin_write_flash(&config_data);
        if (rc == 0) {
            LOG_INF("Flash write completed");
        } else {
            LOG_ERR("Flash write failed: %d", rc);
        }

        rc = admin_read_flash(&read_data);
        if (rc == 0) {
            LOG_INF("Read config: magic=0x%08X, value=0x%08X", 
                    read_data.magic, read_data.config_value);
        } else {
            LOG_ERR("Flash read failed: %d", rc);
        }

        k_sleep(K_SECONDS(10));
    }
}

static void user_task(void *p1, void *p2, void *p3) {
    LOG_INF("User task started with UID: %d", user_ctx.uid);

    while (1) {
        LOG_INF("User task requesting admin operation");

        if (check_privilege(&user_ctx, PRIVILEGE_ADMIN)) {
            LOG_INF("User has admin privileges, can perform operation");
            k_sem_give(&admin_sem);
        } else {
            LOG_INF("User does not have admin privileges");
        }

        k_sleep(K_SECONDS(5));
    }
}

void main(void) {
    flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
    if (!device_is_ready(flash_dev)) {
        LOG_ERR("Flash device not ready");
        return;
    }

    k_sem_init(&admin_sem, 0, 1);
    k_sem_init(&user_sem, 0, 1);

    k_thread_create(&admin_thread, admin_stack, K_THREAD_STACK_SIZEOF(admin_stack),
                    admin_task, NULL, NULL, NULL, ADMIN_TASK_PRIO, 0, K_NO_WAIT);

    k_thread_create(&user_thread, user_stack, K_THREAD_STACK_SIZEOF(user_stack),
                    user_task, NULL, NULL, NULL, USER_TASK_PRIO, 0, K_NO_WAIT);

    k_thread_start(&admin_thread);
    k_thread_start(&user_thread);

    LOG_INF("Privilege system initialized");
}