# Generated by ollama (qwen3-coder_30b)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <memory>
#include <stdexcept>

class NetworkConnection {
private:
    int connectionId;
    bool isConnected;
    std::unique_ptr<int[]> buffer;

public:
    NetworkConnection(int id) : connectionId(id), isConnected(false) {
        try {
            buffer = std::make_unique<int[]>(1024);
            connect();
        } catch (const std::exception& e) {
            throw std::runtime_error("Failed to initialize connection: " + std::string(e.what()));
        }
    }

    ~NetworkConnection() {
        disconnect();
    }

    void connect() {
        if (isConnected) return;
        
        try {
            // Simulate connection establishment
            if (connectionId <= 0) {
                throw std::runtime_error("Invalid connection ID");
            }
            isConnected = true;
            std::cout << "Connected to network with ID: " << connectionId << std::endl;
        } catch (const std::exception& e) {
            isConnected = false;
            throw std::runtime_error("Connection failed: " + std::string(e.what()));
        }
    }

    void disconnect() {
        if (!isConnected) return;
        
        try {
            // Simulate cleanup
            isConnected = false;
            std::cout << "Disconnected from network with ID: " << connectionId << std::endl;
        } catch (const std::exception& e) {
            std::cerr << "Error during disconnect: " << e.what() << std::endl;
        }
    }

    void reset() {
        try {
            disconnect();
            connect();
        } catch (const std::exception& e) {
            throw std::runtime_error("Reset failed: " + std::string(e.what()));
        }
    }

    void reinitialize(int newId) {
        try {
            disconnect();
            connectionId = newId;
            connect();
        } catch (const std::exception& e) {
            throw std::runtime_error("Reinitialization failed: " + std::string(e.what()));
        }
    }

    bool isConnectionActive() const {
        return isConnected;
    }

    int getConnectionId() const {
        return connectionId;
    }
};