# Generated by ollama (qwen3-coder_30b)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>
#include <chrono>
#include <memory>

class Session {
private:
    std::string userId;
    std::chrono::steady_clock::time_point createTime;
    bool isActive;

public:
    Session(const std::string& userId) : userId(userId), isActive(true) {
        createTime = std::chrono::steady_clock::now();
    }
    
    const std::string& getUserId() const { return userId; }
    bool getIsActive() const { return isActive; }
    void setActive(bool active) { isActive = active; }
    
    bool isExpired(int timeoutSeconds) const {
        auto now = std::chrono::steady_clock::now();
        auto duration = std::chrono::duration_cast<std::chrono::seconds>(now - createTime);
        return duration.count() > timeoutSeconds;
    }
};

class SessionManager {
private:
    std::vector<Session*> sessions;
    int timeoutSeconds;

public:
    SessionManager(int timeout = 3600) : timeoutSeconds(timeout) {}
    
    ~SessionManager() {
        cleanup();
    }
    
    Session* createSession(const std::string& userId) {
        Session* session = new Session(userId);
        sessions.push_back(session);
        return session;
    }
    
    void removeSession(const std::string& userId) {
        auto it = std::find_if(sessions.begin(), sessions.end(),
            [&userId](Session* s) { return s->getUserId() == userId; });
        
        if (it != sessions.end()) {
            delete *it;
            sessions.erase(it);
        }
    }
    
    Session* getSession(const std::string& userId) {
        auto it = std::find_if(sessions.begin(), sessions.end(),
            [&userId](Session* s) { return s->getUserId() == userId; });
        
        if (it != sessions.end() && !(*it)->isExpired(timeoutSeconds)) {
            return *it;
        }
        return nullptr;
    }
    
    void cleanupExpiredSessions() {
        auto it = sessions.begin();
        while (it != sessions.end()) {
            if ((*it)->isExpired(timeoutSeconds)) {
                delete *it;
                it = sessions.erase(it);
            } else {
                ++it;
            }
        }
    }
    
    void cleanup() {
        for (Session* session : sessions) {
            delete session;
        }
        sessions.clear();
    }
    
    size_t getSessionCount() const {
        return sessions.size();
    }
};