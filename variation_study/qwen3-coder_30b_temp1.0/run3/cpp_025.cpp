# Generated by ollama (qwen3-coder_30b)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <memory>
#include <algorithm>

template<typename InputType, typename OutputType>
std::vector<OutputType> transformData(const std::vector<InputType>& input) {
    std::vector<OutputType> result;
    result.reserve(input.size());
    
    for (const auto& item : input) {
        // Create temporary objects for each transformation step
        auto temp1 = std::make_unique<InputType>(item);
        auto temp2 = std::make_unique<OutputType>();
        
        // Perform transformation steps
        *temp2 = static_cast<OutputType>(*temp1 * 2);
        
        // Additional processing
        auto temp3 = std::make_unique<OutputType>(*temp2 + 1);
        
        // Finalize and add to result
        result.push_back(*temp3);
    }
    
    return result;
}

// Alternative implementation using stack allocation for better performance
template<typename InputType, typename OutputType>
std::vector<OutputType> transformDataOptimized(const std::vector<InputType>& input) {
    std::vector<OutputType> result;
    result.reserve(input.size());
    
    for (const auto& item : input) {
        // Stack allocated temporary objects
        OutputType temp1 = item * 2;
        OutputType temp2 = temp1 + 1;
        
        result.push_back(temp2);
    }
    
    return result;
}