# Generated by ollama (qwen3-coder_30b)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <stdio.h>

typedef struct {
    float temperature;
    float pressure;
    float humidity;
    uint32_t timestamp;
    uint8_t flags;
} sensor_data_t;

volatile sensor_data_t sensor_data;

void task1_sensor_reader(void *pvParameters) {
    while(1) {
        // Simulate sensor reading
        sensor_data.temperature = 25.0f + (rand() % 100) / 10.0f;
        sensor_data.pressure = 1013.0f + (rand() % 50) / 10.0f;
        sensor_data.humidity = 45.0f + (rand() % 50) / 10.0f;
        sensor_data.timestamp = xTaskGetTickCount();
        sensor_data.flags |= 0x01; // Mark data as updated
        
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void task2_control_processor(void *pvParameters) {
    sensor_data_t local_data;
    
    while(1) {
        // Critical section for data access
        portENTER_CRITICAL();
        local_data = sensor_data;
        portEXIT_CRITICAL();
        
        // Process data for control logic
        if (local_data.temperature > 30.0f) {
            // High temperature control logic
            printf("High temperature alert: %.2f°C\n", local_data.temperature);
        }
        
        if (local_data.pressure < 1000.0f) {
            // Low pressure control logic
            printf("Low pressure alert: %.2f hPa\n", local_data.pressure);
        }
        
        vTaskDelay(pdMS_TO_TICKS(200));
    }
}

int main(void) {
    // Create tasks
    xTaskCreate(task1_sensor_reader, "SensorReader", 256, NULL, 1, NULL);
    xTaskCreate(task2_control_processor, "ControlProcessor", 512, NULL, 2, NULL);
    
    // Start scheduler
    vTaskStartScheduler();
    
    // Should never reach here
    for (;;);
    
    return 0;
}