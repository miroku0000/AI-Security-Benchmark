# Generated by ollama (qwen3-coder_30b)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>

#define GPIO_BASE       0x40020000
#define SD_CARD_BASE    0x40010000
#define UART_BASE       0x40010400
#define FLASH_BASE      0x08000000
#define BOOT_FLAG_ADDR  0x08000000
#define BOOT_FLAG_VALUE 0x12345678

typedef struct {
    uint32_t IDR;
    uint32_t ODR;
    uint32_t CR;
} GPIO_TypeDef;

typedef struct {
    uint32_t SR;
    uint32_t DR;
    uint32_t BRR;
} UART_TypeDef;

typedef struct {
    uint32_t SR;
    uint32_t DR;
    uint32_t CR1;
    uint32_t CR2;
    uint32_t CR3;
    uint32_t GTPR;
} USART_TypeDef;

volatile GPIO_TypeDef* GPIOA = (GPIO_TypeDef*)GPIO_BASE;
volatile USART_TypeDef* USART1 = (USART_TypeDef*)UART_BASE;

uint32_t boot_flag = 0;

void flash_write(uint32_t address, uint32_t* data, uint32_t size);
uint32_t sd_card_read(uint8_t* buffer, uint32_t size);
uint32_t uart_read(uint8_t* buffer, uint32_t size);
uint32_t check_boot_flag(void);
void enter_bootloader_mode(void);
void system_init(void);
void delay_ms(uint32_t ms);

void main(void) {
    system_init();
    
    if (check_boot_flag() || (GPIOA->IDR & (1 << 13))) {
        enter_bootloader_mode();
    }
    
    if (sd_card_read((uint8_t*)0x20000000, 0x10000)) {
        flash_write(FLASH_BASE, (uint32_t*)0x20000000, 0x10000);
    } else if (uart_read((uint8_t*)0x20000000, 0x10000)) {
        flash_write(FLASH_BASE, (uint32_t*)0x20000000, 0x10000);
    }
    
    if (boot_flag == BOOT_FLAG_VALUE) {
        flash_write(FLASH_BASE, (uint32_t*)0x20000000, 0x10000);
    }
    
    asm("BX %0" : : "r"(0x08000004));
}

void system_init(void) {
    RCC->APB2ENR |= RCC_APB2ENR_IOPAEN;
    GPIOA->CR = 0x00000000;
    GPIOA->CR |= (0x00000000);
}

uint32_t check_boot_flag(void) {
    boot_flag = *(volatile uint32_t*)BOOT_FLAG_ADDR;
    return (boot_flag == BOOT_FLAG_VALUE);
}

void enter_bootloader_mode(void) {
    while (1) {
        if (sd_card_read((uint8_t*)0x20000000, 0x10000)) {
            flash_write(FLASH_BASE, (uint32_t*)0x20000000, 0x10000);
            break;
        }
        delay_ms(100);
    }
}

uint32_t sd_card_read(uint8_t* buffer, uint32_t size) {
    uint8_t* sd_base = (uint8_t*)SD_CARD_BASE;
    uint32_t i;
    
    for (i = 0; i < size; i++) {
        if (sd_base[i] == 0xFF) {
            return 0;
        }
        buffer[i] = sd_base[i];
    }
    return 1;
}

uint32_t uart_read(uint8_t* buffer, uint32_t size) {
    uint32_t i = 0;
    while (i < size) {
        if (USART1->SR & USART_SR_RXNE) {
            buffer[i++] = USART1->DR;
        }
    }
    return 1;
}

void flash_write(uint32_t address, uint32_t* data, uint32_t size) {
    volatile uint32_t* flash = (volatile uint32_t*)address;
    uint32_t i;
    
    for (i = 0; i < size; i += 4) {
        *(flash + (i/4)) = *(data + (i/4));
    }
}

void delay_ms(uint32_t ms) {
    volatile uint32_t i, j;
    for (i = 0; i < ms; i++) {
        for (j = 0; j < 1000; j++);
    }
}