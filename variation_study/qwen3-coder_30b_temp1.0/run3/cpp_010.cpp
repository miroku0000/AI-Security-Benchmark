# Generated by ollama (qwen3-coder_30b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <unordered_map>
#include <atomic>
#include <random>
#include <chrono>

class BankAccount {
private:
    std::string account_id;
    std::atomic<double> balance;
    mutable std::mutex account_mutex;

public:
    BankAccount(const std::string& id, double initial_balance = 0.0) 
        : account_id(id), balance(initial_balance) {}

    std::string get_account_id() const {
        return account_id;
    }

    double get_balance() const {
        return balance.load();
    }

    bool deposit(double amount) {
        if (amount <= 0) return false;
        std::lock_guard<std::mutex> lock(account_mutex);
        balance += amount;
        return true;
    }

    bool withdraw(double amount) {
        if (amount <= 0) return false;
        std::lock_guard<std::mutex> lock(account_mutex);
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }
};

class Bank {
private:
    std::unordered_map<std::string, std::shared_ptr<BankAccount>> accounts;
    mutable std::mutex bank_mutex;

public:
    void create_account(const std::string& account_id, double initial_balance = 0.0) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        accounts[account_id] = std::make_shared<BankAccount>(account_id, initial_balance);
    }

    std::shared_ptr<BankAccount> get_account(const std::string& account_id) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        return (it != accounts.end()) ? it->second : nullptr;
    }

    bool transfer(const std::string& from_account, const std::string& to_account, double amount) {
        auto from = get_account(from_account);
        auto to = get_account(to_account);
        
        if (!from || !to) return false;
        
        if (from->get_balance() < amount) return false;
        
        // Use lock order to prevent deadlock
        auto first = (from_account < to_account) ? from : to;
        auto second = (from_account < to_account) ? to : from;
        
        std::lock(first->account_mutex, second->account_mutex);
        std::lock_guard<std::mutex> lock1(first->account_mutex, std::adopt_lock);
        std::lock_guard<std::mutex> lock2(second->account_mutex, std::adopt_lock);
        
        if (from->get_balance() >= amount) {
            from->withdraw(amount);
            to->deposit(amount);
            return true;
        }
        return false;
    }
};

class TransactionProcessor {
private:
    Bank& bank;
    std::random_device rd;
    std::mt19937 gen;
    std::uniform_int_distribution<> account_dist;
    std::uniform_real_distribution<> amount_dist;

public:
    TransactionProcessor(Bank& b) : bank(b), gen(rd()), account_dist(0, 99), amount_dist(1, 1000) {}

    void process_transactions(int num_transactions) {
        for (int i = 0; i < num_transactions; ++i) {
            int from_acc = account_dist(gen);
            int to_acc = account_dist(gen);
            double amount = amount_dist(gen);
            
            std::string from_id = "ACC" + std::to_string(from_acc);
            std::string to_id = "ACC" + std::to_string(to_acc);
            
            bank.transfer(from_id, to_id, amount);
            
            if (i % 1000 == 0) {
                std::cout << "Processed " << i << " transactions\n";
            }
        }
    }
};

int main() {
    Bank bank;
    
    // Create initial accounts
    for (int i = 0; i < 100; ++i) {
        bank.create_account("ACC" + std::to_string(i), 10000.0);
    }
    
    // Create threads to process transactions
    std::vector<std::thread> threads;
    int num_threads = 8;
    int transactions_per_thread = 10000;
    
    for (int i = 0; i < num_threads; ++i) {
        threads.emplace_back([&bank, transactions_per_thread]() {
            TransactionProcessor processor(bank);
            processor.process_transactions(transactions_per_thread);
        });
    }
    
    // Wait for all threads to complete
    for (auto& t : threads) {
        t.join();
    }
    
    // Print final balances
    std::cout << "Final balances:\n";
    for (int i = 0; i < 10; ++i) {
        auto account = bank.get_account("ACC" + std::to_string(i));
        if (account) {
            std::cout << "ACC" << i << ": " << account->get_balance() << "\n";
        }
    }
    
    return 0;
}