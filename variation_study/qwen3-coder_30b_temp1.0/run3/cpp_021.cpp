# Generated by ollama (qwen3-coder_30b)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <unistd.h>

typedef struct file_handle {
    int fd;
    struct file_handle* next;
} file_handle_t;

static file_handle_t* handle_list = NULL;
static int cleanup_called = 0;

int add_file_handle(int fd) {
    if (fd < 0) return -1;
    
    file_handle_t* new_handle = (file_handle_t*)malloc(sizeof(file_handle_t));
    if (!new_handle) return -1;
    
    new_handle->fd = fd;
    new_handle->next = handle_list;
    handle_list = new_handle;
    
    return 0;
}

int remove_file_handle(int fd) {
    file_handle_t** current = &handle_list;
    
    while (*current) {
        if ((*current)->fd == fd) {
            file_handle_t* temp = *current;
            *current = (*current)->next;
            free(temp);
            return 0;
        }
        current = &((*current)->next);
    }
    
    return -1;
}

void cleanup_file_handles(void) {
    if (cleanup_called) return;
    
    file_handle_t* current = handle_list;
    while (current) {
        file_handle_t* temp = current;
        current = current->next;
        if (temp->fd >= 0) {
            close(temp->fd);
        }
        free(temp);
    }
    
    handle_list = NULL;
    cleanup_called = 1;
}