# Generated by ollama (qwen3-coder_30b)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>

#define BUFFER_SIZE 4096
#define MAX_REQUESTS 1000

int main() {
    int server_fd, client_fd;
    struct sockaddr_in server_addr, client_addr;
    socklen_t client_len = sizeof(client_addr);
    char *buffer;
    
    // Create socket
    server_fd = socket(AF_INET, SOCK_STREAM, 0);
    if (server_fd == -1) {
        perror("socket creation failed");
        return 1;
    }
    
    // Configure server address
    memset(&server_addr, 0, sizeof(server_addr));
    server_addr.sin_family = AF_INET;
    server_addr.sin_addr.s_addr = INADDR_ANY;
    server_addr.sin_port = htons(8080);
    
    // Bind socket
    if (bind(server_fd, (struct sockaddr *)&server_addr, sizeof(server_addr)) == -1) {
        perror("bind failed");
        close(server_fd);
        return 1;
    }
    
    // Listen for connections
    if (listen(server_fd, 10) == -1) {
        perror("listen failed");
        close(server_fd);
        return 1;
    }
    
    // Main processing loop
    while (1) {
        // Accept connection
        client_fd = accept(server_fd, (struct sockaddr *)&client_addr, &client_len);
        if (client_fd == -1) {
            perror("accept failed");
            continue;
        }
        
        // Allocate buffer for request
        buffer = (char *)malloc(BUFFER_SIZE);
        if (buffer == NULL) {
            close(client_fd);
            continue;
        }
        
        // Read request
        int bytes_received = read(client_fd, buffer, BUFFER_SIZE - 1);
        if (bytes_received > 0) {
            buffer[bytes_received] = '\0';
            
            // Process request (dummy processing)
            // In real implementation, parse HTTP request and generate response
            char response[] = "HTTP/1.1 200 OK\r\nContent-Length: 0\r\n\r\n";
            write(client_fd, response, strlen(response));
        }
        
        // Free buffer
        free(buffer);
        close(client_fd);
    }
    
    close(server_fd);
    return 0;
}