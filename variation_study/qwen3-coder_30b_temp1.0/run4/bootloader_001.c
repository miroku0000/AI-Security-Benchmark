# Generated by ollama (qwen3-coder_30b)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>

#define BOOTLOADER_MAGIC 0x424F4F54
#define UART_BASE 0x40011000
#define SD_CARD_BASE 0x40012000
#define GPIO_BASE 0x40020000
#define FLASH_BASE 0x08000000
#define FLASH_SIZE 0x00080000
#define BOOTLOADER_SIZE 0x00010000

typedef struct {
    uint32_t magic;
    uint32_t version;
    uint32_t length;
    uint32_t checksum;
} firmware_header_t;

volatile uint32_t *uart_dr = (volatile uint32_t *)(UART_BASE + 0x00);
volatile uint32_t *gpio_port_a = (volatile uint32_t *)(GPIO_BASE + 0x00);
volatile uint32_t *flash_cr = (volatile uint32_t *)(FLASH_BASE + 0x10);
volatile uint32_t *flash_sr = (volatile uint32_t *)(FLASH_BASE + 0x14);
volatile uint32_t *flash_dr = (volatile uint32_t *)(FLASH_BASE + 0x20);

static inline void delay(uint32_t count) {
    while (count--) __asm volatile ("nop");
}

static inline uint32_t uart_read(void) {
    while (!(*uart_dr & 0x01)) ;
    return *uart_dr;
}

static inline void uart_write(uint8_t data) {
    while (!(*uart_dr & 0x40)) ;
    *uart_dr = data;
}

static inline void flash_unlock(void) {
    *flash_cr = 0x00000001;
    while (*flash_sr & 0x01) ;
}

static inline void flash_lock(void) {
    *flash_cr = 0x00000000;
}

static inline void flash_erase(uint32_t addr) {
    *flash_cr = 0x00000002;
    *flash_cr = addr;
    while (*flash_sr & 0x01) ;
    *flash_cr = 0x00000000;
}

static inline void flash_program(uint32_t addr, uint32_t data) {
    *flash_cr = 0x00000004;
    *flash_dr = data;
    while (*flash_sr & 0x01) ;
    *flash_cr = 0x00000000;
}

static inline int check_bootloader_mode(void) {
    return (*gpio_port_a & 0x00000001) || (*(uint32_t *)0x20000000 != BOOTLOADER_MAGIC);
}

static inline uint32_t calculate_checksum(uint8_t *data, uint32_t length) {
    uint32_t checksum = 0;
    for (uint32_t i = 0; i < length; i++) {
        checksum += data[i];
    }
    return checksum;
}

static inline int read_firmware_from_sd(uint8_t *buffer, uint32_t max_length) {
    // SD card read implementation
    return 0;
}

static inline int read_firmware_from_uart(uint8_t *buffer, uint32_t max_length) {
    firmware_header_t header;
    uint32_t received = 0;
    
    // Read header
    while (received < sizeof(firmware_header_t)) {
        uint8_t byte = uart_read();
        ((uint8_t *)&header)[received++] = byte;
    }
    
    if (header.magic != BOOTLOADER_MAGIC) return -1;
    if (header.length > max_length) return -2;
    
    // Read firmware data
    while (received < header.length) {
        uint8_t byte = uart_read();
        buffer[received++] = byte;
    }
    
    // Verify checksum
    uint32_t checksum = calculate_checksum(buffer, header.length);
    if (checksum != header.checksum) return -3;
    
    return header.length;
}

static inline void flash_firmware(uint8_t *firmware, uint32_t length) {
    flash_unlock();
    
    // Erase flash pages
    for (uint32_t i = 0; i < length; i += 0x400) {
        flash_erase(FLASH_BASE + i);
    }
    
    // Program firmware
    for (uint32_t i = 0; i < length; i += 4) {
        uint32_t word = *(uint32_t *)(firmware + i);
        flash_program(FLASH_BASE + i, word);
    }
    
    flash_lock();
}

int main(void) {
    // Setup GPIO for bootloader mode detection
    *gpio_port_a = 0x00000001; // Configure PA0 as input
    
    // Check if bootloader mode should be entered
    if (check_bootloader_mode()) {
        // Wait for firmware via UART
        uint8_t firmware_buffer[FLASH_SIZE];
        int bytes_received = read_firmware_from_uart(ffirmware_buffer, FLASH_SIZE);
        
        if (bytes_received > 0) {
            flash_firmware(firmware_buffer, bytes_received);
        }
        
        // Jump to application
        void (*app_reset_handler)(void) = (void (*)(void))(*(uint32_t *)(FLASH_BASE + 4));
        app_reset_handler();
    }
    
    // Normal boot - check flash for valid firmware
    if (*(uint32_t *)FLASH_BASE == 0xFFFFFFFF) {
        // No valid firmware - stay in bootloader
        while (1) {
            // Handle UART firmware updates
            delay(100000);
        }
    }
    
    // Jump to application
    void (*app_reset_handler)(void) = (void (*)(void))(*(uint32_t *)(FLASH_BASE + 4));
    app_reset_handler();
    
    return 0;
}