# Generated by ollama (qwen3-coder_30b)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>
#include <chrono>

class Session {
private:
    std::string userId;
    std::chrono::steady_clock::time_point createTime;
    bool isActive;

public:
    Session(const std::string& userId) : userId(userId), isActive(true) {
        createTime = std::chrono::steady_clock::now();
    }
    
    const std::string& getUserId() const { return userId; }
    bool getIsActive() const { return isActive; }
    void setActive(bool active) { isActive = active; }
    
    bool isExpired(int timeoutSeconds) const {
        auto now = std::chrono::steady_clock::now();
        auto duration = std::chrono::duration_cast<std::chrono::seconds>(now - createTime);
        return duration.count() > timeoutSeconds;
    }
};

class SessionManager {
private:
    std::vector<Session*> sessions;
    int timeoutSeconds;

public:
    SessionManager(int timeout = 3600) : timeoutSeconds(timeout) {}
    
    ~SessionManager() {
        cleanupExpiredSessions();
    }
    
    Session* addSession(const std::string& userId) {
        Session* newSession = new Session(userId);
        sessions.push_back(newSession);
        return newSession;
    }
    
    bool removeSession(const std::string& userId) {
        auto it = std::find_if(sessions.begin(), sessions.end(),
            [&userId](Session* session) {
                return session && session->getUserId() == userId;
            });
        
        if (it != sessions.end()) {
            delete *it;
            sessions.erase(it);
            return true;
        }
        return false;
    }
    
    Session* getSession(const std::string& userId) {
        auto it = std::find_if(sessions.begin(), sessions.end(),
            [&userId](Session* session) {
                return session && session->getUserId() == userId;
            });
        
        if (it != sessions.end() && *it) {
            if ((*it)->isExpired(timeoutSeconds)) {
                delete *it;
                sessions.erase(it);
                return nullptr;
            }
            return *it;
        }
        return nullptr;
    }
    
    void cleanupExpiredSessions() {
        auto it = sessions.begin();
        while (it != sessions.end()) {
            if (*it && (*it)->isExpired(timeoutSeconds)) {
                delete *it;
                it = sessions.erase(it);
            } else {
                ++it;
            }
        }
    }
    
    size_t getActiveSessionCount() {
        cleanupExpiredSessions();
        return sessions.size();
    }
};