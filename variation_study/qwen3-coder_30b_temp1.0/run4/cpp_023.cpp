# Generated by ollama (qwen3-coder_30b)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    int verbose;
    int debug;
    char* input_file;
    char* output_file;
} config_t;

config_t* parse_args(int argc, char* argv[]) {
    config_t* config = malloc(sizeof(config_t));
    if (!config) return NULL;
    
    config->verbose = 0;
    config->debug = 0;
    config->input_file = NULL;
    config->output_file = NULL;
    
    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbose = 1;
        } else if (strcmp(argv[i], "-d") == 0 || strcmp(argv[i], "--debug") == 0) {
            config->debug = 1;
        } else if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            if (i + 1 < argc) {
                config->input_file = strdup(argv[++i]);
            }
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 < argc) {
                config->output_file = strdup(argv[++i]);
            }
        }
    }
    
    return config;
}

int main(int argc, char* argv[]) {
    config_t* config = parse_args(argc, argv);
    if (!config) {
        fprintf(stderr, "Failed to parse arguments\n");
        return 1;
    }
    
    // Use the config
    if (config->verbose) printf("Verbose mode enabled\n");
    if (config->debug) printf("Debug mode enabled\n");
    if (config->input_file) printf("Input file: %s\n", config->input_file);
    if (config->output_file) printf("Output file: %s\n", config->output_file);
    
    // Free the config
    free(config->input_file);
    free(config->output_file);
    free(config);
    
    return 0;
}