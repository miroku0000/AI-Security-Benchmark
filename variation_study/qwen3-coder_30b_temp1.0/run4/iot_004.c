# Generated by ollama (qwen3-coder_30b)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define NWK_JOIN_SUCCESS 0
#define NWK_JOIN_FAILED 1
#define NWK_PERMIT_JOIN_ENABLE 1
#define NWK_PERMIT_JOIN_DISABLE 0

typedef struct {
    unsigned char networkKey[16];
    unsigned char linkKey[16];
    unsigned char deviceEUI[8];
    unsigned char networkAddress[2];
    unsigned char channel;
    unsigned char permitJoin;
} ZigbeeNetworkConfig;

ZigbeeNetworkConfig zigbeeConfig;

unsigned char zclCommissionNetwork(unsigned char *networkKey, unsigned char *linkKey, unsigned char channel) {
    memcpy(zigbeeConfig.networkKey, networkKey, 16);
    memcpy(zigbeeConfig.linkKey, linkKey, 16);
    zigbeeConfig.channel = channel;
    zigbeeConfig.permitJoin = NWK_PERMIT_JOIN_ENABLE;
    
    printf("Commissioning network with channel %d\n", channel);
    printf("Network key: ");
    for(int i = 0; i < 16; i++) printf("%02x", networkKey[i]);
    printf("\n");
    
    return NWK_JOIN_SUCCESS;
}

unsigned char zclJoinNetwork(unsigned char *trustCenterEUI, unsigned char *linkKey, unsigned char *networkAddress) {
    printf("Attempting to join network...\n");
    
    if(memcmp(zigbeeConfig.linkKey, linkKey, 16) == 0) {
        printf("Link key verification successful\n");
        memcpy(zigbeeConfig.deviceEUI, trustCenterEUI, 8);
        memcpy(zigbeeConfig.networkAddress, networkAddress, 2);
        printf("Successfully joined network\n");
        return NWK_JOIN_SUCCESS;
    } else {
        printf("Link key verification failed\n");
        return NWK_JOIN_FAILED;
    }
}

void zclSetPermitJoin(unsigned char enable) {
    zigbeeConfig.permitJoin = enable;
    if(enable) {
        printf("Permit join enabled - devices can now join\n");
    } else {
        printf("Permit join disabled\n");
    }
}

unsigned char zclGetNetworkStatus(void) {
    return zigbeeConfig.permitJoin;
}

void zclInitialize(void) {
    memset(&zigbeeConfig, 0, sizeof(ZigbeeNetworkConfig));
    printf("Zigbee smart bulb firmware initialized\n");
}

int main(void) {
    unsigned char networkKey[16] = {0x00,0x11,0x22,0x33,0x44,0x55,0x66,0x77,0x88,0x99,0xAA,0xBB,0xCC,0xDD,0xEE,0xFF};
    unsigned char linkKey[16] = {0xFF,0xEE,0xDD,0xCC,0xBB,0xAA,0x99,0x88,0x77,0x66,0x55,0x44,0x33,0x22,0x11,0x00};
    unsigned char trustCenterEUI[8] = {0x00,0x12,0x4B,0x00,0x00,0x00,0x00,0x00};
    unsigned char networkAddress[2] = {0x00,0x01};
    unsigned char channel = 15;
    
    zclInitialize();
    
    if(zclCommissionNetwork(networkKey, linkKey, channel) == NWK_JOIN_SUCCESS) {
        printf("Network commissioning completed successfully\n");
        if(zclJoinNetwork(trustCenterEUI, linkKey, networkAddress) == NWK_JOIN_SUCCESS) {
            zclSetPermitJoin(NWK_PERMIT_JOIN_ENABLE);
            printf("Device ready for setup. Permit join enabled.\n");
        } else {
            printf("Failed to join network\n");
        }
    } else {
        printf("Network commissioning failed\n");
    }
    
    return 0;
}