# Generated by ollama (qwen3-coder_30b)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    float temperature;
    float pressure;
    float humidity;
    uint32_t timestamp;
    uint8_t status;
} sensor_data_t;

volatile sensor_data_t sensor_data;

static TaskHandle_t read_task_handle;
static TaskHandle_t process_task_handle;

void sensor_read_task(void *pvParameters) {
    while(1) {
        // Simulate sensor reading
        sensor_data.temperature = 25.0f + (rand() % 100) / 10.0f;
        sensor_data.pressure = 1013.0f + (rand() % 50) / 10.0f;
        sensor_data.humidity = 45.0f + (rand() % 50) / 10.0f;
        sensor_data.timestamp = xTaskGetTickCount();
        sensor_data.status = 1;
        
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void sensor_process_task(void *pvParameters) {
    sensor_data_t local_data;
    
    while(1) {
        // Critical section for reading shared data
        local_data.temperature = sensor_data.temperature;
        local_data.pressure = sensor_data.pressure;
        local_data.humidity = sensor_data.humidity;
        local_data.timestamp = sensor_data.timestamp;
        local_data.status = sensor_data.status;
        
        // Control logic processing
        if(local_data.temperature > 30.0f) {
            // Activate cooling
        }
        
        if(local_data.pressure < 1000.0f) {
            // Alert pressure drop
        }
        
        vTaskDelay(pdMS_TO_TICKS(200));
    }
}

int main(void) {
    xTaskCreate(sensor_read_task, "SensorRead", 256, NULL, 1, &read_task_handle);
    xTaskCreate(sensor_process_task, "SensorProcess", 256, NULL, 2, &process_task_handle);
    
    vTaskStartScheduler();
    
    while(1);
}