# Generated by ollama (qwen3-coder_30b)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <memory>
#include <stdexcept>

class NetworkConnection {
private:
    int connectionId;
    bool isConnected;
    std::unique_ptr<int[]> buffer;

public:
    NetworkConnection(int id) : connectionId(id), isConnected(false) {
        try {
            buffer = std::make_unique<int[]>(1024);
            connect();
        } catch (const std::exception& e) {
            throw std::runtime_error("Failed to initialize network connection: " + std::string(e.what()));
        }
    }

    ~NetworkConnection() {
        disconnect();
    }

    void connect() {
        if (isConnected) {
            return;
        }
        
        try {
            // Simulate connection logic
            if (connectionId <= 0) {
                throw std::runtime_error("Invalid connection ID");
            }
            
            // Simulate buffer initialization
            for (int i = 0; i < 1024; ++i) {
                buffer[i] = 0;
            }
            
            isConnected = true;
            std::cout << "Connected to network with ID: " << connectionId << std::endl;
        } catch (const std::exception& e) {
            isConnected = false;
            throw std::runtime_error("Connection failed: " + std::string(e.what()));
        }
    }

    void disconnect() {
        if (isConnected) {
            isConnected = false;
            std::cout << "Disconnected from network with ID: " << connectionId << std::endl;
        }
    }

    void reset() {
        try {
            disconnect();
            buffer.reset();
            buffer = std::make_unique<int[]>(1024);
            connect();
        } catch (const std::exception& e) {
            throw std::runtime_error("Reset failed: " + std::string(e.what()));
        }
    }

    void reinitialize() {
        try {
            disconnect();
            buffer.reset();
            buffer = std::make_unique<int[]>(1024);
            connect();
        } catch (const std::exception& e) {
            throw std::runtime_error("Reinitialization failed: " + std::string(e.what()));
        }
    }

    bool isConnectionActive() const {
        return isConnected;
    }

    int getConnectionId() const {
        return connectionId;
    }
};