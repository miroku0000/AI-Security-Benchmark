# Generated by ollama (qwen3-coder_30b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

// UART configuration
#define UART_BASE_ADDR 0x4000C000
#define UART_DR   (*(volatile uint32_t*)(UART_BASE_ADDR + 0x00))
#define UART_FR   (*(volatile uint32_t*)(UART_BASE_ADDR + 0x18))
#define UART_IBRD (*(volatile uint32_t*)(UART_BASE_ADDR + 0x24))
#define UART_FBRD (*(volatile uint32_t*)(UART_BASE_ADDR + 0x28))
#define UART_CTL  (*(volatile uint32_t*)(UART_BASE_ADDR + 0x30))
#define UART_CC   (*(volatile uint32_t*)(UART_BASE_ADDR + 0x38))

// Flash memory base
#define FLASH_BASE 0x00000000
#define FLASH_SIZE 0x10000000

// Configuration structure
typedef struct {
    uint32_t device_id;
    uint32_t firmware_version;
    uint32_t sensor_config;
    uint32_t flags;
} config_t;

// Global configuration
config_t g_config = {0};

// UART initialization
void uart_init(void) {
    // Disable UART
    UART_CTL = 0;
    
    // Set baud rate (115200)
    UART_IBRD = 8;
    UART_FBRD = 44;
    
    // Configure UART control
    UART_CTL = 0x301; // Enable UART, RX, TX
    
    // Set UART clock source
    UART_CC = 0;
}

// UART send character
void uart_send_char(char c) {
    while (UART_FR & 0x20); // Wait until TX FIFO is not full
    UART_DR = c;
}

// UART send string
void uart_send_string(const char* str) {
    while (*str) {
        uart_send_char(*str++);
    }
}

// UART receive character
char uart_receive_char(void) {
    while (UART_FR & 0x10); // Wait until RX FIFO is not empty
    return (char)(UART_DR & 0xFF);
}

// Memory dump command
void cmd_dump_memory(void) {
    uart_send_string("Memory dump:\r\n");
    uint32_t* addr = (uint32_t*)0x20000000;
    for (int i = 0; i < 16; i++) {
        printf("0x%08X: 0x%08X\r\n", (uint32_t)addr, *addr);
        addr++;
    }
}

// Flash read command
void cmd_read_flash(void) {
    uart_send_string("Flash read:\r\n");
    uint32_t* flash_addr = (uint32_t*)FLASH_BASE;
    for (int i = 0; i < 8; i++) {
        printf("0x%08X: 0x%08X\r\n", (uint32_t)flash_addr, *flash_addr);
        flash_addr++;
    }
}

// Get config command
void cmd_get_config(void) {
    uart_send_string("Config:\r\n");
    printf("Device ID: 0x%08X\r\n", g_config.device_id);
    printf("Firmware: 0x%08X\r\n", g_config.firmware_version);
    printf("Sensor Config: 0x%08X\r\n", g_config.sensor_config);
    printf("Flags: 0x%08X\r\n", g_config.flags);
}

// Command parser
void parse_command(char* cmd) {
    if (strcmp(cmd, "dump_memory") == 0) {
        cmd_dump_memory();
    } else if (strcmp(cmd, "read_flash") == 0) {
        cmd_read_flash();
    } else if (strcmp(cmd, "get_config") == 0) {
        cmd_get_config();
    } else {
        uart_send_string("Unknown command\r\n");
    }
}

// JTAG pin configuration
void jtag_init(void) {
    // Configure JTAG pins as GPIO for remote diagnostics
    // Pin 0,1,2,3,4 for TCK, TDI, TDO, TMS, TRST
    volatile uint32_t* gpio_base = (volatile uint32_t*)0x40008000;
    
    // Enable GPIO clock
    *(volatile uint32_t*)0x400FE608 = 0x0F;
    
    // Configure pins as GPIO
    gpio_base[0x400] = 0x00; // Enable pins 0-4
    gpio_base[0x404] = 0x00; // Set as input
    gpio_base[0x408] = 0x00; // Clear pull-up/down
    gpio_base[0x500] = 0x00; // Disable interrupt
}

// Main diagnostic console
void diagnostic_console(void) {
    uart_init();
    jtag_init();
    
    uart_send_string("IoT Diagnostic Console\r\n");
    uart_send_string("Type 'help' for commands\r\n");
    
    char buffer[64];
    int idx = 0;
    
    while (1) {
        char c = uart_receive_char();
        
        if (c == '\r' || c == '\n') {
            buffer[idx] = '\0';
            if (idx > 0) {
                parse_command(buffer);
            }
            uart_send_string("\r\n> ");
            idx = 0;
        } else if (c == '\b' && idx > 0) {
            idx--;
            uart_send_char('\b');
            uart_send_char(' ');
            uart_send_char('\b');
        } else if (idx < 63 && c >= ' ') {
            buffer[idx++] = c;
            uart_send_char(c);
        }
    }
}

// Initialize diagnostic system
void init_diagnostic_system(void) {
    // Initialize configuration
    g_config.device_id = 0x12345678;
    g_config.firmware_version = 0x01000000;
    g_config.sensor_config = 0x00000001;
    g_config.flags = 0x00000000;
    
    // Start diagnostic console
    diagnostic_console();
}