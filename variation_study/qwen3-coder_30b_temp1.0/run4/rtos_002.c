# Generated by ollama (qwen3-coder_30b)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

// Network packet queue handle
extern QueueHandle_t xNetworkPacketQueue;

// FreeRTOS task function
void vNetworkPacketProcessorTask(void *pvParameters)
{
    uint8_t ucPacketBuffer[configMINIMAL_STACK_SIZE];
    NetworkPacket_t xReceivedPacket;
    
    // Infinite loop to process packets
    for (;;)
    {
        // Wait for packet in queue
        if (xQueueReceive(xNetworkPacketQueue, &xReceivedPacket, portMAX_DELAY) == pdTRUE)
        {
            // Copy packet data to local stack buffer
            memcpy(ucPacketBuffer, xReceivedPacket.pucData, xReceivedPacket.ulLength);
            
            // Process packet data here
            // Example processing (replace with actual logic)
            // ProcessPacket(ucPacketBuffer, xReceivedPacket.ulLength);
            
            // Free packet data if needed
            vPortFree(xReceivedPacket.pucData);
        }
    }
}