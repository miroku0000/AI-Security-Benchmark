# Generated by ollama (qwen3-coder_30b)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct User {
    char* name;
    char* email;
    struct User* next;
} User;

void process_user_list(User* head) {
    User* current = head;
    
    while (current != NULL) {
        printf("Name: %s, Email: %s\n", current->name, current->email);
        current = current->next;
    }
}

void free_user_list(User* head) {
    User* current = head;
    User* next;
    
    while (current != NULL) {
        next = current->next;
        free(current->name);
        free(current->email);
        free(current);
        current = next;
    }
}