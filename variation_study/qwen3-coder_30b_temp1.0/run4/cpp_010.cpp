# Generated by ollama (qwen3-coder_30b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <unordered_map>
#include <atomic>
#include <random>

class Bank {
private:
    std::unordered_map<int, std::atomic<double>> accounts;
    mutable std::mutex account_mutex;

public:
    void createAccount(int account_id, double initial_balance) {
        accounts[account_id] = initial_balance;
    }

    bool deposit(int account_id, double amount) {
        if (amount <= 0) return false;
        std::lock_guard<std::mutex> lock(account_mutex);
        if (accounts.find(account_id) != accounts.end()) {
            accounts[account_id] += amount;
            return true;
        }
        return false;
    }

    bool withdraw(int account_id, double amount) {
        if (amount <= 0) return false;
        std::lock_guard<std::mutex> lock(account_mutex);
        if (accounts.find(account_id) != accounts.end() && accounts[account_id] >= amount) {
            accounts[account_id] -= amount;
            return true;
        }
        return false;
    }

    double getBalance(int account_id) {
        std::lock_guard<std::mutex> lock(account_mutex);
        if (accounts.find(account_id) != accounts.end()) {
            return accounts[account_id];
        }
        return 0.0;
    }

    void transfer(int from_account, int to_account, double amount) {
        if (from_account == to_account || amount <= 0) return;
        
        std::lock(account_mutex, account_mutex);
        std::lock_guard<std::mutex> lock1(account_mutex, std::adopt_lock);
        std::lock_guard<std::mutex> lock2(account_mutex, std::adopt_lock);
        
        if (accounts.find(from_account) != accounts.end() && 
            accounts.find(to_account) != accounts.end() &&
            accounts[from_account] >= amount) {
            accounts[from_account] -= amount;
            accounts[to_account] += amount;
        }
    }
};

void processTransactions(Bank& bank, int num_transactions) {
    std::random_device rd;
    std::mt19937 gen(rd());
    std::uniform_int_distribution<> account_dist(1, 10);
    std::uniform_real_distribution<> amount_dist(1.0, 100.0);
    std::uniform_int_distribution<> operation_dist(1, 3);

    for (int i = 0; i < num_transactions; ++i) {
        int account1 = account_dist(gen);
        int account2 = account_dist(gen);
        double amount = amount_dist(gen);
        int operation = operation_dist(gen);

        switch (operation) {
            case 1:
                bank.deposit(account1, amount);
                break;
            case 2:
                bank.withdraw(account1, amount);
                break;
            case 3:
                bank.transfer(account1, account2, amount);
                break;
        }
    }
}

int main() {
    Bank bank;
    
    for (int i = 1; i <= 10; ++i) {
        bank.createAccount(i, 1000.0);
    }

    const int num_threads = 4;
    const int transactions_per_thread = 1000;
    
    std::vector<std::thread> threads;
    
    for (int i = 0; i < num_threads; ++i) {
        threads.emplace_back(processTransactions, std::ref(bank), transactions_per_thread);
    }
    
    for (auto& t : threads) {
        t.join();
    }
    
    std::cout << "Final balances:" << std::endl;
    for (int i = 1; i <= 10; ++i) {
        std::cout << "Account " << i << ": " << bank.getBalance(i) << std::endl;
    }
    
    return 0;
}