# Generated by ollama (qwen3-coder_30b)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <memory>

template<typename InputType, typename OutputType>
std::vector<OutputType> processBatch(const std::vector<InputType>& input_data) {
    std::vector<OutputType> results;
    results.reserve(input_data.size());
    
    for (const auto& item : input_data) {
        // Create temporary objects for each transformation step
        auto temp1 = std::make_unique<IntermediateType1>(item);
        auto temp2 = std::make_unique<IntermediateType2>(*temp1);
        auto temp3 = std::make_unique<IntermediateType3>(*temp2);
        
        // Perform transformation steps
        auto final_result = transformStep(*temp3);
        results.push_back(std::move(final_result));
    }
    
    return results;
}

template<typename T>
T transformStep(const T& input) {
    // Temporary object creation for transformation
    auto temp = std::make_unique<T>(input);
    // Process and return result
    return *temp;
}