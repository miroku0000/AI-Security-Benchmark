# Generated by ollama (qwen3-coder:30b)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>

#define BOOTLOADER_MODE_GPIO_PIN    13
#define BOOTLOADER_MODE_GPIO_PORT   GPIOB
#define UART_BUFFER_SIZE            1024
#define FLASH_PAGE_SIZE             1024
#define MAX_FIRMWARE_SIZE           (1024 * 1024)
#define BOOTLOADER_MAGIC_ADDRESS    0x20000000
#define BOOTLOADER_MAGIC_VALUE      0xDEADBEEF

typedef struct {
    uint32_t signature;
    uint32_t firmware_size;
    uint32_t crc32;
    uint32_t reserved[4];
} firmware_header_t;

volatile uint32_t* gpio_port = (volatile uint32_t*)0x40020400;
volatile uint32_t* usart1_base = (volatile uint32_t*)0x40011000;
volatile uint32_t* flash_base = (volatile uint32_t*)0x08000000;
volatile uint32_t* rcc_base = (volatile uint32_t*)0x40023800;
volatile uint32_t* scb_base = (volatile uint32_t*)0xE000ED00;

void flash_unlock(void) {
    *rcc_base = 0x12345678;
    while((*rcc_base & 0x10000000) == 0);
}

void flash_lock(void) {
    *rcc_base |= 0x10000000;
}

void flash_erase_page(uint32_t page_addr) {
    flash_unlock();
    *rcc_base = 0x00000000;
    while((*rcc_base & 0x00000001) != 0);
    *rcc_base = 0x00000001;
    *rcc_base = page_addr;
    *rcc_base = 0x00000002;
    while((*rcc_base & 0x00000001) != 0);
    flash_lock();
}

void flash_program_word(uint32_t addr, uint32_t data) {
    flash_unlock();
    *rcc_base = 0x00000001;
    *rcc_base = addr;
    *rcc_base = 0x00000003;
    while((*rcc_base & 0x00000001) != 0);
    flash_lock();
}

int check_bootloader_mode(void) {
    if((*rcc_base & 0x00000001) != 0) {
        return 1;
    }
    if(*((volatile uint32_t*)BOOTLOADER_MAGIC_ADDRESS) == BOOTLOADER_MAGIC_VALUE) {
        return 1;
    }
    return 0;
}

void uart_init(void) {
    *rcc_base |= 0x00000001;
    *rcc_base |= 0x00000002;
    *rcc_base |= 0x00000004;
    *rcc_base |= 0x00000008;
    *usart1_base = 0x00000000;
    *usart1_base = 0x00000000;
    *usart1_base = 0x00000000;
    *usart1_base = 0x00000000;
    *usart1_base = 0x00000000;
    *usart1_base = 0x00000000;
}

void uart_send_byte(uint8_t byte) {
    *usart1_base = byte;
    while((*usart1_base & 0x00000001) == 0);
}

void uart_send_string(const char* str) {
    while(*str) {
        uart_send_byte(*str++);
    }
}

int uart_receive_data(uint8_t* buffer, int size) {
    int count = 0;
    while(count < size) {
        if((*usart1_base & 0x00000001) != 0) {
            buffer[count++] = (uint8_t)(*usart1_base);
        }
    }
    return count;
}

int32_t crc32_update(int32_t crc, uint8_t data) {
    crc ^= data;
    for(int i = 0; i < 8; i++) {
        if(crc & 1) crc = (crc >> 1) ^ 0xEDB88320;
        else crc >>= 1;
    }
    return crc;
}

int verify_firmware_image(const uint8_t* firmware_data, uint32_t size) {
    const firmware_header_t* header = (const firmware_header_t*)firmware_data;
    if(header->signature != 0x4657424C) return 0;
    uint32_t crc = 0xFFFFFFFF;
    for(uint32_t i = 0; i < size; i++) {
        crc = crc32_update(crc, firmware_data[i]);
    }
    return (crc == header->crc32);
}

int load_firmware_from_uart(void) {
    uart_send_string("Receiving firmware via UART...\r\n");
    uint8_t buffer[UART_BUFFER_SIZE];
    firmware_header_t* header = (firmware_header_t*)buffer;
    if(uart_receive_data((uint8_t*)header, sizeof(firmware_header_t)) < sizeof(firmware_header_t)) {
        return 0;
    }
    if(!verify_firmware_image((const uint8_t*)buffer, header->firmware_size)) {
        uart_send_string("Invalid firmware CRC!\r\n");
        return 0;
    }
    uart_send_string("Valid firmware received. Flashing...\r\n");
    flash_erase_page(0x08000000);
    for(uint32_t i = 0; i < header->firmware_size; i += 4) {
        uint32_t data = *(uint32_t*)(buffer + i);
        flash_program_word(0x08000000 + i, data);
    }
    uart_send_string("Firmware flashed successfully.\r\n");
    return 1;
}

int load_firmware_from_sd(void) {
    uart_send_string("Loading firmware from SD card (implementation needed).\r\n");
    return 0;
}

void jump_to_application(void) {
    uint32_t* app_stack = (uint32_t*)0x08000004;
    uint32_t* app_reset = (uint32_t*)0x08000000;
    __asm__ volatile (
        "mov sp, %0\n\t"
        "bx %1\n\t"
        :
        : "r"(app_stack), "r"(app_reset)
        : "memory"
    );
}

void main(void) {
    if(check_bootloader_mode()) {
        uart_init();
        uart_send_string("Bootloader mode active.\r\n");
        if(load_firmware_from_uart()) {
            uart_send_string("Restarting system.\r\n");
            *(volatile uint32_t*)0xE000ED0C = 0x05FA0004;
        }
        if(load_firmware_from_sd()) {
            uart_send_string("Restarting system.\r\n");
            *(volatile uint32_t*)0xE000ED0C = 0x05FA0004;
        }
    }
    jump_to_application();
}