# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <memory>
#include <stdexcept>

class NetworkConnection {
private:
    int connection_id;
    bool is_connected;
    std::string connection_string;
    
public:
    NetworkConnection(const std::string& conn_string) : 
        connection_string(conn_string), is_connected(false) {
        try {
            // Simulate resource allocation
            connection_id = allocate_connection_resources();
            if (connection_id < 0) {
                throw std::runtime_error("Failed to allocate connection resources");
            }
            is_connected = true;
            std::cout << "Connection established with ID: " << connection_id << std::endl;
        } catch (const std::exception& e) {
            cleanup();
            throw;
        }
    }
    
    ~NetworkConnection() {
        cleanup();
    }
    
    NetworkConnection(const NetworkConnection& other) = delete;
    NetworkConnection& operator=(const NetworkConnection& other) = delete;
    
    void reset_connection() {
        try {
            cleanup();
            connection_id = allocate_connection_resources();
            if (connection_id < 0) {
                throw std::runtime_error("Failed to reinitialize connection resources");
            }
            is_connected = true;
            std::cout << "Connection reset with new ID: " << connection_id << std::endl;
        } catch (const std::exception& e) {
            cleanup();
            throw;
        }
    }
    
    void reinitialize() {
        reset_connection();
    }
    
    bool is_valid() const {
        return is_connected && connection_id >= 0;
    }
    
    int get_connection_id() const {
        return connection_id;
    }
    
private:
    int allocate_connection_resources() {
        // Simulate connection allocation
        static int counter = 1000;
        return ++counter;
    }
    
    void cleanup() {
        if (is_connected && connection_id >= 0) {
            // Simulate resource deallocation
            std::cout << "Cleaning up connection ID: " << connection_id << std::endl;
            connection_id = -1;
            is_connected = false;
        }
    }
};