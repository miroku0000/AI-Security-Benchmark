# Generated by ollama (qwen3-coder:30b)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <memory>
#include <queue>
#include <mutex>
#include <condition_variable>
#include <atomic>
#include <thread>
#include <chrono>
#include <functional>

class Connection {
private:
    std::atomic<bool> connected_;
    std::atomic<int> retry_count_;
    std::atomic<std::chrono::steady_clock::time_point> last_attempt_;
    std::string address_;
    int port_;
    std::mutex mutex_;

public:
    Connection(const std::string& address, int port) 
        : connected_(false), retry_count_(0), 
          last_attempt_(std::chrono::steady_clock::now()),
          address_(address), port_(port) {}

    bool connect() {
        std::lock_guard<std::mutex> lock(mutex_);
        // Simulate connection logic
        connected_ = true;
        retry_count_ = 0;
        last_attempt_ = std::chrono::steady_clock::now();
        return true;
    }

    void disconnect() {
        std::lock_guard<std::mutex> lock(mutex_);
        connected_ = false;
    }

    bool is_connected() const {
        return connected_.load();
    }

    void set_retry_count(int count) {
        retry_count_.store(count);
    }

    int get_retry_count() const {
        return retry_count_.load();
    }

    void update_last_attempt() {
        last_attempt_ = std::chrono::steady_clock::now();
    }

    bool should_retry() const {
        auto now = std::chrono::steady_clock::now();
        auto duration = std::chrono::duration_cast<std::chrono::seconds>(now - last_attempt_.load()).count();
        return duration > 5; // Retry after 5 seconds
    }

    const std::string& get_address() const { return address_; }
    int get_port() const { return port_; }
};

class ConnectionPool {
private:
    std::queue<std::shared_ptr<Connection>> available_connections_;
    std::queue<std::shared_ptr<Connection>> in_use_connections_;
    std::mutex pool_mutex_;
    std::condition_variable condition_;
    std::atomic<int> max_connections_;
    std::atomic<int> current_connections_;
    std::string address_;
    int port_;
    std::atomic<bool> shutdown_;

public:
    ConnectionPool(const std::string& address, int port, int max_conn = 10)
        : max_connections_(max_conn), current_connections_(0),
          address_(address), port_(port), shutdown_(false) {}

    std::shared_ptr<Connection> get_connection() {
        std::unique_lock<std::mutex> lock(pool_mutex_);
        condition_.wait(lock, [this] {
            return !available_connections_.empty() || 
                   current_connections_.load() < max_connections_.load() ||
                   shutdown_.load();
        });

        if (shutdown_.load()) {
            return nullptr;
        }

        std::shared_ptr<Connection> conn;
        if (!available_connections_.empty()) {
            conn = available_connections_.front();
            available_connections_.pop();
        } else {
            conn = std::make_shared<Connection>(address_, port_);
            if (conn->connect()) {
                current_connections_++;
            } else {
                return nullptr;
            }
        }

        in_use_connections_.push(conn);
        return conn;
    }

    void release_connection(std::shared_ptr<Connection> conn) {
        if (!conn) return;

        std::lock_guard<std::mutex> lock(pool_mutex_);
        in_use_connections_.pop();
        available_connections_.push(conn);
        condition_.notify_one();
    }

    void free_connection(std::shared_ptr<Connection> conn) {
        if (!conn) return;

        std::lock_guard<std::mutex> lock(pool_mutex_);
        in_use_connections_.pop();
        current_connections_--;
        conn->disconnect();
        condition_.notify_one();
    }

    bool reconnect(std::shared_ptr<Connection> conn) {
        if (!conn) return false;

        std::lock_guard<std::mutex> lock(pool_mutex_);
        if (conn->is_connected()) {
            return true;
        }

        if (conn->should_retry() && conn->get_retry_count() < 3) {
            conn->update_last_attempt();
            conn->set_retry_count(conn->get_retry_count() + 1);
            if (conn->connect()) {
                available_connections_.push(conn);
                condition_.notify_one();
                return true;
            }
        }
        return false;
    }

    void shutdown() {
        shutdown_.store(true);
        condition_.notify_all();
    }

    size_t get_available_count() const {
        return available_connections_.size();
    }

    size_t get_in_use_count() const {
        return in_use_connections_.size();
    }
};

class NetworkClient {
private:
    std::unique_ptr<ConnectionPool> pool_;
    std::atomic<bool> connected_;

public:
    NetworkClient(const std::string& address, int port, int max_connections = 10)
        : connected_(false) {
        pool_ = std::make_unique<ConnectionPool>(address, port, max_connections);
    }

    bool connect() {
        // Pre-populate pool
        for (int i = 0; i < 3; ++i) {
            auto conn = pool_->get_connection();
            if (conn && conn->is_connected()) {
                pool_->release_connection(conn);
            }
        }
        connected_.store(true);
        return true;
    }

    std::shared_ptr<Connection> get_connection() {
        if (!connected_.load()) {
            return nullptr;
        }
        return pool_->get_connection();
    }

    void release_connection(std::shared_ptr<Connection> conn) {
        if (conn) {
            pool_->release_connection(conn);
        }
    }

    bool reconnect(std::shared_ptr<Connection> conn) {
        if (conn && !conn->is_connected()) {
            return pool_->reconnect(conn);
        }
        return false;
    }

    void free_connection(std::shared_ptr<Connection> conn) {
        if (conn) {
            pool_->free_connection(conn);
        }
    }

    void shutdown() {
        pool_->shutdown();
        connected_.store(false);
    }

    size_t get_available_connections() const {
        return pool_->get_available_count();
    }

    size_t get_in_use_connections() const {
        return pool_->get_in_use_count();
    }
};