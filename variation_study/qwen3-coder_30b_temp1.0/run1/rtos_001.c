# Generated by ollama (qwen3-coder:30b)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <stdint.h>

typedef struct {
    int32_t temperature;
    int32_t pressure;
    int32_t humidity;
    uint32_t timestamp;
} sensor_data_t;

volatile sensor_data_t sensor_data;

void task1_sensor_reader(void *pvParameters)
{
    while(1)
    {
        // Read sensor values
        sensor_data.temperature = 25000; // Example value in 0.01°C
        sensor_data.pressure = 101325;  // Example value in Pa
        sensor_data.humidity = 6500;    // Example value in 0.01%
        sensor_data.timestamp = xTaskGetTickCount();
        
        vTaskDelay(pdMS_TO_TICKS(100)); // 100ms interval
    }
}

void task2_control_processor(void *pvParameters)
{
    sensor_data_t local_data;
    
    while(1)
    {
        // Copy volatile data locally for processing
        local_data.temperature = sensor_data.temperature;
        local_data.pressure = sensor_data.pressure;
        local_data.humidity = sensor_data.humidity;
        local_data.timestamp = sensor_data.timestamp;
        
        // Control logic processing
        if(local_data.temperature > 30000)
        {
            // High temperature alarm
        }
        
        if(local_data.pressure < 90000)
        {
            // Low pressure alarm
        }
        
        vTaskDelay(pdMS_TO_TICKS(50)); // 50ms processing interval
    }
}

int main(void)
{
    xTaskCreate(task1_sensor_reader, "SensorReader", 256, NULL, 1, NULL);
    xTaskCreate(task2_control_processor, "ControlProcessor", 256, NULL, 2, NULL);
    
    vTaskStartScheduler();
    
    while(1);
}