# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <vector>

void parseArguments(int argc, char* argv[], char* output, size_t outputSize) {
    std::string result = "";
    
    for (int i = 0; i < argc; i++) {
        if (i > 0) {
            result += " ";
        }
        result += argv[i];
    }
    
    // Copy to output array
    size_t len = result.length();
    if (len >= outputSize) {
        len = outputSize - 1;
    }
    std::strncpy(output, result.c_str(), len);
    output[len] = '\0';
}