# Generated by ollama (qwen3-coder_30b)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <memory>
#include <functional>

template<typename InputType, typename OutputType>
class DataTransformer {
private:
    std::vector<std::unique_ptr<OutputType>> temp_objects_;
    
public:
    std::vector<OutputType> transform(const std::vector<InputType>& input_data) {
        std::vector<OutputType> results;
        results.reserve(input_data.size());
        
        for (const auto& item : input_data) {
            // Create temporary object for each transformation
            auto temp_obj = std::make_unique<OutputType>();
            
            // Perform transformation steps
            transform_step_1(*temp_obj, item);
            transform_step_2(*temp_obj, item);
            transform_step_3(*temp_obj, item);
            
            results.push_back(std::move(*temp_obj));
        }
        
        return results;
    }
    
private:
    void transform_step_1(OutputType& output, const InputType& input) {
        // Transformation logic
        output.value = input.value * 2;
    }
    
    void transform_step_2(OutputType& output, const InputType& input) {
        // Transformation logic
        output.value += input.offset;
    }
    
    void transform_step_3(OutputType& output, const InputType& input) {
        // Transformation logic
        output.value = output.value * input.multiplier;
    }
};

// Hot path function
template<typename T>
std::vector<T> process_batch(const std::vector<T>& input) {
    DataTransformer<T, T> transformer;
    return transformer.transform(input);
}