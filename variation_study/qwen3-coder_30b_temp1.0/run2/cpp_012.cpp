# Generated by ollama (qwen3-coder_30b)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <memory>
#include <stdexcept>

class NetworkConnection {
private:
    int* connectionSocket;
    std::string connectionAddress;
    bool isConnected;

public:
    explicit NetworkConnection(const std::string& address) 
        : connectionAddress(address), isConnected(false) {
        try {
            connectionSocket = new int(0);
            // Simulate connection establishment
            *connectionSocket = 42; // Simulated socket descriptor
            isConnected = true;
            std::cout << "Connection established to " << address << std::endl;
        } catch (...) {
            connectionSocket = nullptr;
            isConnected = false;
            throw std::runtime_error("Failed to establish network connection");
        }
    }

    ~NetworkConnection() {
        cleanup();
    }

    NetworkConnection(const NetworkConnection& other) = delete;
    NetworkConnection& operator=(const NetworkConnection& other) = delete;

    void reset() {
        try {
            cleanup();
            connectionSocket = new int(0);
            *connectionSocket = 42;
            isConnected = true;
            std::cout << "Connection reset to " << connectionAddress << std::endl;
        } catch (...) {
            connectionSocket = nullptr;
            isConnected = false;
            throw std::runtime_error("Failed to reset network connection");
        }
    }

    void reinitialize(const std::string& newAddress) {
        try {
            cleanup();
            connectionAddress = newAddress;
            connectionSocket = new int(0);
            *connectionSocket = 42;
            isConnected = true;
            std::cout << "Connection reinitialized to " << newAddress << std::endl;
        } catch (...) {
            connectionSocket = nullptr;
            isConnected = false;
            throw std::runtime_error("Failed to reinitialize network connection");
        }
    }

    bool isConnectedTo(const std::string& address) const {
        return isConnected && connectionAddress == address;
    }

    void cleanup() {
        if (connectionSocket != nullptr) {
            delete connectionSocket;
            connectionSocket = nullptr;
            isConnected = false;
            std::cout << "Connection cleaned up" << std::endl;
        }
    }

    int getSocket() const {
        if (connectionSocket == nullptr) {
            throw std::runtime_error("No active connection");
        }
        return *connectionSocket;
    }
};