# Generated by ollama (qwen3-coder_30b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <map>
#include <random>
#include <chrono>

class BankAccount {
private:
    std::string account_id;
    double balance;
    mutable std::mutex account_mutex;

public:
    BankAccount(const std::string& id, double initial_balance = 0.0) 
        : account_id(id), balance(initial_balance) {}

    std::string get_account_id() const {
        return account_id;
    }

    double get_balance() const {
        std::lock_guard<std::mutex> lock(account_mutex);
        return balance;
    }

    bool deposit(double amount) {
        if (amount <= 0) return false;
        std::lock_guard<std::mutex> lock(account_mutex);
        balance += amount;
        return true;
    }

    bool withdraw(double amount) {
        if (amount <= 0) return false;
        std::lock_guard<std::mutex> lock(account_mutex);
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }
};

class Bank {
private:
    std::map<std::string, BankAccount> accounts;
    mutable std::mutex bank_mutex;

public:
    void create_account(const std::string& account_id, double initial_balance = 0.0) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        accounts.emplace(account_id, BankAccount(account_id, initial_balance));
    }

    bool deposit(const std::string& account_id, double amount) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        if (it != accounts.end()) {
            return it->second.deposit(amount);
        }
        return false;
    }

    bool withdraw(const std::string& account_id, double amount) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        if (it != accounts.end()) {
            return it->second.withdraw(amount);
        }
        return false;
    }

    double get_balance(const std::string& account_id) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        if (it != accounts.end()) {
            return it->second.get_balance();
        }
        return 0.0;
    }

    void print_balances() {
        std::lock_guard<std::mutex> lock(bank_mutex);
        for (const auto& pair : accounts) {
            std::cout << "Account " << pair.first << ": $" << pair.second.get_balance() << std::endl;
        }
    }
};

void transaction_worker(Bank& bank, int num_transactions, int thread_id) {
    std::random_device rd;
    std::mt19937 gen(rd());
    std::uniform_int_distribution<> account_dist(1, 10);
    std::uniform_int_distribution<> amount_dist(1, 1000);
    std::uniform_int_distribution<> type_dist(1, 2);

    for (int i = 0; i < num_transactions; ++i) {
        std::string account_id = "ACC" + std::to_string(account_dist(gen));
        double amount = amount_dist(gen);
        int type = type_dist(gen);

        if (type == 1) {
            bank.deposit(account_id, amount);
            std::cout << "Thread " << thread_id << " deposited $" << amount 
                      << " to " << account_id << std::endl;
        } else {
            bank.withdraw(account_id, amount);
            std::cout << "Thread " << thread_id << " withdrew $" << amount 
                      << " from " << account_id << std::endl;
        }

        std::this_thread::sleep_for(std::chrono::milliseconds(10));
    }
}

int main() {
    Bank bank;
    
    for (int i = 1; i <= 10; ++i) {
        bank.create_account("ACC" + std::to_string(i), 10000.0);
    }

    const int num_threads = 5;
    const int transactions_per_thread = 10;
    std::vector<std::thread> threads;

    for (int i = 0; i < num_threads; ++i) {
        threads.emplace_back(transaction_worker, std::ref(bank), transactions_per_thread, i);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    std::cout << "\nFinal balances:" << std::endl;
    bank.print_balances();

    return 0;
}