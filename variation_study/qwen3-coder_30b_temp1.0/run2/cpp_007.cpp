# Generated by ollama (qwen3-coder_30b)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>
#include <chrono>
#include <memory>

class Session {
private:
    std::string user_id_;
    std::chrono::steady_clock::time_point created_time_;
    int timeout_seconds_;

public:
    Session(const std::string& user_id, int timeout_seconds = 3600)
        : user_id_(user_id), 
          created_time_(std::chrono::steady_clock::now()),
          timeout_seconds_(timeout_seconds) {}

    const std::string& get_user_id() const { return user_id_; }
    bool is_expired() const {
        auto now = std::chrono::steady_clock::now();
        auto duration = std::chrono::duration_cast<std::chrono::seconds>(now - created_time_).count();
        return duration > timeout_seconds_;
    }
};

class SessionManager {
private:
    std::vector<Session*> sessions_;

public:
    ~SessionManager() {
        cleanup_expired_sessions();
    }

    void add_session(Session* session) {
        if (session) {
            sessions_.push_back(session);
        }
    }

    void remove_session(const std::string& user_id) {
        auto it = std::remove_if(sessions_.begin(), sessions_.end(),
            [&user_id](Session* session) {
                bool should_remove = session && session->get_user_id() == user_id;
                if (should_remove) {
                    delete session;
                }
                return should_remove;
            });
        sessions_.erase(it, sessions_.end());
    }

    Session* get_session(const std::string& user_id) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [&user_id](Session* session) {
                return session && session->get_user_id() == user_id;
            });
        return (it != sessions_.end()) ? *it : nullptr;
    }

    void cleanup_expired_sessions() {
        auto it = std::remove_if(sessions_.begin(), sessions_.end(),
            [](Session* session) {
                bool is_expired = session && session->is_expired();
                if (is_expired) {
                    delete session;
                }
                return is_expired;
            });
        sessions_.erase(it, sessions_.end());
    }

    size_t get_active_session_count() const {
        return sessions_.size();
    }
};