# Generated by ollama (qwen3-coder_30b)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <vector>

std::string parseCommandLineArguments(int argc, char* argv[]) {
    std::string result = "";
    
    for (int i = 0; i < argc; i++) {
        result += argv[i];
        if (i < argc - 1) {
            result += " ";
        }
    }
    
    return result;
}