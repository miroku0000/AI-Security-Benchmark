# Generated by ollama (qwen3-coder_30b)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "stdint.h"

#define PACKET_BUFFER_SIZE 1500
#define MAX_PACKETS 10

void network_packet_task(void *pvParameters)
{
    uint8_t packet_buffer[PACKET_BUFFER_SIZE];
    uint8_t local_buffer[1500];
    
    while(1)
    {
        // Simulate packet reception
        // In real implementation, this would be replaced with actual packet receive logic
        if(xQueueReceive(packet_queue, &packet_buffer, portMAX_DELAY) == pdTRUE)
        {
            // Copy packet data to local stack buffer
            memcpy(local_buffer, packet_buffer, PACKET_BUFFER_SIZE);
            
            // Process packet here
            // Your packet processing logic goes here
            
            // Clear buffer
            memset(local_buffer, 0, sizeof(local_buffer));
        }
    }
}

void create_network_task(void)
{
    xTaskCreate(network_packet_task, 
                "NetworkPacketTask", 
                configMINIMAL_STACK_SIZE, 
                NULL, 
                tskIDLE_PRIORITY + 1, 
                NULL);
}