# Generated by ollama (qwen3-coder_30b)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/security/privilege.h>

#define USER_STACK_SIZE 1024
#define ADMIN_STACK_SIZE 2048

K_THREAD_STACK_DEFINE(user_stack, USER_STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, ADMIN_STACK_SIZE);

struct k_thread user_thread;
struct k_thread admin_thread;

static const struct flash_sector sector = {
    .offset = 0x10000,
    .size = 4096
};

static struct flash_page page = {
    .offset = 0x10000,
    .size = 4096
};

static int admin_operations_enabled = 0;
static int user_requests = 0;

static int check_privilege(void)
{
    return z_privilege_check(Z_PRIVILEGE_ADMIN);
}

static int flash_write_operation(const void *data, size_t len)
{
    const struct device *flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash));
    
    if (!device_is_ready(flash_dev)) {
        return -ENODEV;
    }
    
    if (check_privilege() != 0) {
        return -EPERM;
    }
    
    int ret = flash_write(flash_dev, sector.offset, data, len);
    return ret;
}

static int modify_config(const char *config_data)
{
    if (check_privilege() != 0) {
        return -EPERM;
    }
    
    admin_operations_enabled = 1;
    return 0;
}

static void user_task(void *p1, void *p2, void *p3)
{
    while (1) {
        user_requests++;
        printk("User task requesting admin operation %d\n", user_requests);
        
        if (user_requests > 5) {
            break;
        }
        
        k_msleep(1000);
    }
}

static void admin_task(void *p1, void *p2, void *p3)
{
    char data[] = "Admin config data";
    int ret;
    
    while (1) {
        if (user_requests > 0) {
            printk("Admin task processing request\n");
            
            ret = modify_config(data);
            if (ret == 0) {
                printk("Config modified successfully\n");
            } else {
                printk("Failed to modify config: %d\n", ret);
            }
            
            ret = flash_write_operation(data, sizeof(data));
            if (ret == 0) {
                printk("Flash write successful\n");
            } else {
                printk("Flash write failed: %d\n", ret);
            }
            
            user_requests = 0;
        }
        
        k_msleep(2000);
    }
}

void main(void)
{
    printk("Starting privilege system demo\n");
    
    k_thread_create(&user_thread, user_stack, USER_STACK_SIZE,
                    user_task, NULL, NULL, NULL,
                    5, 0, K_NO_WAIT);
    
    k_thread_create(&admin_thread, admin_stack, ADMIN_STACK_SIZE,
                    admin_task, NULL, NULL, NULL,
                    3, 0, K_NO_WAIT);
    
    k_thread_start(&user_thread);
    k_thread_start(&admin_thread);
    
    while (1) {
        k_msleep(5000);
    }
}