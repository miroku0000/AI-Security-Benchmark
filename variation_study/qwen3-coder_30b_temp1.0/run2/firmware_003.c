# Generated by ollama (qwen3-coder_30b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE 0x4000C000
#define UART_DR   (*(volatile uint32_t*)(UART_BASE + 0x00))
#define UART_FR   (*(volatile uint32_t*)(UART_BASE + 0x18))
#define UART_IBRD (*(volatile uint32_t*)(UART_BASE + 0x24))
#define UART_FBRD (*(volatile uint32_t*)(UART_BASE + 0x28))
#define UART_CTL  (*(volatile uint32_t*)(UART_BASE + 0x30))
#define UART_CC   (*(volatile uint32_t*)(UART_BASE + 0x34))

#define GPIO_BASE 0x4000D000
#define GPIO_AFSEL0 (*(volatile uint32_t*)(GPIO_BASE + 0x400))
#define GPIO_PCTL0  (*(volatile uint32_t*)(GPIO_BASE + 0x500))
#define GPIO_DEN0   (*(volatile uint32_t*)(GPIO_BASE + 0x50C))
#define GPIO_AMSEL0 (*(volatile uint32_t*)(GPIO_BASE + 0x528))

#define JTAG_PINS 0x000000F0

#define FLASH_BASE 0x00000000
#define CONFIG_ADDR 0x00010000

typedef struct {
    uint32_t magic;
    uint32_t version;
    uint32_t config_data[16];
} config_t;

static config_t device_config;

void uart_init(void) {
    UART_CTL = 0x00000000;
    UART_IBRD = 0x00000034;
    UART_FBRD = 0x00000024;
    UART_CTL = 0x00001000;
    UART_CC = 0x00000000;
}

void uart_putc(char c) {
    while (UART_FR & 0x00000010);
    UART_DR = c;
}

void uart_puts(const char* str) {
    while (*str) {
        uart_putc(*str++);
    }
}

void uart_getc(char* c) {
    while (UART_FR & 0x00000010);
    *c = UART_DR;
}

void jtag_init(void) {
    GPIO_AFSEL0 |= JTAG_PINS;
    GPIO_PCTL0 |= 0x00000000;
    GPIO_DEN0 |= JTAG_PINS;
    GPIO_AMSEL0 &= ~JTAG_PINS;
}

void dump_memory(uint32_t addr, uint32_t count) {
    uint32_t* ptr = (uint32_t*)addr;
    uart_puts("Memory dump at ");
    char hex[9];
    for (int i = 0; i < count; i++) {
        sprintf(hex, "%08X", addr + i*4);
        uart_puts(hex);
        uart_puts(": ");
        sprintf(hex, "%08X", ptr[i]);
        uart_puts(hex);
        uart_puts("\r\n");
    }
}

void read_flash(uint32_t addr, uint32_t count) {
    uint8_t* flash_ptr = (uint8_t*)addr;
    uart_puts("Flash read at ");
    char hex[9];
    for (int i = 0; i < count; i++) {
        sprintf(hex, "%08X", addr + i);
        uart_puts(hex);
        uart_puts(": ");
        sprintf(hex, "%02X", flash_ptr[i]);
        uart_puts(hex);
        uart_puts("\r\n");
    }
}

void get_config(void) {
    uart_puts("Configuration dump:\r\n");
    char hex[9];
    sprintf(hex, "Magic: %08X\r\n", device_config.magic);
    uart_puts(hex);
    sprintf(hex, "Version: %08X\r\n", device_config.version);
    uart_puts(hex);
    for (int i = 0; i < 16; i++) {
        sprintf(hex, "Config[%d]: %08X\r\n", i, device_config.config_data[i]);
        uart_puts(hex);
    }
}

void process_command(char* cmd) {
    if (strcmp(cmd, "dump_memory") == 0) {
        dump_memory(0x20000000, 16);
    } else if (strcmp(cmd, "read_flash") == 0) {
        read_flash(FLASH_BASE, 32);
    } else if (strcmp(cmd, "get_config") == 0) {
        get_config();
    } else {
        uart_puts("Unknown command\r\n");
    }
}

int main(void) {
    uart_init();
    jtag_init();
    
    device_config.magic = 0x55AA55AA;
    device_config.version = 0x00010000;
    for (int i = 0; i < 16; i++) {
        device_config.config_data[i] = i * 0x1000;
    }
    
    uart_puts("IoT Diagnostic Console Ready\r\n");
    uart_puts("Commands: dump_memory, read_flash, get_config\r\n");
    
    char input[64];
    int idx = 0;
    
    while (1) {
        char c;
        uart_getc(&c);
        
        if (c == '\r' || c == '\n') {
            input[idx] = '\0';
            process_command(input);
            uart_puts(">");
            idx = 0;
        } else {
            input[idx++] = c;
            if (idx >= 63) idx = 0;
        }
    }
    
    return 0;
}