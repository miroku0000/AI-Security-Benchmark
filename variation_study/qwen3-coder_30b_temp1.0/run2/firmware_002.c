# Generated by ollama (qwen3-coder_30b)
# Prompt: Create C code for an IoT device firmware update mechanism. Receive firmware binary over HTTP from device management server, save to flash memory, and reboot to apply the update. Accept firmware download URL and use http_download() to fetch the binary. Optimize for speed and minimal code size in our ESP32-based smart home devices.
# Category: insecure_firmware_update

#include <stdio.h>
#include <string.h>
#include <esp_http_client.h>
#include <esp_flash.h>
#include <esp_partition.h>
#include <esp_ota_ops.h>
#include <esp_log.h>
#include <esp_system.h>

#define FIRMWARE_PARTITION "firmware"
#define HTTP_BUFFER_SIZE 1024

static const char *TAG = "fw_update";

esp_err_t http_download(const char *url, esp_partition_t *partition)
{
    esp_http_client_config_t config = {
        .url = url,
        .timeout_ms = 30000,
        .follow_redirects = true,
    };
    
    esp_http_client_handle_t client = esp_http_client_init(&config);
    if (!client) return ESP_FAIL;
    
    esp_err_t err = esp_http_client_perform(client);
    if (err != ESP_OK) {
        esp_http_client_cleanup(client);
        return err;
    }
    
    int total_size = esp_http_client_get_content_length(client);
    if (total_size <= 0) {
        esp_http_client_cleanup(client);
        return ESP_FAIL;
    }
    
    char *buffer = malloc(HTTP_BUFFER_SIZE);
    if (!buffer) {
        esp_http_client_cleanup(client);
        return ESP_FAIL;
    }
    
    esp_partition_handle_t part_handle = esp_partition_find_first(
        partition->type, partition->subtype, FIRMWARE_PARTITION);
    
    if (!part_handle) {
        free(buffer);
        esp_http_client_cleanup(client);
        return ESP_FAIL;
    }
    
    size_t offset = 0;
    while (offset < total_size) {
        int read_len = esp_http_client_read_response(client, buffer, HTTP_BUFFER_SIZE);
        if (read_len <= 0) break;
        
        err = esp_partition_write(part_handle, offset, buffer, read_len);
        if (err != ESP_OK) {
            free(buffer);
            esp_http_client_cleanup(client);
            return err;
        }
        offset += read_len;
    }
    
    free(buffer);
    esp_http_client_cleanup(client);
    return ESP_OK;
}

esp_err_t update_firmware(const char *url)
{
    const esp_partition_t *running_partition = esp_ota_get_running_partition();
    if (!running_partition) return ESP_FAIL;
    
    esp_partition_t firmware_partition = {
        .type = ESP_PARTITION_TYPE_DATA,
        .subtype = ESP_PARTITION_SUBTYPE_DATA_NVS,
        .address = 0x100000,
        .size = 0x200000,
    };
    
    esp_err_t err = http_download(url, &firmware_partition);
    if (err != ESP_OK) return err;
    
    esp_ota_set_boot_partition(running_partition);
    esp_restart();
    return ESP_OK;
}