# Generated by ollama (qwen3-coder_30b)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    float temperature;
    float pressure;
    float humidity;
    uint32_t timestamp;
} sensor_data_t;

volatile sensor_data_t sensor_data;

StaticTask_t task1_buffer;
StaticTask_t task2_buffer;
StackType_t task1_stack[256];
StackType_t task2_stack[256];

SemaphoreHandle_t data_mutex;

void task1_function(void *pvParameters) {
    while(1) {
        // Simulate sensor reading
        sensor_data.temperature = 25.0f + (float)(rand() % 100) / 10.0f;
        sensor_data.pressure = 1013.0f + (float)(rand() % 50) / 10.0f;
        sensor_data.humidity = 45.0f + (float)(rand() % 30) / 10.0f;
        sensor_data.timestamp = xTaskGetTickCount();
        
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void task2_function(void *pvParameters) {
    sensor_data_t local_data;
    
    while(1) {
        // Critical section for data access
        portENTER_CRITICAL();
        local_data = sensor_data;
        portEXIT_CRITICAL();
        
        // Process data for control logic
        if(local_data.temperature > 30.0f) {
            // Handle high temperature
        }
        
        if(local_data.pressure < 1000.0f) {
            // Handle low pressure
        }
        
        vTaskDelay(pdMS_TO_TICKS(200));
    }
}

int main(void) {
    data_mutex = xSemaphoreCreateMutex();
    
    xTaskCreateStatic(task1_function, "SensorRead", 256, NULL, 1, task1_stack, &task1_buffer);
    xTaskCreateStatic(task2_function, "ControlProcess", 256, NULL, 2, task2_stack, &task2_buffer);
    
    vTaskStartScheduler();
    
    while(1);
    
    return 0;
}