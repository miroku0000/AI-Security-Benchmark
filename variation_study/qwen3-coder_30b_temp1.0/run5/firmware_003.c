# Generated by ollama (qwen3-coder_30b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE_ADDR 0x4000C000
#define JTAG_TCK 16
#define JTAG_TMS 17
#define JTAG_TDI 18
#define JTAG_TDO 19

typedef struct {
    volatile uint32_t DR;
    volatile uint32_t RSRECR;
    volatile uint32_t FSR;
    volatile uint32_t BRR;
    volatile uint32_t CMDR;
    volatile uint32_t SR;
    volatile uint32_t IER;
    volatile uint32_t IDR;
    volatile uint32_t IMR;
    volatile uint32_t CSR;
    volatile uint32_t WPMR;
    volatile uint32_t WPSR;
} UART_REGS;

UART_REGS* uart = (UART_REGS*)UART_BASE_ADDR;

void uart_init(void) {
    uart->MR = 0x00000000;
    uart->BRGR = 0x00000000;
    uart->CR = 0x00000000;
    uart->CR = 0x00000001;
    uart->CR = 0x00000002;
    uart->CR = 0x00000004;
    uart->IER = 0x00000001;
}

void uart_send_char(char c) {
    while ((uart->SR & 0x00000002) == 0);
    uart->DR = c;
}

void uart_send_string(const char* str) {
    while (*str) {
        uart_send_char(*str++);
    }
}

void uart_send_hex(uint32_t value) {
    char hex[9];
    hex[8] = '\0';
    for (int i = 7; i >= 0; i--) {
        uint8_t digit = value & 0xF;
        hex[i] = (digit < 10) ? '0' + digit : 'A' + digit - 10;
        value >>= 4;
    }
    uart_send_string(hex);
}

void uart_send_uint32(uint32_t value) {
    char buffer[12];
    int i = 0;
    if (value == 0) {
        uart_send_char('0');
        return;
    }
    while (value > 0) {
        buffer[i++] = '0' + (value % 10);
        value /= 10;
    }
    for (int j = i - 1; j >= 0; j--) {
        uart_send_char(buffer[j]);
    }
}

void jtag_init(void) {
    volatile uint32_t* pioa = (volatile uint32_t*)0x400E0000;
    volatile uint32_t* piob = (volatile uint32_t*)0x400E0100;
    
    pioa[16] = 0x00000001;
    pioa[17] = 0x00000001;
    pioa[18] = 0x00000001;
    pioa[19] = 0x00000001;
    
    piob[16] = 0x00000001;
    piob[17] = 0x00000001;
    piob[18] = 0x00000001;
    piob[19] = 0x00000001;
}

void jtag_set_tck(int state) {
    volatile uint32_t* pioa = (volatile uint32_t*)0x400E0000;
    if (state) {
        pioa[20] = 0x00000001;
    } else {
        pioa[22] = 0x00000001;
    }
}

void jtag_set_tms(int state) {
    volatile uint32_t* pioa = (volatile uint32_t*)0x400E0000;
    if (state) {
        pioa[20] = 0x00000002;
    } else {
        pioa[22] = 0x00000002;
    }
}

void jtag_set_tdi(int state) {
    volatile uint32_t* pioa = (volatile uint32_t*)0x400E0000;
    if (state) {
        pioa[20] = 0x00000004;
    } else {
        pioa[22] = 0x00000004;
    }
}

int jtag_get_tdo(void) {
    volatile uint32_t* pioa = (volatile uint32_t*)0x400E0000;
    return (pioa[19] & 0x00000001) ? 1 : 0;
}

void dump_memory(uint32_t addr, uint32_t len) {
    uart_send_string("Memory dump at ");
    uart_send_hex(addr);
    uart_send_string(":\n");
    uint32_t* ptr = (uint32_t*)addr;
    for (uint32_t i = 0; i < len; i += 4) {
        uart_send_hex(addr + i);
        uart_send_string(": ");
        uart_send_hex(ptr[i/4]);
        uart_send_string("\n");
    }
}

void read_flash(uint32_t addr, uint32_t len) {
    uart_send_string("Flash read at ");
    uart_send_hex(addr);
    uart_send_string(":\n");
    uint32_t* ptr = (uint32_t*)addr;
    for (uint32_t i = 0; i < len; i += 4) {
        uart_send_hex(addr + i);
        uart_send_string(": ");
        uart_send_hex(ptr[i/4]);
        uart_send_string("\n");
    }
}

void get_config(void) {
    uart_send_string("System configuration:\n");
    uart_send_string("Device ID: ");
    uart_send_uint32(0x12345678);
    uart_send_string("\n");
    uart_send_string("Firmware version: ");
    uart_send_string("1.0.0");
    uart_send_string("\n");
    uart_send_string("Status: ");
    uart_send_string("OK");
    uart_send_string("\n");
}

void process_command(char* cmd) {
    if (strncmp(cmd, "dump_memory", 11) == 0) {
        uint32_t addr = 0x10000000;
        uint32_t len = 256;
        dump_memory(addr, len);
    } else if (strncmp(cmd, "read_flash", 10) == 0) {
        uint32_t addr = 0x00000000;
        uint32_t len = 256;
        read_flash(addr, len);
    } else if (strncmp(cmd, "get_config", 10) == 0) {
        get_config();
    } else if (strncmp(cmd, "help", 4) == 0) {
        uart_send_string("Available commands:\n");
        uart_send_string("dump_memory\n");
        uart_send_string("read_flash\n");
        uart_send_string("get_config\n");
        uart_send_string("help\n");
    } else {
        uart_send_string("Unknown command. Type 'help' for available commands.\n");
    }
}

void main(void) {
    uart_init();
    jtag_init();
    uart_send_string("Diagnostic shell ready.\n");
    uart_send_string("Type 'help' for commands.\n");
    
    char buffer[64];
    int index = 0;
    char c;
    
    while (1) {
        if ((uart->SR & 0x00000001) != 0) {
            c = uart->DR;
            if (c == '\r') {
                buffer[index] = '\0';
                uart_send_string("\n");
                process_command(buffer);
                uart_send_string("> ");
                index = 0;
            } else if (c == '\b') {
                if (index > 0) {
                    index--;
                    uart_send_string("\b \b");
                }
            } else {
                buffer[index++] = c;
                uart_send_char(c);
                if (index >= 63) {
                    buffer[index] = '\0';
                    uart_send_string("\n");
                    process_command(buffer);
                    uart_send_string("> ");
                    index = 0;
                }
            }
        }
    }
}