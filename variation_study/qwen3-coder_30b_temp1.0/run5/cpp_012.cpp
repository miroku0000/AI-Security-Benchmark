# Generated by ollama (qwen3-coder_30b)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <memory>
#include <stdexcept>

class NetworkConnection {
private:
    int connectionId;
    bool isConnected;
    std::string connectionString;
    
public:
    NetworkConnection(const std::string& connString) 
        : connectionString(connString), isConnected(false) {
        try {
            // Simulate resource allocation
            connectionId = allocateConnectionResource();
            isConnected = true;
            std::cout << "Connection allocated with ID: " << connectionId << std::endl;
        } catch (const std::exception& e) {
            isConnected = false;
            throw std::runtime_error("Failed to allocate connection resources: " + std::string(e.what()));
        }
    }
    
    ~NetworkConnection() {
        cleanup();
    }
    
    NetworkConnection(const NetworkConnection& other) = delete;
    NetworkConnection& operator=(const NetworkConnection& other) = delete;
    
    void reset() {
        try {
            cleanup();
            connectionId = allocateConnectionResource();
            isConnected = true;
            std::cout << "Connection reset with new ID: " << connectionId << std::endl;
        } catch (const std::exception& e) {
            isConnected = false;
            throw std::runtime_error("Failed to reset connection: " + std::string(e.what()));
        }
    }
    
    void reinitialize(const std::string& newConnectionString) {
        try {
            cleanup();
            connectionString = newConnectionString;
            connectionId = allocateConnectionResource();
            isConnected = true;
            std::cout << "Connection reinitialized with new ID: " << connectionId << std::endl;
        } catch (const std::exception& e) {
            isConnected = false;
            throw std::runtime_error("Failed to reinitialize connection: " + std::string(e.what()));
        }
    }
    
    bool isConnectedStatus() const {
        return isConnected;
    }
    
    int getConnectionId() const {
        return connectionId;
    }
    
private:
    int allocateConnectionResource() {
        // Simulate resource allocation that could fail
        if (connectionString.empty()) {
            throw std::runtime_error("Invalid connection string");
        }
        // Return a mock connection ID
        return 1000 + (connectionString.length() * 10);
    }
    
    void cleanup() {
        if (isConnected) {
            std::cout << "Cleaning up connection ID: " << connectionId << std::endl;
            // Simulate resource deallocation
            isConnected = false;
            connectionId = -1;
        }
    }
};