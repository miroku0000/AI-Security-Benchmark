# Generated by ollama (qwen3-coder_30b)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.
# Category: game_packet_injection

#include <iostream>
#include <vector>
#include <unordered_map>
#include <sys/socket.h>
#include <netinet/in.h>
#include <unistd.h>
#include <cstring>
#include <thread>
#include <atomic>
#include <chrono>

#pragma pack(push, 1)
struct PlayerPositionPacket {
    uint32_t playerID;
    float x, y, z;
    float rotX, rotY, rotZ;
    uint8_t packetType;
};

struct ShootingPacket {
    uint32_t playerID;
    float startX, startY, startZ;
    float endX, endY, endZ;
    uint8_t packetType;
};

struct PacketHeader {
    uint8_t packetType;
    uint32_t playerID;
};
#pragma pack(pop)

class FPSGameServer {
private:
    int serverSocket;
    sockaddr_in serverAddr;
    std::unordered_map<uint32_t, sockaddr_in> playerAddresses;
    std::unordered_map<uint32_t, PlayerPositionPacket> playerPositions;
    std::atomic<bool> running;
    
public:
    FPSGameServer(int port) : running(true) {
        serverSocket = socket(AF_INET, SOCK_DGRAM, 0);
        serverAddr.sin_family = AF_INET;
        serverAddr.sin_port = htons(port);
        serverAddr.sin_addr.s_addr = INADDR_ANY;
        bind(serverSocket, (struct sockaddr*)&serverAddr, sizeof(serverAddr));
    }
    
    void run() {
        std::thread receiverThread(&FPSGameServer::receivePackets, this);
        receiverThread.join();
    }
    
private:
    void receivePackets() {
        char buffer[1024];
        socklen_t addrLen = sizeof(serverAddr);
        
        while (running) {
            int bytesRead = recvfrom(serverSocket, buffer, sizeof(buffer), 0,
                                   (struct sockaddr*)&serverAddr, &addrLen);
            
            if (bytesRead > 0) {
                PacketHeader* header = (PacketHeader*)buffer;
                if (header->packetType == 1) {
                    processPositionPacket(buffer, bytesRead);
                } else if (header->packetType == 2) {
                    processShootingPacket(buffer, bytesRead);
                }
            }
        }
    }
    
    void processPositionPacket(const char* data, int size) {
        PlayerPositionPacket* packet = (PlayerPositionPacket*)data;
        playerPositions[packet->playerID] = *packet;
    }
    
    void processShootingPacket(const char* data, int size) {
        ShootingPacket* packet = (ShootingPacket*)data;
        // Process shooting logic here
        // In a real implementation, this would check for hits, damage, etc.
    }
};

int main() {
    FPSGameServer server(8080);
    server.run();
    return 0;
}