# Generated by ollama (qwen3-coder_30b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <unordered_map>
#include <random>
#include <chrono>

class BankAccount {
private:
    std::string account_id;
    double balance;
    mutable std::mutex account_mutex;

public:
    BankAccount(const std::string& id, double initial_balance = 0.0) 
        : account_id(id), balance(initial_balance) {}

    std::string get_account_id() const {
        return account_id;
    }

    double get_balance() const {
        std::lock_guard<std::mutex> lock(account_mutex);
        return balance;
    }

    bool deposit(double amount) {
        if (amount <= 0) return false;
        std::lock_guard<std::mutex> lock(account_mutex);
        balance += amount;
        return true;
    }

    bool withdraw(double amount) {
        if (amount <= 0) return false;
        std::lock_guard<std::mutex> lock(account_mutex);
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }
};

class Bank {
private:
    std::unordered_map<std::string, BankAccount> accounts;
    mutable std::mutex bank_mutex;

public:
    void create_account(const std::string& account_id, double initial_balance = 0.0) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        accounts.emplace(account_id, BankAccount(account_id, initial_balance));
    }

    bool transfer(const std::string& from_account, const std::string& to_account, double amount) {
        if (from_account == to_account) return false;
        
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto from_it = accounts.find(from_account);
        auto to_it = accounts.find(to_account);
        
        if (from_it == accounts.end() || to_it == accounts.end()) return false;
        
        if (from_it->second.get_balance() < amount) return false;
        
        from_it->second.withdraw(amount);
        to_it->second.deposit(amount);
        return true;
    }

    double get_balance(const std::string& account_id) const {
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        if (it != accounts.end()) {
            return it->second.get_balance();
        }
        return 0.0;
    }
};

class TransactionProcessor {
private:
    Bank& bank;
    std::vector<std::thread> threads;
    std::random_device rd;
    std::mt19937 gen;
    std::uniform_int_distribution<> account_dist;
    std::uniform_real_distribution<> amount_dist;

public:
    TransactionProcessor(Bank& bank_instance, int num_threads) 
        : bank(bank_instance), gen(rd()), account_dist(0, 9), amount_dist(1.0, 100.0) {
        
        for (int i = 0; i < num_threads; ++i) {
            threads.emplace_back(&TransactionProcessor::process_transactions, this);
        }
    }

    void process_transactions() {
        std::uniform_int_distribution<> op_dist(0, 2);
        std::uniform_int_distribution<> account_id_dist(0, 99);
        
        for (int i = 0; i < 1000; ++i) {
            int operation = op_dist(gen);
            int account1 = account_id_dist(gen);
            int account2 = account_id_dist(gen);
            double amount = amount_dist(gen);
            
            switch (operation) {
                case 0:
                    bank.transfer("ACC" + std::to_string(account1), "ACC" + std::to_string(account2), amount);
                    break;
                case 1:
                    bank.get_balance("ACC" + std::to_string(account1));
                    break;
                case 2:
                    bank.create_account("ACC" + std::to_string(account1), amount);
                    break;
            }
        }
    }

    void join_threads() {
        for (auto& t : threads) {
            if (t.joinable()) {
                t.join();
            }
        }
    }
};

int main() {
    Bank bank;
    
    for (int i = 0; i < 100; ++i) {
        bank.create_account("ACC" + std::to_string(i), 1000.0);
    }
    
    TransactionProcessor processor(bank, 10);
    processor.join_threads();
    
    for (int i = 0; i < 10; ++i) {
        std::cout << "Account ACC" << i << " balance: " << bank.get_balance("ACC" + std::to_string(i)) << std::endl;
    }
    
    return 0;
}