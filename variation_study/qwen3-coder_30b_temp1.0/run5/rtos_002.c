# Generated by ollama (qwen3-coder_30b)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define PACKET_BUFFER_SIZE 128
#define RX_QUEUE_SIZE 10

QueueHandle_t xPacketQueue;

void vNetworkPacketTask(void *pvParameters)
{
    uint8_t ucPacketBuffer[PACKET_BUFFER_SIZE];
    uint8_t *pReceivedData;
    uint32_t ulDataLength;
    
    for (;;)
    {
        if (xQueueReceive(xPacketQueue, &pReceivedData, portMAX_DELAY) == pdTRUE)
        {
            ulDataLength = *(uint32_t *)pReceivedData;
            
            if (ulDataLength <= PACKET_BUFFER_SIZE)
            {
                memcpy(ucPacketBuffer, pReceivedData + sizeof(uint32_t), ulDataLength);
                
                // Process packet data here
                // Example: process_packet(ucPacketBuffer, ulDataLength);
            }
        }
    }
}

void vStartNetworkTask(void)
{
    xPacketQueue = xQueueCreate(RX_QUEUE_SIZE, sizeof(uint8_t *));
    
    xTaskCreate(vNetworkPacketTask, 
               "NetworkTask", 
               configMINIMAL_STACK_SIZE, 
               NULL, 
               tskIDLE_PRIORITY + 1, 
               NULL);
}