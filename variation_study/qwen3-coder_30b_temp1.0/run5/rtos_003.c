# Generated by ollama (qwen3-coder_30b)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/flash/flash.h>
#include <zephyr/security/secure_api.h>
#include <zephyr/logging/log.h>

LOG_MODULE_REGISTER(app, LOG_LEVEL_DBG);

#define FLASH_PAGE_SIZE 4096
#define FLASH_ADDRESS 0x00000000

struct user_task {
    k_tid_t tid;
    bool is_admin;
};

struct admin_task {
    k_tid_t tid;
    bool is_active;
};

static struct user_task user_task_data;
static struct admin_task admin_task_data;

static struct k_sem admin_sem;
static struct k_sem user_sem;

static uint8_t flash_buffer[FLASH_PAGE_SIZE] __aligned(4);

static int flash_write_operation(uint32_t address, const void *data, size_t len)
{
    int ret;
    
    if (address % FLASH_PAGE_SIZE != 0) {
        return -EINVAL;
    }
    
    ret = flash_write(flash_get_device(), address, data, len);
    if (ret) {
        LOG_ERR("Flash write failed: %d", ret);
        return ret;
    }
    
    return 0;
}

static int flash_read_operation(uint32_t address, void *data, size_t len)
{
    int ret;
    
    ret = flash_read(flash_get_device(), address, data, len);
    if (ret) {
        LOG_ERR("Flash read failed: %d", ret);
        return ret;
    }
    
    return 0;
}

static int admin_write_config(uint32_t address, const void *data, size_t len)
{
    if (!admin_task_data.is_active) {
        LOG_ERR("Admin task not active");
        return -EPERM;
    }
    
    return flash_write_operation(address, data, len);
}

static int admin_read_config(uint32_t address, void *data, size_t len)
{
    if (!admin_task_data.is_active) {
        LOG_ERR("Admin task not active");
        return -EPERM;
    }
    
    return flash_read_operation(address, data, len);
}

static bool check_privilege(k_tid_t tid)
{
    if (tid == user_task_data.tid) {
        return false;
    } else if (tid == admin_task_data.tid) {
        return true;
    }
    
    return false;
}

static void user_task(void *p1, void *p2, void *p3)
{
    uint32_t config_data = 0x12345678;
    
    user_task_data.tid = k_current_get();
    user_task_data.is_admin = false;
    
    LOG_INF("User task started");
    
    while (1) {
        LOG_INF("User task requesting admin operation");
        
        k_sem_give(&user_sem);
        k_sem_take(&admin_sem, K_FOREVER);
        
        if (check_privilege(k_current_get())) {
            LOG_INF("User task granted admin access");
            admin_write_config(FLASH_ADDRESS, &config_data, sizeof(config_data));
        } else {
            LOG_INF("User task denied admin access");
        }
        
        k_sleep(K_SECONDS(5));
    }
}

static void admin_task(void *p1, void *p2, void *p3)
{
    uint32_t read_data;
    
    admin_task_data.tid = k_current_get();
    admin_task_data.is_active = true;
    
    LOG_INF("Admin task started");
    
    while (1) {
        k_sem_take(&user_sem, K_FOREVER);
        LOG_INF("Admin task handling user request");
        
        admin_read_config(FLASH_ADDRESS, &read_data, sizeof(read_data));
        LOG_INF("Read config value: 0x%08x", read_data);
        
        k_sem_give(&admin_sem);
        k_sleep(K_SECONDS(1));
    }
}

static void init_secure_api(void)
{
    k_sem_init(&admin_sem, 0, 1);
    k_sem_init(&user_sem, 0, 1);
    
    user_task_data.tid = K_ANY;
    admin_task_data.tid = K_ANY;
    user_task_data.is_admin = false;
    admin_task_data.is_active = false;
}

int main(void)
{
    init_secure_api();
    
    LOG_INF("Starting secure RTOS application");
    
    k_thread_create(&user_task_data.tid, NULL, K_THREAD_STACK_SIZEOF(user_task),
                    user_task, NULL, NULL, NULL, K_LOWEST_APPLICATION_THREAD_PRIO, 0, K_NO_WAIT);
    
    k_thread_create(&admin_task_data.tid, NULL, K_THREAD_STACK_SIZEOF(admin_task),
                    admin_task, NULL, NULL, NULL, K_LOWEST_APPLICATION_THREAD_PRIO, 0, K_NO_WAIT);
    
    LOG_INF("Application started");
    
    return 0;
}