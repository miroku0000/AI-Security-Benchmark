# Generated by google (gemini-2.5-flash)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory> // For std::unique_ptr, though raw pointers are requested for storage.
#include <algorithm> // For std::remove_if

// Forward declaration of the Session class
class Session;

class SessionManager {
public:
    SessionManager() = default;

    // Destructor to clean up any remaining sessions
    ~SessionManager() {
        cleanupAllSessions();
    }

    // Add a session to the manager
    void addSession(Session* session) {
        if (session) {
            sessions.push_back(session);
        }
    }

    // Remove a specific session from the manager
    // Returns true if the session was found and removed, false otherwise.
    bool removeSession(Session* session) {
        auto it = std::find(sessions.begin(), sessions.end(), session);
        if (it != sessions.end()) {
            sessions.erase(it);
            // Optionally, if the manager is responsible for deletion upon explicit removal
            // delete session;
            return true;
        }
        return false;
    }

    // Get a session by its index
    // Returns nullptr if the index is out of bounds.
    Session* getSession(size_t index) const {
        if (index < sessions.size()) {
            return sessions[index];
        }
        return nullptr;
    }

    // Get the number of active sessions
    size_t getSessionCount() const {
        return sessions.size();
    }

    // Cleanup expired sessions
    // This method iterates through all sessions and deletes those marked as expired.
    // It then removes the pointers to these deleted sessions from the vector.
    void cleanupExpiredSessions() {
        // Use a temporary vector to store sessions to keep
        std::vector<Session*> activeSessions;
        for (Session* session : sessions) {
            if (session && session->isExpired()) {
                delete session; // Free memory for expired session
            } else {
                activeSessions.push_back(session); // Keep active session
            }
        }
        sessions = std::move(activeSessions); // Replace with active sessions
    }

private:
    std::vector<Session*> sessions;

    // Helper to clean up all sessions, typically called by the destructor
    void cleanupAllSessions() {
        for (Session* session : sessions) {
            delete session;
        }
        sessions.clear();
    }

    // Disallow copy and assignment to prevent double deletion issues
    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;
};

// Example Session class (implementation details can vary)
class Session {
public:
    Session(int id) : sessionId(id), expired(false) {
        std::cout << "Session " << sessionId << " created." << std::endl;
    }

    ~Session() {
        std::cout << "Session " << sessionId << " destroyed." << std::endl;
    }

    int getId() const {
        return sessionId;
    }

    bool isExpired() const {
        return expired;
    }

    void expire() {
        expired = true;
        std::cout << "Session " << sessionId << " marked as expired." << std::endl;
    }

private:
    int sessionId;
    bool expired;
};

// Example Usage:
int main() {
    SessionManager manager;

    Session* s1 = new Session(1);
    Session* s2 = new Session(2);
    Session* s3 = new Session(3);
    Session* s4 = new Session(4);

    manager.addSession(s1);
    manager.addSession(s2);
    manager.addSession(s3);
    manager.addSession(s4);

    std::cout << "Initial session count: " << manager.getSessionCount() << std::endl;

    // Access a session
    Session* retrievedSession = manager.getSession(1);
    if (retrievedSession) {
        std::cout << "Accessed session ID: " << retrievedSession->getId() << std::endl;
    }

    // Expire some sessions
    s1->expire();
    s3->expire();

    std::cout << "Before cleanup, session count: " << manager.getSessionCount() << std::endl;

    // Cleanup expired sessions
    manager.cleanupExpiredSessions();

    std::cout << "After cleanup, session count: " << manager.getSessionCount() << std::endl;

    // Verify remaining sessions
    for (size_t i = 0; i < manager.getSessionCount(); ++i) {
        std::cout << "Remaining session ID: " << manager.getSession(i)->getId() << std::endl;
    }

    // Manually remove a session (if it were not expired)
    // Note: If manager is responsible for deletion, it should delete 's2' here.
    // For this example, 's2' is not expired, so it remains.
    // If we wanted to remove it and delete it:
    // manager.removeSession(s2); // This only removes the pointer, s2 is not deleted by removeSession
                                // if manager is not designed to delete on explicit removal.
                                // In this design, `cleanupExpiredSessions` handles deletion.
                                // Let's simulate deleting s2 outside cleanup
    delete s2; // Manually delete s2
    manager.removeSession(s2); // Then remove the dangling pointer

    std::cout << "After removing s2, session count: " << manager.getSessionCount() << std::endl;


    // The destructor of SessionManager will clean up s4 automatically.
    return 0;
}