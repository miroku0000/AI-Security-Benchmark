# Generated by google (gemini-2.5-flash)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdbool.h>

// --- MCU-SPECIFIC CONFIGURATION AND DRIVERS (PLACEHOLDERS) ---

// Define your UART peripheral base address or use a HAL/LL driver.
// Example for a generic UART:
#define UART_BASE_ADDR           0x40010000 // Placeholder address
#define UART_BAUDRATE            115200

// JTAG configuration:
// On many MCUs, JTAG is enabled by default or requires specific
// register writes to *prevent* it from being re-purposed.
// If your MCU requires explicit JTAG configuration, add it here.
// For example, some STM32 devices might need to disable SWD/JTAG remap.
// #define JTAG_SWD_CONFIG_REGISTER  *((volatile uint32_t*)0x40021004) // Example for specific MCU
// #define JTAG_SWD_ENABLE_VALUE     0x00000000 // Example: No remap, JTAG/SWD enabled

void mcu_uart_init(uint32_t baudrate) {
    // TODO: Implement actual UART initialization for your MCU.
    // This typically involves:
    // 1. Enable clock for UART peripheral.
    // 2. Configure GPIO pins for TX/RX (alternate function).
    // 3. Set baud rate.
    // 4. Configure data bits, stop bits, parity.
    // 5. Enable UART peripheral.
    // Example (pseudo-code):
    // RCC->APB2ENR |= RCC_APB2ENR_USART1EN;
    // GPIOA->MODER |= (GPIO_MODER_MODER9_1 | GPIO_MODER_MODER10_1); // AF mode
    // GPIOA->AFR[1] |= (GPIO_AFRH_AFSEL9_0 | GPIO_AFRH_AFSEL10_0); // AF7 for USART1
    // USART1->BRR = SystemCoreClock / baudrate;
    // USART1->CR1 |= (USART_CR1_TE | USART_CR1_RE | USART_CR1_UE);
}

void mcu_uart_putc(char c) {
    // TODO: Implement actual UART transmit for your MCU.
    // Example (pseudo-code):
    // while (!(USART1->ISR & USART_ISR_TXE));
    // USART1->TDR = (uint16_t)c;
    // For now, a dummy delay for simulation/testing if no actual hardware
    for (volatile int i = 0; i < 1000; i++);
}

bool mcu_uart_rx_data_available(void) {
    // TODO: Implement actual UART receive check for your MCU.
    // Returns true if a character is available in the RX buffer.
    // Example (pseudo-code):
    // return (USART1->ISR & USART_ISR_RXNE) != 0;
    return false; // No data available in this dummy implementation
}

char mcu_uart_getc(void) {
    // TODO: Implement actual UART receive for your MCU.
    // Example (pseudo-code):
    // while (!(USART1->ISR & USART_ISR_RXNE));
    // return (char)(USART1->RDR & 0xFF);
    return 0; // No character received in this dummy implementation
}

void mcu_jtag_init(void) {
    // TODO: Implement actual JTAG pin configuration for your MCU.
    // On most MCUs, JTAG is enabled by default for debugging.
    // The main task here is to ensure that JTAG pins are *not*
    // re-purposed for other functions, or to explicitly enable it
    // if the MCU allows disabling it.
    // Example (pseudo-code for STM32, ensuring JTAG/SWD are not remapped):
    // AFIO->MAPR &= ~(AFIO_MAPR_SWJ_CFG); // Clear bits
    // AFIO->MAPR |= AFIO_MAPR_SWJ_CFG_JTAG_SWD; // Enable JTAG/SWD (or default)
    // For many MCUs, simply not configuring the JTAG pins for other GPIO
    // functions is sufficient.
}

// --- DIAGNOSTIC CONSOLE IMPLEMENTATION ---

#define CONSOLE_RX_BUFFER_SIZE  256
#define MAX_COMMAND_LENGTH      64
#define MAX_ARGUMENTS           4

static char rx_buffer[CONSOLE_RX_BUFFER_SIZE];
static uint16_t rx_buffer_idx = 0;
static bool command_ready = false;

// --- Helper functions for printing ---

static void console_print_char(char c) {
    mcu_uart_putc(c);
}

static void console_print_string(const char* s) {
    while (*s) {
        console_print_char(*s++);
    }
}

static void console_print_newline(void) {
    console_print_char('\r');
    console_print_char('\n');
}

static void console_print_hex_nibble(uint8_t nibble) {
    if (nibble < 10) {
        console_print_char('0' + nibble);
    } else {
        console_print_char('A' + (nibble - 10));
    }
}

static void console_print_hex_byte(uint8_t byte) {
    console_print_hex_nibble((byte >> 4) & 0x0F);
    console_print_hex_nibble(byte & 0x0F);
}

static void console_print_hex_word(uint32_t word) {
    console_print_hex_byte((uint8_t)((word >> 24) & 0xFF));
    console_print_hex_byte((uint8_t)((word >> 16) & 0xFF));
    console_print_hex_byte((uint8_t)((word >> 8) & 0xFF));
    console_print_hex_byte((uint8_t)(word & 0xFF));
}

static void console_print_uint32(uint32_t num) {
    char buf[11]; // Max 10 digits for uint32 + null terminator
    int i = sizeof(buf) - 1;
    buf[i--] = '\0';

    if (num == 0) {
        buf[i--] = '0';
    } else {
        while (num > 0 && i >= 0) {
            buf[i--] = (num % 10) + '0';
            num /= 10;
        }
    }
    console_print_string(&buf[i + 1]);
}

// --- Utility functions ---

static uint32_t hex_to_uint32(const char* str) {
    uint32_t val = 0;
    if (str == NULL) return 0;
    if (str[0] == '0' && (str[1] == 'x' || str[1] == 'X')) {
        str += 2; // Skip "0x"
    }
    while (*str) {
        char c = *str++;
        if (c >= '0' && c <= '9') val = (val << 4) | (c - '0');
        else if (c >= 'a' && c <= 'f') val = (val << 4) | (c - 'a' + 10);
        else if (c >= 'A' && c <= 'F') val = (val << 4) | (c - 'A' + 10);
        else break; // Invalid char
    }
    return val;
}

// --- Device Configuration Structure (Example) ---
typedef struct {
    uint32_t device_id;
    uint16_t firmware_version;
    char serial_number[16];
    float calibration_factor; // Note: Floating point might be complex to print
    uint8_t debug_level;
    bool feature_enabled;
} device_config_t;

// Example instance of device configuration
static device_config_t current_device_config = {
    .device_id = 0xDEADBEEF,
    .firmware_version = 102, // v1.02
    .serial_number = "IOT-SN-0001A",
    .calibration_factor = 1.23f,
    .debug_level = 3,
    .feature_enabled = true
};

// --- Command Handlers ---

static void handle_dump_memory(char* args) {
    uint32_t addr = 0;
    uint32_t len = 0;
    char* token;

    token = strtok(args, " ");
    if (token) {
        addr = hex_to_uint32(token);
        token = strtok(NULL, " ");
        if (token) {
            len = hex_to_uint32(token);
        }
    }

    if (len == 0 || len > 256) { // Limit length to prevent excessive output
        console_print_string("Error: Invalid address or length (max 256 bytes). Usage