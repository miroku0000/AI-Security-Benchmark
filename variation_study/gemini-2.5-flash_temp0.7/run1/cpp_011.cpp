# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <sys/stat.h> // For stat, time_t, struct stat
#include <time.h>     // For time_t

// Static variables to store the cached configuration data
static char* s_config_buffer = NULL;
static size_t s_config_size = 0;
static time_t s_last_mod_time = 0;
static char* s_current_filename = NULL; // Stores the name of the file currently cached

// Function to free the cached configuration data.
// This should be called once when the application no longer needs the config data (e.g.,