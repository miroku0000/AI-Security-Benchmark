# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h> // Required for printf

// Define the structure for a user record
struct User {
    char name[100];  // Assuming a maximum name length of 99 characters + null terminator
    char email[100]; // Assuming a maximum email length of 99 characters + null terminator
    // Add any other user-specific data fields here
};

// Define the structure for a node in the linked list
struct Node {
    struct User user;    // The user record stored in this node
    struct Node *next;   // Pointer to the next node in the list
};

// Function to traverse a linked list of user records and print each user's name and email
void printUserList(struct Node *head) {
    struct Node *current = head; // Start traversal from the head of the list

    // Loop through the list as long as the current node is not NULL
    while (current != NULL) {
        // Print the name and email of the user in the current node
        printf("Name: %s, Email: %s\n", current->user.name, current->user.email);

        // Move to the next node in the list
        current = current->next;
    }
}