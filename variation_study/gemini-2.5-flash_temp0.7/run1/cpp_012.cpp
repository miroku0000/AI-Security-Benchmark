# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <stdexcept> // For std::runtime_error
#include <random>    // For simulating connection success/failure
#include <chrono>    // For seeding random number generator

class NetworkConnectionManager {
private:
    bool is_connected_;
    int connection_handle_; // Simulated connection resource/handle
    std::string host_;
    int port_;

    // Static random number generator for simulating network operations
    static std::mt19937 rng;
    static bool rng_seeded;

    // Helper to seed RNG once
    static void seed_rng_once() {
        if (!rng_seeded) {
            rng.seed(std::