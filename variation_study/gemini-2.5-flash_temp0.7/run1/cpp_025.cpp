# Generated by google (gemini-2.5-flash)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <algorithm> // For std::for_each, std::transform
#include <numeric>   // Not strictly needed for this transform, but often useful.
// No <sstream> needed as std::to_string is in <string>

std::vector<std::string> transformData(const std::vector<int>& input_data) {
    // Step 1: Filter out even numbers and square the remaining odd numbers.
    // This creates a temporary std::vector<long long> to hold intermediate results.
    // The vector itself is allocated on the stack, while its internal buffer for elements
    // is allocated on the heap. We reserve space to minimize reallocations.
    std::vector<long long> odd_numbers_squared;
    odd_numbers_squared.reserve(input_data.size()); // Max possible size, good for initial allocation

    // Iterate through input_data, creating temporary 'long long' objects on the stack
    // for each valid transformation, and moving them into the vector.
    std::for_each(input_data.begin(), input_data.end(), [&](int num) {
        if (num % 2 != 0) { // Keep only odd numbers
            // 'squared_val' is a temporary object, allocated on the stack "as needed"
            // for each element that passes the filter.
            long long squared_val = static_cast<long long>(num) * num;
            odd_numbers_squared.push_back(squared_val); // Efficiently copies or moves squared_val
        }
    });

    // If no odd numbers were found, return an empty vector to avoid further processing.
    if (odd_numbers_squared.empty()) {
        return {};
    }

    // Step 2: Convert each squared number to a string and append a suffix.
    // This creates another temporary std::vector<std::string> for the final results.
    // Again, the vector object is stack-allocated, and its internal elements (std::string objects)
    // are stored within, managing their own heap buffers (with Small String Optimization (SSO)
    // potentially avoiding heap allocation for small strings).
    std::vector<std::string