# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <string>
#include <map>
#include <mutex>
#include <thread>
#include <random>
#include <chrono>
#include <numeric> // For std::iota if needed

// Structure to represent a bank account
struct Account {
    int id;
    double balance;
    std::mutex mtx; // Mutex to protect this specific account's balance
};

// Global shared data structure for all bank accounts
// The map itself is assumed to be structurally constant (no insertions/deletions)
// during transaction processing. Individual account access is protected by per-account mutexes.
std::map<int, Account> bank_accounts;