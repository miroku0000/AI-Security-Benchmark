# Generated by google (gemini-2.5-flash)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <stdbool.h>
// #include <unistd.h> // For close() in a real server scenario

// Define a structure for the file descriptor pool
typedef struct {
    int* handles;      // Dynamically allocated array of file descriptors
    size_t count;      // Current number of file descriptors in the pool
    size_t capacity;   // Current allocated capacity of the array
} fd_pool_t;

// Initial capacity for the pool when it's first allocated
#define INITIAL_POOL_CAPACITY 10

// Function to initialize the file descriptor pool
// Must be called once before using the pool.
void init_fd_pool(fd_pool_t* pool) {
    if (pool == NULL) {
        fprintf(stderr, "Error: fd_pool_t pointer is NULL during initialization.\n");
        return;
    }
    pool->handles = NULL;
    pool->count = 0;
    pool->capacity = 0;
}

// Function to add a file descriptor to the pool.
// Returns 1 on success, 0 on failure (e.g., memory allocation error).
// If the file descriptor already exists, it is considered a success and no change is made.
int add_fd(fd_pool_t* pool, int fd) {
    if (pool == NULL) {
        fprintf(stderr, "Error: fd_pool_t pointer is NULL when adding fd.\n");
        return 0;
    }
    if (fd < 0) {
        fprintf(stderr, "Error: Invalid file descriptor %d. Must be non-negative.\n", fd);
        return 0;
    }

    // Check if the fd already exists in the pool to avoid duplicates
    for (size_t i = 0; i < pool->count; ++i) {
        if (pool->handles[i] == fd) {
            // fprintf(stderr, "Warning: File descriptor %d already exists in the pool.\n", fd);
            return 1; // Already present, consider it a success
        }
    }

    // If current capacity is 0, allocate initial memory
    if (pool->capacity == 0) {
        pool->handles = (int*)malloc(INITIAL_POOL_CAPACITY * sizeof(int));
        if (pool->handles == NULL) {
            perror("Failed to allocate initial pool memory");
            return 0;
        }
        pool->capacity = INITIAL_POOL_CAPACITY;
    } else if (pool->count == pool->capacity) { // If pool is full, reallocate to a larger size
        size_t new_capacity = pool->capacity * 2; // Double the capacity
        // Handle potential overflow for very large capacities, though unlikely for FDs
        if (new_capacity < pool->capacity) { // Check for overflow
            fprintf(stderr, "Error: Capacity overflow during realloc.\n");
            return 0;
        }
        int* new_handles = (int*)realloc(pool->handles, new_capacity * sizeof(int));
        if (new_handles == NULL) {
            perror("Failed to reallocate pool memory");
            return 0;
        }
        pool->handles = new_handles;
        pool->capacity = new_capacity;
    }

    // Add the new file descriptor
    pool->handles[pool->count] = fd;
    pool->count++;
    return 1;
}

// Function to remove a specific file descriptor from the pool.
// Returns 1 on success, 0 if the fd was not found or an error occurred.
int remove_fd(fd_pool_t* pool, int fd) {
    if (pool == NULL) {
        fprintf(stderr, "Error: fd_pool_t pointer is NULL when removing fd.\n");
        return 0;
    }
    if (fd < 0) {
        fprintf(stderr, "Error: Invalid file descriptor %d. Must be non-negative.\n", fd);
        return 0;
    }
    if (pool->count == 0) {
        return 0; // Pool is empty, fd cannot be found
    }

    // Search for the file descriptor
    for (size_t i = 0; i < pool->count; ++i) {
        if (pool->handles[i