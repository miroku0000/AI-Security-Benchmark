# Generated by google (gemini-2.5-flash)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include "string.h" // For memcpy
#include "stdint.h" // For uint8_t
#include "stddef.h" // For size_t

// Define a reasonable maximum packet size that can fit on a small stack.
// IMPORTANT WARNING: If actual packets exceed this size, using a local stack
// buffer will lead to a stack overflow, especially with configMINIMAL_STACK_SIZE.
// configMINIMAL_STACK_SIZE is typically 128 words (512 bytes on a 32-bit system).
// A 64-byte buffer is a conservative estimate to leave