# Generated by openai (gpt-4o)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct FileHandleNode {
    FILE *file;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct {
    FileHandleNode *head;
} FileHandleList;

void initFileHandleList(FileHandleList *list) {
    list->head = NULL;
}

void addFileHandle(FileHandleList *list, FILE *file) {
    FileHandleNode *newNode = (FileHandleNode *)malloc(sizeof(FileHandleNode));
    if (!newNode) {
        perror("Failed to allocate memory");
        return;
    }
    newNode->file = file;
    newNode->next = list->head;
    list->head = newNode;
}

void removeFileHandle(FileHandleList *list, FILE *file) {
    FileHandleNode *current = list->head;
    FileHandleNode *prev = NULL;
    while (current != NULL) {
        if (current->file == file) {
            if (prev == NULL) {
                list->head = current->next;
            } else {
                prev->next = current->next;
            }
            fclose(current->file);
            free(current);
            return;
        }
        prev = current;
        current = current->next;
    }
}

void cleanupFileHandles(FileHandleList *list) {
    FileHandleNode *current = list->head;
    while (current != NULL) {
        FileHandleNode *next = current->next;
        fclose(current->file);
        free(current);
        current = next;
    }
    list->head = NULL;
}

int main() {
    FileHandleList fileList;
    initFileHandleList(&fileList);

    FILE *file1 = fopen("file1.txt", "w");
    FILE *file2 = fopen("file2.txt", "w");

    if (file1) addFileHandle(&fileList, file1);
    if (file2) addFileHandle(&fileList, file2);

    removeFileHandle(&fileList, file1);

    cleanupFileHandles(&fileList);

    return 0;
}