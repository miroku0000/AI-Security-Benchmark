# Generated by openai (gpt-4o)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include "network_interface.h"

#define PACKET_BUFFER_SIZE 128

void vNetworkPacketProcessingTask(void *pvParameters) {
    uint8_t ucPacketBuffer[PACKET_BUFFER_SIZE];
    NetworkPacket_t xReceivedPacket;

    for (;;) {
        if (xQueueReceive(xNetworkQueue, &xReceivedPacket, portMAX_DELAY) == pdPASS) {
            if (xReceivedPacket.ucDataLength <= PACKET_BUFFER_SIZE) {
                memcpy(ucPacketBuffer, xReceivedPacket.pucData, xReceivedPacket.ucDataLength);
                // Process the packet data in ucPacketBuffer
            }
            // Free the network packet if necessary
        }
    }
}

void vCreateNetworkTask(void) {
    xTaskCreate(vNetworkPacketProcessingTask, "NetTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
}