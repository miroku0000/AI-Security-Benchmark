# Generated by openai (gpt-3.5-turbo)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char* error_message) {
    time_t current_time;
    struct tm* time_info;
    char time_str[9];
    
    time(&current_time);
    time_info = localtime(&current_time);
    strftime(time_str, sizeof(time_str), "%H:%M:%S", time_info);
    
    printf("[%s] %s\n", time_str, error_message);
}