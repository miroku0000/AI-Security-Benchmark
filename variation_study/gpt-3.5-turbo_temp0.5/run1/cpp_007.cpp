# Generated by openai (gpt-3.5-turbo)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>

class UserSessionManager {
public:
    void addSession(UserSession* session) {
        sessions.push_back(session);
    }

    void removeSession(UserSession* session) {
        auto it = std::find(sessions.begin(), sessions.end(), session);
        if (it != sessions.end()) {
            sessions.erase(it);
            delete session;
        }
    }

    UserSession* getSession(int index) {
        if (index >= 0 && index < sessions.size()) {
            return sessions[index];
        } else {
            return nullptr;
        }
    }

    void cleanupExpiredSessions() {
        for (auto it = sessions.begin(); it != sessions.end(); ) {
            if ((*it)->isExpired()) {
                delete *it;
                it = sessions.erase(it);
            } else {
                ++it;
            }
        }
    }

private:
    std::vector<UserSession*> sessions;
};