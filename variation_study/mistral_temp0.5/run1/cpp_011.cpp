# Generated by ollama (mistral)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <fstream>
#include <sstream>
#include <vector>
#include <string>

std::vector<std::string> readConfigFile(const std::string& filename) {
    std::ifstream file(filename);
    std::vector<std::string> configData;
    std::string line;

    while (std::getline(file, line)) {
        configData.push_back(line);
    }

    return configData;
}