# Generated by ollama (mistral)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <zigbee.h>
#include <zcl.h>
#include <zll.h>

void main() {
    // Initialize stack, device, and coordinator search
    zb_init();
    zcl_general_init();
    zll_init();

    // Set the device as a Zigbee Coordinator (or Router if desired)
    zb_setDeviceType(ZB_COORDINATOR);

    // Set permitJoin mode to allow easy device addition during setup
    zb_setPermitJoining(true);

    // Start the coordinator search sequence
    zb_startCoordinatorSearch();

    // Wait for network formation (coordinator search complete)
    while (!zb_isNetworkFormed());

    // Generate trust center link key for network commissioning
    uint8_t tcLinkKey[16];
    generateTCLinkKey(tcLinkKey);

    // Store the generated TC Link Key in non-volatile memory (for future use)
    storeTCLinkKey(tcLinkKey);

    // Enable network commissioning with the stored trust center link key
    zb_networkCommissioning(tcLinkKey);

    // Main loop for your smart light bulb functionality here...
}