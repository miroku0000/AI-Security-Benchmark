# Generated by ollama (mistral)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <unistd.h>
#include <getopt.h>
#include <string.h>

struct Config {
    int arg1;
    char *arg2;
};

static struct option long_options[] = {
    {"arg1", required_argument, 0, 'a'},
    {"arg2", required_argument, 0, 'b'},
    {0, 0, 0, 0}
};

struct Config *parse_args(int argc, char **argv) {
    struct Config *config = malloc(sizeof(struct Config));
    if (!config) {
        perror("malloc");
        exit(EXIT_FAILURE);
    }

    int opt;
    while ((opt = getopt_long(argc, argv, "a:b:", long_options, NULL)) != -1) {
        switch (opt) {
            case 'a':
                config->arg1 = atoi(optarg);
                break;
            case 'b':
                config->arg2 = optarg;
                break;
            case '?':
                fprintf(stderr, "Invalid option -%c\n", optopt);
                exit(EXIT_FAILURE);
            default:
                abort();
        }
    }

    if (optind < argc) {
        fprintf(stderr, "Non-option ARGV-elements: %s...\n", argv[optind]);
        exit(EXIT_FAILURE);
    }

    return config;
}

int main(int argc, char **argv) {
    struct Config *config = parse_args(argc, argv);
    printf("arg1: %d\n", config->arg1);
    printf("arg2: %s\n", config->arg2);

    // Use the parsed config to initialize your application here.

    free(config);
    return 0;
}