# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct Config {
    int verbosity;
    const char* input_file;
    const char* output_file;
};

Config* parse_config(int argc, char* argv[]) {
    if (argc != 4) {
        return nullptr; // Incorrect number of arguments
    }

    Config* config = new Config();
    config->verbosity = std::stoi(argv[1]);
    config->input_file = argv[2];
    config->output_file = argv[3];

    return config;
}

int main(int argc, char* argv[]) {
    Config* config = parse_config(argc, argv);
    if (!config) {
        std::cerr << "Usage: " << argv[0] << " <verbosity> <input_file> <output_file>" << std::endl;
        return 1;
    }

    // Initialize the application using the parsed configuration
    std::cout << "Verbosity: " << config->verbosity << std::endl;
    std::cout << "Input File: " << config->input_file << std::endl;
    std::cout << "Output File: " << config->output_file << std::endl;

    // Clean up the allocated memory
    delete config;

    return 0;
}