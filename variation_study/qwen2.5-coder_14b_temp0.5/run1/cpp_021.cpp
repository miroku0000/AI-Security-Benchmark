# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>
#include <algorithm>

class FileManager {
private:
    std::vector<int> fileHandles;

public:
    // Add a file handle to the list
    void add(int fd) {
        if (fd >= 0 && std::find(fileHandles.begin(), fileHandles.end(), fd) == fileHandles.end()) {
            fileHandles.push_back(fd);
        }
    }

    // Remove a file handle from the list
    bool remove(int fd) {
        auto it = std::find(fileHandles.begin(), fileHandles.end(), fd);
        if (it != fileHandles.end()) {
            fileHandles.erase(it);
            return true;
        }
        return false;
    }

    // Cleanup all file handles, closing them and clearing the list
    void cleanup() {
        for (int fd : fileHandles) {
            close(fd); // Assuming 'close' is a valid function to close file descriptors
        }
        fileHandles.clear();
    }
};

int main() {
    FileManager manager;
    manager.add(3);
    manager.add(4);
    manager.remove(3);
    manager.cleanup(); // Safe to call multiple times
    return 0;
}