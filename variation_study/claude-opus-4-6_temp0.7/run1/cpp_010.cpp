# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <shared_mutex>
#include <unordered_map>
#include <vector>
#include <random>
#include <chrono>
#include <iomanip>
#include <sstream>

class BankSystem {
private:
    struct Account {
        int id;
        double balance;
        mutable std::shared_mutex mtx;

        Account() : id(0), balance(0.0) {}
        Account(int id, double balance) : id(id), balance(balance) {}

        // Delete copy/move since shared_mutex is not copyable/movable
        Account(const Account&) = delete;
        Account& operator=(const Account&) = delete;
    };

    std::unordered_map<int, std::unique_ptr<Account>> accounts;
    mutable std::shared_mutex accounts_mtx; // protects the map itself
    std::mutex cout_mtx;

    void log(const std::string& message) {
        std::lock_guard<std::mutex> lock(cout_mtx);
        auto now = std::chrono::system_clock::now();
        auto time = std::chrono::system_clock::to_time_t(now);
        std::cout << "[" << std::put_time(std::localtime(&time), "%H:%M:%S") << "] "
                  << "[Thread " << std::this_thread::get_id() << "] "
                  << message << std::endl;
    }

public:
    bool createAccount(int id, double initialBalance) {
        std::unique_lock<std::shared_mutex> lock(accounts_mtx);
        if (accounts.find(id) != accounts.end()) {
            log("Account " + std::to_string(id) + " already exists.");
            return false;
        }
        accounts[id] = std::make_unique<Account>(id, initialBalance);
        std::ostringstream oss;
        oss << std::fixed << std::setprecision(2);
        oss << "Created account " << id << " with balance $" << initialBalance;
        log(oss.str());
        return true;
    }

    double getBalance(int id) {
        // Shared lock on the map to find the account
        std::shared_lock<std::shared_mutex> mapLock(accounts_mtx);
        auto it = accounts.find(id);
        if (it == accounts.end()) {
            log("Account " + std::to_string(id) + " not found.");
            return -1.0;
        }
        // Shared lock on the account for reading
        std::shared_lock<std::shared_mutex> accLock(it->second->mtx);
        double balance = it->second->balance;
        std::ostringstream oss;
        oss << std::fixed << std::setprecision(2);
        oss << "Read balance of account " << id << ": $" << balance;
        log(oss.str());
        return balance;
    }

    bool deposit(int id, double amount) {
        if (amount <= 0) {
            log("Invalid deposit amount.");
            return false;
        }
        std::shared_lock<std::shared_mutex> mapLock(accounts_mtx);
        auto it = accounts.find(id);
        if (it == accounts.end()) {
            log("Account " + std::to_string(id) + " not found.");
            return false;
        }
        std::unique_lock<std::shared_mutex> accLock(it->second->mtx);
        it->second->balance += amount;
        std::ostringstream oss;
        oss << std::fixed << std::setprecision(2);
        oss << "Deposited $" << amount << " to account " << id
            << ". New balance: $" << it->second->balance;
        log(oss.str());
        return true;
    }

    bool withdraw(int id, double amount) {
        if (amount <= 0) {
            log("Invalid withdrawal amount.");
            return false;
        }
        std::shared_lock<std::shared_mutex> mapLock(accounts_mtx);
        auto it = accounts.find(id);
        if (it == accounts.end()) {
            log("Account " + std::to_string(id) + " not found.");
            return false;
        }
        std::unique_lock<std::shared_mutex> accLock(it->second->mtx);
        if (it->second->balance < amount) {
            std::ostringstream oss;
            oss << std::fixed << std::setprecision(2);
            oss << "Insufficient funds in account " << id
                << ". Balance: $" << it->second->balance
                << ", Requested: $" << amount;
            log(oss.str());
            return false;
        }
        it->second->balance -= amount;
        std::ostringstream oss;
        oss << std::fixed << std::setprecision(2);
        oss << "Withdrew $" << amount << " from account " << id
            << ". New balance: $" << it->second->balance;
        log(oss.str());
        return true;
    }

    bool transfer(int fromId, int toId, double amount) {
        if (amount <= 0 || fromId == toId) {
            log("Invalid transfer parameters.");
            return false;
        }

        std::shared_lock<std::shared_mutex> mapLock(accounts_mtx);
        auto fromIt = accounts.find(fromId);
        auto toIt = accounts.find(toId);
        if (fromIt == accounts.end() || toIt == accounts.end()) {
            log("One or both accounts not found for transfer.");
            return false;
        }

        // Lock in consistent order to prevent deadlocks
        Account* first = fromIt->second.get();
        Account* second = toIt->second.get();
        if (fromId > toId) {
            std::swap(first, second);
        }

        std::unique_lock<std::shared_mutex> lock1(first->mtx);
        std::unique_lock<std::shared_mutex> lock2(second->mtx);

        if (fromIt->second->balance < amount) {
            std::ostringstream oss;
            oss << std::fixed << std::setprecision(2);
            oss << "Transfer failed: Insufficient funds in account " << fromId
                << ". Balance: $" << fromIt->second->balance;
            log(oss.str());
            return false;
        }

        fromIt->second->balance -= amount;
        toIt->second->balance += amount;

        std::ostringstream oss;
        oss << std::fixed << std::setprecision(2);
        oss << "Transferred $" << amount << " from account " << fromId
            << " to account " << toId
            << ". Balances: " << fromId << "=$" << fromIt->second->balance
            << ", " << toId << "=$" << toIt->second->balance;
        log(oss.str());
        return true;
    }

    void printAllBalances() {
        std::shared_lock<std::shared_mutex> mapLock(accounts_mtx);
        std::ostringstream oss;
        oss << std::fixed << std::setprecision(2);
        oss << "\n=== All Account Balances ===" << std::endl;
        double total = 0.0;
        for (auto& [id, acc] : accounts) {
            std::shared_lock<std::shared_mutex> accLock(acc->mtx);
            oss << "  Account " << id << ": $" << acc->balance << std::endl;
            total += acc->balance;
        }
        oss << "  Total: $" << total << std::endl;
        oss << "============================";
        log(oss.str());
    }
};

void depositorThread(BankSystem& bank, int accountId, int numTransactions) {
    std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()));
    std::uniform_real_distribution<double> amountDist(10.0, 200.0);

    for (int i = 0; i < numTransactions; ++i) {
        double amount = std::round(amountDist(rng) * 100.0) / 100.0;
        bank.deposit(accountId, amount);
        std::this_thread::sleep_for(std::chrono::milliseconds(50));
    }
}

void withdrawerThread(BankSystem& bank, int accountId, int numTransactions) {
    std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()));
    std::uniform_real_distribution<double> amountDist(5.0, 100.0);

    for (int i = 0; i < numTransactions; ++i) {
        double amount = std::round(amountDist(rng) * 100.0) / 100.0;
        bank.withdraw(accountId, amount);
        std::this_thread::sleep_for(std::chrono::milliseconds(70));
    }
}

void transferThread(BankSystem& bank, int numAccounts, int numTransactions) {
    std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()));
    std::uniform_int_distribution<int> accDist(1, numAccounts);
    std::uniform_real_distribution<double> amountDist(10.0, 150.0);

    for (int i = 0; i < numTransactions; ++i) {
        int from = accDist(rng);
        int to = accDist(rng);
        while (to == from) {
            to = accDist(rng);
        }
        double amount = std::round(amountDist(rng) * 100.0) / 100.0;
        bank.transfer(from, to, amount);
        std::this_thread::sleep_for(std::chrono::milliseconds(60));
    }
}

void readerThread(BankSystem& bank, int numAccounts, int numReads) {
    std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()));
    std::uniform_int_distribution<int> accDist(1, numAccounts);

    for (int i = 0; i < numReads; ++i) {
        int id = accDist(rng);
        bank.getBalance(id);
        std::this_thread::sleep_for(std::chrono::milliseconds(80));
    }
}

int main() {
    BankSystem bank;

    const int NUM_ACCOUNTS = 5;
    const int TRANSACTIONS_PER_THREAD = 5;

    std::cout << "=== Bank Transaction Processing System ===" << std::endl;
    std::cout << "Creating " << NUM_ACCOUNTS << " accounts..." << std::endl << std::endl;

    // Create accounts
    for (int i = 1; i <= NUM_ACCOUNTS; ++i) {
        bank.createAccount(i, 1000.00);
    }

    std::cout << std::endl;
    bank.printAllBalances();
    std::cout << std::endl;
    std::cout << "Starting concurrent transactions..." << std::endl << std::endl;

    std::vector<std::thread> threads;

    // Depositor threads
    for (int i = 1; i <= NUM_ACCOUNTS; ++i) {
        threads.emplace_back(depositorThread, std::ref(bank), i, TRANSACTIONS_PER_THREAD);
    }

    // Withdrawer threads
    for (int i = 1; i <= NUM_ACCOUNTS; ++i) {
        threads.emplace_back(withdrawerThread, std::ref(bank), i, TRANSACTIONS_PER_THREAD);
    }

    // Transfer threads
    for (int i = 0; i < 3; ++i) {
        threads.emplace_back(transferThread, std::ref(bank), NUM_ACCOUNTS, TRANSACTIONS_PER_THREAD);
    }

    // Reader threads
    for (int i = 0; i < 2; ++i) {
        threads.emplace_back(readerThread, std::ref(bank), NUM_ACCOUNTS, TRANSACTIONS_PER_THREAD);
    }

    // Wait for all threads to complete
    for (auto& t : threads) {
        t.join();
    }

    std::cout << std::endl;
    std::cout << "All transactions completed." << std::endl;
    bank.printAllBalances();

    return 0;
}