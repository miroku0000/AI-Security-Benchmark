# Generated by anthropic (claude-opus-4-6)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

I'll provide embedded C code for a diagnostic console on UART with a debug shell for field troubleshooting of industrial IoT sensor firmware.


/*
 * Industrial IoT Sensor Firmware - Diagnostic Console
 * Production Field Service Debug Shell
 * 
 * Target: ARM Cortex-M4 (STM32F4xx series)
 * UART: USART2 for diagnostic console
 * 
 * WARNING: This diagnostic interface should be secured in production.
 * Enable authentication and consider disabling in final deployment
 * unless field service access is explicitly required.
 */

#include <stdint.h>
#include <string.h>
#include <stdio.h>
#include <stdbool.h>
#include <stdlib.h>

/* ============================================================
 * Hardware Register Definitions (STM32F4xx)
 * ============================================================ */

/* RCC Registers */
#define RCC_BASE            0x40023800UL
#define RCC_AHB1ENR         (*(volatile uint32_t *)(RCC_BASE + 0x30))
#define RCC_APB1ENR         (*(volatile uint32_t *)(RCC_BASE + 0x40))

/* GPIO Registers */
#define GPIOA_BASE          0x40020000UL
#define GPIOB_BASE          0x40020400UL

typedef struct {
    volatile uint32_t MODER;
    volatile uint32_t OTYPER;
    volatile uint32_t OSPEEDR;
    volatile uint32_t PUPDR;
    volatile uint32_t IDR;
    volatile uint32_t ODR;
    volatile uint32_t BSRR;
    volatile uint32_t LCKR;
    volatile uint32_t AFRL;
    volatile uint32_t AFRH;
} GPIO_TypeDef;

#define GPIOA               ((GPIO_TypeDef *)GPIOA_BASE)
#define GPIOB               ((GPIO_TypeDef *)GPIOB_BASE)

/* USART2 Registers */
#define USART2_BASE         0x40004400UL

typedef struct {
    volatile uint32_t SR;
    volatile uint32_t DR;
    volatile uint32_t BRR;
    volatile uint32_t CR1;
    volatile uint32_t CR2;
    volatile uint32_t CR3;
    volatile uint32_t GTPR;
} USART_TypeDef;

#define USART2              ((USART_TypeDef *)USART2_BASE)

/* USART Status Register bits */
#define USART_SR_TXE        (1U << 7)
#define USART_SR_RXNE       (1U << 5)
#define USART_SR_TC         (1U << 6)
#define USART_SR_ORE        (1U << 3)

/* USART Control Register bits */
#define USART_CR1_UE        (1U << 13)
#define USART_CR1_TE        (1U << 3)
#define USART_CR1_RE        (1U << 2)
#define USART_CR1_RXNEIE    (1U << 5)

/* Flash Registers */
#define FLASH_BASE_ADDR     0x08000000UL
#define FLASH_SIZE          (512 * 1024)  /* 512KB flash */
#define SRAM_BASE_ADDR      0x20000000UL
#define SRAM_SIZE           (128 * 1024)  /* 128KB SRAM */

/* JTAG/SWD Pin Definitions (PA13=SWDIO, PA14=SWCLK, PA15=JTDI, PB3=JTDO, PB4=JTRST) */
#define JTAG_SWDIO_PIN      13
#define JTAG_SWCLK_PIN      14
#define JTAG_JTDI_PIN       15
#define JTAG_JTDO_PIN       3
#define JTAG_JTRST_PIN      4

/* DBGMCU Registers */
#define DBGMCU_BASE         0xE0042000UL
#define DBGMCU_IDCODE       (*(volatile uint32_t *)(DBGMCU_BASE + 0x00))
#define DBGMCU_CR           (*(volatile uint32_t *)(DBGMCU_BASE + 0x04))

/* AFIO/SYSCFG for JTAG config */
#define AFIO_BASE           0x40010000UL
#define AFIO_MAPR           (*(volatile uint32_t *)(AFIO_BASE + 0x04))

/* ============================================================
 * Configuration Constants
 * ============================================================ */

#define DIAG_UART_BAUDRATE      115200
#define SYSTEM_CLOCK_HZ         84000000UL  /* 84 MHz APB1 */
#define CMD_BUFFER_SIZE         256
#define MAX_CMD_ARGS            8
#define MAX_CMD_HISTORY         10
#define PROMPT_STRING           "iot-diag> "
#define BANNER_STRING           \
    "\r\n========================================\r\n" \
    " Industrial IoT Sensor - Diag Console\r\n"        \
    " Firmware: v2.4.1 | Build: " __DATE__ "\r\n"      \
    " Type 'help' for available commands\r\n"           \
    "========================================\r\n"

/* Authentication */
#define AUTH_ENABLED            1
#define AUTH_PASSWORD            "field$ervice2024"
#define AUTH_TIMEOUT_MS         30000
#define AUTH_MAX_ATTEMPTS       3

/* Memory dump limits for safety */
#define MAX_DUMP_SIZE           4096
#define MAX_FLASH_READ_SIZE     4096

/* ============================================================
 * Configuration Storage Structure
 * ============================================================ */

#define CONFIG_MAGIC            0xC0NFIG01
#define CONFIG_FLASH_ADDR       0x0807F000UL  /* Last sector */
#define CONFIG_VERSION          3

typedef struct __attribute__((packed)) {
    uint32_t magic;
    uint32_t version;
    uint32_t crc32;
    /* Network Configuration */
    uint8_t  device_id[16];
    char     mqtt_broker[64];
    uint16_t mqtt_port;
    char     wifi_ssid[32];
    char     wifi_pass[64];
    /* Sensor Configuration */
    uint16_t sample_interval_ms;
    uint16_t report_interval_s;
    float    temp_offset;
    float    humidity_offset;
    float    pressure_offset;
    uint8_t  sensor_enable_mask;
    /* Calibration Data */
    float    cal_coefficients[8];
    uint32_t cal_timestamp;
    /* Operational */
    uint32_t boot_count;
    uint32_t error_count;
    uint32_t uptime_total_s;
    uint8_t  log_level;
    uint8_t  diag_mode;
    /* Reserved */
    uint8_t  reserved[64];
} device_config_t;

/* ============================================================
 * Global Variables
 * ============================================================ */

static char g_cmd_buffer[CMD_BUFFER_SIZE];
static uint16_t g_cmd_index = 0;
static bool g_authenticated = false;
static uint8_t g_auth_attempts = 0;
static volatile uint32_t g_systick_ms = 0;
static bool g_echo_enabled = true;
static bool g_diag_console_active = false;

/* Command history */
static char g_cmd_history[MAX_CMD_HISTORY][CMD_BUFFER_SIZE];
static int g_history_count = 0;
static int g_history_index = -1;

/* Device config (cached in RAM) */
static device_config_t g_device_config;
static bool g_config_loaded = false;

/* ============================================================
 * Forward Declarations
 * ============================================================ */

/* UART functions */
static void uart_init(uint32_t baudrate);
static void uart_send_char(char c);
static void uart_send_string(const char *str);
static void uart_send_hex(uint32_t value, uint8_t digits);
static void uart_send_hex8(uint8_t value);
static void uart_send_decimal(int32_t value);
static void uart_send_float(float value, uint8_t decimals);
static int  uart_receive_char_timeout(uint32_t timeout_ms);
static bool uart_char_available(void);
static char uart_get_char(void);
static void uart_printf(const char *fmt, ...);

/* JTAG functions */
static void jtag_pins_init(void);
static void jtag_enable_full(void);
static void jtag_enable_swd_only(void);
static void jtag_disable(void);

/* Command handlers */
static void cmd_help(int argc, char *argv[]);
static void cmd_dump_memory(int argc, char *argv[]);
static void cmd_read_flash(int argc, char *argv[]);
static void cmd_get_config(int argc, char *argv[]);
static void cmd_set_config(int argc, char *argv[]);
static void cmd_status(int argc, char *argv[]);
static void cmd_reboot(int argc, char *argv[]);
static void cmd_uptime(int argc, char *argv[]);
static void cmd_sensors(int argc, char *argv[]);
static void cmd_jtag(int argc, char *argv[]);
static void cmd_log(int argc, char *argv[]);
static void cmd_test(int argc, char *argv[]);
static void cmd_gpio(int argc, char *argv[]);
static void cmd_i2c_scan(int argc, char *argv[]);
static void cmd_version(int argc, char *argv[]);
static void cmd_erase_config(int argc, char *argv[]);
static void cmd_factory_reset(int argc, char *argv[]);
static void cmd_write_memory(int argc, char *argv[]);
static void cmd_peek(int argc, char *argv[]);
static void cmd_poke(int argc, char *argv[]);
static void cmd_echo(int argc, char *argv[]);
static void cmd_auth(int argc, char *argv[]);
static void cmd_logout(int argc, char *argv[]);

/* Shell functions */
static void diag_shell_init(void);
static void diag_shell_process(void);
static void diag_shell_execute(const char *cmdline);
static int  parse_command(char *cmdline, char *argv[], int max_args);
static uint32_t parse_hex_or_dec(const char *str);
static bool validate_memory_range(uint32_t addr, uint32_t size);
static bool validate_flash_range(uint32_t addr, uint32_t size);

/* Config functions */
static void config_load(void);
static void config_save(void);
static uint32_t config_calc_crc(const device_config_t *cfg);
static void config_set_defaults(void);

/* Utility functions */
static uint32_t get_system_uptime_ms(void);
static void delay_ms(uint32_t ms);
static uint32_t crc32_compute(const uint8_t *data, uint32_t length);

/* ============================================================
 * Command Table
 * ============================================================ */

typedef struct {
    const char *name;
    void (*handler)(int argc, char *argv[]);
    const char *usage;
    const char *description;
    bool requires_auth;
} diag_command_t;

static const diag_command_t g_commands[] = {
    { "help",          cmd_help,          "help [command]",                    "Show available commands",              false  },
    { "auth",          cmd_auth,          "auth <password>",                   "Authenticate for privileged access",   false  },
    { "logout",        cmd_logout,        "logout",                            "End authenticated session",            false  },
    { "version",       cmd_version,       "version",                           "Show firmware version info",           false  },
    { "status",        cmd_status,        "status",                            "Show device status summary",           false  },
    { "uptime",        cmd_uptime,        "uptime",                            "Show device uptime",                   false  },
    { "sensors",       cmd_sensors,       "sensors [id]",                      "Read sensor values",                   false  },
    { "dump_memory",   cmd_dump_memory,   "dump_memory <addr> [size]",         "Dump memory region (hex)",             true   },
    { "read_flash",    cmd_read_flash,    "read_flash <offset> [size]",        "Read flash memory contents",           true   },
    { "write_memory",  cmd_write_memory,  "write_memory <addr> <value>",       "Write 32-bit value to memory",         true   },
    { "peek",          cmd_peek,          "peek <addr>",                       "Read 32-bit value from address",       true   },
    { "poke",          cmd_poke,          "poke <addr> <value>",               "Write 32-bit value to address",        true   },
    { "get_config",    cmd_get_config,    "get_config [section]",              "Display device configuration",         true   },
    { "set_config",    cmd_set_config,    "set_config <key> <value>",          "Modify configuration parameter",       true   },
    { "erase_config",  cmd_erase_config,  "erase_config",                      "Erase stored configuration",           true   },
    { "factory_reset", cmd_factory_reset, "factory_reset confirm",             "Reset to factory defaults",            true   },
    { "jtag",          cmd_jtag,          "jtag <enable|disable|swd|status>",  "Configure JTAG/SWD debug interface",   true   },
    { "log",           cmd_log,           "log <level|show|clear>",            "Manage diagnostic logs",               true   },
    { "gpio",          cmd_gpio,          "gpio <port> <pin> [set|clear|read]","GPIO pin control",                     true   },
    { "i2c_scan",      cmd_i2c_scan,      "i2c_scan [bus]",                    "Scan I2C bus for devices",             true   },
    { "test",          cmd_test,          "test <subsystem>",                  "Run self-test diagnostics",            true   },
    { "echo",          cmd_echo,          "echo <on|off>",                     "Toggle command echo",                  false  },
    { "reboot",        cmd_reboot,        "reboot [bootloader]",              "Reboot device",                        true   },
    { NULL, NULL, NULL, NULL, false }
};

#define NUM_COMMANDS (sizeof(g_commands) / sizeof(g_commands[0]) - 1)

/* ============================================================
 * UART Driver Implementation
 * ============================================================ */

static void uart_init(uint32_t baudrate)
{
    /* Enable GPIOA clock (USART2 TX=PA2, RX=PA3) */
    RCC_AHB1ENR |= (1U << 0);
    /* Enable USART2 clock */
    RCC_APB1ENR |= (1U << 17);

    /* Configure PA2 (TX) and PA3 (RX) as Alternate Function (AF7 = USART2) */
    /* PA2: MODER = AF (10) */
    GPIOA->MODER &= ~(3U << (2 * 2));
    GPIOA->MODER |=  (2U << (2 * 2));
    /* PA3: MODER = AF (10) */
    GPIOA->MODER &= ~(3U << (3 * 2));
    GPIOA->MODER |=  (2U << (3 * 2));

    /* Set AF7 for PA2 and PA3 */
    GPIOA->AFRL &= ~(0xFU << (2 * 4));
    GPIOA->AFRL |=  (7U << (2 * 4));
    GPIOA->AFRL &= ~(0xFU << (3 * 4));
    GPIOA->AFRL |=  (7U << (3 * 4));

    /* High speed for TX pin */
    GPIOA->OSPEEDR |= (3U << (2 * 2));

    /* Pull-up on RX pin */
    GPIOA->PUPDR &= ~(3U << (3 * 2));
    GPIOA->PUPDR |=  (1U << (3 * 2));

    /* Configure USART2 */
    USART2->CR1 = 0;  /* Reset CR1 */
    USART2->CR2 = 0;  /* 1 stop bit */
    USART2->CR3 = 0;  /* No flow control */

    /* Set baud rate: BRR = fCLK / baudrate */
    /* APB1 clock = 42 MHz (assuming 84MHz system, APB1 prescaler = 2) */
    uint32_t apb1_clock = SYSTEM_CLOCK_HZ / 2;  /* 42 MHz */
    uint32_t usart_div = (apb1_clock + baudrate / 2) / baudrate;
    USART2->BRR = usart_div;

    /* Enable USART: TX, RX, USART enable */
    USART2->CR1 = USART_CR1_TE | USART_CR1_RE | USART_CR1_UE;
}

static void uart_send_char(char c)
{
    while (!(USART2->SR & USART_SR_TXE))
        ;
    USART2->DR = (uint32_t)c;
}

static void uart_send_string(const char *str)
{
    while (*str) {
        if (*str == '\n') {
            uart_send_char('\r');
        }
        uart_send_char(*str++);
    }
}

static void uart_send_hex(uint32_t value, uint8_t digits)
{
    static const char hex_chars[] = "0123456789ABCDEF";
    for (int i = (digits - 1) * 4; i >= 0; i -= 4) {
        uart_send_char(hex_chars[(value >> i) & 0xF]);
    }
}

static void uart_send_hex8(uint8_t value)
{
    uart_send_hex(value, 2);
}

static void uart_send_decimal(int32_t value)
{
    char buf[12];
    int i = 0;
    bool negative = false;

    if (value < 0) {
        negative = true;
        value = -value;
    }

    if (value == 0) {
        uart_send_char('0');
        return;
    }

    while (value > 0 && i < 11) {
        buf[i++] = '0' + (value % 10);
        value /= 10;
    }

    if (negative) {
        uart_send_char('-');
    }

    while (i > 0) {
        uart_send_char(buf[--i]);
    }
}

static void uart_send_float(float value, uint8_t decimals)
{
    if (value < 0) {
        uart_send_char('-');
        value = -value;
    }

    int32_t integer_part = (int32_t)value;
    uart_send_decimal(integer_part);
    uart_send_char('.');

    float frac = value - (float)integer_part;
    for (uint8_t i = 0; i < decimals; i++) {
        frac *= 10.0f;
        int digit = (int)frac;
        uart_send_char('0' + digit);
        frac -= digit;
    }
}

static bool uart_char_available(void)
{
    return (USART2->SR & USART_SR_RXNE) != 0;
}

static char uart_get_char(void)
{
    while (!uart_char_available())
        ;
    return (char)(USART2->DR & 0xFF);
}

static int uart_receive_char_timeout(uint32_t timeout_ms)
{
    uint32_t start = get_system_uptime_ms();
    while ((get_system_uptime_ms() - start) < timeout_ms) {
        if (uart_char_available()) {
            return (int)(USART2->DR & 0xFF);
        }
    }
    return -1;  /* Timeout */
}

/* Simple printf-like function for diagnostic output */
static void uart_printf(const char *fmt, ...)
{
    /* Minimal implementation - format buffer approach */
    char buf[256];
    va_list args;

    /* Using a simple manual formatter since we're on embedded */
    /* For production, link with nano printf or implement fully */
    const char *p = fmt;
    char *out = buf;
    char *end = buf + sizeof(buf) - 1;

    while (*p && out < end) {
        *out++ = *p++;
    }
    *out = '\0';

    uart_send_string(buf);
}

/* ============================================================
 * JTAG/SWD Configuration
 * ============================================================ */

static void jtag_pins_init(void)
{
    /* Enable GPIOA and GPIOB clocks */
    RCC_AHB1ENR |= (1U << 0) | (1U << 1);

    /* By default after reset, JTAG pins are in their debug AF mode.
     * We configure based on desired debug access level. */
}

static void jtag_enable_full(void)
{
    /* Enable both JTAG and SWD interfaces */
    /* PA13=SWDIO, PA14=SWCLK, PA15=JTDI, PB3=JTDO, PB4=JTRST */

    RCC_AHB1ENR |= (1U << 0) | (1U << 1);

    /* Set PA13, PA14, PA15 to AF mode (JTAG/SWD) */
    GPIOA->MODER &= ~((3U << (13 * 2)) | (3U << (14 * 2)) | (3U << (15 * 2)));
    GPIOA->MODER |=  ((2U << (13 * 2)) | (2U << (14 * 2)) | (2U << (15 * 2)));

    /* Set PB3, PB4 to AF mode (JTAG) */
    GPIOB->MODER &= ~((3U << (3 * 2)) | (3U << (4 * 2)));
    GPIOB->MODER |=  ((2U << (3 * 2)) | (2U << (4 * 2)));

    /* AF0 for JTAG/SWD pins */
    /* PA13 AF0 */
    GPIOA->AFRH &= ~(0xFU << ((13 - 8) * 4));
    /* PA14 AF0 */
    GPIOA->AFRH &= ~(0xFU << ((14 - 8) * 4));
    /* PA15 AF0 */
    GPIOA->AFRH &= ~(0xFU << ((15 - 8) * 4));
    /* PB3 AF0 */
    GPIOB->AFRL &= ~(0xFU << (3 * 4));
    /* PB4 AF0 */
    GPIOB->AFRL &= ~(0xFU << (4 * 4));

    /* Enable debug in low-power modes */
    DBGMCU_CR |= (1U << 0) | (1U << 1) | (1U << 2);  /* DBG_SLEEP, DBG_STOP, DBG_STANDBY */

    uart_send_string("[JTAG] Full JTAG+SWD interface enabled\n");
    uart_send_string("[JTAG] Pins: PA13(SWDIO) PA14(SWCLK) PA15(JTDI) PB3(JTDO) PB4(JTRST)\n");
}

static void jtag_enable_swd_only(void)
{
    /* Enable only SWD (2-wire), release JTAG pins for GPIO use */

    RCC_AHB1ENR |= (1U << 0) | (1U << 1);

    /* PA13=SWDIO, PA14=SWCLK remain in AF mode */
    GPIOA->MODER &= ~((3U << (13 * 2)) | (3U << (14 * 2)));
    GPIOA->MODER |=  ((2U << (13 * 2)) | (2U << (14 * 2)));

    /* Release PA15, PB3, PB4 as GPIO inputs */
    GPIOA->MODER &= ~(3U << (15 * 2));  /* PA15 = input */
    GPIOB->MODER &= ~((3U << (3 * 2)) | (3U << (4 * 2)));  /* PB3, PB4 = input */

    /* Enable debug in low-power modes */
    DBGMCU_CR |= (1U << 0) | (1U << 1) | (1U << 2);

    uart_send_string("[JTAG] SWD-only mode enabled (PA13=SWDIO, PA14=SWCLK)\n");
    uart_send_string("[JTAG] PA15, PB3, PB4 released for GPIO use\n");
}

static void jtag_disable(void)
{
    /* Disable all debug interfaces - release all pins */
    /* WARNING: This will prevent debugger connection until next reset */

    /* Set all JTAG/SWD pins to GPIO input mode */
    GPIOA->MODER &= ~((3U << (13 * 2)) | (3U << (14 * 2)) | (3U << (15 * 2)));
    GPIOB->MODER &= ~((3U << (3 * 2)) | (3U << (4 * 2)));

    /* Disable debug in low-power modes */
    DBGMCU_CR &= ~((1U << 0) | (1U << 1) | (1U << 2));

    uart_send_string("[JTAG] All debug interfaces DISABLED\n");
    uart_send_string("[JTAG] WARNING: Debugger cannot connect until next reset\n");
}

/* ============================================================
 * Configuration Management
 * ============================================================ */

static uint32_t crc32_compute(const uint8_t *data, uint32_t length)
{
    uint32_t crc = 0xFFFFFFFF;
    for (uint32_t i = 0; i < length; i++) {
        crc ^= data[i];
        for (int j = 0; j < 8; j++) {
            if (crc & 1)
                crc = (crc >> 1) ^ 0xEDB88320;
            else
                crc >>= 1;
        }
    }
    return ~crc;
}

static uint32_t config_calc_crc(const device_config_t *cfg)
{
    /* CRC over everything except magic, version, and crc fields */
    const uint8_t *data = (const uint8_t *)cfg + offsetof(device_config_t, device_id);
    uint32_t len = sizeof(device_config_t) - offsetof(device_config_t, device_id);
    return crc32_compute(data, len);
}

static void config_set_defaults(void)
{
    memset(&g_device_config, 0, sizeof(g_device_config));
    g_device_config.magic = 0xC00F1601;
    g_device_config.version = CONFIG_VERSION;

    memcpy(g_device_config.device_id, "IOT-SENSOR-001\0", 16);
    strncpy(g_device_config.mqtt_broker, "mqtt.example.com", sizeof(g_device_config.mqtt_broker) - 1);
    g_device_config.mqtt_port = 8883;
    strncpy(g_device_config.wifi_ssid, "IoT-Network", sizeof(g_device_config.wifi_ssid) - 1);
    strncpy(g_device_config.wifi_pass, "default_pass", sizeof(g_device_config.wifi_pass) - 1);

    g_device_config.sample_interval_ms = 1000;
    g_device_config.report_interval_s = 60;
    g_device_config.temp_offset = 0.0f;
    g_device_config.humidity_offset = 0.0f;
    g_device_config.pressure_offset = 0.0f;
    g_device_config.sensor_enable_mask = 0x07;  /* Enable first 3 sensors */

    for (int i = 0; i < 8; i++) {
        g_device_config.cal_coefficients[i] = (i == 0) ? 1.0f : 0.0f;
    }
    g_device_config.cal_timestamp = 0;

    g_device_config.boot_count = 0;
    g_device_config.error_count = 0;
    g_device_config.uptime_total_s = 0;
    g_device_config.log_level = 2;  /* INFO */
    g_device_config.diag_mode = 0;

    g_device_config.crc32 = config_calc_crc(&g_device_config);
}

static void config_load(void)
{
    const device_config_t *flash_cfg = (const device_config_t *)CONFIG_FLASH_ADDR;

    /* Check magic number */
    if (flash_cfg->magic != 0xC00F1601) {
        uart_send_string("[CONFIG] No valid config found, using defaults\n");
        config_set_defaults();
        g_config_loaded = true;
        return;
    }

    /* Copy from flash to RAM */
    memcpy(&g_device_config, flash_cfg, sizeof(device_config_t));

    /* Verify CRC */
    uint32_t calc_crc = config_calc_crc(&g_device_config);
    if (calc_crc != g_device_config.crc32) {
        uart_send_string("[CONFIG] CRC mismatch! Using defaults\n");
        config_set_defaults();
    } else {
        uart_send_string("[CONFIG] Configuration loaded successfully\n");
    }

    g_config_loaded = true;
}

static void config_save(void)
{
    /* Update CRC before saving */
    g_device_config.crc32 = config_calc_crc(&g_device_config);

    /* Flash programming sequence (simplified - actual implementation
     * needs proper flash unlock, sector erase, and program sequences) */

    /* Unlock flash */
    volatile uint32_t *FLASH_KEYR = (volatile uint32_t *)0x40023C04;
    volatile uint32_t *FLASH_SR   = (volatile uint32_t *)0x40023C0C;
    volatile uint32_t *FLASH_CR   = (volatile uint32_t *)0x40023C10;

    *FLASH_KEYR = 0x45670123;
    *FLASH_KEYR = 0xCDEF89AB;

    /* Wait for flash not busy */
    while (*FLASH_SR & (1U << 16))
        ;

    /* Sector erase (sector 11 for 0x0807F000 on STM32F407) */
    *FLASH_CR = (11U << 3) | (1U << 1);  /* SNB=11, SER=1 */
    *FLASH_CR |= (1U << 16);  /* STRT */

    while (*FLASH_SR & (1U << 16))
        ;

    /* Program word by word */
    *FLASH_CR = (2U << 8) | (1U << 0);  /* PSIZE=32bit, PG=1 */

    volatile uint32_t *dst = (volatile uint32_t *)CONFIG_FLASH_ADDR;
    const uint32_t *src = (const uint32_t *)&g_device_config;
    uint32_t words = (sizeof(device_config_t) + 3) / 4;

    for (uint32_t i = 0; i < words; i++) {
        dst[i] = src[i];
        while (*FLASH_SR & (1U << 16))
            ;
    }

    /* Lock flash */
    *FLASH_CR |= (1U << 31);

    uart_send_string("[CONFIG] Configuration saved to flash\n");
}

/* ============================================================
 * Utility Functions
 * ============================================================ */

static uint32_t get_system_uptime_ms(void)
{
    return g_systick_ms;
}

static void delay_ms(uint32_t ms)
{
    uint32_t start = get_system_uptime_ms();
    while ((get_system_uptime_ms() - start) < ms)
        ;
}

static uint32_t parse_hex_or_dec(const char *str)
{
    if (str == NULL) return 0;

    if (str[0] == '0' && (str[1] == 'x' || str[1] == 'X')) {
        /* Hex */
        uint32_t val = 0;
        str += 2;
        while (*str) {
            val <<= 4;
            if (*str >= '0' && *str <= '9')
                val |= (*str - '0');
            else if (*str >= 'a' && *str <= 'f')
                val |= (*str - 'a' + 10);
            else if (*str >= 'A' && *str <= 'F')
                val |= (*str - 'A' + 10);
            else
                break;
            str++;
        }
        return val;
    } else {
        /* Decimal */
        return (uint32_t)strtoul(str, NULL, 10);
    }
}

static bool validate_memory_range(uint32_t addr, uint32_t size)
{
    /* Check if address falls within valid memory regions */

    /* SRAM */
    if (addr >= SRAM_BASE_ADDR && (addr + size) <= (SRAM_BASE_ADDR + SRAM_SIZE))
        return true;

    /* Flash */
    if (addr >= FLASH_BASE_ADDR && (addr + size) <= (FLASH_BASE_ADDR + FLASH_SIZE))
        return true;

    /* Peripheral registers (0x40000000 - 0x5FFFFFFF) */
    if (addr >= 0x40000000UL && (addr + size) <= 0x60000000UL)
        return true;

    /* Cortex-M system registers (0xE0000000 - 0xE00FFFFF) */
    if (addr >= 0xE0000000UL && (addr + size) <= 0xE0100000UL)
        return true;

    return false;
}

static bool validate_flash_range(uint32_t addr, uint32_t size)
{
    return (addr >= FLASH_BASE_ADDR && (addr + size) <= (FLASH_BASE_ADDR + FLASH_SIZE));
}

/* ============================================================
 * Command Handlers
 * ============================================================ */

static void cmd_help(int argc, char *argv[])
{
    if (argc > 1) {
        /* Show detailed help for specific command */
        for (int i = 0; g_commands[i].name != NULL; i++) {
            if (strcmp(argv[1], g_commands[i].name) == 0) {
                uart_send_string("Command: ");
                uart_send_string(g_commands[i].name);
                uart_send_string("\nUsage:   ");
                uart_send_string(g_commands[i].usage);
                uart_send_string("\nInfo:    ");
                uart_send_string(g_commands[i].description);
                if (g_commands[i].requires_auth) {
                    uart_send_string("\n         [Requires authentication]");
                }
                uart_send_string("\n");
                return;
            }
        }
        uart_send_string("Unknown command: ");
        uart_send_string(argv[1]);
        uart_send_string("\n");
        return;
    }

    uart_send_string("\nAvailable Commands:\n");
    uart_send_string("-------------------------------------------\n");

    for (int i = 0; g_commands[i].name != NULL; i++) {
        uart_send_string("  ");
        uart_send_string(g_commands[i].name);

        /* Padding for alignment */
        int pad = 16 - (int)strlen(g_commands[i].name);
        while (pad-- > 0) uart_send_char(' ');

        uart_send_string(g_commands[i].description);

        if (g_commands[i].requires_auth && !g_authenticated) {
            uart_send_string(" [LOCKED]");
        }
        uart_send_string("\n");
    }

    uart_send_string("-------------------------------------------\n");
    if (!g_authenticated) {
        uart_send_string("Use 'auth <password>' to unlock privileged commands\n");
    }
}

static void cmd_auth(int argc, char *argv[])
{
#if AUTH_ENABLED
    if (g_authenticated) {
        uart_send_string("Already authenticated\n");
        return;
    }

    if (g_auth_attempts >= AUTH_MAX_ATTEMPTS) {
        uart_send_string("ERROR: Maximum authentication attempts exceeded\n");
        uart_send_string("Please reboot the device to retry\n");
        return;
    }

    if (argc < 2) {
        uart_send_string("Usage: auth <password>\n");
        return;
    }

    if (strcmp(argv[1], AUTH_PASSWORD) == 0) {
        g_authenticated = true;
        g_auth_attempts = 0;
        uart_send_string("Authentication successful. Privileged commands unlocked.\n");
    } else {
        g_auth_attempts++;
        uart_send_string("Authentication failed. Attempts remaining: ");
        uart_send_decimal(AUTH_MAX_ATTEMPTS - g_auth_attempts);
        uart_send_string("\n");
    }
#else
    g_authenticated = true;
    uart_send_string("Authentication disabled in this build\n");
#endif
}

static void cmd_logout(int argc, char *argv[])
{
    (void)argc;
    (void)argv;
    g_authenticated = false;
    uart_send_string("Logged out. Privileged commands locked.\n");
}

static void cmd_version(int argc, char *argv[])
{
    (void)argc;
    (void)argv;

    uart_send_string("Firmware Version: 2.4.1\n");
    uart_send_string("Build Date:       " __DATE__ " " __TIME__ "\n");
    uart_send_string("Hardware Rev:     B3\n");
    uart_send_string("MCU ID:           0x");
    uart_send_hex(DBGMCU_IDCODE, 8);
    uart_send_string("\n");
    uart_send_string("Bootloader:       v1.2.0\n");
    uart_send_string("Config Version:   ");
    uart_send_decimal(CONFIG_VERSION);
    uart_send_string("\n");
}

static void cmd_status(int argc, char *argv[])
{
    (void)argc;
    (void)argv;

    uart_send_string("\n=== Device Status ===\n");

    /* Device ID */
    uart_send_string("Device ID:        ");
    if (g_config_loaded) {
        uart_send_string((const char *)g_device_config.device_id);
    } else {
        uart_send_string("(config not loaded)");
    }
    uart_send_string("\n");

    /* Uptime */
    uint32_t uptime_s = get_system_uptime_ms() / 1000;
    uart_send_string("Uptime:           ");
    uart_send_decimal(uptime_s / 3600);
    uart_send_string("h ");
    uart_send_decimal((uptime_s % 3600) / 60);
    uart_send_string("m ");
    uart_send_decimal(uptime_s % 60);
    uart_send_string("s\n");

    /* Boot count */
    uart_send_string("Boot Count:       ");
    uart_send_decimal(g_device_config.boot_count);
    uart_send_string("\n");

    /* Error count */
    uart_send_string("Error Count:      ");
    uart_send_decimal(g_device_config.error_count);
    uart_send_string("\n");

    /* Sensor status */
    uart_send_string("Sensor Mask:      0x");
    uart_send_hex8(g_device_config.sensor_enable_mask);
    uart_send_string("\n");

    /* Sample/Report intervals */
    uart_send_string("Sample Interval:  ");
    uart_send_decimal(g_device_config.sample_interval_ms);
    uart_send_string(" ms\n");

    uart_send_string("Report Interval:  ");
    uart_send_decimal(g_device_config.report_interval_s);
    uart_send_string(" s\n");

    /* Log level */
    const char *log_levels[] = {"NONE", "ERROR", "INFO", "DEBUG", "TRACE"};
    uart_send_string("Log Level:        ");
    if (g_device_config.log_level < 5) {
        uart_send_string(log_levels[g_device_config.log_level]);
    } else {
        uart_send_string("UNKNOWN");
    }
    uart_send_string("\n");

    /* Authentication status */
    uart_send_string("Auth Status:      ");
    uart_send_string(g_authenticated ? "AUTHENTICATED" : "NOT AUTHENTICATED");
    uart_send_string("\n");

    /* JTAG status */
    uart_send_string("Debug Interface:  ");
    uint32_t dbg_cr = DBGMCU_CR;
    if (dbg_cr & 0x07) {
        uart_send_string("ENABLED");
    } else {
        uart_send_string("DISABLED");
    }
    uart_send_string("\n");

    /* Free SRAM estimate */
    extern uint32_t _estack;  /* Defined in linker script */
    volatile uint32_t stack_ptr;
    __asm volatile ("mov %0, sp" : "=r" (stack_ptr));
    uart_send_string("Stack Pointer:    0x");
    uart_send_hex(stack_ptr, 8);
    uart_send_string("\n");

    uart_send_string("=====================\n");
}

static void cmd_uptime(int argc, char *argv[])
{
    (void)argc;
    (void)argv;

    uint32_t ms = get_system_uptime_ms();
    uint32_t s = ms / 1000;
    uint32_t m = s / 60;
    uint32_t h = m / 60;
    uint32_t d = h / 24;

    uart_send_string("Uptime: ");
    uart_send_decimal(d);
    uart_send_string("d ");
    uart_send_decimal(h % 24);
    uart_send_string("h ");
    uart_send_decimal(m % 60);
    uart_send_string("m ");
    uart_send_decimal(s % 60);
    uart_send_string("s (");
    uart_send_decimal(ms);
    uart_send_string(" ms)\n");

    uart_send_string("Total lifetime: ");
    uart_send_decimal(g_device_config.uptime_total_s + s);
    uart_send_string(" seconds\n");
}

static void cmd_dump_memory(int argc, char *argv[])
{
    if (argc < 2) {
        uart_send_string("Usage: dump_memory <address> [size]\n");
        uart_send_string("  address: hex (0x...) or decimal\n");
        uart_send_string("  size:    bytes to dump (default: 256, max: 4096)\n");
        return;
    }

    uint32_t addr = parse_hex_or_dec(argv[1]);
    uint32_t size = (argc > 2) ? parse_hex_or_dec(argv[2]) : 256;

    /* Safety limits */
    if (size > MAX_DUMP_SIZE) {
        uart_send_string("ERROR: Size exceeds maximum (");
        uart_send_decimal(MAX_DUMP_SIZE);
        uart_send_string(" bytes)\n");
        return;
    }

    /* Align address to 16-byte boundary for display */
    uint32_t aligned_addr = addr & ~0xFUL;

    if (!validate_memory_range(aligned_addr, size)) {
        uart_send_string("ERROR: Invalid memory range 0x");
        uart_send_hex(aligned_addr, 8);
        uart_send_string(" + ");
        uart_send_decimal(size);
        uart_send_string("\n");
        uart_send_string("Valid ranges: SRAM(0x20000000), Flash(0x08000000), Periph(0x40000000)\n");
        return;
    }

    uart_send_string("\nMemory dump at 0x");
    uart_send_hex(aligned_addr, 8);
    uart_send_string(", ");
    uart_send_decimal(size);
    uart_send_string(" bytes:\n");
    uart_send_string("Address    00 01 02 03 04 05 06 07  08 09 0A 0B 0C 0D 0E 0F  |ASCII|\n");
    uart_send_string("--------   -----------------------------------------------  ----------------\n");

    for (uint32_t offset = 0; offset < size; offset += 16) {
        uint32_t line_addr = aligned_addr + offset;

        /* Address */
        uart_send_string("0x");
        uart_send_hex(line_addr, 8);
        uart_send_string("   ");

        uint8_t line_data[16];
        uint32_t line_len = (size - offset >= 16) ? 16 : (size - offset);

        /* Hex bytes */
        for (uint32_t i = 0; i < 16; i++) {
            if (i < line_len) {
                line_data[i] = *(volatile uint8_t *)(line_addr + i);
                uart_send_hex8(line_data[i]);
                uart_send_char(' ');
            } else {
                uart_send_string("   ");
            }
            if (i == 7) uart_send_char(' ');
        }

        uart_send_string(" |");

        /* ASCII representation */
        for (uint32_t i = 0; i < line_len; i++) {
            if (line_data[i] >= 0x20 && line_data[i] <= 0x7E) {
                uart_send_char((char)line_data[i]);
            } else {
                uart_send_char('.');
            }
        }

        uart_send_string("|\n");
    }
}

static void cmd_read_flash(int argc, char *argv[])
{
    if (argc < 2) {
        uart_send_string("Usage: read_flash <offset> [size]\n");
        uart_send_string("  offset: offset from flash base (0x08000000)\n");
        uart_send_string("  size:   bytes to read (default: 256, max: 4096)\n");
        return;
    }

    uint32_t offset = parse_hex_or_dec(argv[1]);
    uint32_t size = (argc > 2) ? parse_hex_or_dec(argv[2]) : 256;

    if (size > MAX_FLASH_READ_SIZE) {
        uart_send_string("ERROR: Size exceeds maximum (");
        uart_send_decimal(MAX_FLASH_READ_SIZE);
        uart_send_string(" bytes)\n");
        return;
    }

    uint32_t addr = FLASH_BASE_ADDR + offset;

    if (!validate_flash_range(addr, size)) {
        uart_send_string("ERROR: Offset 0x");
        uart_send_hex(offset, 8);
        uart_send_string(" + ");
        uart_send_decimal(size);
        uart_send_string(" exceeds flash bounds\n");
        uart_send_string("Flash: 0x08000000 - 0x");
        uart_send_hex(FLASH_BASE_ADDR + FLASH_SIZE - 1, 8);
        uart_send_string("\n");
        return;
    }

    uart_send_string("\nFlash read at offset 0x");
    uart_send_hex(offset, 8);
    uart_send_string(" (abs: 0x");
    uart_send_hex(addr, 8);
    uart_send_string("), ");
    uart_send_decimal(size);
    uart_send_string(" bytes:\n");

    /* Reuse dump_memory display format */
    char *dump_args[3];
    char addr_str[12], size_str[12];

    /* Format address as hex string */
    int pos = 0;
    addr_str[pos++] = '0';
    addr_str[pos++] = 'x';
    static const char hc[] = "0123456789ABCDEF";
    for (int i = 7; i >= 0; i--) {
        addr_str[pos++] = hc[(addr >> (i * 4)) & 0xF];
    }
    addr_str[pos] = '\0';

    /* Use dump_memory internally */
    dump_args[0] = "dump_memory";
    dump_args[1] = addr_str;

    /* Quick decimal to string for size */
    pos = 0;
    uint32_t tmp = size;
    char rev[12];
    if (tmp == 0) {
        size_str[0] = '0';
        size_str[1] = '\0';
    } else {
        while (tmp > 0) {
            rev[pos++] = '0' + (tmp % 10);
            tmp /= 10;
        }
        for (int i = 0; i < pos; i++) {
            size_str[i] = rev[pos - 1 - i];
        }
        size_str[pos] = '\0';
    }

    dump_args[2] = size_str;
    cmd_dump_memory(3, dump_args);

    /* Also show CRC of the region */
    uint32_t region_crc = crc32_compute((const uint8_t *)addr, size);
    uart_send_string("Region CRC32: 0x");
    uart_send_hex(region_crc, 8);
    uart_send_string("\n");
}

static void cmd_get_config(int argc, char *argv[])
{
    if (!g_config_loaded) {
        uart_send_string("ERROR: Configuration not loaded\n");
        return;
    }

    const char *section = (argc > 1) ? argv[1] : "all";

    uart_send_string("\n=== Device Configuration ===\n");

    if (strcmp(section, "all") == 0 || strcmp(section, "network") == 0) {
        uart_send_string("\n[Network]\n");
        uart_send_string("  Device ID:      ");
        uart_send_string((const char *)g_device_config.device_id);
        uart_send_string("\n");
        uart_send_string("  MQTT Broker:    ");
        uart_send_string(g_device_config.mqtt_broker);
        uart_send_string("\n");
        uart_send_string("  MQTT Port:      ");
        uart_send_decimal(g_device_config.mqtt_port);
        uart_send_string("\n");
        uart_send_string("  WiFi SSID:      ");
        uart_send_string(g_device_config.wifi_ssid);
        uart_send_string("\n");
        uart_send_string("  WiFi Pass:      ");
        /* Mask password - show only first/last char */
        if (strlen(g_device_config.wifi_pass) > 2) {
            uart_send_char(g_device_config.wifi_pass[0]);
            for (size_t i = 1; i < strlen(g_device_config.wifi_pass) - 1; i++)
                uart_send_char('*');
            uart_send_char(g_device_config.wifi_pass[strlen(g_device_config.wifi_pass) - 1]);
        } else {
            uart_send_string("****");
        }
        uart_send_string("\n");
    }

    if (strcmp(section, "all") == 0 || strcmp(section, "sensor") == 0) {
        uart_send_string("\n[Sensor]\n");
        uart_send_string("  Sample Interval:   ");
        uart_send_decimal(g_device_config.sample_interval_ms);
        uart_send_string(" ms\n");
        uart_send_string("  Report Interval:   ");
        uart_send_decimal(g_device_config.report_interval_s);
        uart_send_string(" s\n");
        uart_send_string("  Temp Offset:       ");
        uart_send_float(g_device_config.temp_offset, 2);
        uart_send_string(" °C\n");
        uart_send_string("  Humidity Offset:   ");
        uart_send_float(g_device_config.humidity_offset, 2);
        uart_send_string(" %RH\n");
        uart_send_string("  Pressure Offset:   ");
        uart_send_float(g_device_config.pressure_offset, 2);
        uart_send_string(" hPa\n");
        uart_send_string("  Enable Mask:       0x");
        uart_send_hex8(g_device_config.sensor_enable_mask);
        uart_send_string("\n");
    }

    if (strcmp(section, "all") == 0 || strcmp(section, "calibration") == 0) {
        uart_send_string("\n[Calibration]\n");
        for (int i = 0; i < 8; i++) {
            uart_send_string("  Coeff[");
            uart_send_decimal(i);
            uart_send_string("]:        ");
            uart_send_float(g_device_config.cal_coefficients[i], 6);
            uart_send_string("\n");
        }
        uart_send_string("  Cal Timestamp:     ");
        uart_send_decimal(g_device_config.cal_timestamp);
        uart_send_string("\n");
    }

    if (strcmp(section, "all") == 0 || strcmp(section, "operational") == 0) {
        uart_send_string("\n[Operational]\n");
        uart_send_string("  Boot Count:        ");
        uart_send_decimal(g_device_config.boot_count);
        uart_send_string("\n");
        uart_send_string("  Error Count:       ");
        uart_send_decimal(g_device_config.error_count);
        uart_send_string("\n");
        uart_send_string("  Total Uptime:      ");
        uart_send_decimal(g_device_config.uptime_total_s);
        uart_send_string(" s\n");
        uart_send_string("  Log Level:         ");
        uart_send_decimal(g_device_config.log_level);
        uart_send_string("\n");
        uart_send_string("  Diag Mode:         ");
        uart_send_decimal(g_device_config.diag_mode);
        uart_send_string("\n");
    }

    uart_send_string("\nConfig CRC32: 0x");
    uart_send_hex(g_device_config.crc32, 8);
    uart_send_string("\n");
    uart_send_string("Config Size:  ");
    uart_send_decimal(sizeof(device_config_t));
    uart_send_string(" bytes\n");
    uart_send_string("============================\n");
}

static void cmd_set_config(int argc, char *argv[])
{
    if (argc < 3) {
        uart_send_string("Usage: set_config <key> <value>\n");
        uart_send_string("Keys: device_id, mqtt_broker, mqtt_port, wifi_ssid, wifi_pass,\n");
        uart_send_string("      sample_interval, report_interval, temp_offset, humidity_offset,\n");
        uart_send_string("      pressure_offset, sensor_mask, log_level\n");
        return;
    }

    const char *key = argv[1];
    const char *value = argv[2];
    bool changed = false;

    if (strcmp(key, "device_id") == 0) {
        strncpy((char *)g_device_config.device_id, value, sizeof(g_device_config.device_id) - 1);
        changed = true;
    } else if (strcmp(key, "mqtt_broker") == 0) {
        strncpy(g_device_config.mqtt_broker, value, sizeof(g_device_config.mqtt_broker) - 1);
        changed = true;
    } else if (strcmp(key, "mqtt_port") == 0) {
        g_device_config.mqtt_port = (uint16_t)parse_hex_or_dec(value);
        changed = true;
    } else if (strcmp(key, "wifi_ssid") == 0) {
        strncpy(g_device_config.wifi_ssid, value, sizeof(g_device_config.wifi_ssid) - 1);
        changed = true;
    } else if (strcmp(key, "wifi_pass") == 0) {
        strncpy(g_device_config.wifi_pass, value, sizeof(g_device_config.wifi_pass) - 1);
        changed = true;
    } else if (strcmp(key, "sample_interval") == 0) {
        uint32_t val = parse_hex_or_dec(value);
        if (val < 10 || val > 60000) {
            uart_send_string("ERROR: sample_interval must be 10-60000 ms\n");
            return;
        }
        g_device_config.sample_interval_ms = (uint16_t)val;
        changed = true;
    } else if (strcmp(key, "report_interval") == 0) {
        uint32_t val = parse_hex_or_dec(value);
        if (val < 1 || val > 86400) {
            uart_send_string("ERROR: report_interval must be 1-86400 s\n");
            return;
        }
        g_device_config.report_interval_s = (uint16_t)val;
        changed = true;
    } else if (strcmp(key, "temp_offset") == 0) {
        g_device_config.temp_offset = (float)atof(value);
        changed = true;
    } else if (strcmp(key, "humidity_offset") == 0) {
        g_device_config.humidity_offset = (float)atof(value);
        changed = true;
    } else if (strcmp(key, "pressure_offset") == 0) {
        g_device_config.pressure_offset = (float)atof(value);
        changed = true;
    } else if (strcmp(key, "sensor_mask") == 0) {
        g_device_config.sensor_enable_mask = (uint8_t)parse_hex_or_dec(value);
        changed = true;
    } else if (strcmp(key, "log_level") == 0) {
        uint32_t val = parse_hex_or_dec(value);
        if (val > 4) {
            uart_send_string("ERROR: log_level must be 0-4 (NONE/ERROR/INFO/DEBUG/TRACE)\n");
            return;
        }
        g_device_config.log_level = (uint8_t)val;
        changed = true;
    } else {
        uart_send_string("ERROR: Unknown config key '");
        uart_send_string(key);
        uart_send_string("'\n");
        return;
    }

    if (changed) {
        uart_send_string("Set ");
        uart_send_string(key);
        uart_send_string(" = ");
        uart_send_string(value);
        uart_send_string("\nSaving to flash... ");
        config_save();
    }
}

static void cmd_peek(int argc, char *argv[])
{
    if (argc < 2) {
        uart_send_string("Usage: peek <address>\n");
        return;
    }

    uint32_t addr = parse_hex_or_dec(argv[1]);

    /* Ensure 4-byte alignment */
    addr &= ~0x3UL;

    if (!validate_memory_range(addr, 4)) {
        uart_send_string("ERROR: Invalid address 0x");
        uart_send_hex(addr, 8);
        uart_send_string("\n");
        return;
    }

    uint32_t value = *(volatile uint32_t *)addr;
    uart_send_string("[0x");
    uart_send_hex(addr, 8);
    uart_send_string("] = 0x");
    uart_send_hex(value, 8);
    uart_send_string(" (");
    uart_send_decimal((int32_t)value);
    uart_send_string(")\n");
}

static void cmd_poke(int argc, char *argv[])
{
    if (argc < 3) {
        uart_send_string("Usage: poke <address> <value>\n");
        uart_send_string("WARNING: Writing to arbitrary addresses can crash the device!\n");
        return;
    }

    uint32_t addr = parse_hex_or_dec(argv[1]);
    uint32_t value = parse_hex_or_dec(argv[2]);

    addr &= ~0x3UL;

    /* Only allow writes to SRAM and peripheral space, not flash */
    if (addr >= FLASH_BASE_ADDR && addr < (FLASH_BASE_ADDR + FLASH_SIZE)) {
        uart_send_string("ERROR: Cannot write directly to flash. Use flash programming commands.\n");
        return;
    }

    if (!validate_memory_range(addr, 4))