# Generated by anthropic (claude-opus-4-6)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdio.h>
#include <string.h>

typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    float vibration;
    uint32_t timestamp;
    uint8_t sensor_status;
    uint8_t data_ready;
} SensorData_t;

volatile SensorData_t sensor_data = {0};

SemaphoreHandle_t xSensorMutex;

TaskHandle_t xSensorReadTaskHandle = NULL;
TaskHandle_t xControlTaskHandle = NULL;

/* Simulated hardware sensor read functions */
static float read_temperature_sensor(void)
{
    /* Replace with actual hardware register read */
    static float temp = 25.0f;
    temp += 0.1f;
    if (temp > 100.0f) temp = 25.0f;
    return temp;
}

static float read_pressure_sensor(void)
{
    static float pressure = 101.3f;
    pressure += 0.05f;
    if (pressure > 200.0f) pressure = 101.3f;
    return pressure;
}

static float read_flow_rate_sensor(void)
{
    static float flow = 50.0f;
    flow += 0.2f;
    if (flow > 150.0f) flow = 50.0f;
    return flow;
}

static float read_vibration_sensor(void)
{
    static float vib = 0.0f;
    vib += 0.01f;
    if (vib > 10.0f) vib = 0.0f;
    return vib;
}

static uint8_t check_sensor_health(void)
{
    /* 0xFF = all sensors OK, individual bits represent each sensor */
    return 0xFF;
}

/* Task 1: Sensor Reading Task - High Priority */
void vSensorReadTask(void *pvParameters)
{
    TickType_t xLastWakeTime;
    const TickType_t xReadPeriod = pdMS_TO_TICKS(10); /* 10ms read cycle */
    float temp_temperature;
    float temp_pressure;
    float temp_flow_rate;
    float temp_vibration;
    uint8_t temp_status;

    (void)pvParameters;

    xLastWakeTime = xTaskGetTickCount();

    for (;;)
    {
        /* Read all sensors outside the critical section to minimize lock time */
        temp_temperature = read_temperature_sensor();
        temp_pressure = read_pressure_sensor();
        temp_flow_rate = read_flow_rate_sensor();
        temp_vibration = read_vibration_sensor();
        temp_status = check_sensor_health();

        /* Take mutex to update shared struct atomically */
        if (xSemaphoreTake(xSensorMutex, pdMS_TO_TICKS(5)) == pdTRUE)
        {
            sensor_data.temperature = temp_temperature;
            sensor_data.pressure = temp_pressure;
            sensor_data.flow_rate = temp_flow_rate;
            sensor_data.vibration = temp_vibration;
            sensor_data.sensor_status = temp_status;
            sensor_data.timestamp = (uint32_t)xTaskGetTickCount();
            sensor_data.data_ready = 1;

            xSemaphoreGive(xSensorMutex);

            /* Notify control task that new data is available */
            xTaskNotifyGive(xControlTaskHandle);
        }
        else
        {
            /* Mutex timeout - log error for diagnostics */
            printf("[SENSOR] ERROR: Mutex acquisition timeout at tick %lu\n",
                   (unsigned long)xTaskGetTickCount());
        }

        /* Precise periodic execution */
        vTaskDelayUntil(&xLastWakeTime, xReadPeriod);
    }
}

/* Control logic helper functions */
static void apply_temperature_control(float temperature)
{
    const float TEMP_HIGH_THRESHOLD = 80.0f;
    const float TEMP_LOW_THRESHOLD = 10.0f;
    const float TEMP_CRITICAL = 95.0f;

    if (temperature >= TEMP_CRITICAL)
    {
        printf("[CONTROL] CRITICAL: Temperature %.2f - Emergency shutdown initiated\n",
               temperature);
        /* Trigger emergency shutdown actuator */
    }
    else if (temperature >= TEMP_HIGH_THRESHOLD)
    {
        printf("[CONTROL] WARNING: High temperature %.2f - Increasing cooling\n",
               temperature);
        /* Increase cooling actuator output */
    }
    else if (temperature <= TEMP_LOW_THRESHOLD)
    {
        printf("[CONTROL] WARNING: Low temperature %.2f - Activating heater\n",
               temperature);
        /* Activate heating element */
    }
}

static void apply_pressure_control(float pressure)
{
    const float PRESSURE_MAX = 180.0f;
    const float PRESSURE_MIN = 50.0f;

    if (pressure > PRESSURE_MAX)
    {
        printf("[CONTROL] WARNING: High pressure %.2f - Opening relief valve\n",
               pressure);
        /* Open pressure relief valve */
    }
    else if (pressure < PRESSURE_MIN)
    {
        printf("[CONTROL] WARNING: Low pressure %.2f - Closing outlet valve\n",
               pressure);
        /* Close outlet valve */
    }
}

static void apply_flow_control(float flow_rate)
{
    const float FLOW_TARGET = 100.0f;
    const float FLOW_TOLERANCE = 10.0f;
    float error;

    error = FLOW_TARGET - flow_rate;

    if (error > FLOW_TOLERANCE || error < -FLOW_TOLERANCE)
    {
        printf("[CONTROL] Adjusting flow: current=%.2f target=%.2f error=%.2f\n",
               flow_rate, FLOW_TARGET, error);
        /* Apply PID correction to flow control valve */
    }
}

static void check_vibration_alarm(float vibration)
{
    const float VIBRATION_ALARM = 7.0f;

    if (vibration > VIBRATION_ALARM)
    {
        printf("[CONTROL] ALARM: Excessive vibration %.2f - Check mechanical components\n",
               vibration);
        /* Trigger maintenance alarm */
    }
}

/* Task 2: Control Logic Task - Lower Priority than Sensor Read */
void vControlTask(void *pvParameters)
{
    SensorData_t local_data;
    uint32_t ulNotificationValue;

    (void)pvParameters;

    for (;;)
    {
        /* Wait for notification from sensor task, timeout after 50ms as safety */
        ulNotificationValue = ulTaskNotifyTake(pdTRUE, pdMS_TO_TICKS(50));

        if (ulNotificationValue > 0)
        {
            /* Take mutex and copy data to local struct for processing */
            if (xSemaphoreTake(xSensorMutex, pdMS_TO_TICKS(5)) == pdTRUE)
            {
                local_data.temperature = sensor_data.temperature;
                local_data.pressure = sensor_data.pressure;
                local_data.flow_rate = sensor_data.flow_rate;
                local_data.vibration = sensor_data.vibration;
                local_data.timestamp = sensor_data.timestamp;
                local_data.sensor_status = sensor_data.sensor_status;
                local_data.data_ready = sensor_data.data_ready;
                sensor_data.data_ready = 0;

                xSemaphoreGive(xSensorMutex);
            }
            else
            {
                printf("[CONTROL] ERROR: Mutex acquisition timeout at tick %lu\n",
                       (unsigned long)xTaskGetTickCount());
                continue;
            }

            /* Verify sensor health before processing */
            if (local_data.sensor_status != 0xFF)
            {
                printf("[CONTROL] WARNING: Sensor fault detected, status=0x%02X\n",
                       local_data.sensor_status);
                /* Enter degraded mode or use last known good values */
                continue;
            }

            /* Process control logic with local copy - no mutex held */
            printf("[CONTROL] Processing: T=%.2f P=%.2f F=%.2f V=%.2f ts=%lu\n",
                   local_data.temperature,
                   local_data.pressure,
                   local_data.flow_rate,
                   local_data.vibration,
                   (unsigned long)local_data.timestamp);

            apply_temperature_control(local_data.temperature);
            apply_pressure_control(local_data.pressure);
            apply_flow_control(local_data.flow_rate);
            check_vibration_alarm(local_data.vibration);
        }
        else
        {
            /* Notification timeout - sensor task may be stuck */
            printf("[CONTROL] WARNING: No sensor data received within timeout period\n");
            /* Implement failsafe: hold last outputs or go to safe state */
        }
    }
}

int main(void)
{
    /* Initialize the sensor data struct */
    memset((void *)&sensor_data, 0, sizeof(SensorData_t));

    /* Create mutex for shared data protection */
    xSensorMutex = xSemaphoreCreateMutex();

    if (xSensorMutex == NULL)
    {
        printf("FATAL: Failed to create sensor mutex\n");
        for (;;);
    }

    /* Create sensor read task at higher priority for deterministic timing */
    if (xTaskCreate(vSensorReadTask,
                    "SensorRead",
                    configMINIMAL_STACK_SIZE * 2,
                    NULL,
                    tskIDLE_PRIORITY + 3,
                    &xSensorReadTaskHandle) != pdPASS)
    {
        printf("FATAL: Failed to create sensor read task\n");
        for (;;);
    }

    /* Create control task at lower priority */
    if (xTaskCreate(vControlTask,
                    "Control",
                    configMINIMAL_STACK_SIZE * 4,
                    NULL,
                    tskIDLE_PRIORITY + 2,
                    &xControlTaskHandle) != pdPASS)
    {
        printf("FATAL: Failed to create control task\n");
        for (;;);
    }

    printf("Industrial Control System Starting...\n");
    printf("Sensor Read Task: Priority %d, Period 10ms\n", tskIDLE_PRIORITY + 3);
    printf("Control Task:     Priority %d, Event-driven\n", tskIDLE_PRIORITY + 2);

    /* Start the FreeRTOS scheduler */
    vTaskStartScheduler();

    /* Should never reach here */
    printf("FATAL: Scheduler exited unexpectedly\n");
    for (;;);

    return 0;
}

/* FreeRTOS hook for stack overflow detection */
void vApplicationStackOverflowHook(TaskHandle_t xTask, char *pcTaskName)
{
    (void)xTask;
    printf("FATAL: Stack overflow in task: %s\n", pcTaskName);
    for (;;);
}

/* FreeRTOS hook for malloc failure */
void vApplicationMallocFailedHook(void)
{
    printf("FATAL: Memory allocation failed\n");
    for (;;);
}