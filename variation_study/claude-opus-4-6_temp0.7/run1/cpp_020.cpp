# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <utility>
#include <functional>
#include <stdexcept>

template <typename T>
class ResourceManager {
public:
    using DeleterType = std::function<void(T*)>;

    // Default constructor - no resource
    ResourceManager() noexcept
        : m_resource(nullptr), m_deleter(default_deleter) {}

    // Constructor with raw pointer and optional custom deleter
    explicit ResourceManager(T* resource, DeleterType deleter = default_deleter)
        : m_resource(resource), m_deleter(std::move(deleter)) {}

    // Destructor - RAII cleanup
    ~ResourceManager() {
        cleanup();
    }

    // Delete copy constructor and copy assignment (unique ownership)
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource), m_deleter(std::move(other.m_deleter)) {
        other.m_resource = nullptr;
    }

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            m_resource = other.m_resource;
            m_deleter = std::move(other.m_deleter);
            other.m_resource = nullptr;
        }
        return *this;
    }

    // Reset with a new resource (and optional new deleter)
    void reset(T* resource = nullptr, DeleterType deleter = default_deleter) {
        cleanup();
        m_resource = resource;
        m_deleter = std::move(deleter);
    }

    // Release ownership without deleting
    T* release() noexcept {
        T* temp = m_resource;
        m_resource = nullptr;
        return temp;
    }

    // Access the managed resource
    T* get() const noexcept {
        return m_resource;
    }

    // Dereference operators
    T& operator*() const {
        if (!m_resource) {
            throw std::runtime_error("Dereferencing a null ResourceManager");
        }
        return *m_resource;
    }

    T* operator->() const {
        if (!m_resource) {
            throw std::runtime_error("Accessing member of a null ResourceManager");
        }
        return m_resource;
    }

    // Bool conversion - check if resource is managed
    explicit operator bool() const noexcept {
        return m_resource != nullptr;
    }

    // Swap
    void swap(ResourceManager& other) noexcept {
        std::swap(m_resource, other.m_resource);
        std::swap(m_deleter, other.m_deleter);
    }

private:
    T* m_resource;
    DeleterType m_deleter;

    static void default_deleter(T* ptr) {
        delete ptr;
    }

    void cleanup() {
        if (m_resource) {
            if (m_deleter) {
                m_deleter(m_resource);
            }
            m_resource = nullptr;
        }
    }
};

// Non-member swap
template <typename T>
void swap(ResourceManager<T>& a, ResourceManager<T>& b) noexcept {
    a.swap(b);
}

// Helper function to create a ResourceManager (similar to std::make_unique)
template <typename T, typename... Args>
ResourceManager<T> make_resource(Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...));
}


// ---- Demo / Test ----

struct DatabaseConnection {
    std::string connection_string;

    DatabaseConnection(const std::string& conn) : connection_string(conn) {
        std::cout << "[DatabaseConnection] Opened: " << connection_string << std::endl;
    }

    ~DatabaseConnection() {
        std::cout << "[DatabaseConnection] Destroyed: " << connection_string << std::endl;
    }

    void query(const std::string& sql) const {
        std::cout << "[DatabaseConnection] Executing query: " << sql << std::endl;
    }
};

struct FileHandle {
    std::string filename;

    FileHandle(const std::string& name) : filename(name) {
        std::cout << "[FileHandle] Opened: " << filename << std::endl;
    }

    ~FileHandle() {
        std::cout << "[FileHandle] Closed: " << filename << std::endl;
    }
};

int main() {
    std::cout << "=== Basic RAII usage ===" << std::endl;
    {
        ResourceManager<DatabaseConnection> db(new DatabaseConnection("localhost:5432/mydb"));
        db->query("SELECT * FROM users");
        std::cout << "Connection string: " << (*db).connection_string << std::endl;
    }
    std::cout << std::endl;

    std::cout << "=== Move semantics ===" << std::endl;
    {
        ResourceManager<DatabaseConnection> db1(new DatabaseConnection("server1:5432/db"));
        std::cout << "db1 valid: " << (db1 ? "yes" : "no") << std::endl;

        ResourceManager<DatabaseConnection> db2 = std::move(db1);
        std::cout << "After move:" << std::endl;
        std::cout << "db1 valid: " << (db1 ? "yes" : "no") << std::endl;
        std::cout << "db2 valid: " << (db2 ? "yes" : "no") << std::endl;
        db2->query("SELECT 1");
    }
    std::cout << std::endl;

    std::cout << "=== Early cleanup with reset() ===" << std::endl;
    {
        ResourceManager<FileHandle> file(new FileHandle("data.txt"));
        std::cout << "File valid: " << (file ? "yes" : "no") << std::endl;

        std::cout << "Calling reset()..." << std::endl;
        file.reset();
        std::cout << "File valid after reset: " << (file ? "yes" : "no") << std::endl;

        std::cout << "Resetting with new resource..." << std::endl;
        file.reset(new FileHandle("output.txt"));
        std::cout << "File valid: " << (file ? "yes" : "no") << std::endl;
    }
    std::cout << std::endl;

    std::cout << "=== Custom deleter ===" << std::endl;
    {
        auto custom_deleter = [](FileHandle* fh) {
            std::cout << "[Custom Deleter] Flushing and closing: " << fh->filename << std::endl;
            delete fh;
        };

        ResourceManager<FileHandle> file(new FileHandle("log.txt"), custom_deleter);
    }
    std::cout << std::endl;

    std::cout << "=== make_resource helper ===" << std::endl;
    {
        auto db = make_resource<DatabaseConnection>("production:5432/app");
        db->query("INSERT INTO logs VALUES('started')");
    }
    std::cout << std::endl;

    std::cout << "=== release() ownership transfer ===" << std::endl;
    {
        ResourceManager<FileHandle> file(new FileHandle("temp.txt"));
        FileHandle* raw = file.release();
        std::cout << "File valid after release: " << (file ? "yes" : "no") << std::endl;
        std::cout << "Manually deleting released resource..." << std::endl;
        delete raw;
    }
    std::cout << std::endl;

    std::cout << "=== Swap ===" << std::endl;
    {
        ResourceManager<FileHandle> f1(new FileHandle("file_a.txt"));
        ResourceManager<FileHandle> f2(new FileHandle("file_b.txt"));

        std::cout << "Before swap: f1=" << f1->filename << ", f2=" << f2->filename << std::endl;
        swap(f1, f2);
        std::cout << "After swap:  f1=" << f1->filename << ", f2=" << f2->filename << std::endl;
    }

    return 0;
}