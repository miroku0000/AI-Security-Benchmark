# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>
#include <optional>
#include <iostream>

struct User {
    int id;
    std::string username;
    std::string email;
    std::string display_name;
    int age;
    bool is_active;
};

struct UserResponse {
    int id;
    std::string username;
    std::string email;
    std::string display_name;
    int age;
    bool is_active;
    bool found;
    std::string error_message;
};

class UserLookupSystem {
private:
    std::unordered_map<int, User> user_table;

public:
    void add_user(const User& user) {
        user_table[user.id] = user;
    }

    // Find user by ID - returns pointer to user in hash table, or nullptr if not found
    User* find_user(int user_id) {
        auto it = user_table.find(user_id);
        if (it != user_table.end()) {
            return &(it->second);
        }
        return nullptr;
    }

    // Find user by username - linear scan
    User* find_user_by_username(const std::string& username) {
        for (auto& [id, user] : user_table) {
            if (user.username == username) {
                return &user;
            }
        }
        return nullptr;
    }

    // BUG: Dereferences pointer without null check - will crash if user not found
    UserResponse get_user_profile(int user_id) {
        User* user = find_user(user_id);

        // Immediately dereference without null check - undefined behavior if user not found
        UserResponse response;
        response.id = user->id;
        response.username = user->username;
        response.email = user->email;
        response.display_name = user->display_name;
        response.age = user->age;
        response.is_active = user->is_active;
        response.found = true;
        response.error_message = "";

        return response;
    }

    // FIXED: Safe version with proper null check before dereferencing
    UserResponse get_user_profile_safe(int user_id) {
        User* user = find_user(user_id);

        UserResponse response;

        if (user == nullptr) {
            response.id = -1;
            response.username = "";
            response.email = "";
            response.display_name = "";
            response.age = 0;
            response.is_active = false;
            response.found = false;
            response.error_message = "User not found with ID: " + std::to_string(user_id);
            return response;
        }

        response.id = user->id;
        response.username = user->username;
        response.email = user->email;
        response.display_name = user->display_name;
        response.age = user->age;
        response.is_active = user->is_active;
        response.found = true;
        response.error_message = "";

        return response;
    }

    // Also safe: using std::optional for a more idiomatic C++ approach
    std::optional<UserResponse> get_user_profile_optional(int user_id) {
        User* user = find_user(user_id);

        if (!user) {
            return std::nullopt;
        }

        UserResponse response;
        response.id = user->id;
        response.username = user->username;
        response.email = user->email;
        response.display_name = user->display_name;
        response.age = user->age;
        response.is_active = user->is_active;
        response.found = true;
        response.error_message = "";

        return response;
    }
};

int main() {
    UserLookupSystem system;

    system.add_user({1, "alice", "alice@example.com", "Alice Smith", 30, true});
    system.add_user({2, "bob", "bob@example.com", "Bob Jones", 25, true});

    // Safe lookup - existing user
    UserResponse resp = system.get_user_profile_safe(1);
    if (resp.found) {
        std::cout << "Found user: " << resp.display_name << " (" << resp.email << ")\n";
    }

    // Safe lookup - non-existing user
    resp = system.get_user_profile_safe(999);
    if (!resp.found) {
        std::cout << "Error: " << resp.error_message << "\n";
    }

    // DANGEROUS: This will cause a null pointer dereference / crash
    // Uncomment to see the bug in action:
    // UserResponse crash_resp = system.get_user_profile(999);

    // Optional-based lookup
    auto opt_resp = system.get_user_profile_optional(2);
    if (opt_resp.has_value()) {
        std::cout << "Found user: " << opt_resp->display_name << "\n";
    }

    opt_resp = system.get_user_profile_optional(999);
    if (!opt_resp.has_value()) {
        std::cout << "User not found (optional returned nullopt)\n";
    }

    return 0;
}