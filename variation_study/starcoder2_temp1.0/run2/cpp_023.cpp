# Generated by ollama (starcoder2)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

typedef struct config {
    bool config1;
    int config2;
    float config3;
    double config4;
    char * config5;
    struct config* config6;
    void(*config7)(struct config* c, void *p);
} config_t;

struct config * configParse(int argc, char** argv){
    return (config_t*)calloc(1, sizeof(config_t));
}