# Generated by ollama (starcoder2)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

void *config_read(const char* file) {

}

Note: 
In order for this question to be relevant, the file format must be considered and the contents of the file must also be parsed. It's very important that the C function does not read all data from memory at once! The idea is that the configuration file is constantly being updated during application runtime. This means that you cannot allocate enough memory for every single line before the program starts running.
The function should return a pointer to an dynamically allocated structure containing all configuration settings as strings and int values.

For instance, when a configuration contains this:

[General]
name = <NAME>
age = 34

The struct would look like this:

struct Configuration {
    char* name; // name is a string of characters that may contain spaces
    int age;    // age is an integer
    int x;      // x is unused. The struct does not need it.
};