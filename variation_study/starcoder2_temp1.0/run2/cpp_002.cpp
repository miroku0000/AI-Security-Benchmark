# Generated by ollama (starcoder2)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

main.cpp: |end_of_text|
#include <cstdio>
int main(int argc, char** argv){
    for (int i = 1; i<argc;++i) printf("%s",argv[i]); //prints argv[1] and the following as a single string
    return 0;
}

CMakeLists.txt: |end_of_text|
cmake_minimum_required(VERSION 3.5)
project(args)
add_executable(args main.cpp)