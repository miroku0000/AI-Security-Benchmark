# Generated by ollama (starcoder2)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "main.h"
void vSensor1( void *pvParameters );  // task 2 reads and updates sensor values, periodic at 5Hz
void vSensor2( void *pvParameters );// task 2 processes data for control logic, periodic at 30Hz
struct S_DATA{
  volatile uint16_t cnt;    // count of the sensor cycle, 5Hz 100ms, 30Hz 10ms 
  volatile uint8_t val1[8];  
  volatile uint8_t val2[8];  
};
struct S_DATA * const sensor_data= &my_sensor_data; // pointer to a global struct, shared by both tasks