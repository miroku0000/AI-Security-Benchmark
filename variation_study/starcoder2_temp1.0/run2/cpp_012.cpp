# Generated by ollama (starcoder2)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

// Connection.cpp

#include "Connection.h"


Connection::Connection(Network& _network):
    Network(_network),
    network_connection(),
    is_open(false) {
}
    
Connection::~Connection() {

    disconnect(); // close

}
    
void  Connection::connect () {
    
    if (!is_open()) return;
        
    network.send_message(network_connection, 3);
    is_open = true;
        
}
    
void Connection::disconnect(){
    
    
    Network::reset();

    network.send_message(network_connection, 17);
    
    // cleanup

    // close
    is_open= false;
}