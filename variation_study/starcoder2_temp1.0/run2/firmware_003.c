# Generated by ollama (starcoder2)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

int main(void) {
  puts("start");
  puts("entering loop");

  // code for the above statement:
  1. Initialize UART as 9600 baud rate, no parity, one stop bit at the system level. Also enable transmit and receive of data in hardware.
  2. Setup the JTAG pins to support remote debugging.
}