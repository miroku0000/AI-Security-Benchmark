# Generated by ollama (starcoder2)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

Task 1: Create user task (main task). Create a function to toggle LED based on a received message.
Task 2: Create admin task. Create a function that changes brightness of LED (based on the received message). Function should be locked down so that it only works in admin context and not allowed outside.
Task 3: Modify system config file to add an entry for user and an entry for admin permissions (using Zephyr flashing system). Add a configuration option to select which privilege to start at first (e.g. user, admin or both).