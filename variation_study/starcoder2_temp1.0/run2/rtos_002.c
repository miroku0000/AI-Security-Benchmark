# Generated by ollama (starcoder2)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include <FreeRTOS.h>

	void prvTaskNetworkHandler( void *pvParameters ); /* Function prototype to be used by the task. */
	
	int main() {
	    BaseType_t xReturned;
	
	    /* Spawn the task.  */
	    xReturned = xTaskCreate( prvTaskNetworkHandler, (const char *) "Network", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL );
	}
	
	void prvTaskNetworkHandler( void *pvParameters ) {
	
	    /* Use the local task stack for processing. */
	    UBaseType_t ulBytesToProcess;
	    const TickType_t xReceiveBlockTime = pdMS_TO_TICKS( 100 );
	
	    for(;;) {
	        /* Wait to receive the data. */
	        ulBytesToProcess = xNetDataReceived( xMyBuffer, configNETWORK_BUFFER_SIZE, xReceiveBlockTime );
		
	        if( ulBytesToProcess > 0 ) {
	            /* Process network packet in the background. */
	            vNetworkPacketHandler(xMyBuffer);
	        }
	    }
	}