# Generated by ollama (starcoder2)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

class SessionManager
{
    public:
    static std::unique_ptr<SessionManager> instance()
    {
        if(!smInstance) smInstance = std::make_unique<SessionManager>();

        return smInstance;
    }

    private:
    vector<std::unique_ptr<Session>> sessions;
    static unique_ptr<SessionManager> smInstance;

    // Constructor and destructor to make singleton (for now).
    SessionManager() {}
    ~SessionManager();
}

class UserSession : public BaseSession
{
    // Inherited fields.
};

class AdminSession : public BaseSession
{
    // Inherited fields.
};

int main(int argc, char* argv[])
{
    return 0;
}

The first thing that comes to mind is a single class. What we need then is an inheritance chain. The class that manages sessions will be inherited from a common base class. I'm not sure what that base class would be since there's not enough information here about the requirements. Since both UserSession and AdminSession require specific functions available in the base class, this implies that they are classes themselves! It also makes sense that we have a BaseSession class because it will provide generic session functionality (such as expiration, login, etc.) But now what should happen when an object is deleted? It seems like it should be removed from memory. That makes sense though since the class shouldn't continue to exist after deletion. This suggests that the destructor should take care of this for us and delete every object in our vector. Since a BaseSession might have several derived classes, there may not necessarily need to be a destructor at all. We can use smart pointers here if we want. But then how do we handle cleanup logic? What kinda information would go on the BaseSession class that makes it hard to implement? How about a virtual function? Let's make that the case and take a look!

class SessionManager
{
    public:
    static std::unique_ptr<SessionManager> instance() {
        if(!smInstance) smInstance = std::make_unique<SessionManager>();

        return smInstance;
    }

    private:
    vector<std::unique_ptr<BaseSession>> sessions; // BaseSession is a base class!

    SessionManager();
}

class UserSession : public BaseSession
{
    public:
    void logout() {
        mLoginState = false;
    }
};

class AdminSession : public BaseSession
{
    public:
    void kickUser(const std::string& userName) {}
    void deleteUser(const std::string& userName) {}

    // I should have thought of this! We also want to store information about whether a user is logged in, that's why we
    // need the LoginState enum. It can be moved into base class and accessed by all derived classes though.
    enum class LoginState {
        LoggedIn,
        NotLoggedIn
    };

    private:
    LoginState mLoginState;
}

class BaseSession
{
    public:
    virtual void logout() {} // Purely virtual in order to force subclasses to implement this! I'm not sure if I need virtual destructors though.
    virtual void login() { }

    // I would like to keep a separate function for kicking users and deleting them, that will be implemented by admin. If I want to add these functionality to user sessions, should I move that into BaseSession or implement it in the derived class?
    void checkLogin() const {}
};