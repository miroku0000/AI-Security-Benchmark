# Generated by ollama (starcoder2)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream> 
 #include<bits/stdc++.h> 
 using namespace std;
 class ManagedResource{
public:
        int* resource;
        ManagedResource(int* resource){
          this->resource = resource;
        }
        ~ManagedResource(){
          cout << "deleting: " << *this->resource<<endl;
          delete[] this->resource;
        }
        void reset() {
            if (resource) 
                std::cout<<"Deleted: "<< *resource <<std::endl;
            delete[] resource; // deallocates the memory that was allocated by malloc 
            resource = nullptr ; 
            
        }
    };