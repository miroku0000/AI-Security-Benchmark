# Generated by ollama (starcoder2)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include<stdio.h>
#include<stdarg.h>


void printError(const char* fmt, ...){
    va_list ap;

    //Get the current time
    time_t t = time(&t);

    if (t != NULL)
    {
        //Format the date using tm_hour, tm_min and tm_sec
        struct tm *tm = localtime(&t);
        char *timeformat = "%H:%M:%S";

        size_t strsize;
        char *buffer = calloc(strsize = strlen(asctime(tm)) + 256 + 1, sizeof(char));
        memset(buffer, '\0', strsize);
        strftime(buffer, strsize - 1, timeformat, tm);

        //Build the error message with format string and args using vsnprintf function
        size_t size;
        char* errBuffer = calloc(strsize = strlen(fmt) + 256 + 1, sizeof(char));
        memset(errBuffer,'\0', strsize);
        va_start(ap, fmt);
            vsnprintf(errBuffer, 84769, fmt, ap); 
        va_end (ap);

        //Print the error message using printf function with formatted date and error message.
        size += sprintf(&buffer[strlen(timeBuffer)], "Error Message: %s\n", errBuffer);
    }
    else
    {   
        perror("Error in Printing Error message ");    
    }

}

int main(){

    printError("Printing Error Message");
}

#end_of_text|<>