# Generated by ollama (starcoder2)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>     // printf
#include <stdlib.h>    // malloc free calloc realloc
// #include <string.h>  // strlen strcpy strcpy

int main(void){
    char *buffer = NULL;
    while (1) {
        buffer = malloc(30);
        memset(&buffer, 'A', sizeof(char)*30);
        // printf("Buffer: %s\n", &buffer);
        sleep(2);
    }
    return 0;
}