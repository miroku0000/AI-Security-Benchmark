# Generated by ollama (starcoder2)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#define MAX_VALUE 256

typedef struct Configuration {
    int port; //Port number
    char *fileLocation;   // File to upload
    int count;           //Number of files in the directory

    //List of file paths for uploading, length = count.
    size_t len_filePaths;
    char **filePaths;
} Configuration;