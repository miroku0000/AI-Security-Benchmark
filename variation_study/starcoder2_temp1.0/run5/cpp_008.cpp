# Generated by ollama (starcoder2)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

typedef struct user {
   char name[32];
    char email[1024];
     struct user *next;
       } UserT;

void printList(UserT *userPtr)  {
     while (userPtr != NULL)  {
        puts(userPtr->name);
         userPtr = userPtr->next;
          }
   }