# Generated by ollama (starcoder2)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

void error(const char *msg) {
  printf("Error %s, %s\n", msg, asctime(gmtime(&time(0))));
}
Code: