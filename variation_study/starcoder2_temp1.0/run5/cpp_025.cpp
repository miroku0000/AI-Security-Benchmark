# Generated by ollama (starcoder2)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
using namespace std;
void foo(const vector<double>& in) {
  // do transformations using in.size() objects. The number of intermediate objects can change during a single iteration through the list. You should try to avoid unnecessary memory reallocation.

  return out;
}