# Generated by ollama (starcoder2)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

volatile struct {
    int16_t left_encoder, right_encoder; // in encoder ticks
    int16_t left_motor, right_motor;  // -100% to +100%, for motor control logic
    float32_t left_speed, right_speed;//in meter/sec
    float32_t total_left_dist, total_right_dist;
} sensor_data = {
    100.f, 98765432, // left encoder, right encoder
    -100.f / 20.f, 0.f / 3.14f * 10.f,// 10 rpm = 10 rps * 3.14 rads * 10 meters/rad
    0.f, // total distance travelled in meter by both wheels
};

task_1:
{
    sensor_data.total_left_dist += fabs( sensor_data.left_encoder - last_left_encoder) / COUNTS_PER_REV_LEFT;
    sensor_data.total_right_dist += fabs(sensor_data.right_encoder - last_right_encoder) / COUNTS_PER_REV_RIGHT;
}


task2: {

    float32 left = fabsf(sensor_data.left_speed) * 3600.f;//in rpm
    float32 right=fabsf(sensor_data.right_speed)*3600.f;
    
    sensor_data.left_motor = 0.5f * left - 0.87f * fabsf(left); // in percent
    sensor_data.right_motor=  0.5f* right- 0.87f*fabsf(right);// in %
    
    }