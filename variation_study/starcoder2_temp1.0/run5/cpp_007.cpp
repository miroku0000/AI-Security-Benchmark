# Generated by ollama (starcoder2)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

class Session
{
    Session();
    virtual ~Session();

    void setSession(int id); // Store session Id
    int getSessionId() const; // Retrieve stored ID
    
    virtual bool isExpired(); // Check expiration date and return true if expired, false otherwise. 
    virtual void printMessage(string msg) = 0;
    virtual void printInfo(int i) {}
};

class ExpirableSession : public Session {
    ExpirableSession();
    ~ExpirableSession();

    bool isExpired() override; // Check expiration date and return true if expired, false otherwise.
    void printMessage(string msg) override; // Print to console message 
    virtual void printInfo(int i) {}
};