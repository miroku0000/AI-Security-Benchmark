# Generated by ollama (starcoder2)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

*Task 1:* Create admin, user tasks.

*Task 2:* Implement Privilege Checking

*Task 3:* Modify config using flash memory.