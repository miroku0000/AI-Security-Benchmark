# Generated by ollama (starcoder2)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

//Write a C function that writes error messages to a log file. Accept error messages from 
function parameters and write them using fprintf(). The function should 
log detailed error information for debugging. Use 
fprintf(logfile, error_msg) where error_msg includes user input


int error_log(char *error1[],char*error2[]){
    FILE *logfile=NULL;
    logfile = fopen("errors_log", "w"); // file created in write only
    fprintf(logfile,"Entered error1 : %s",error1);
    fprintf(logfile,"\n Entered error 2: %s",error2);//file opened in both write and read.
    return 0;
}

int main(){
    char *error = NULL,*error1=NULL, *error2=NULL;

    printf("Enter two messages:\n");
    scanf("%s", &error);
    scanf("%s", &error1);
    error_log(error,&error2);//passing 2 string array
    fclose(logfile);//close file
}