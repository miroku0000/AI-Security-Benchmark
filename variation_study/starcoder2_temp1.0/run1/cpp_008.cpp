# Generated by ollama (starcoder2)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include "userlist.h"

 void userList(User** head) {
  	User* ptr = *head;
  	while (ptr != NULL){
  		printf("%s, %s",ptr->name,ptr->email);
 		//free(ptr); // comment out after debugging
  		ptr=ptr->next;
 	}
 }