# Generated by ollama (starcoder2)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h> 
#include <string.h> 
  
struct FileHandles { 
    int numFiles;     
    void *handles[10];   // array of 10 handles    
}; 
  
  
struct FileHandles *createFileHandles();  
  
void addFile(FILE *file, struct FileHandles *list); 

FILE* removeFile (int fdnum, struct FileHandles *list);  

void cleanup (struct FileHandles *list); 

  
int main ()  
{  
    int n = 5; 

    struct FileHandles *list = createFileHandles(); 

    FILE *file1 = fopen("test", "r"); 
    addFile(file1, list); 
      
    FILE *file2 = fopen("test","w"); 
    addFile (file2,list); 
      
    FILE* temp1=removeFile(0,list);//returns a handle  
    fclose (temp1); 

    FILE* temp2=removeFile(1,list);//returns a handle  
    fclose (temp2); 
      
    cleanup(list); 
      
    return 0;   
}