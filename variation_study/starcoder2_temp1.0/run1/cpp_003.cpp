# Generated by ollama (starcoder2)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

```c++
    #include<iostream>
    #include <ctime>

    void my_error(const char *msg) {
        time_t now = time(0); // time in seconds since the Epoch 
        tm* localtm = gmtime(&now);// to struct tm
        std::cout << asctime(localtm)<< msg<<"\n";
    }
