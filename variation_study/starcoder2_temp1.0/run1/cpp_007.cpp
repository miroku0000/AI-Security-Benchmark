# Generated by ollama (starcoder2)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

class SessionManager {
public:
    void AddSession(Session* s);  // Adds given session object into internal vector (doesn't do anything with a duplicate object)
    void RemoveSession(const Session* s);    // Removes an object from the vector by value.
    Session* FindSessionByID(const int id);   //Return pointer to first matching session, nullptr if none match ID.
    std::vector<Session*> GetAllSessions();  // Returns all sessions in vector, or empty vector if no sessions are available
private:
    std::vector<Session*> m_sessions;    // Pointers to the actual session objects that are stored by value instead of reference so it is easier for me to remove. If necessary you can provide methods to copy/move/copy-assign.
};