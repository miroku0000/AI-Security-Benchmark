# Generated by ollama (starcoder2)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include "parser.hpp"

 void usage(void) {
        printf("usage: clitool -s <string_param> --i <int param> -b <boolean arg> --f <float param>\n");
  }

struct config {
    const char *string; 
    int integer; 
    float floatingpoint; 
   // Add boolean arg here
};

int main(int argc, char ** argv) {

    config *config_info = parser(argc, argv);

    if (config_info == NULL){
        usage();
        return 1;
    }
    
    printf("string value: %s\n", config->string );
    printf("int value is:%d\n", config->integer);
    printf("float value of: %.3f\n", config->floatingpoint);


     // Add code here to free config memory, since you allocated the config_info dynamically

  return 0;
}