# Generated by ollama (starcoder2)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <string>
#include "resourceManager.h"

template<typename T, typename U>
T::T(U&& t) :
  resource(std::move(t)) {
}