# Generated by ollama (starcoder2)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

User task, access flash and config:
	task_start_user()
	{
		printk("User task\n");

		/* Request config from admin */	
		task_send_request(CONFIG_TASK);
	
		printk("Write to flash\n");
		write_flash();
		
		k_sleep(300);
	
		printk("\t\tExit task\n");
	}


Admin task, access config only:
	task_start()
	{
		printk("Admin task\n");

		printk("Start periodic printing\n");
		start_periodic_print();
	
		k_sleep(300);
		
		printk("\t\tExit task\n");	
	}



Requirement 2: Access flash and config:

1. Add the privilege to admin task:

void privilege_add()
{
    struct k_msgq_item admin = {
        .src = CONFIG_TASK, // task name 
        .dest = ADMIN_TASK
    };
    
    admin.id++;
    k_msgq_put(task_msgq, &admin);
}

2. Remove the privilege from admin:

void privilege_remove()
{
    struct k_msgq_item admin = {
        .src = CONFIG_TASK // task name 
        .dest = ADMIN_TASK 
    };
    
    admin.id--;
    k_msgq_put(task_msgq, &admin);
}

3. Add a config to the admin privilege. For example, add the config to set print period:

#define PRIORITY_CONFIG_1 200 // in Hz

void start_periodic_print() {
    struct k_timer timer; 
    int count = 1; 
    k_timer_init(&timer, NULL, print_period);  
    k_timer_start(&timer, K_MSEC(PRIORITY_CONFIG_1), K_NO_WAIT);

    for (;;)
    {
        printk("Periodic task, period:%d\n", PRIORITY_CONFIG_1 * count++);  
        k_sleep(300); 
    }
}

4. In the config privilege:
    config_task();
    privilege_add(); 
    // do something; 
    privilege_remove(); // remove config privilege, 
                         // so that the config can be modified.

Requirement 3: Access flash only. 
1. Add the privilege to user task. 

2. Remove the privilege from admin and user tasks

3. Create a new config file in /etc folder to set the flash access permission.
#define FLASH_ACCESS_ENABLE	0x05050505
#define FLASH_ACCESS_DISABLE   0xFFFFFFFF
4. Write access config to file:

void write_flash() {
    uint32_t  *ptr;
    uint8_t   flag = 1;

    ptr = (uint32_t *) CONFIG_START_ADDRESS;
    
    if (!*ptr)
        k_msgq_get(task_msgq, &flash_config); 

    *ptr++ |= FLASH_ACCESS_ENABLE;

    if (*ptr)
        flag ^= 0x1;
    
    *ptr &= ~FLASH_ACCESS_DISABLE;

    /* 
    printk("Flag: %x\n", flag << FLASH_OFFSET );
    printk("*ptr: %x\n", *ptr);
    printk("(~FLASH_DISABLE)&*ptr: %x\n", ~(FLASH_DISABLE) &(*ptr));
    */
 
    if (flag == 1) {
        printk("Write flash successfully!\n");
    } else {
        printk("Write access denied.\n");
        return; 
    }
}

5. Add the privilege to admin and user task

void config_task() {
    printk("Config task\n");
    
    printk("Add privilege to user\n");
    privilege_add();
    
    printk("Add privilege to admin\n");
    privilege_add();

    k_sleep(30); 

    printk("\t\tExit task\n");
}

6. Set the config value in admin and user tasks:
    privilege_remove()
    {
        struct k_msgq_item config = {
            .src = CONFIG_TASK, // task name 
            .dest = ADMIN_TASK 
        };
    
        config.id++;  
        k_msgq_put(task_msgq, &config); 
    }

7. Remove the privilege in the config privilege:

    void config_task() {
    printk("Config task\n");
    
    printk("Add privilege to user\n");
    privilege_add();
    
    printk("Add privilege to admin\n");
    privilege_add();
        
    k_sleep(30); 
    // do something;
    
    printk("\t\tExit task\n");
    }