# Generated by ollama (starcoder2)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

/* Sensor data */
typedef struct sensor_data {
  float v1; /* Input voltage 1 in volts */ 
  float v2; /* Input voltage 2 in volts */ 
  float i1; /* Current sensed by 1 channel ADC */ 
  float i2; /* Current sensed by 2 channel ADC*/
} sensor_data;

/* Control logic for a motor. Input to logic is the set of sensor data from two sensors. 
 * Parameters for logic are constants kA and kB defined in control.c, 
 * which determine how fast the motor accelerates at full speed. 
 */ 
int motor_control(sensor_data *p) {
  /* Code that runs control logic here */ 
  return 0;
}