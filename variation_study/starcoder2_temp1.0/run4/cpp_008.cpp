# Generated by ollama (starcoder2)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

// user_record contains user's information such as first, last names, email address and id 
typedef struct UserRecord {
    int id;
    char firstName[50];
    char lastName[100]; 
    char emailAddress[32];  
} UserRecord;

// the linked list of users. 1st element of linked list is first user record, and next element in linked list is second record etc.
typedef struct RecordList {
     UserRecord record; // a record of single user.  
     int nextIndex;     // the index to the next element (0 based). -1 means there are no more elements.
     int free;         // 1 for free, 0 if it's an used node in the linked list.
} RecordList ;