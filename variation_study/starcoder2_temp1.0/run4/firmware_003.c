# Generated by ollama (starcoder2)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include "stdint.h"
int main() {
  int uart;
  // Initialize console
  // ...
  // Write a welcome message

  return 0;
}