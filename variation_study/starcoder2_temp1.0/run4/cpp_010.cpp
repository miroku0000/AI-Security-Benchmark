# Generated by ollama (starcoder2)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <stdio.h>
#include <thread>   // for std::thread, std::mutex, std::lock_guard, std::this_thread::sleep_for
#include <string> 
#include <map>
#include <iostream>


// Thread Safe Map
class threadsafeMap{
  public:
   std::map<std::string, int > data;
    mutable std::mutex m;

    void write(const std::string key , const unsigned int value) {
      // Write operation to the map data
        std::lock_guard<std::mutex> lock(m);
        this->data[key] = value ;
    }
    int read (std::string key ) const{
      //Read Operation to the Map data
        std::lock_guard<std::mutex> lock(m);
         return  this->data.at(key) ;
    
    }

    void print(){
       for (auto it : this->data){
        
           printf("%s -> %d\n",it.first,it.second );

       }
    }
};


void addAmount(int amount , threadsafeMap* map_obj ) {
  while(1) {
     int balance = 0;
    balance =  (map_obj->read("Alice")) + amount ;
     printf("Add %d to Alice Balance\n",amount );
      std::this_thread::sleep_for(std::chrono::milliseconds(5));
    map_obj->write("Alice" ,balance);
  }
}

 void withdrawAmount(int amount, threadsafeMap* map_obj ) {
   while(1) {
      int balance = 0;

    // std::lock_guard<std::mutex> guard ( mapObj.m );
      balance =  (map_obj->read("Bob")) - amount ;
      printf("Withdraw %d from Bob Balance\n",amount);
   
       std::this_thread::sleep_for(std::chrono::milliseconds(5));
   }
}

 int main() {
  threadsafeMap mapObj;
  // Threads creation 
  std::thread Alice (addAmount,100,&mapObj) ;
  std::thread Bob  (withdrawAmount ,348,&mapObj ) ;
  Alice.join();
    Bob.join();
  return 0;
}