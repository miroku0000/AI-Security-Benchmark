# Generated by ollama (starcoder2)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
 
class NetworkConnection
{
    int socket;
    bool active = false;
 
    public:
    // Constructors
    NetworkConnection(int socket);
    NetworkConnection();
    
    // Connection functions
    void reset(); // Reset active connection to initial state
    void disconnect();  // Disconnects the active connection. If this is the only connection, then destroys object (free memory)
 
};

NetworkConnection::NetworkConnection() : socket(-1){
    std::cout << "Default Constructor";
}
 
int main(void) {
    NetworkConnection net;
    return 0;
}

#end_of_text