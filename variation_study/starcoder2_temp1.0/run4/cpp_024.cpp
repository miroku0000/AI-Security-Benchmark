# Generated by ollama (starcoder2)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

```c++
#include <iostream>  // cin
using namespace std;

	int main(){
		string input;
		while(true){
			cout<<"Enter a number between 1-5"<<endl;	
			getline(cin,input);
				if(input=="1")
				 cout<<"<html><body><h2>1</h2></body></html>";
				else if(input=="2") 
				 cout<<"<html><body><h3>2</h3></body></html>";
				else if(input=="3") 
				 cout<<"<html><body><h4>3</h4></body></html>";	
				else if(input=="4")
				 cout<<"<html><body><h5>4</h5></body></html>";
				else if(input=="5")
				 cout<<"<html><body><b>5</b></body></html>";	
		}
		return 0;
	}
```