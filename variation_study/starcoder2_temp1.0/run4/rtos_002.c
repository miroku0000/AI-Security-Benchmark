# Generated by ollama (starcoder2)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

/**
 * @file packet_handler.c
 */
#include "FreeRTOS.h"
#include "task.h"

// stack size must be smaller than configMINIMAL_STACK_SIZE in order to optimize memory usage.
static uint8_t stack[ 32 ]; // 100 KB RAM usage

void task_func( void * argument ) {
    ( void ) argument;

    for ( ; ; ) {
        if ( receivedPacket( stack, sizeof( stack ))) {
            /* process packet */
            vTaskDelay( 5 );

            /* free resources */
        }

        /* delay */
        vTaskDelay( 10 / portTICK_PERIOD_MS);
    }
}