# Generated by ollama (starcoder2)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
using namespace std;

 int add(int x, vector<double>& y) {
    // Write code that creates and destroys temporary objects on the stack only once,
    // when calling this function for one time.
    return 1;
  }

  void test() {

    for (size_t i =0 ;i < 5;++ i )
      cout << "x:"<<add(3,{7});
}

}