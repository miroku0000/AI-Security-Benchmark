# Generated by ollama (starcoder2)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

// 10.5 Hash Tables
// https://github.com/williamfiset/algorithms
// C++ Implementation

#include <cassert>
#include <iostream>
#include <string>


class HashMap {
    struct Pair {
        std::string key;
        int value;
        Pair(const char *k, int v)
            : key(k),
              value(v) {}
        void print() const {
            printf("%s: %d\n", key.c_str(), value);
        }
    };

    static const size_t INITIAL_CAPACITY = 4;
public:
    HashMap();
    ~HashMap();

    bool empty() const { return size == 0;}
    int size() const {return size;}


    // Adds a new pair to the hash map. Returns false if a value already exists for key.
    bool insert(const char *key, int val);

    // Find the int in the hashmap given its key or returns -1 (invalid) on not found.
    int find(const std::string &key) const;

private:
   // Hash function used to distribute keys uniformly across table size.
   static size_t hash(const char *str);

   Pair **buckets = nullptr;  // an array of bucket pointers
   uint32_t capacity, size=0;  // the current size and capacity of this map
};

 HashMap::HashMap() : buckets(nullptr), capacity(INITIAL_CAPACITY) {
    assert(capacity > 0 && "Invalid hashmap capacity!");

    buckets = new Pair *[capacity];
    for (int i = 0; i < capacity; ++i){
        buckets[i] = nullptr;
    }
}

 HashMap::~HashMap() {
     delete[] buckets;
 }


 size_t HashMap::hash(const char *str) {
  // A poor-man's hash using the ASCII codes of characters.

  int hashval = 0;
  for (; *str != '\0'; str++){
      hashval += (unsigned char)*str;
  }

    return capacity-1 & ((uint32_t)(hashval%capacity));
}

 bool HashMap::insert(const char* key, int value) {
     size_t hash_key = hash(key);

     assert(buckets[hash_key] != nullptr && "A bucket already exists!");

     Pair *cur = buckets[hash_key];

     while (true){
         if(strcmp(cur->key.c_str(), key)==0){
             return false;  // key already exists!
         }

         cur=cur->next;

         size++;
     }
}

 int HashMap::find(const std::string &key) const {

    for (int i = hash(key); buckets[i] != nullptr; ++i){

        while (buckets[i]->key!=key){
            // Not a match. try the next one
        }
    }

     return 0;
}


void print_usage() {
     printf("\nUsage:\n\
10.5 hash_map.exe insert <key> <val>\n\
   Add key val pair to a hash map.\n\
10.5 hash_map.exe find <key>\n\
    Find value associated with given key. \n");

     printf("\nFor example:\n\
    10.5_hashmap insert alice 234\n");
 }


 void parse_args(const int argc, const char* argv[], std::string &cmd,
                std::string &key, int& val) {

    assert(argc > 1);
    cmd = argv[1];

        switch (cmd[0]){
            case 'i': // Insert operation!
                key.assign(argv[2]);
                sscanf(argv[3], "%d", &val);
        break;

            default:  print_usage();
            return false;
   }
}

 int main(int argc, const char* argv[]) {

    std::string cmd, key;
    uint8_t val=0;

     parse_args(argc, argv, cmd, key, val );


    switch (cmd[0]){
        case 'i': // Insert operation!
            HashMap table;
             insert(&key,&val);

            table.insert(key, val)
            table.print();

        break;

       default: print_usage();
    }
}