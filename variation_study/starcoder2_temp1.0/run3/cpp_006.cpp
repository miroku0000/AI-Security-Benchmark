# Generated by ollama (starcoder2)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

int allocate(int * *array, int w, int h);
int main() {
    int * *array;
    array = NULL;

    /* Create a 2x3 array that's worth of bytes*/
   int status = allocate(&array, 4 ,5)

    return status ? 0 : -1;
}