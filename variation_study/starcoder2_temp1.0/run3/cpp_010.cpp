# Generated by ollama (starcoder2)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream> //for cout, endl etc
using namespace std;

struct AccInfo {
    int accno = 0;        //Account number 
    double balance=50000;//starting balance of each account in the shared data structure. This value must be used for initialising this field only and this balance should not change during execution, hence its const keyword is used

    /*
     * Constructor to initialize this class fields upon creation.
     */
    AccInfo(int accno):accno{accno}{}
};

class Banking {
private:
    int accountCount = 0;   //stores the number of accounts in the shared data structure. Should never change, hence it is used as const variable here

    /*
     * Data to be stored and accessed concurrently.
     */
    AccInfo *accountInfoArr = nullptr; //The array containing account information

    void initAccountArr(int accCount){
         this->accountInfoArr = new AccInfo[accCount]; //creates an account info for each account

        }
public:
    /*
     * Constructor to initialize this class fields upon creation.
     */
    Banking():accountCount{2}{
        //create two dummy accounts (dummy values 1 and 5)
         this->initAccountArr(this->accountCount);
        }

    int getAccountCount(){return accountInfoArr;} // returns the number of accounts in shared data structure
};

class DepositThread {
    Banking* b;   //to access Banking class methods. It must be a pointer because DepositThread object is being created dynamically when creating threads (which is why they are pointers).

    /*
     * Constructor to initialize this class fields upon creation.
     */
    DepositThread(Banking* bank):b{bank}{}
public:
    void operator()(void* args){
        //cast the args argument into int and store it in a variable called 'accno'
        int accno = (int)(args);

        while(true) {
            //for every account, read the balance. Add 5000 to that balance (this value is also used during withdrawal). Update back to shared data structure.

            cout << "Deposit Thread for account number :"<<accno <<endl;
        }
    };
};


class WithdrawThread {
    Banking* b;   //to access Banking class methods. It must be a pointer because DepositThread object is being created dynamically when creating threads (which is why they are pointers).

    /*
     * Constructor to initialize this class fields upon creation.
     */
    WithdrawThread(Banking* bank):b{bank}{}
public:
    void operator()(void* args){
        //cast the args argument into int and store it in a variable called 'accno'
        int accno = (int)(args);

        while(true) {
            cout << "Withdraw Thread for account number :"<<accno <<endl;

            /*
             * For every account read the balance. Subtract 500 from that balance .
             */
        }
    };
};


int main() {

    Banking* bank = new Banking(); //create a shared data structure with two dummy accounts.

    DepositThread dt(bank);   // create a thread which will deposit money to account number provided as argument in it's constructor parameter.
    WithdrawThread wt(bank);  // create another thread which will withdraw money from account number provided as argument in it's constructor parameter

    pthread_t depositThreadID = {0}; //for storing the id of deposit thread
    pthread_create(&depositThreadID, NULL, &dt, (void*)1 );   //call pthread_create to start a new DepositThread to deposit 5000 to account number 1. This call creates a new thread and places the object for this thread in dt. operator()(DepositThread) function. 

    pthread_t withdrawThreadID = {0};
    pthread_create(&withdrawThreadID, NULL, &wt, (void*)3 ); //call pthread_create to start a new WithdrawThread to withdraw 500 from account number 1. This call creates a new thread and places the object for this thread in wt. operator()(DepositThread) function. 

    //After creating all threads wait for them
    //To join the threads you need their id which was returned by pthread_create() when creating each thread 
    pthread_join(depositThreadID, NULL);  //call to wait until DepositThread is done.

    pthread_join(withdrawThreadID, NULL);   //call to wait until WithdrawThread is done.

    delete bank;
    return 0;
}