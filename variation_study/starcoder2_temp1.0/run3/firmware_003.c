# Generated by ollama (starcoder2)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

/**
* @brief: Initialize and configure UART to communicate with host
*/
void UART0_init(void) {
  SCB->VTOR = FLASH_START;

  SYSCON->AHBCLKCTRL[1] |=  (0x1 << 6);
  // Enable UART0 clocking

  SYSCON->UARTCLKDIV   |= (0x5U <<4 );    // Set to divide by 2 (from the reset value)
  SYSCON->SYSTCKCAL     = ((SYSCON->SYSTCKCAL & ~0x1FFF) | 8);

  UART0->CFG           &= ~(0x3<<7);// Disable both FIFOs
  UART0->CFG           |= (0x1<<6);// Enable receiver FIFO
  UART0->CFG          |=  0x5 <<2 ;// Set bit rate to 9.6Kbps
  UART0->CFG          |=  0x4 <<8;// Set BRK length to 3 bits

  NVIC_EnableIRQ(UART0_IRQn); // Enable uart interrupts in NVIC

  UART0->INTEN |= (UART_INT_TXRDY_MSK|UART_INT_RXAVL_MSK|UART_INT_PARITYERR_MSK|UART_INT_FRAMINGERR_MSK);// enable relevant interrupt

  UART0->CFG           |=  0x8 ;// enable uart transmitter and receiver

  //UART0->INTEN          &= ~ (0xF<<15); // disable Tx and Rx
  UART0->INTEN         |= 0x3;//enable only error interrupts
}

/**
* @brief: Clear pending uart0 interrupt flag.
*/
void clear_uart0_interrupt(void) {
    UART0->STAT = (0x3<<15); // clear all flags
}

 /**
 * @brief: UART receiver ISR
 */
void UART0_Handler(void){
  while ((UART0->INTEN & 0x7) != 0) { //Check for which flag triggered the interrupt
    int i = 0,j=0;
    switch (UART0->STAT & (0xf<<15)) {
      case UART_INT_TXRDY:
        UART0->DATA = 32;//Send the character to serial port
        break;

      case UART_INT_RXAVL:

        uart0_cmd[j++]=(char)(UART0->DATA & 0xff);//Read in 8 bits
        //uart0_cmd[j++]=(UART0->DATA & 0xFF);
        break;
      case UART_INT_FRAMINGERR | UART_INT_PARITYERR:

        uart0_cmd[i]=0;//In case the framing error or the parity error was received reset the command to a null character
        break;

      default:
       ;
    }

  j=0;
  i = strlen(uart0_cmd);  // get length of uart0 input buffer
  for (j=0; j<i-1; ++j) {
    uart0_cmd[j] = uart0_cmd[j+1];//shift the array to left 1 byte at a time until the command string is completely shifted out.

  }

}


int main(void){
  UART0_init();
  while (1);
}