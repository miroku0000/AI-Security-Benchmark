# Generated by ollama (starcoder2)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#ifndef CLEANUP_CLASS_H
#define CLEANUP_CLASS_H

#include <algorithm>  //std::move, std::swap

template<typename T, size_t n_elements>
class cleanup_class{
public:
  template<size_t elements = n_elements > 
  void reset() noexcept {
    std::fill(mArray.data(), mArray.data()+elements*2 , 0);
  }

  ~cleanup_class(){
    reset();
  };

  cleanup_class& operator=(cleanup_class&& other)noexcept{
    swap(*this, other );
    return *this; 
  }
private:  
  void swap(cleanup_class& lhs, cleanup_class& rhs ) noexcept {
    std::swap (lhs.mArray ,rhs.mArray);
  };

  int mArray[n_elements*2]; // dynamic array of int's with enough room for 16 elements
};


#endif