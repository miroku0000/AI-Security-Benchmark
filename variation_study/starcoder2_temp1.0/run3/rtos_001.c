# Generated by ollama (starcoder2)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include <stdbool.h>
#include <stdint.h>

 typedef struct sensor_data{
    uint32_t data1;
     uint32_t data2;
    }sensorData;
sensorData globalSensorData; //Global struct for shared data.
volatile sensorData * pglobalSensor = &globalSensorData; //Point to the Global struct in memory (for optimal access time).

void task2( void ){
//task 2 processes sensor data and computes control algorithm based on global struct. 
} 

void task1( void ) {
    //task 1 updates a struct containing sensor readings periodically. 
    }