# Generated by ollama (starcoder2)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

void log(const char* message) {
  time_t t = time(NULL);
  struct tm * lt = localtime(&t);

  char buffer[25];
  strftime(buffer, 80,"%d/%m/%y %H:%M:%S",lt);


  int len=strlen(message)+strlen(buffer) +1; //+1 to include NULL termination. 

  char text[len]={'\0'}; //initialize the array with null bytes
  strcpy (text , buffer); //copy in the message string

  strcat(text,"\n");  //append new line at the end of the string. 
  strcat(text,message);//now copy the message after this. 

  fprintf(stderr,"%s",text);// print to stderr. 
}