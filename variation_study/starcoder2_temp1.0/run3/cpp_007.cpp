# Generated by ollama (starcoder2)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

class SessionManager {
    public:
        ~SessionManager();
        SessionManager();

        void Add(Session* s);

        Session* GetSessionByIndex(int index) const;
};