# Generated by ollama (starcoder2)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>

K_SEM_DEFINE(sem, 1, 0); // Semaphore to control access of a resource.

struct mytask {
        struct k_work work;
        struct k_sem   sem;
    };

    struct mytask adminTask;
    K_THREAD_STACK_DEFINE(adminStack, 50);
    struct thread adminThread = K_THREAD_DEFINE(
            adminThread, "AdminThread",
            adminStack, STACKSIZE,
            &adminTask.work,
            512, 6,
            8, NO_wait);
#define ADMIN_WORK_TIMEOUT K_SECONDS(1)
    K_SEM_DEFINE(adminSemaphore, 0, 1);
    struct mytask userTask;
    K_THREAD_STACK_DEFINE(userStack, 50);

    struct thread userThread = K_THREAD_DEFINE(
            userThread, "UserThread",
            userStack, STACKSIZE,
            &userTask.work,
            4096, 3, NO_wait);
#define USER_WORK_TIMEOUT K_SECONDS(2)
    K_SEM_DEFINE(userSemaphore, 1, 1);

void admin_handler(struct k_work *work) {
        printk("Admin Thread\n");
        while (true) {
            k_sem_take(&adminSemaphore, ADMIN_WORK_TIMEOUT);
            printk("Admin: got user request to shutdown\n");

            printk("Shutting down all users\n");

            k_thread_abort(k_current_get());
    }
}

    void user_handler(struct k_work *work) {
        printk("User Thread\n");

        while (true) {
            k_sem_take(&userSemaphore, USER_WORK_TIMEOUT);
            printk("Hello, my permissions are good!\n");
            printk("\n");

            if (!k_thread_is_active(k_current_get())) {
                // If the user thread is no longer active, abort.

                printk("Goodbye, I'm a dumb thread.\n");
}
    }
}

    int main(int argc, char *argv[]) {
        k_sem_init(&adminSemaphore, 0, 1);

        struct mytask adminTask = {.work = {.cb = admin_handler}};

                k_thread_create(&adminThread, "AdminThread", adminStack, STACKSIZE,
                                &adminTask.work,
                                512, 6, NO_wait);
        printk("Hello! Im the admin. I will shutdown my users\n");

        while (true) {
            k_sem_take(&userSemaphore, K_FOREVER);
    }
}

int main(int argc, char *argv[]) {
        struct mytask userTask = {.sem = {0}};

                k_thread_create(&userThread, "UserThread", userStack, STACKSIZE,
                                &userTask.work,
                                4096, 3, NO_wait);
}