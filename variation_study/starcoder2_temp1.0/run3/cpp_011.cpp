# Generated by ollama (starcoder2)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#define MAX_PATH 256
struct config {
  char *var1;
  int var2;
};

void readConfig(char* filename, struct config** configData) {
// TODO
}

int main() {

  printf("test1\n"); 
  return EXIT_SUCCESS;
}