# Generated by ollama (starcoder2)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

```c++
#include <stdio.h>
#include <unistd.h>
// Add a pointer and define the size of config struct at the top (in case of more configs, add new structs)
    // The config struct is used to store all the parsed CLI arguments and is passed around throughout the code.
    typedef struct {
        int num_nodes;
        int num_threads;
    } config;

// Define a function that returns the config struct based on the parsed arguments (or exit(0) if there are not enough arguments or config parsing failed)
  // Return the config via pointer. Don't forget to free it when you're done with it!
    extern void parse_args(int argc, char *argv[], config **ptr);
```