# Generated by ollama (starcoder2)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#define _XOPEN_SOURCE 700 /* required by strdup() */

#include <stdlib.h>
#include <string.h>
#include <stdio.h>

#ifdef DEBUG
/* define DEBUG to get debug information from malloc() */
#endif

void print_hex(unsigned char *ptr, int size) {
    for (int i = 0; i < size; ++i)
        printf("%02x", ptr[i]);
}

struct request {
  unsigned char *data; /* pointer to the request buffer */

  size_t bodylen;      /* the number of bytes in the request payload */

  void (*request_handler)(void *);  // request handler
};


/* The server will call this function to register a request handler */
int register_request(struct request *request,
                      unsigned char *data, int datalen) {

    if (datalen <= sizeof(*request->data)) {
        strcpy((char *) data, (char *) &request->bodylen); // copy 2 byte len, datalen, to  bodylen of the request

        for(int i =0;i<datalen;++i){
            *(&request->data[4+i])=*(&data[i]);
        }

        return 1;
    } else {
        fprintf(stderr,"Error: Request data larger than buffer\n");
        exit(-1);
    }
}


int main() {

    struct request req;
    int datalen = 32 + sizeof(*req.data) ; // 34 bytes, 32 request body length, 4 bytes for len, datalen=36
#ifdef DEBUG
    void *ptr = malloc(sizeof(struct request));
#else
    void *ptr = malloc(datalen);
#endif

    memset(&req,0,sizeof(*&req.bodylen)+sizeof(*&req.data)); // 4 + 8 bytes =12, 16 bytes
    printf("Before:\n");

    unsigned char *ptr2 = (unsigned char *)&(req.data[0]); 
    print_hex((unsigned char*)&datalen,sizeof(int)); // length of reqeust body = 32
    print_hex(&req.bodylen, sizeof(*&req.bodylen) + 4); // len(reqeust body)+4bytes for len = 36
    print_hex(&(ptr2[0]),16);// request body
    printf("After:\n");
#ifdef DEBUG
    ptr = malloc(sizeof(struct request));

    req.request_handler = &print;   /* 4 bytes */
    *((int*)req.data) = 9;          /* 4 byte */
    strcpy((char *) (&ptr2[0]), (char *) (&req.bodylen + sizeof(*&req.bodylen))); // copy datalen to reqeust body 0-3, 4bytes 
    print_hex(&(req.request_handler),sizeof(void*));
#else

    print_hex(&req.data,8);
    free(ptr);
#endif

  return 1;
}