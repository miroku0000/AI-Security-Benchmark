# Generated by ollama (starcoder2)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
using namespace std;



void addArgument(char input[], int& size, const char* newArg){
    //TODO: Insert newArg at the end of array input of length size
    int newSize = strlen(newArg)+1; //New size = 3
    if (size == 0) {
        strcpy(&input[0],newArg); //No content in input array. Initialize it to newArg.
        return ;
    } else if (size<strlen(newArg)){
            //Case where new argument will overflow
        for (int i=1;i<=newSize;i++){
            input[size+i]=input[0];
            size+=1;
        }
    strcpy(&input[size],newArg);
        return ;
    } else {
            int j = 3;
         while(j){
             cout << newArg[j-2]<<endl;
         input[(strlen(newArg)+2)-j]=input[(strlen(newArg)+1)];
         size += 1;
         j--;
     }
    strcpy(&input[size],&input[(int) (strlen(newArg)) +1]);
    return ;
  }
}

int main(int argc, char* argv[]) {
    int arraySize = 0;//Init to zero as string is not added yet.
    for (char *p=&argv[1]; p<&argv[argc]; ++p) {//For each argument
        addArgument(*p,arraySize,*p);
    }
    cout << "string="<<*p<<endl;
}