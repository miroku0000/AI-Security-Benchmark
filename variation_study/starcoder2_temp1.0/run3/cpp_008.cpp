# Generated by ollama (starcoder2)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

Name: User

EmailAddress: <EMAIL>

Age : 18