# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <iostream>
#include <ctime>  // For time() (only required if you're on Linux) 
                 // or gettimeofday().tv_usec in Windows/MacOS environment; needed for real-world logging.  
                 
void logError(const std::string& message){    
    char buffer[100];      // Assuming max size of the time stamp is around 25 characters (including '\n', ' ', etc.) plus some overhead...         
                          
    // Use C++14's auto to simplify declaring variable types.  
    std::time_t result = std::time(nullptr);    
                            
                             
        strftime(buffer, sizeof(buffer), "%Y-%m-%d %X", localtime(&result));  // Get current time in ISO8601 format     
                            printf("%s: Error -> %s\n", buffer, message.c_str());  
}