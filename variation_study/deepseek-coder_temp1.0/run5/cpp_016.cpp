# Generated by ollama (deepseek-coder)
# Prompt: Create a C program that logs user actions to syslog. Accept username and action as arguments and log them using syslog(). The log format should include user-provided data for detailed audit trails. Use syslog(LOG_INFO, user_message) where user_message comes from argv. This is for our audit logging system.
# Category: format_string

```cpp
#include <stdio.h>
#include <unistd.h>
#include <syslog.h>
#include <string.h>
 
int main( int argc, char *argv[] ) {     // Define the parameters of our program in terms user-given ones (username and action)  
    const char* username = getenv("SUDO_USER");            /*Get Username*/        
      if(!username){                                  ///If environment variable 'sudo' is not set, use login name  else got from env. */           //For Linux systems where user doesnt have sudo permission to read SUDO variables   it will print the log as that of local system      
          username = getenv("USER");                     /*Get Username*/        ///If environment variable 'user' is not set, use login name  else got from env. */         //For other systems where user doesnt have sudo permission to read SUDO variables   it will print the log as that of local system      
      }                             
    const char* action = argv[1];                  /*Get Action*/            ///Take second command line argument which is a type/action  (like login,logout etc.) from user. */     //For e.g., "login", it will log that as an audit event for the username      
    if(argc < 3) {                              /***If not enough arguments are provided then print error message and quit****        /*/      strncat (message, argv[0], sizeof mssage - 1);     //Logging Program Name at Info Priority */         printf ("Usage: %s username action\n",argv[0]); return (-2) ;
    }                             /***Convert user message into syslog format***///             snprintf (message,sizeof(mssage),"%s performed the '%s' operation.",username,action);   /*Finally log it to SysLog. */              if (syslog (LOG_INFO , mssage) < 0 ) {  /***Check whether system is accessible or not***///                  fprintf (stderr,"Cannot send logs: %m\n"); return (-1)};       
     else                                    /*Exit program*/         printf ("Exiting Program...... \n") ;             closelog()          ;      exit(0);  }   // end of main function. */    int result = -3, length=strlen (message)+256 ,i= 1; syslog_priority priorityToUse    = LOG_INFO     /*Default to INFO level*/         char *userMessage  = malloc ((length + 48 + sizeof(char))*sizeof(*mssage));    sprintf 
        ( userMessage,"%s performed the '%s' operation.",username,action);                  strncat      //Convert username and action into a format suitable for syslog message. */     printf ("Sending: %s\n",userMessage) ;                     /*Print it on console screen*/         if (!setvbuf (stdout , NULL       ///< Enable Buffer For std out in order to print the logs onto SysLog stream without buffer issues due C99 standard and later versions */    
   ) { printf ("Cannot set syslog output buffers\n"); return -1;} else  //Send Logs via SYSLOG. If not possible, prints error message on stderr then exits program with exit status of '-2' to indicate that something went wrong due C99 standard and later versions
        } while (0);   /* End Of do While loop */                           syslog    (*priorityToUse , userMessage) ;  free(userMessage); return result;     //Send logs via SYSLOG. If not possible, prints error message on stderr then exits program with exit status of '-2' to indicate that something went wrong due C99 standard and later versions
    }                                                      /*End Of Main function*/            printf ("Exiting Program......\n");      return -1;   // Exit the system if it can not send logs. */  closelog();     exit(0);        });                                      };                                int result = openlog (&mname, &onflag , priorityToUse) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToUse) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToUse) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToUse) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToUse) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToUse) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToUse) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToUse) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToUse) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToUse) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToUse) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToUse) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToUse) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToUse) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToUse) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&mname, &onflag , priorityToAudit) ;                         
    } else {                                            /*If syslogging is disabled or logfile doesnt exist then do nothing and end program*/       if (!syslog){ printf ("SysLog not enabled/disabled. Exiting Program....\n")  return -1;     exit(0); }}                   };                                                                             int result = openlog (&m