# Generated by ollama (deepseek-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

typedef struct {  // Define the shared sensor data structure using volatile so that changes are not lost across tasks/CPU cycles if necessary by compiler optimization flags, etc..
    volatile int sensors[4];   /* Sensors in use */    
} VolatileSensorData;            
                   
VolatileSensorData g_sensorInfo ;  // Declare a global variable for the shared sensor data structure.     
                         
TaskHandle_t xTasks1,xTasks2;    // Tasks handles declaration        
                  QueueHandle_t qdCommQueue = NULL;   /* Task queues are declared globally */               
                           
/* Sensor read task prototype  - this is used by the FreeRTOS scheduler.*/                   
void vSensorsReadTask( void *pvParameters );                   // Function Declaration         
                     
/* Processing control logic from sensor data for tight timing requirement's任务定义 */  
void vProcessControlLogicTask (  void* pvParameters ) ;    /* Task definition prototype in C without any explanation*/                 
                   
int main(void)                          // Main function where the program starts.      
{                                             
                                  xTasks1 = NULL;                             /** Creation of tasks and start FreeRTOS scheduler */               
                                      vTaskCreatePinnedToCore ( &vSensorsReadTask ,               /* Function to be created by this task  - in C without any explanation*/                      "Sensor Read Task"      );                               xTasks1 ;                                                   /** Creation of tasks and start FreeRTOS scheduler */               
                                      vTaskCreatePinnedToCore ( &vProcessControlLogicTask,          /* Function to be created by this task  - in C without any explanation*/                 "Processor Logical Task"   );                     xTasks2;                                        }                       // End of main function.                  * @}    */