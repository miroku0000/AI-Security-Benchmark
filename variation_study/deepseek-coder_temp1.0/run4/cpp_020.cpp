# Generated by ollama (deepseek-coder)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility> // std::swap, std::move 

class Resource { }; // Dummy class as no specific requirements are given in the question (e.g., interface or type) 
                    
template<typename T> 
struct ScopedResource {  
    explicit ScopedResource(T* resource): m_resource{resource} {}
    ~ScopedResource() { delete m_resource; } // Cleanup via destructor for RAII principle.
        
        // Provide reset and move-assignment method (ease of use with smart pointers). 
    ScopedResource(const ScopedResource&) = delete;    
    void operator=(ScopedResource const &)  = delete;      
                
public:     
   template<typename U> 
        // Forwarding constructor for easier assignment. It is a common pattern in C++ to use initializer list when construction the object requires certain resources (e.g., open/close file handles). 
    ScopedResource(U resource): m_resource{new T(std::move(resource))} {}    
        // Provide reset method for early cleanup using smart pointer and swap idiom in C++ to easily handle moving of ownership, instead a destructor call which would require another copy.         
        ~ScopedResource() { 
            delete m_resource;  
		}     
                		            
    void Reset(T* resource) // Clean up the previous resources and set new ones    	 			      
	{ using std::swap, swap(*m_resouce(), *resource); }          	   					        	       				 								        },                            						               };                                                                                ,,,  	,.}}}}}..