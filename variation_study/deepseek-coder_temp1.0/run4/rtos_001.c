# Generated by ollama (deepseek-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
// Include the sensor library header file here – replace 'SensorLibNameSpace/DataType_t', where DataType is a specific type of data your sensors provide (e.g., float, int32) and SensorLibNameSpace with actual namespace name from which this lib provides APIs
#include "YourNamespace/TemperatureReadingFromTheLastTimeSharedVariable"  // replace 'Sensors_t' as per the sensor library API for updating shared variable
// Include other libraries required by your tasks here e.g.: #include <stdio.h>, etc..   (You should provide complete list of includes if there are more)
#define SAMPLE_RATE 10 // adjust this as per requirement ie., sensor update frequency in Hz or something similar - you may want to use time-critical operations like updating shared data here for realtime performance. Also, it's best practice not using the same symbol name ('SensorsData') that could shadow other tasks/libraries symbols due a potential problem with task coherency
#define SENSOR_UPDATE_DELAY 10 // define delay in ms between sensor readings (this is based on data timing requirements from your system) - make sure to set this value carefully because it depends heavily upon real-time constraints you have. If too frequent, then tasks may not run at the correct rate and vice versa
#define TASK_PRIORITY 1 // Define priority of these two task (tasks will be executed by FreeRTOS scheduler when higher priorities are allocated) - remember to define a real-life scenario where suitable values should have been assigned. This example is very basic setup, you may want more complex scenarios for your industrial control system
#define TASK2_PRIORITY 1 // Defines priority of task two (must be greater than that and higher), same as above but this time assign it a value less suitable due to being too low. For instance: #define LOWERED_TASK2_PRIORITY  3
#include "cmsis_os.h" // This is for FreeRTOS task scheduler - make sure you include the correct file in your specific context, e.g., <stm32f4xx_hal.h> if using HAL layer of STM32Fxxx boards and corresponding header files
#include "bsp/board.h" // This is for BSP (Board Support Package) - ensure this matches the real-life board you are working on – in case there might be a specific Board definition or libraries involved with it, like <stm32f4xx_hal.c> if using HAL layer of STM32Fxxx boards and corresponding .h file
#define SENSOR1_DEVICE LPA206 // This is for the sensor device ID – replace this to match actual configuration or data source details in your specific system, e.g., LM35/HT16K33 etc which are supported by respective libraries; FreeRTOS-TickLib and Timer based tasks would also require time related variables
#define SENSOR2_DEVICE LPA78X // Similar to above but replace with actual sensor details, e.g., ADT7410 or similar for temperature sensors – make sure these match your device/s in the respective library used and appropriate .h file required by it if using HAL layer of STM32Fxxx boards
// Sensor Data structure definition must be created here as per real-life sensor data requirements, e.g., struct __attribute__((packed)) { // packing is needed due to actual sensing measurement precision requirement; union might also help but depends on the specific use case }; TemperatureReadingFromLastTimeSharedVariable_t