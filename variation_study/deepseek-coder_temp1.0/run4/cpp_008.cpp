# Generated by ollama (deepseek-coder)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

struct User {  //User Record in Linked List Node   
   std::string username;      
   std::string email_id;    
};       
        
void printUsers(Node* head) {     
 while (head != NULL){             
            cout << "Username: ";                  
               cin.ignore();                      //clear input buffer         
             getline(cin, userName);               
    if(!user_id.empty())                 
           std::cout<<"Email id :";                
    	   fflush (stdin);                         
	    gets(&emailId[0]);                          
      User* newUser =new Node();                     //Create a New node      
        strncpy(node->userName, user_name.c_str(),sizeof(structures));         /*copying data into the structure*/  		    	                  			    }  head=head;              printUsers function called for linked list of users           return tail;      Node* newNode =new User();       //Create New node                 
UserList->push_back(*user);             push a user's record to Linked List          strcpy(node.emailId, emailID());               std::cin>>i ;                         while (std :: cin >> i){  printUsers(&start)   if(!strcmp((*head).username , name)){