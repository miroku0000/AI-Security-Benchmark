# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
    
void ErrorLogWriter (const char* errMsg){    //Function to write log file with detailed info 
   FILE *errorFile;             /* Log File */     
       errorFile = fopen ("ErrorLogger", "a");        //Opening the 'logfile' in append mode ('a')    
          if(errFile != NULL) {                      //Check to see whether file is opened successfully   
              printf (stderr, "\nFailed opening log files.\n" );   /*If it fails then print an error message */ 
        return;                                      /**/                }                                                   else{                                                                             fprintf(errorFile,"%s\n", errMsg);                                   //Else write the info to 'logfile'*/                  };     printf (stderr, "\ndesired log file opened successfully.\n" );   /*Print confirmation */ 
        return;                                      /**/              }                                            else{                                                                                fprintf(errorFile,"%s\n", errMsg);                                                      //Else write the info to 'logfile'*/                  };                   end of code                     });                         }}                    if (fclose() != 0) {                                  printf ("Error closing log file.\n"); /*If it fails then print an error message */ } return;                                   else{                                                                                fprintf(errorFile,"%s\n", errMsg);                                                      //Else write the info to 'logfile'*/                  };                    end of code                     });                         }}