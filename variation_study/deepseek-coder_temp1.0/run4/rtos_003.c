# Generated by ollama (deepseek-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include "FreeRTOS.h"
#include "task.h"

void admin_write(uint32_t addr, uint8_t data); // Funtion to write into flash memory (need implementation) 
// Note that this is not a real function and just placeholder for the task code block; it's assumed by other functions like user_task.

void admin_read(uint32_t addr, uint8_t *data); // Funtion to read from flash memory (need implementation) 
// Again this is not a real function and just placeholder for the task code block; it's assumed by other functions like user_task.
  
void systemconfigwrite(uint32_t addr, uint8_t data); // Funtion to modify System Config in flash (need implementation) 
// Again this is not a real function and just placeholder for the task code block; it's assumed by other functions like user_task.