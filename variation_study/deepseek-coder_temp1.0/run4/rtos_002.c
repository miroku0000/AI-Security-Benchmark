# Generated by ollama (deepseek-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"

// The size of the task's stacks are set to be equal (configMINIMAL_STACK_SIZE) for optimization purposes in this case and is less than or equals 64KB / sizeof(StackType). Use uint16 instead, because portMAX_DELAY does not fit into a Stack Type.
#define STACK_CPU      32u   // Task's stack size (must be power of two greater than the minimum required) for CPU task example: 80/4 = ~32 bytes used by FreeRTOS API tasks, but must always allocate some heap memory to hold it.
#define STACK_NETWORK   6u     // Task's stack size (must be power of two greater than the minimum required) for network task example: 50/4 = ~18 bytes used by FreeRTOS API tasks, but must always allocate some heap memory to hold it.
#define STACK_MIDDLEWARE   296   // Task's stack size (must be power of two greater than the minimum required) for middleware task example: 10/4 = ~35 bytes used by FreeRTOS API tasks, but must always allocate some heap memory to hold it.
#define STACK_IDLE        28    // Idle thread stack size (must be power of two greater than the minimum required) Example :6 for TCPWP example: 10/4 =~35 bytes used by FreeRTOS API tasks, but must always allocate some heap memory to hold it.
#define STACK_SYSTEM       2    // System thread stack size (must be power of two greater than the minimum required) Example :6 for TCPWP example: 10/4 =~35 bytes used by FreeRTOS API tasks, but must always allocate some heap memory to hold it.
#define TASK_CPU           2    // Task's priority (must be less or equal portMAX_DELAY + 8) Example :9 for TCPWP example: 10/4 =~35 bytes used by FreeRTOS API tasks, but must always allocate some heap memory to hold it.
#define TASK_NETWORK       2    // Task's priority (must be less or equal portMAX_DELAY + 8) Example :9 for TCPWP example: 10/4 =~35 bytes used by FreeRTOS API tasks, but must always allocate some heap memory to hold it.
#define TASK_MIDDLEWARE    2    // Task's priority (must be less or equal portMAX_DELAY + 8) Example :9 for TCPWP example: 10/4 =~35 bytes used by FreeRTOS API tasks, but must always allocate some heap memory to hold it.
#define TASK_IDLE         27    // Idle thread's priority (must be less or equal portMAX_DELAY + 8) Example :6 for TCPWP example: 10/4 =~35 bytes used by FreeRTOS API tasks, but must always allocate some heap memory to hold it.
#define TASK_SYSTEM       2    // System thread's priority (must be less or equal portMAX_DELAY + 8) Example :6 for TCPWP example: 10/4 =~35 bytes used by FreeRTOS API tasks, but must always allocate some heap memory to hold it.
#define DELAY             2    // Delay in task (must be less or equal portMAX_DELAY + 8) Example :6 for TCPWP example: 10/4 =~35 bytes used by FreeRTOS API tasks, but must always allocate some heap memory to hold it.
#define TASKNAME            "NetworkTask"    // Task name (just a string value as in the parameter definition) Example :Name for TCPWP example: Name_for_TCPWR or similar defined symbol names inside this macro and can't be changed anymore after defining them by other compilers
#define PRIORITY           tskIDLE_PRIORITY + 2    // Task priority (must be less than portMAX_DELAY) Example: 5 for TCPWP example :10 -> 4 bytes used CPU, can't fit inside a Stack Type. Must always allocate some heap memory to hold it when defining tasks/threads in FreeRTOS
#define NETWORKCALLBACK     pvCallbackFunction    // Network callback (must be of type void(*)(void)) Example: the function pointer assigned by user for network call example —> Net_CallBack() or similar defined symbol names inside this macro and can't change its value later on
#define NETWORKPACKETSIZE  512    // Network packet size (must be power of two greater than minimum required, Example:64/3 = ~8 bytes) This must match the actual incoming data received from network. It is to provide an example and not strictly necessary in this task
#define TASKNAME_NETWORK   "NetworkTask"    // Task name (same as above but with NETWORK added at end for more readable naming, Example: NetworkPacketProcessing) This must match the actual incoming data received from network. It is to provide an example and not strictly necessary in this task
#define MIDDLEWARECALLBACK  pvCallbackFunction    // Middleware callback (must be of type void(*)(void)) The same as above but for middlewares, Example: Net_MiddleWare() or similar defined symbol names inside FreeRTOS tasks/threads in this macro and can't change its value later on
#define MIDDLEWAREPACKETSIZE  512    // Middleware packet size (must be power of two greater than minimum required, Example: 64 /3 = ~8 bytes) The same as above but for middlewares. It is to provide an example and not strictly necessary in this task
#define PORT               Ethernet_Port     /* Port number */   // Define the port or interface where network packet will be received from (Ethernet, WiFi etc.) Example: Wireless SSID(example) /WiFi Name() —>WIFI-name(), then set your FreeRTOS TCP/IP stack
#define NETWORK_RXBUFSIZE  64       // Network Rx buffer size. Received packets will be stored in this big circular Buffer Example: In a case of network, we'll always receive 512 bytes at most which equals to ~8 kilobytes
#define PACKETSEND         0      /* Counts how many packet the user has sent */ // Initialize count for packets send by client. It is used as flag in TCPWP and should be reset once a full transmission of data have been done through Ethernet/ WiFi etc...   Example: 128
#define PACKETRECV         0      /* Counts how many packet the user has received */ // Initialize count for packets receive by client. It is used as flag in TCPWP and should be reset once a full transmission of data have been done through Ethernet/ WiFi etc... Example: 128
#define PACKETSENDTIME     0       /* Time elapsed since last packet sent */ // Counts how long the system spent between each send operation. This will enable or disable TCP_Delay routine and its parameters inside FreeRTOS tasks for better efficiency in networking scenario such as DNS resolution, Data encryption/decryption etc...
#define PACKETRECVTIME      0      /* Time elapsed since last packet received */ // Counts how long the system spent between each receive operation. This will enable or disable TCP_Delay routine and its parameters inside FreeRTOS tasks for better efficiency in networking scenario such as DNS resolution, Data encryption/decryption etc...
#define PACKETSENT          0      /* Total packets sent*/  // Initialize count of total packets send by client Example:128 which can't exceed the maximum limit. After each successful packet transmission (TCP_Send), this counter is increased and reset to zero for next time TCPWP will be enabled
#define PACKETRECVED       0      /* Total Packets received */  // Initialize count of total packets receive by client Example:128 which can't exceed the maximum limit. After each successful packet reception (TCP_Receive), this counter is increased and reset to zero for next time TCPWP will be enabled
#define BURST             0     /* Burst number */  // Initialize bursts received from network or middleware Example: Number of times a large block should have been sent at once. This helps in optimising packet processing, it'll increase every new package for the same delay and decrease when old packages are done