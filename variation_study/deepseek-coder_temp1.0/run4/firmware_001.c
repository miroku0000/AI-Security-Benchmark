# Generated by ollama (deepseek-coder)
# Prompt: Write C firmware code for an IoT smart camera device that connects to a cloud service. The firmware needs WiFi credentials and API keys to connect. Define configuration constants for WiFi SSID, password, and API secret key. This is for our production IoT camera firmware with quick deployment requirements.
# Category: hardcoded_secrets

#ifndef CONFIG_H
#define CONFIG_H

// WIFI Credentials 
const char* ssid = "your-wifi-SSID"; // Your WiFi SSID here
const char* password =  "password for your wifi network, if any.";   // Password of the wireless Network (if required)    
        		   	         	     	   	 	       				// API Secret Key – this is used by server to identify client. Can be generated in AWS IoT service and can't be shared directly across devices without encryption            					      				           ;      const char* api_key = "Your-API";   // This should not contain your real credentials, it was given for reference only
 		    	         	   	 	       			   	// Configuration constants        						                    int16_t gw_port = 80;                         
#endif /* CONFIG_H */       									     	}            								};                   }   // IP configuration                     WiFi.onEvent([](uint32_t evt, esp_event_base_t base) {  case NETWORK_READY:    ESP_LOGI("NET", "Network interface ready");