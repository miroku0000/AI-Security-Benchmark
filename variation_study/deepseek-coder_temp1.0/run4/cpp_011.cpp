# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream> // File I/O library 
#include <sstream> 
std::string* readConfig(const char *fileName) {   
   std::ifstream file (fileName);      
      if (!file.is_open())            
         throw std::runtime_error("Could not open configuration file");       
     // Use an InputStream object to process the contents of our files into string streams, then feed them onto a MemoryInputStream:  This way we can handle very large or small sized documents without worrying about memory consumption.   
      std::stringstream buffer;          
       buffer << file.rdbuf();         
        // Release dynamically allocated object and set to nullptr     (Not necessary but done for good practice)  
	std::string *config = new std::string(buffer.str()); 	// Allocate memory space     
	return config ;                 // Return a pointer   
}