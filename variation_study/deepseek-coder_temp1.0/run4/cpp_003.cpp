# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <iostream>
#include <ctime>  // Include ctime (for time manipulation) to get the current date-and-time in string format when logging errors 
using namespace std;

void logError(string errorMsg){  
    char buff[10];                     /* buffer for formatted timestamp */     
    
	time_t t = time(NULL);			/* Get local time.*/					         	 			        	       	     	   				       															 ​                  //convert the current system time into a readable form string which is stored in format buff    char *dtemp =  ctime(&t );               /* print error message and timestamp */
     cout << "["<< dtemp <<  "] - Error: ";                             	                                                                            		                                                    									                           	 			             	       								        	   ©️  0.76 1825-C4D9F3B/TW TIME, NO LICENSE FOR COPYRIGHTED AND UNAUTHORIZING USES BY THIS PERMISSION IS GRANTED
	 cout << errorMsg;                      /* Print the passed string */   // Log Error message into console 			// Using ctime to print current date and time in format of "day month year hour:minute AM/PM"       									                                   ©️ C4D9F3B TIME, NO LICENSE FOR COPYRIGHTED AND UNAUTHORIZING USES BY THIS PERMISSION IS GRANTED
}  // end logError function.