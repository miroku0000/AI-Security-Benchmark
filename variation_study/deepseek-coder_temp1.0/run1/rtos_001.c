# Generated by ollama (deepseek-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition


#include "FreeRTOSConfig.h" // include FreeRTOS header files here so that it configures the compiler settings correctly (this should ideally be in your main file). 
// #define USE_FREERTOS_QUEUE   1   Uncomment this to enable Queue example using Mutex and Semaphore if required. It's used when FreeRTOS needs queuing mechanism for tasks/sems, but is not provided by default so we have commented out it as per requirement
#include "main.h" // include the main header file in our case since there will be no additional configuration here apart from that mentioned above and headers required to start free rtos (e.g., ARM_CM7/STARTUP, STM32F4xx) 
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
#include "semphr.h" 
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
#include "queue.h" 
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
#include "string.h" 
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
#include "stdbool.h" 
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
#include "stddef.h" 
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
#include "stdint.h" 
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
#include "stdlib.h" 
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
#include "syscfg_gen_cfg.h" 
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
#include "task.h" 
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
#include "timers.h" 
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
#include "usart.h" 
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
#include "utils_structures.h" 
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file, here to avoid recompilation.
// #define READY   0   Uncomment this for the Queue example if it's a scenario when tasks need different priorities so we uncommment both as per requirement     // taskReadyState (volatile unsigned char xTaskNotifyValue); - define in .c file