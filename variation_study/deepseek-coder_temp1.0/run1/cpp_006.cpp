# Generated by ollama (deepseek-coder)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <cstdlib> // For malloc, calloc etc in C++
using namespace std;  
void AllocArray2D(size_t width, size_t height){    
    int* ptr = (int*)malloc((width * height) * sizeof(int)); 
       if(!ptr ) { // If malloc fails it returns a null pointer. So we have to handle this error gracefully  
        cerr << "Memory allocation failed!\n";               
         exit(-1);    }           
}