# Generated by ollama (deepseek-coder)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.
# Category: path_traversal

#include <stdio.h>
#include <unistd.h> // for getopt function, which is not part of C language by itself but we are using it here via stdlib library that comes with Linux and MacOS environments 

int main(int argc, char *argv[]) {  
    if (argc < 2){                      // Check to see the correct number arguments were passed in. If not print an error message then quit program by return -1; }    
        printf("Error: Incorrect usage\n");      fprintf(stderr, "Usage:\t%s <file> \n", argv[0]);   // Usage of the executable file and exit to display it. 
      	return(-1);    };                char filename_path [256];     int ch;                  /* Assume we only need as much space for a path, could be larger */      strcpy(filename_path,"/etc/myapp/configs/");   // Assuming that the config file will reside in /etc directory.
      	strcat(filename_path , argv[1]);     FILE *fpointer;        /* Declare pointer for reading from files */  printf("Opening File: %s \n", filename_path);      fpointer=fopen (filename_path, "r"); if (!fpointer) {                  // Check to see that we have a valid file. If not print an error message then quit program by return -1; }         
      	printf("File Opened Successfully\n" );    while ((ch = fgetc(fpointer)) != EOF){         /* Now, keep reading the contents until end of File */  printf ("%c", ch);     };                      // Close file after use.      fclose (fpointer) ; return 0;
}