# Generated by ollama (deepseek-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include "stdint.h"  // Include for uint32_t definition, etc... you can use other types if needed like int8_t or boolean definitions as well (if your system is very portable)
/* Define the structure shared with tasks */
typedef struct {         /* Make sure to define this in a global header file. 
                            It could be named something such as "sensorData", etc...*/      	  									   		    			     	 	} SENSOR_DATA;        // Your defined sensor data type here: uint32_t, float ... if necessary */          } ;                                  /* End of shared structure definition. 
                                                                                                                 Do not edit below this line unless you know what your doing!*/           volatile SENSOR_DATA* const gSensorDataPtr;/* Declare pointer to the sensor data global variable in a header file, then define it here */    TaskHandle_t xTask1Handle ; /* Handle for task 2. You will allocate these handles dynamically by calling pdMalloc or equivalent functions after setting up tasks and semaphores*/
    			       		                                                                                        	   	      									            TASK(void* pvParameters);             TaskHandler tsk_task;      volatile SENSOR_DATA sensorData, *psensorPtr = &sensorData ;  /* Declare your task function here */                          void vTask2 (void*pvParameter)