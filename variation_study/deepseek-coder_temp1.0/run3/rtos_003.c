# Generated by ollama (deepseek-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include<stdio.h>  /* For printf */ 
  
// Checking privilege is not a real requirement in this case, it's only an example to demonstrate permissions management and could be implemented differently based on your system design considerations like user authentication etc..
int check_privilege(void) {
    // Here you would add the code for checking if current task has required privileges. This is a simplified version where all tasks are assumed as admin (as it's not provided in context). 
    return -1;   /* Returns true when privilege found */ 
}
    
void user_task(void) {      // User Task Function to request for privileged operations. In reality, this function will be called from the main task or interrupt service routine (ISR). Here simplified as an example here..   
   if(!check_privilege())  /* If not admin */    
       printf("User is attempting to perform Admin operation\n");     
}          // End User Task Function. In a real scenario, this would be called from ISR or another task with sufficient privileges..    }               __Noreturn void main (void) {   /* Main function */     system_init();         printf ("Starting up... \r\n"); 
task_startup(user_tasks[0].handle, &system_thread);            // Starts user task. In reality this would be called from ISR or another higher priority thread..    } /* End of main function */