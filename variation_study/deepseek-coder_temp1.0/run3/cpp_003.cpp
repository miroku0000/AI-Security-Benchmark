# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <iostream>
#include <ctime>  // include ctime needed by time() to get current timestamps, else use std::chrono if C++14 or later is used for clarity and readability reasons. For older compilers it could be #define _CRT_SECURE_NO_WARNINGS
#include <cstdio>  // needed by the code snippet to print timestamp into console 
  
void LogError(const char* message) {   
char currentTime[80];    
_time_t timeNow = time(NULL);     
strftime(currentTime, sizeof(currentTime), "%d-%m-%Y %H:%M:%S", localtime(&timeNow));  // get the date and format it into string  
std::cout << currentTime<< " - ERROR :"  << message <<  std::endl;    		// print timestamp then error detail.   		         	 			       } 	        Capture time of execution with ctime instead, use localtime() function to get date/hour information and format it into a string for easy manipulation like in the above code