# Generated by ollama (deepseek-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#define STACK_SIZE configMINIMAL_STACK_SIZE

/* FreeRTOs task function */
void vNetworkPacketProcessor(void *pvParameters);  /* Task's parameter*/  
StackType_t xTaskBuffer[STACK_SIZE];     // Defined as per requirement. Set it to small size for optimization in RAM constraints (e.g., configMINIMAL_STACK_SIZE) . You can adjust according your requirements   
int main(void){  /* Start program execution */  	
// Create task with default setup and priority, stack & pvTaskParameter set here as required		     // Allocate Stack for this tasks (stack size must be greater than configMINIMAL_STACK_SIZE)					     			      	    } void main(void){  /* Start program execution */