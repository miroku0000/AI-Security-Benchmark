# Generated by ollama (deepseek-coder)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility> // std::swap, std::enable_shared_from_this 等价物需要在下面使用。请自行检查是否存在这些库的定义或包含文件，或者如何添加它到你的项目中以使其正常工作！确保你了解并遵守C++中的RAII和移动语义的要求：