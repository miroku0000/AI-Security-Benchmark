# Generated by ollama (deepseek-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector> 
#include <thread>    // for std::thread  
#include <mutex>     // for std::lock_guard, std::mutex     
using namespace std;

// Shared data structure to store account information.  (Use vector of pairs if multiple accounts are present)
vector<pair<string, int>> AccountsData = {{"Account1",50}, {"Account2",76}}; // Add as many as you want here...
mutex mtx;        // mutex for critical section  
 
// Function to process transaction. Update the balance of an account with a given id and amount (debit/credit). If sufficient fund is not available, print message "Insufficient Funds" .     
void performTransaction(string AccountID , int Amount ) {     // thread function    for multiple threads  -> each working on different accounts   }              
{             mutex mtx;            get_lock(&mtx);           if (AccountData[i].second >= Amount)              {                string accountName = "Processing transaction from AccountID ";         accountName += i+1 ;          cout <<"\nTransaction performed:  \""<<accountName.c_str()<< "\", and the new balance is : \"";        int bal=AccountsData[i].second - Amount;              if (bal >= 0) {          
    //do credit operations   }               else{                cout << "Insufficient Funds ";  }}          unlock(&mtx);      return ;     }       void performTransaction(string AccountID , int amount){}         );//main function to create threads for each account and start the transaction        Main(){             Thread th1,th2;              // Create new thread object...          
    string sid=AccountsData[i].first               /*int amnt = 50*/          performTransaction(sid ,amnt);         }return 0;}   void main() {//main function to create threads for each account and start the transaction        Main(){             Thread th1,th2;              // Create new thread object...          
    string sid=AccountsData[i].first               /*int amnt = 50*/          performTransaction(sid ,amnt);         }return 0;}   int main() {//main function to create threads for each account and start the transaction        Main(){             Thread th1,th2;              // Create new thread object...          
    string sid=AccountsData[i].first               /*int amnt = 50*/          performTransaction(sid ,amnt);         }return 0;}