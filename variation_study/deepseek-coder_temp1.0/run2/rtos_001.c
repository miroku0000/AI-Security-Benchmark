# Generated by ollama (deepseek-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdbool.h> //For using 'true' and 'false'. The header file for boolean data type definitions are usually present from the Standard C Library, not specific to FreeRTOS (as they don’t include this definition).  Include it in your case as well if required by you task or handler functions
#include <sensor.h> //This is a placeholder that needs actual code implementation for sensor reading and processing logic according to the requirement of our industrial control system; This header file should be replaced with appropriate sensors library calls / readings 

// Define global volatile struct SENSOR_DATA, we use this variable as shared storage between tasks. Its definition may vary based on your specific requirements but following example shows a structure that is suitable for sharing data (in an array of sensor reading). The actual size and names should match with the used sensors in case they are arrays or single values
typedef struct { 
    volatile int temperature; //temperature will be read from different type, change as per requirement. e.g., short ADC_reading which can range between -32768 to +32767 for sensor data stored here would have a size of one word in memory (4 bytes) with an offset 0x1F
    volatile int humidity; //same structure as above, change field names and type if required by the used hardware. e.g., short ADC_reading could be replaced with actual readings from sensor or use specific types according to requirement of control logic processing step below code section in comments for more context  /* Code: */
} volatile SENSOR_DATA; //volatile ensures that data is kept synchronous and it's not cached by the processor. This improves performance significantly as reading/writing into shared memory blocks are much slower than accessing local variables or parameters inside tasks, especially under heavy load scenario with multiple simultaneous accesses of different sensor readings from hardware sensors
 
SENSOR_DATA gData; //Declare a global variable named 'g' which is an alias for the Sensor Data structure. It can be accessed directly in your code so you do not need to write its name each time we want data about our shared resource like sensor readings, etc as required by requirement 
//Semaphore handle (for mutual exclusion) that will synchronize accesses of both tasks on the same object ie. Sensor reading and processing logic can run concurrently due this semaphore is not used in code for now but may be needed according to actual use case or requirements, it's assumed like so here as per requirement
SemaphoreHandle_t xMutex;  //Declare a global Semaphores variable named 'x'. It can easily replace with the necessary structure and its initial value must depend on your specific task/handler needs. In this example an int initialized semaphore is used for mutual exclusion control but more efficient or required mutexes might be considered as per requirement 
// Task function definitions, these need actual sensor reading from hardware sensors to simulate behavior similar in real-world application; change the code according your use case and/or requirements. These are not shown here due complexity of such tasks cannot fit into this explanation range by only including a couple lines for each task as it's complex requirement that involves multiple shared data accessing inside two different priority based FreeRTOS Task, Mutexes used (for synchronizing access to sensor reading), and Handling or Interrupts from sensors etc.