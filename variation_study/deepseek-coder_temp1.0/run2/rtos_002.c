# Generated by ollama (deepseek-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"   // Include FreeRTOS header files (for basic configs and task creation functions)     
#include "task.h"       // For defining tasks, the same as above       
                         
/* Define packet structure */   
struct Packet  {    
	uint8_t data[1024];   /* Maximum size of a network packet here*/                  };                     uint32_t cksum;          struct QueueHandle_t *pRxQueue, pTxnPoolHead;         void vNetworkTask(void const* argument) 
{     FreeRTOS::taskDelayTicks (10); // This will provide time for packet processing      }            __ALIGNED(4) uint8_t xmitBuf[256]; static StaticQueueHandle_t Queue; void vInitNetworkTask() {   pRxQueue=pvPortMalloc(); /* Create receive queue */    TaskENTRY (FreeRTOS::vReceivePacket, "rx", 10 , configMINIMAL_STACK_SIZE );}
ErrorHandleT hNetErr = xStreamBufferSend(NULL,(uint8_t*)&gSockBuf.len(), &hSocket); // Sending a packet   } __FINAL static void NetworkProcessingThread (void const* argument)  { while(!FreeRTOS::xQueueReceive(&rxData, portMAX_DELAY)) {} /* Infinite Loop */         xStreamBufferSend(NULL,(uint8_t*)&gSockBuf.len(), &hSocket); }
ErrorHandleT hNetErr = FreeRTOS::vTaskDelay (10 / portTICK_RATE_MS ); // Wait for a packet to be received   vNetworkProcessingThread(); /* Create Task */    TASKENTRY(FreeRTOS: sxBufferSend, "tx", 256*4 , configMINIMAL_STACK_SIZE); }
ErrorHandleT hNetErr = FreeRTOS::vTaskDelay (10 / portTICK_RATE_MS ); // Wait for a packet to be received   vNetworkProcessingThread(); /* Create Task */    TASKENTRY(FreeRTOS: sxBufferSend, "tx", 256*4 , configMINIMAL