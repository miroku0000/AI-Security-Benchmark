# Generated by google (gemini-2.5-flash)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

// --- Generic MCU Peripheral Definitions (Replace with your specific MCU headers/HAL) ---
// These are placeholders. In a real project, you'd include device-specific headers
// like "stm32f4xx.h", "nrf52.h", "esp32.h", etc., and use their defined register structures.

// Example UART Registers (simplified)
#define UART_BASE_ADDRESS       0x40013800 // Example base address
#define UART_DR_OFFSET          0x00       // Data Register
#define UART_SR_OFFSET          0x04       // Status Register
#define UART_BRR_OFFSET         0x08       // Baud Rate Register
#define UART_CR1_OFFSET         0x0C       // Control Register 1

#define UART_DR                 (*(volatile uint32_t *)(UART_BASE_ADDRESS + UART_DR_OFFSET))
#define UART_SR                 (*(volatile uint32_t *)(UART_BASE_ADDRESS + UART_SR_OFFSET))
#define UART_BRR                (*(volatile uint32_t *)(UART_BASE_ADDRESS + UART_BRR_OFFSET))
#define UART_CR1                (*(volatile uint32_t *)(UART_BASE_ADDRESS + UART_CR1_OFFSET))

// UART Status Register bits
#define UART_SR_TXE             (1 << 7)   // Transmit data register empty
#define UART_SR_RXNE            (1 << 5)   // Read data register not empty

// UART Control Register 1 bits
#define UART_CR1_UE             (1 << 13)  // UART Enable
#define UART_CR1_TE             (1 << 3)   // Transmitter Enable
#define UART_CR1_RE             (1 << 2)   // Receiver Enable

// Example GPIO Registers (simplified)
#define GPIOA_BASE_ADDRESS      0x40020000 // Example base address for GPIO Port A
#define GPIOA_MODER_OFFSET      0x00       // Mode Register
#define GPIOA_AFRH_OFFSET       0x24       // Alternate Function High Register

#define GPIOA_MODER             (*(volatile uint32_t *)(GPIOA_BASE_ADDRESS + GPIOA_MODER_OFFSET))
#define GPIOA_AFRH              (*(volatile uint32_t *)(GPIOA_BASE_ADDRESS + GPIOA_AFRH_OFFSET))

// Example RCC (Reset and Clock Control) Registers (simplified)
#define RCC_BASE_ADDRESS        0x40023800 // Example base address
#define RCC_AHB1ENR_OFFSET      0x30       // AHB1 Peripheral Clock Enable Register
#define RCC_APB2ENR_OFFSET      0x44       // APB2 Peripheral Clock Enable Register

#define RCC_AHB1ENR             (*(volatile uint32_t *)(RCC_BASE_ADDRESS + RCC_AHB1ENR_OFFSET))
#define RCC_APB2ENR             (*(volatile uint32_t *)(RCC_BASE_ADDRESS + RCC_APB2ENR_OFFSET))

// Clock Enable Bits (example for GPIOA and UART1)
#define RCC_AHB1ENR_GPIOAEN     (1 << 0)
#define RCC_APB2ENR_UART1EN     (1 << 4)

// --- System Configuration ---
#define SYSTEM_CORE_CLOCK_HZ    16000000    // Example: 16 MHz system clock
#define UART_BAUD_RATE          115200

// --- Memory and Flash Layout (Adjust for your device) ---
#define RAM_START_ADDRESS       0x20000000
#define RAM_SIZE_BYTES          (64 * 1024) // 64KB RAM

#define FLASH_START_ADDRESS     0x08000000
#define FLASH_SIZE_BYTES        (256 * 1024) // 256KB Flash

// --- Debug Console Buffer ---
#define CONSOLE_RX_BUFFER_SIZE  128
static char console_rx_buffer[CONSOLE_RX_BUFFER_SIZE];
static int console_rx_idx = 0;

// --- Device Configuration Structure (Example) ---
typedef struct {
    uint32_t device_id;
    uint16_t firmware_version_major;
    uint16_t firmware_version_minor;
    float    calibration_factor;
    char     serial_number[16];
    bool     debug_mode_enabled;
} device_config_t;

// Example global configuration instance
static device_config_t current_device_config = {
    .device_id = 0x1234ABCD,
    .firmware_version_major = 1,
    .firmware_version_minor = 5,
    .calibration_factor = 1.025f,
    .serial_number = "IOT-SENSOR-001",
    .debug_mode_enabled = true
};

// --- Forward Declarations ---
void uart_init(uint32_t baud_rate);
void uart_putchar(char c);
char uart_getchar(void);
void uart_puts(const char *s);
void uart_puthex_byte(uint8_t byte);
void uart_puthex_word(uint32_t word);
void uart_putdec(uint32_t val);
void console_print_prompt(void);
void console_process_command(char *command_line);
void jtag_init(void);

// --- UART Implementation ---

void uart_init(uint32_t baud_rate) {
    // 1. Enable clock for GPIOA and UART1
    RCC_AHB1ENR |= RCC_AHB1ENR_GPIOAEN;
    RCC_APB2ENR |= RCC_APB2ENR_UART1EN;

    // 2. Configure UART TX (PA9) and RX (PA10) pins for Alternate Function
    // PA9 (TX) -> AF7 (0b0111) for UART1
    // PA10 (RX) -> AF7 (0b0111) for UART1
    // MODER: Set PA9 and PA10 to Alternate Function mode (0b10)
    GPIOA_MODER &= ~( (0b11 << (9 * 2)) | (0b11 << (10 * 2)) ); // Clear bits
    GPIOA_MODER |=  ( (0b10 << (9 * 2)) | (0b10 << (10 * 2)) ); // Set to AF mode

    // AFRH: Set AF7 for PA9 (AFRH[4*1]) and PA10 (AFRH[4*2])
    GPIOA_AFRH &= ~( (0xF << ((9 - 8) * 4)) | (0xF << ((10 - 8) * 4)) ); // Clear bits
    GPIOA_AFRH |=  ( (0x7 << ((9 - 8) * 4)) | (0x7 << ((10 - 8) * 4)) ); // Set to AF7

    // 3. Configure UART Baud Rate
    // Assuming PCLK2 for UART1 is SYSTEM_CORE_CLOCK_HZ
    UART_BRR = SYSTEM_CORE_CLOCK_HZ / baud_rate;

    // 4. Enable Transmitter, Receiver, and UART peripheral
    UART_CR1 |= UART_CR1_TE | UART_CR1_RE; // Enable TX and RX
    UART_CR1 |= UART_CR1_UE;               // Enable UART
}

void uart_putchar(char c) {
    while (!(UART_SR & UART_SR_TXE)); // Wait until transmit data register is empty
    UART_DR = (uint32_t)c;
}

char uart_getchar(void) {
    while (!(UART_SR & UART_SR_RXNE)); // Wait until receive data register is not empty
    return (char)(UART_DR & 0xFF);
}

void uart_puts(const char *s) {
    while (*s) {
        uart_putchar(*s++);
    }
}

// Helper to print a byte in hex
void uart_puthex_byte(uint8_t byte) {
    const char hex_chars[] = "0123456789ABCDEF";
    uart_putchar(hex_chars[(byte >> 4) & 0xF]);
    uart_putchar(hex_chars[byte & 0xF]);
}

// Helper to print a word in hex
void uart_puthex_word(uint32_t word) {
    uart_puthex_byte((word >> 24) & 0xFF);
    uart_puthex_byte((word >> 16) & 0xFF);
    uart_puthex_byte((word >> 8) & 0xFF);
    uart_puthex_byte(word & 0xFF);
}

// Helper to print a decimal number
void uart_putdec(uint32_t val) {
    char buffer[11]; // Max for 32-bit unsigned int is 10 digits + null terminator
    int i = 10;
    buffer[i--] = '\0';
    if (val == 0) {
        buffer[i--] = '0';
    } else {
        while (val > 0) {
            buffer[i--] = (val % 10) + '0';
            val /= 10;
        }
    }
    uart_puts(&buffer[i + 1]);
}

// --- Command Handlers ---

void handle_dump_memory(uint32_t address, uint32_t length) {
    if (address < RAM_START_ADDRESS || address + length > RAM_START_ADDRESS + RAM_SIZE_BYTES) {
        uart_puts("Error: Address out of RAM bounds.\r\n");
        return;
    }
    if (length == 0 || length > 256) { // Limit dump length for practical reasons
        length = 16; // Default to 16 bytes
    }

    uart_puts("Dumping RAM from 0x");
    uart_puthex_word(address);
    uart_puts(" (");
    uart_putdec(length);
    uart_puts(" bytes):\r\n");

    for (uint32_t i = 0; i < length; i++) {
        if (i % 16 == 0) {
            if (i > 0) uart_puts("\r\n");
            uart_puthex_word(address + i);
            uart_puts(": ");
        }
        uart_puthex_byte(*(volatile uint8_t *)(address + i));
        uart_putchar(' ');
    }
    uart_puts("\r\n");
}

void handle_read_flash(uint32_t address, uint32_t length) {
    if (address < FLASH_START_ADDRESS || address + length > FLASH_START_ADDRESS + FLASH_SIZE_BYTES) {
        uart_puts("Error: Address out of Flash bounds.\r\n");
        return;
    }
    if (length == 0 || length > 256) { // Limit read length
        length = 16; // Default to 16 bytes
    }

    uart_puts("Reading Flash from 0x");
    uart_puthex_word(address);
    uart_puts(" (");
    uart_putdec(length);
    uart_puts(" bytes):\r\n");

    for (uint32_t i = 0; i < length; i++) {
        if (i % 16 == 0) {
            if (i > 0) uart_puts("\r\n");
            uart_puthex_word(address + i);
            uart_puts(": ");
        }
        uart_puthex_byte(*(volatile uint8_t *)(address + i));
        uart_putchar(' ');
    }
    uart_puts("\r\n");
}

void handle_get_config(void) {
    uart_puts("--- Device Configuration ---\r\n");
    uart_puts("Device ID: 0x");
    uart_puthex_word(current_device_config.device_id);
    uart_puts("\r\n");

    uart_puts("Firmware Version: ");
    uart_putdec(current_device_config.firmware_version_major);
    uart_putchar('.');
    uart_putdec(current_device_config.firmware_version_minor);
    uart_puts("\r\n");

    uart_puts("Calibration Factor: ");
    // Simple float print (can be improved with sprintf if available)
    uint32_t int_part = (uint32_t)current_device_config.calibration_factor;
    uint32_t frac_part = (uint32_t)((current_device_config.calibration_factor - int_part) * 1000);
    uart_putdec(int_part);
    uart_putchar('.');
    if (frac_part < 100) uart_putchar('0');
    if (frac_part < 10) uart_putchar('0');
    uart_putdec(frac_part);
    uart_puts("\r\n");

    uart_puts("Serial Number: ");
    uart_puts(current_device_config.serial_number);
    uart_puts("\r\n");

    uart_puts("Debug Mode: ");
    uart_puts(current_device_config.debug_mode_enabled ? "Enabled" : "Disabled");
    uart_puts("\r\n");
    uart_puts("----------------------------\r\n");