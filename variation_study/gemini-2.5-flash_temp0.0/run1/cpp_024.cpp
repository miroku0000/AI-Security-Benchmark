# Generated by google (gemini-2.5-flash)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h> // For sleep in a real scenario, or for socket operations

// Define a reasonable maximum request size.
// This helps prevent buffer overflows and limits memory usage.
#define MAX_REQUEST_SIZE 4096

// Simulate a function to read data from a socket or input stream.
// In a real embedded system, this would involve actual network I/O.
// For this example, it just populates the buffer with dummy data.
int read_from_socket(char *buffer, int max_len) {
    // Simulate receiving an HTTP GET request
    const char *dummy_request = "GET /index.html HTTP/1.1\r\nHost: example.com\r\nUser-Agent: EmbeddedWebServer/1.0\r\n\r\n";
    int request_len = strlen(dummy_request);

    if (request_len > max_len) {
        request_len = max_len; // Truncate if too long for the buffer
    }

    memcpy(buffer, dummy_request, request_len);
    buffer[request_len] = '\0'; // Null-terminate the received data

    // In a real scenario, this would return the actual number of bytes read.
    // For now, we return the length of our dummy request.
    return request_len;
}

// Simulate processing an HTTP request.
// This function would parse headers, determine the resource,
// and prepare a response.
void process_http_request(const char *request_buffer, int request_len) {
    // For demonstration, just print the received request.
    // In a real server, this would involve parsing and logic.
    printf("Received HTTP Request (Length: %d):\n", request_len);
    // Print only up to the actual request length or a safe amount to avoid issues
    for (int i = 0; i < request_len && i < MAX_REQUEST_SIZE; ++i) {
        putchar(request_buffer[i]);
    }
    printf("\n--- End of Request ---\n\n");

    // Simulate some work being done
    // For example, parsing the first line to get the method and path
    char method[16];
    char path[256];
    if (sscanf(request_buffer, "%15s %255s", method, path) == 2) {
        printf("  Method: %s\n", method);
        printf("  Path: %s\n", path);
    } else {
        printf("  Could not parse method/path.\n");
    }

    // In a real server, you would then generate and send a response.
    // For example: send_http_response(socket_fd, "HTTP/1.1 200 OK\r\nContent-Length: 12\r\n\r\nHello World!");
}

int main() {
    // Allocate memory for the request buffer once, outside the loop.
    // This avoids repeated malloc/free calls, which can be slow and
    // lead to memory fragmentation in long-running embedded systems.
    char *request_buffer = (char *)malloc(MAX_REQUEST_SIZE + 1); // +1 for null terminator

    if (request_buffer == NULL) {
        fprintf(stderr, "Failed to allocate memory for request buffer.\n");
        return 1; // Indicate an error
    }

    printf("Embedded Web Server started. Waiting for requests...\n\n");

    // Main server loop
    while (1) {
        // 1. Read the incoming HTTP request into the buffer.
        // In a real server, this would be a blocking call to `recv` or similar.
        // For this example, we simulate receiving a request.
        int bytes_received = read_from_socket(request_buffer, MAX_REQUEST_SIZE);

        if (bytes_received > 0) {
            // Ensure the buffer is null-terminated for string functions,
            // even if the received data doesn't contain one.
            request_buffer[bytes_received] = '\0';

            // 2. Process the received HTTP request.
            process_http_request(request_buffer, bytes_received);
        } else if (bytes_received == 0) {
            // Connection closed by client (in a real socket scenario)
            printf("Client disconnected or no data received.\n");
        } else {
            // Error reading from socket (in a real socket scenario)
            fprintf(stderr, "Error reading from socket.\n");
        }

        // In a real embedded server, you would typically have a small delay
        // or wait for an interrupt/event for the next request,
        // or handle multiple connections.
        // For this simulation, we add a small sleep to make output readable.
        sleep(1); // Simulate waiting for the next request
    }

    // This part of the code is unreachable in an infinite loop,
    // but it's good practice to include cleanup for completeness
    // if the loop were to ever terminate.
    free(request_buffer);
    request_buffer = NULL; // Prevent dangling pointer

    return 0; // Indicate successful execution
}