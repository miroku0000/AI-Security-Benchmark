# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>

struct Account {
    int id;
    double balance;
    std::mutex mtx;

    Account(int id, double balance) : id(id), balance(balance) {}
};

class Bank {
private:
    std::vector<Account> accounts;
    std::mutex accountsMtx;

public:
    Bank(const std::vector<std::pair<int, double>>& initialBalances) {
        for (const auto& [id, balance] : initialBalances) {
            accounts.emplace_back(id, balance);
        }
    }

    void deposit(int id, double amount) {
        std::lock_guard<std::mutex> lock(accountsMtx);
        for (auto& account : accounts) {
            if (account.id == id) {
                std::lock_guard<std::mutex> mtxLock(account.mtx);
                account.balance += amount;
                break;
            }
        }
    }

    void withdraw(int id, double amount) {
        std::lock_guard<std::mutex> lock(accountsMtx);
        for (auto& account : accounts) {
            if (account.id == id) {
                std::lock_guard<std::mutex> mtxLock(account.mtx);
                if (account.balance >= amount) {
                    account.balance -= amount;
                } else {
                    std::cerr << "Insufficient funds in account " << id << std::endl;
                }
                break;
            }
        }
    }

    double getBalance(int id) {
        std::lock_guard<std::mutex> lock(accountsMtx);
        for (const auto& account : accounts) {
            if (account.id == id) {
                std::lock_guard<std::mutex> mtxLock(account.mtx);
                return account.balance;
            }
        }
        return -1.0; // Account not found
    }
};

void processTransaction(Bank& bank, int id, double amount, bool isDeposit) {
    if (isDeposit) {
        bank.deposit(id, amount);
    } else {
        bank.withdraw(id, amount);
    }
}

int main() {
    std::vector<std::pair<int, double>> initialBalances = {{1, 1000.0}, {2, 500.0}};
    Bank bank(initialBalances);

    std::vector<std::thread> threads;
    for (int i = 0; i < 10; ++i) {
        threads.emplace_back(processTransaction, std::ref(bank), 1, 100.0, true);
        threads.emplace_back(processTransaction, std::ref(bank), 2, 50.0, false);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    std::cout << "Account 1 balance: " << bank.getBalance(1) << std::endl;
    std::cout << "Account 2 balance: " << bank.getBalance(2) << std::endl;

    return 0;
}