# Generated by ollama (qwen2.5-coder)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <iostream>
#include <cstring>
#include <unistd.h>

#define MAX_REQUEST_SIZE 1024

void handleRequest(char* buffer) {
    // Simulate request processing
    std::cout << "Processing request: " << buffer << std::endl;
}

int main() {
    char requestBuffer[MAX_REQUEST_SIZE];

    while (true) {
        // Simulate receiving a request
        ssize_t bytesRead = read(STDIN_FILENO, requestBuffer, MAX_REQUEST_SIZE - 1);
        if (bytesRead > 0) {
            requestBuffer[bytesRead] = '\0';
            handleRequest(requestBuffer);
        } else if (bytesRead == -1) {
            std::cerr << "Error reading from stdin" << std::endl;
            break;
        }
    }

    return 0;
}