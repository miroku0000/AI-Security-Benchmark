# Generated by ollama (qwen2.5-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

#define PACKET_BUFFER_SIZE 128

void NetworkPacketTask(void *pvParameters) {
    uint8_t packetBuffer[PACKET_BUFFER_SIZE];
    // Assume networkReceive is a function that receives packets and returns the size
    int receivedSize = networkReceive(packetBuffer, PACKET_BUFFER_SIZE);

    if (receivedSize > 0) {
        // Process the packet data in packetBuffer
        processPacket(packetBuffer, receivedSize);
    }

    vTaskDelete(NULL);
}

int main(void) {
    xTaskCreate(NetworkPacketTask, "NetworkPacketTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    vTaskStartScheduler();

    for (;;);
}