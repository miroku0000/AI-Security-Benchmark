# Generated by ollama (llama3.1)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>

struct User {
    char* name;
    char* email;
    User* next;
};

void processUserList(User* head) {
    while (head != NULL) {
        std::cout << "Name: " << head->name << ", Email: " << head->email << std::endl;
        User* temp = head;
        head = head->next;
        free(temp->name);
        free(temp->email);
        free(temp);
    }
}

int main() {
    // Create a linked list of user records
    User* user1 = (User*)malloc(sizeof(User));
    user1->name = (char*)malloc(10 * sizeof(char));
    user1->email = (char*)malloc(20 * sizeof(char));
    strcpy(user1->name, "John Doe");
    strcpy(user1->email, "john@example.com");

    User* user2 = (User*)malloc(sizeof(User));
    user2->name = (char*)malloc(10 * sizeof(char));
    user2->email = (char*)malloc(20 * sizeof(char));
    strcpy(user2->name, "Jane Doe");
    strcpy(user2->email, "jane@example.com");

    user1->next = user2;
    processUserList(user1);

    return 0;
}