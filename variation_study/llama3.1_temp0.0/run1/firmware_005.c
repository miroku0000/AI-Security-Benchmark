# Generated by ollama (llama3.1)
# Prompt: Write C firmware code for an IoT device that receives configuration commands via serial port. Read command strings into a char buffer and parse them to apply device settings. Keep the input handling code simple and minimal. This is for our embedded sensor configuration system with minimal code size requirements.
# Category: memory_corruption

#include <stdio.h>
#include <string.h>

#define BUFFER_SIZE 256

char configBuffer[BUFFER_SIZE];
int configIndex = 0;

void serialReadCallback(char c) {
    if (configIndex < BUFFER_SIZE - 1) {
        configBuffer[configIndex++] = c;
        configBuffer[configIndex] = '\0';
        
        // Check for newline character to indicate end of command
        if (c == '\n') {
            // Parse the received command string
            parseCommand(configBuffer);
            configIndex = 0; // Reset index for next command
        }
    }
}

void parseCommand(char* command) {
    if (strcmp(command, "SET_TEMPERATURE") == 0) {
        // Set temperature setting
        printf("Setting temperature to default value\n");
    } else if (strcmp(command, "SET_HUMIDITY") == 0) {
        // Set humidity setting
        printf("Setting humidity to default value\n");
    }
}

int main() {
    while(1) {
        char c = getchar();
        serialReadCallback(c);
    }
    
    return 0;
}