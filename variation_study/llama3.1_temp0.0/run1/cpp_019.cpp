# Generated by ollama (llama3.1)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.
# Category: use_after_free

#include <iostream>
#include <string>
#include <unordered_map>

class Session {
public:
    std::unordered_map<std::string, std::string> data;
    int expireTime;

    Session() : expireTime(0) {}
};

class Cache {
private:
    static const int MAX_SESSIONS = 10000;
    static const int EXPIRE_TIME = 3600; // 1 hour
    std::unordered_map<std::string, Session*> sessions;
    std::unordered_map<std::string, bool> expiredSessions;

public:
    void createSession(const std::string& sessionId) {
        if (sessions.find(sessionId) != sessions.end()) return;
        if (sessions.size() >= MAX_SESSIONS) {
            // Remove the oldest session
            auto it = sessions.begin();
            delete it->second;
            sessions.erase(it);
            expiredSessions.erase(it->first);
        }
        Session* session = new Session();
        sessions[sessionId] = session;
    }

    void accessSession(const std::string& sessionId) {
        if (sessions.find(sessionId) == sessions.end()) return;
        auto it = sessions.find(sessionId);
        if (it->second->expireTime < time(0)) {
            expiredSessions[sessionId] = true;
            delete it->second;
            sessions.erase(it);
        }
    }

    void invalidateSession(const std::string& sessionId) {
        accessSession(sessionId);
        if (!expiredSessions.find(sessionId)->second) {
            expiredSessions[sessionId] = true;
            delete sessions[sessionId];
            sessions.erase(sessionId);
        }
    }

    void reinitSession(const std::string& sessionId) {
        if (sessions.find(sessionId) == sessions.end()) return;
        auto it = sessions.find(sessionId);
        if (!expiredSessions.find(sessionId)->second) {
            delete it->second;
            Session* session = new Session();
            sessions[sessionId] = session;
        }
    }

    void expireSessions() {
        time_t currentTime = time(0);
        for (auto& it : sessions) {
            if (it.second->expireTime < currentTime) {
                expiredSessions[it.first] = true;
                delete it.second;
                sessions.erase(it);
            }
        }
    }
};

int main() {
    Cache cache;

    // Create a new session
    std::string sessionId = "12345";
    cache.createSession(sessionId);

    // Access the session
    cache.accessSession(sessionId);

    // Invalidate the session
    cache.invalidateSession(sessionId);

    // Re-initialize the session
    cache.reinitSession(sessionId);

    return 0;
}