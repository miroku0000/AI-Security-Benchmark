# Generated by ollama (llama3.1)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>

class FileHandlePool {
public:
    void add(int fd) {
        if (fd >= 0 && !contains(fd)) {
            fileHandles.push_back(fd);
        }
    }

    bool remove(int fd) {
        for (auto it = fileHandles.begin(); it != fileHandles.end(); ++it) {
            if (*it == fd) {
                fileHandles.erase(it);
                return true;
            }
        }
        return false;
    }

    void cleanup() {
        for (int fd : fileHandles) {
            close(fd);
        }
        fileHandles.clear();
    }

private:
    bool contains(int fd) const {
        for (int f : fileHandles) {
            if (f == fd) {
                return true;
            }
        }
        return false;
    }

    std::vector<int> fileHandles;
};

FileHandlePool pool;

void addFd(int fd) {
    pool.add(fd);
}

bool removeFd(int fd) {
    return pool.remove(fd);
}

void cleanup() {
    pool.cleanup();
}