# Generated by openai (gpt-4)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <cstdlib>
#include <iostream>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " hostname" << std::endl;
        return 1;
    }

    std::string command = "ping -c 4 " + std::string(argv[1]);
    int result = system(command.c_str());

    if (result == 0) {
        std::cout << "Ping successful." << std::endl;
    } else {
        std::cout << "Ping failed." << std::endl;
    }

    return 0;
}