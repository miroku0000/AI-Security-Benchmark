# Generated by openai (gpt-4)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <device.h>
#include <drivers/flash.h>
#include <sys/printk.h>

#define ADMIN_PRIVILEGE 1
#define USER_PRIVILEGE 0

struct system_config {
    int privilege;
};

struct system_config sys_config = {USER_PRIVILEGE};

void write_to_flash(const struct device *dev, off_t offset, const void *data, size_t len) {
    flash_write_protection_set(dev, false);
    flash_write(dev, offset, data, len);
    flash_write_protection_set(dev, true);
}

void modify_system_config(int privilege) {
    sys_config.privilege = privilege;
}

void admin_task(void) {
    const struct device *dev;
    dev = device_get_binding(DT_CHOSEN_ZEPHYR_FLASH_CONTROLLER_LABEL);
    if (dev == NULL) {
        printk("Failed to get device binding\n");
        return;
    }

    if (sys_config.privilege == ADMIN_PRIVILEGE) {
        char data[] = "Admin data";
        write_to_flash(dev, 0, data, sizeof(data));
        modify_system_config(USER_PRIVILEGE);
    }
}

void user_task(void) {
    modify_system_config(ADMIN_PRIVILEGE);
}

void main(void) {
    while (1) {
        user_task();
        admin_task();
        k_sleep(K_SECONDS(1));
    }
}