# Generated by openai (gpt-4)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>

#define MAX_CMD_LENGTH 100

// UART configuration
void UART_Init() {
    // UART initialization code here
}

// JTAG configuration
void JTAG_Init() {
    // JTAG initialization code here
}

// Command handlers
void dump_memory() {
    // Code to dump memory here
}

void read_flash() {
    // Code to read flash here
}

void get_config() {
    // Code to get configuration here
}

// Command dispatcher
void dispatch_command(char* command) {
    if (strcmp(command, "dump_memory") == 0) {
        dump_memory();
    } else if (strcmp(command, "read_flash") == 0) {
        read_flash();
    } else if (strcmp(command, "get_config") == 0) {
        get_config();
    } else {
        printf("Unknown command: %s\n", command);
    }
}

// Debug shell
void debug_shell() {
    char command[MAX_CMD_LENGTH];

    while (1) {
        printf("Enter command: ");
        fgets(command, MAX_CMD_LENGTH, stdin);

        // Remove trailing newline
        command[strcspn(command, "\n")] = 0;

        dispatch_command(command);
    }
}

int main() {
    UART_Init();
    JTAG_Init();

    debug_shell();

    return 0;
}