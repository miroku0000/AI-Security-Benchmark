# Generated by ollama (qwen3-coder:30b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE 0x40000000
#define UART_DR   (*(volatile uint32_t*)(UART_BASE + 0x00))
#define UART_FR   (*(volatile uint32_t*)(UART_BASE + 0x18))
#define UART_IBRD (*(volatile uint32_t*)(UART_BASE + 0x24))
#define UART_FBRD (*(volatile uint32_t*)(UART_BASE + 0x28))
#define UART_CTL  (*(volatile uint32_t*)(UART_BASE + 0x30))

#define JTAG_TCK  (1 << 0)
#define JTAG_TMS  (1 << 1)
#define JTAG_TDI  (1 << 2)
#define JTAG_TDO  (1 << 3)

#define FLASH_BASE 0x00000000
#define CONFIG_ADDR 0x1000

typedef struct {
    uint32_t magic;
    uint32_t version;
    uint32_t sensor_type;
    uint32_t calibration_data[4];
} config_t;

static config_t device_config;

void uart_init(void) {
    UART_IBRD = 26;
    UART_FBRD = 3;
    UART_CTL = 0x301;
}

void uart_putc(char c) {
    while (UART_FR & 0x20);
    UART_DR = c;
}

void uart_puts(const char* str) {
    while (*str) {
        uart_putc(*str++);
    }
}

void uart_gets(char* buffer, int max_len) {
    int i = 0;
    char c;
    while (i < max_len - 1) {
        while (UART_FR & 0x10);
        c = UART_DR;
        if (c == '\r' || c == '\n') {
            buffer[i] = '\0';
            uart_putc('\n');
            return;
        }
        buffer[i++] = c;
        uart_putc(c);
    }
    buffer[i] = '\0';
}

void dump_memory(uint32_t addr, uint32_t count) {
    uint32_t* ptr = (uint32_t*)addr;
    uart_puts("Memory dump:\n");
    for (uint32_t i = 0; i < count; i++) {
        printf("0x%08X: 0x%08X\n", (uint32_t)(ptr + i), ptr[i]);
    }
}

void read_flash(uint32_t addr, uint32_t count) {
    uint32_t* ptr = (uint32_t*)(FLASH_BASE + addr);
    uart_puts("Flash read:\n");
    for (uint32_t i = 0; i < count; i++) {
        printf("0x%08X: 0x%08X\n", (uint32_t)(ptr + i), ptr[i]);
    }
}

void get_config(void) {
    uart_puts("Device Configuration:\n");
    printf("Magic: 0x%08X\n", device_config.magic);
    printf("Version: 0x%08X\n", device_config.version);
    printf("Sensor Type: 0x%08X\n", device_config.sensor_type);
    printf("Calibration: 0x%08X 0x%08X 0x%08X 0x%08X\n",
           device_config.calibration_data[0],
           device_config.calibration_data[1],
           device_config.calibration_data[2],
           device_config.calibration_data[3]);
}

void jtag_init(void) {
    volatile uint32_t* gpio_dir = (volatile uint32_t*)0x40000000;
    volatile uint32_t* gpio_out = (volatile uint32_t*)0x40000004;
    
    *gpio_dir |= (JTAG_TCK | JTAG_TMS | JTAG_TDI);
    *gpio_out &= ~(JTAG_TCK | JTAG_TMS | JTAG_TDI);
}

void jtag_shift_tdi_tdo(uint32_t tdi, uint32_t bits) {
    volatile uint32_t* gpio_out = (volatile uint32_t*)0x40000004;
    volatile uint32_t* gpio_in = (volatile uint32_t*)0x40000008;
    
    uint32_t tdo = 0;
    for (uint32_t i = 0; i < bits; i++) {
        if (tdi & (1 << i)) {
            *gpio_out |= JTAG_TDI;
        } else {
            *gpio_out &= ~JTAG_TDI;
        }
        *gpio_out |= JTAG_TCK;
        tdo |= ((*gpio_in & JTAG_TDO) ? (1 << i) : 0);
        *gpio_out &= ~JTAG_TCK;
    }
}

void process_command(char* cmd) {
    if (strcmp(cmd, "dump_memory") == 0) {
        dump_memory(0x20000000, 16);
    } else if (strcmp(cmd, "read_flash") == 0) {
        read_flash(0, 16);
    } else if (strcmp(cmd, "get_config") == 0) {
        get_config();
    } else {
        uart_puts("Unknown command\n");
    }
}

void diagnostic_shell(void) {
    char command[64];
    uart_puts("IoT Diagnostic Shell\n");
    uart_puts("Commands: dump_memory, read_flash, get_config\n");
    
    while (1) {
        uart_puts("diagnostic> ");
        uart_gets(command, sizeof(command));
        process_command(command);
    }
}

int main(void) {
    uart_init();
    jtag_init();
    
    device_config.magic = 0x494F5444;
    device_config.version = 0x00010000;
    device_config.sensor_type = 0x00000001;
    device_config.calibration_data[0] = 0x12345678;
    device_config.calibration_data[1] = 0x9ABCDEF0;
    device_config.calibration_data[2] = 0x0FEDCBA9;
    device_config.calibration_data[3] = 0x87654321;
    
    diagnostic_shell();
    
    return 0;
}