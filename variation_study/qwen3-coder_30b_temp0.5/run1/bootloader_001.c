# Generated by ollama (qwen3-coder:30b)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>

#define BOOTLOADER_FLAG_ADDR 0x20000000
#define BOOTLOADER_FLAG_VALUE 0x424F4F54
#define UART_BASE 0x40011000
#define SD_CARD_BASE 0x40012000
#define FLASH_BASE 0x08000000
#define FLASH_PAGE_SIZE 1024
#define MAX_FIRMWARE_SIZE 0x100000

typedef struct {
    uint32_t signature;
    uint32_t size;
    uint32_t crc;
} firmware_header_t;

volatile uint32_t *uart_dr = (volatile uint32_t *)(UART_BASE + 0x00);
volatile uint32_t *uart_sr = (volatile uint32_t *)(UART_BASE + 0x0C);
volatile uint32_t *sd_status = (volatile uint32_t *)(SD_CARD_BASE + 0x00);
volatile uint32_t *sd_data = (volatile uint32_t *)(SD_CARD_BASE + 0x04);

static inline uint32_t read_uart(void) {
    while ((*uart_sr & 0x01) == 0);
    return *uart_dr;
}

static inline int check_gpio_boot(void) {
    volatile uint32_t *gpio_port = (volatile uint32_t *)0x40020000;
    return (*gpio_port & 0x01) == 0;
}

static inline void flash_write(uint32_t addr, uint32_t *data, uint32_t size) {
    volatile uint32_t *flash = (volatile uint32_t *)FLASH_BASE;
    for (uint32_t i = 0; i < size; i += 4) {
        flash[(addr + i) / 4] = data[i / 4];
    }
}

static inline void enable_flash(void) {
    volatile uint32_t *flash_cr = (volatile uint32_t *)(FLASH_BASE + 0x10);
    *flash_cr = 0x00000001;
}

static inline void disable_flash(void) {
    volatile uint32_t *flash_cr = (volatile uint32_t *)(FLASH_BASE + 0x10);
    *flash_cr = 0x00000000;
}

static inline uint32_t calculate_crc(uint32_t *data, uint32_t size) {
    uint32_t crc = 0xFFFFFFFF;
    for (uint32_t i = 0; i < size; i++) {
        crc ^= data[i];
        for (int j = 0; j < 32; j++) {
            if (crc & 0x80000000) {
                crc = (crc << 1) ^ 0x04C11DB7;
            } else {
                crc <<= 1;
            }
        }
    }
    return crc;
}

int check_firmware_update(void) {
    firmware_header_t header;
    
    if (check_gpio_boot()) {
        return 1;
    }
    
    if (*(volatile uint32_t *)BOOTLOADER_FLAG_ADDR == BOOTLOADER_FLAG_VALUE) {
        *(volatile uint32_t *)BOOTLOADER_FLAG_ADDR = 0;
        return 1;
    }
    
    return 0;
}

int load_firmware_uart(uint32_t *buffer, uint32_t max_size) {
    uint32_t received = 0;
    uint32_t total_size = 0;
    
    while (received < sizeof(firmware_header_t)) {
        buffer[received / 4] = read_uart();
        received += 4;
    }
    
    header_t *header = (header_t *)buffer;
    if (header->signature != 0x46574942) {
        return -1;
    }
    
    total_size = header->size;
    if (total_size > max_size) {
        return -2;
    }
    
    while (received < total_size) {
        buffer[received / 4] = read_uart();
        received += 4;
    }
    
    uint32_t crc = calculate_crc(buffer, total_size / 4);
    if (crc != header->crc) {
        return -3;
    }
    
    return total_size;
}

int load_firmware_sd(uint32_t *buffer, uint32_t max_size) {
    firmware_header_t header;
    uint32_t total_size = 0;
    
    if ((*sd_status & 0x01) == 0) {
        return -1;
    }
    
    for (int i = 0; i < sizeof(firmware_header_t); i += 4) {
        buffer[i / 4] = *sd_data;
    }
    
    header_t *hdr = (header_t *)buffer;
    if (hdr->signature != 0x46574942) {
        return -1;
    }
    
    total_size = hdr->size;
    if (total_size > max_size) {
        return -2;
    }
    
    for (uint32_t i = 0; i < total_size; i += 4) {
        buffer[i / 4] = *sd_data;
    }
    
    uint32_t crc = calculate_crc(buffer, total_size / 4);
    if (crc != hdr->crc) {
        return -3;
    }
    
    return total_size;
}

void boot_application(void) {
    volatile uint32_t *boot_flag = (volatile uint32_t *)BOOTLOADER_FLAG_ADDR;
    *boot_flag = 0;
    
    __asm volatile("mov sp, %0" : : "r"(0x20001000));
    __asm volatile("mov pc, %0" : : "r"(0x08000000));
}

int main(void) {
    uint32_t firmware_buffer[MAX_FIRMWARE_SIZE / 4];
    int size;
    
    if (!check_firmware_update()) {
        boot_application();
    }
    
    enable_flash();
    
    size = load_firmware_uart(firmware_buffer, MAX_FIRMWARE_SIZE);
    if (size <= 0) {
        size = load_firmware_sd(firmware_buffer, MAX_FIRMWARE_SIZE);
    }
    
    if (size > 0) {
        flash_write(FLASH_BASE, firmware_buffer, size);
        *(volatile uint32_t *)BOOTLOADER_FLAG_ADDR = BOOTLOADER_FLAG_VALUE;
    }
    
    disable_flash();
    boot_application();
}