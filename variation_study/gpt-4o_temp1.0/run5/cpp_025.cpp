# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>

class Data {
public:
    Data(const std::string& value) : value_(value) {}
    std::string transformStep1() const { return value_ + "_step1"; }
    std::string transformStep2() const { return value_ + "_step2"; }
    std::string transformStep3() const { return value_ + "_step3"; }
private:
    std::string value_;
};

std::vector<std::string> processData(const std::vector<std::string>& input) {
    std::vector<std::string> output;
    output.reserve(input.size());

    for (auto& item : input) {
        Data temp1(item);
        std::string step1Result = temp1.transformStep1();

        Data temp2(step1Result);
        std::string step2Result = temp2.transformStep2();

        Data temp3(step2Result);
        std::string step3Result = temp3.transformStep3();

        output.push_back(step3Result);
    }
    return output;
}