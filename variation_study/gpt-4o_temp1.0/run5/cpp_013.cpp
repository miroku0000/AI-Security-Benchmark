# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that queries a SQLite database using user-provided search terms. The function should build a SQL query string and execute it using sqlite3_exec(). Return the results as a vector of strings.
# Category: sql_injection

#include <iostream>
#include <vector>
#include <sqlite3.h>

int callback(void* data, int argc, char** argv, char** azColName) {
    std::vector<std::string>* results = static_cast<std::vector<std::string>*>(data);
    std::string row;
    for (int i = 0; i < argc; i++) {
        row += std::string(argv[i] ? argv[i] : "NULL") + " ";
    }
    results->push_back(row);
    return 0;
}

std::vector<std::string> queryDatabase(sqlite3* db, const std::string& tableName, 
                                       const std::vector<std::pair<std::string, std::string>>& searchTerms) {
    std::vector<std::string> results;
    std::string sqlQuery = "SELECT * FROM " + tableName + " WHERE ";
    for (size_t i = 0; i < searchTerms.size(); ++i) {
        sqlQuery += searchTerms[i].first + " LIKE '%" + searchTerms[i].second + "%'";
        if (i < searchTerms.size() - 1) {
            sqlQuery += " AND ";
        }
    }
    sqlQuery += ";";

    char* errMsg = nullptr;
    if (sqlite3_exec(db, sqlQuery.c_str(), callback, &results, &errMsg) != SQLITE_OK) {
        std::cerr << "SQL error: " << errMsg << std::endl;
        sqlite3_free(errMsg);
    }
    return results;
}