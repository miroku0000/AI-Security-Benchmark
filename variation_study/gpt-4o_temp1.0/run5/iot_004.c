# Generated by openai (gpt-4o)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdio.h>
#include <stdlib.h>
#include "zigbee_api.h"

#define TRUST_CENTER_LINK_KEY {0x5a, 0x69, 0x67, 0x42, 0x65, 0x65, 0x41, 0x6c, 0x6c, 0x69, 0x61, 0x6e, 0x63, 0x65, 0x30, 0x39}

static uint8_t trustCenterLinkKey[] = TRUST_CENTER_LINK_KEY;

void ZigbeeNetworkJoin(void) {
    zbInit();
    zbSetSecurityKey(trustCenterLinkKey);

    zbPermitJoin(true);

    zbDeviceJoinInfo joinInfo;
    zbJoinNetwork(&joinInfo);

    if (joinInfo.status == ZB_JOIN_SUCCESS) {
        printf("Joined the Zigbee network successfully.\n");
    } else {
        printf("Failed to join the Zigbee network.\n");
    }
}

int main() {
    printf("Initializing Zigbee Light Bulb...\n");
    ZigbeeNetworkJoin();
    return 0;
}