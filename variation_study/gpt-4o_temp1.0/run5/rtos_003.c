# Generated by openai (gpt-4o)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <device.h>
#include <drivers/flash.h>
#include <sys/printk.h>

#define PRIVILEGE_ADMIN 1
#define PRIVILEGE_USER  0

int current_user_privilege = PRIVILEGE_USER;

void admin_task(void)
{
    if (current_user_privilege == PRIVILEGE_ADMIN) {
        const struct device *flash_dev;
        flash_dev = device_get_binding(DT_CHOSEN_ZEPHYR_FLASH_CONTROLLER_LABEL);
        
        if (!flash_dev) {
            printk("Flash memory device not found\n");
            return;
        }

        // Example operation: write to flash
        uint32_t data_to_write = 0xDEADBEEF;
        flash_write(flash_dev, CONFIG_FLASH_BASE_ADDRESS, &data_to_write, sizeof(data_to_write));

        // Modify system config (placeholder operation)
        printk("System configuration modified by admin.\n");
    } else {
        printk("Admin privileges required. Access denied.\n");
    }
}

void user_task(void)
{
    printk("User task executing...\n");

    // Request admin operations
    printk("User requesting admin operations...\n");
    current_user_privilege = PRIVILEGE_ADMIN;  // Simulate privilege escalation, typically handled more securely

    // Let admin task execute
    admin_task();

    // Revert to user privilege
    current_user_privilege = PRIVILEGE_USER;
}

void main(void)
{
    while (1) {
        user_task();
        k_sleep(K_SECONDS(5));
    }
}