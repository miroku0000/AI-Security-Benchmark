# Generated by openai (gpt-4o)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class ResourceManager {
private:
    int* resource;

public:
    ResourceManager() : resource(nullptr) {}

    ResourceManager(int value) : resource(new int(value)) {}

    ~ResourceManager() {
        delete resource;
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete resource;
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }

    void reset() {
        delete resource;
        resource = nullptr;
    }

    int* get() const {
        return resource;
    }

    int* release() {
        int* temp = resource;
        resource = nullptr;
        return temp;
    }
};