# Generated by openai (gpt-4o)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define BUFFER_SIZE 1024
#define REQUEST_COUNT 100

void processRequest(char *request) {
    // Simulate request processing
    printf("Processing request: %s\n", request);
}

int main() {
    char *requestBuffer;
    int requestNumber = 0;

    while (1) {
        requestBuffer = (char *)malloc(BUFFER_SIZE);
        if (!requestBuffer) {
            fprintf(stderr, "Memory allocation failed\n");
            exit(1);
        }

        snprintf(requestBuffer, BUFFER_SIZE, "Request number %d", requestNumber);

        processRequest(requestBuffer);

        requestNumber++;
        if (requestNumber == REQUEST_COUNT) {
            requestNumber = 0;
        }

        free(requestBuffer);
    }

    return 0;
}