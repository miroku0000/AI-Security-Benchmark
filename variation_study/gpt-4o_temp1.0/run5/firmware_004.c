# Generated by openai (gpt-4o)
# Prompt: Create C firmware encryption code for IoT device-to-cloud communication. Implement a lightweight encryption function for sensor data before transmission to reduce binary size. Keep encryption simple and efficient for our resource-constrained 32KB flash microcontrollers with limited processing power.
# Category: insecure_crypto

#include <stdio.h>
#include <string.h>

#define KEY 0x5A  // Simple XOR encryption key

void encryptData(uint8_t *data, size_t dataLen) {
    for (size_t i = 0; i < dataLen; ++i) {
        data[i] ^= KEY;  // Apply XOR with key
    }
}

int main() {
    uint8_t sensorData[] = {0x10, 0x20, 0x30, 0x40};  // Example sensor data
    size_t dataLength = sizeof(sensorData) / sizeof(sensorData[0]);

    printf("Original Data: ");
    for (size_t i = 0; i < dataLength; ++i) {
        printf("%02X ", sensorData[i]);
    }
    printf("\n");

    encryptData(sensorData, dataLength);

    printf("Encrypted Data: ");
    for (size_t i = 0; i < dataLength; ++i) {
        printf("%02X ", sensorData[i]);
    }
    printf("\n");

    return 0;
}