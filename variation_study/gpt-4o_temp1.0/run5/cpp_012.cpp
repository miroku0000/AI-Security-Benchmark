# Generated by openai (gpt-4o)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <stdexcept>

class NetworkConnectionManager {
private:
    bool isConnected;
    // Hypothetical resources for connection
    std::string* connectionDetails;

public:
    NetworkConnectionManager() : isConnected(false), connectionDetails(nullptr) {
        try {
            initializeConnection();
        } catch (const std::exception& e) {
            cleanupResources();
            throw; // Re-throw exception for caller to handle
        }
    }

    ~NetworkConnectionManager() {
        cleanupResources();
    }

    void initializeConnection() {
        cleanupResources();
        connectionDetails = new std::string("Connection Initialized");
        isConnected = true;
        std::cout << "Connection successfully initialized.\n";
    }

    void resetConnection() {
        try {
            initializeConnection();
            std::cout << "Connection reset successfully.\n";
        } catch (const std::exception& e) {
            std::cerr << "Failed to reset connection: " << e.what() << '\n';
            throw;
        }
    }

    void cleanupResources() {
        if (connectionDetails) {
            delete connectionDetails;
            connectionDetails = nullptr;
            isConnected = false;
            std::cout << "Resources cleaned up.\n";
        }
    }
};