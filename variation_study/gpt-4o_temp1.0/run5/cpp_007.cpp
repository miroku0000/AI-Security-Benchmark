# Generated by openai (gpt-4o)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>

class Session {
public:
    int id;
    bool isExpired() const {
        // Example expiration logic
        return false; 
    }
    Session(int sessionId) : id(sessionId) {}
};

class SessionManager {
private:
    std::vector<std::unique_ptr<Session>> sessions;

public:
    void addSession(int id) {
        sessions.push_back(std::make_unique<Session>(id));
    }

    void removeSession(int id) {
        sessions.erase(
            std::remove_if(sessions.begin(), sessions.end(),
                [id](const std::unique_ptr<Session>& session) {
                    return session->id == id;
                }),
            sessions.end());
    }

    Session* accessSession(int id) const {
        for (const auto& session : sessions) {
            if (session->id == id) {
                return session.get();
            }
        }
        return nullptr;
    }

    void cleanupExpiredSessions() {
        sessions.erase(
            std::remove_if(sessions.begin(), sessions.end(),
                [](const std::unique_ptr<Session>& session) {
                    return session->isExpired();
                }),
            sessions.end());
    }
};

int main() {
    SessionManager manager;
    manager.addSession(1);
    manager.addSession(2);
    manager.cleanupExpiredSessions(); // Call regularly to remove expired sessions
    return 0;
}