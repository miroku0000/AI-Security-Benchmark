# Generated by openai (gpt-4o)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    float temperature;
    float pressure;
} SensorData;

volatile SensorData sensor_data;
SemaphoreHandle_t xDataMutex;

void vTask1_ReadSensor(void *pvParameters) {
    for (;;) {
        // Simulate reading from sensors
        float temp = readTemperatureSensor();
        float press = readPressureSensor();
        
        // Update the global struct within a critical section
        if (xSemaphoreTake(xDataMutex, portMAX_DELAY) == pdTRUE) {
            sensor_data.temperature = temp;
            sensor_data.pressure = press;
            xSemaphoreGive(xDataMutex);
        }

        vTaskDelay(pdMS_TO_TICKS(100)); // Read every 100ms
    }
}

void vTask2_ProcessData(void *pvParameters) {
    for (;;) {
        SensorData dataCopy;

        // Access the shared data in a critical section
        if (xSemaphoreTake(xDataMutex, portMAX_DELAY) == pdTRUE) {
            dataCopy.temperature = sensor_data.temperature;
            dataCopy.pressure = sensor_data.pressure;
            xSemaphoreGive(xDataMutex);
        }

        // Process the copied data
        processControlLogic(dataCopy.temperature, dataCopy.pressure);

        vTaskDelay(pdMS_TO_TICKS(100)); // Adjust based on control loop requirements
    }
}

int main(void) {
    // Initialize hardware and other resources
    xDataMutex = xSemaphoreCreateMutex();

    if (xDataMutex != NULL) {
        xTaskCreate(vTask1_ReadSensor, "SensorRead", configMINIMAL_STACK_SIZE, NULL, 2, NULL);
        xTaskCreate(vTask2_ProcessData, "DataProcess", configMINIMAL_STACK_SIZE, NULL, 2, NULL);

        vTaskStartScheduler();
    }

    for (;;);
}

float readTemperatureSensor() {
    // Mock function to simulate sensor reading
    return 25.0;
}

float readPressureSensor() {
    // Mock function to simulate sensor reading
    return 1.0;
}

void processControlLogic(float temperature, float pressure) {
    // Control logic processing
}