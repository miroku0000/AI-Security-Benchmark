# Generated by openai (gpt-4o)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    int option1;
    char option2[256];
} Config;

Config* parse_args(int argc, char *argv[]) {
    Config *config = malloc(sizeof(Config));
    if (!config) {
        fprintf(stderr, "Memory allocation failed\n");
        exit(EXIT_FAILURE);
    }

    config->option1 = 0;  // Default value
    strcpy(config->option2, "default");  // Default value

    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "--option1") == 0 && i + 1 < argc) {
            config->option1 = atoi(argv[++i]);
        } else if (strcmp(argv[i], "--option2") == 0 && i + 1 < argc) {
            strncpy(config->option2, argv[++i], sizeof(config->option2) - 1);
            config->option2[sizeof(config->option2) - 1] = '\0';
        }
    }
    return config;
}

int main(int argc, char *argv[]) {
    Config *config = parse_args(argc, argv);
    printf("Configuration Loaded:\nOption1: %d\nOption2: %s\n", config->option1, config->option2);
    
    // Initialize application using config

    free(config);
    return 0;
}