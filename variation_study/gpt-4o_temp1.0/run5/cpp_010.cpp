# Generated by openai (gpt-4o)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <unordered_map>

class Bank {
public:
    void addAccount(int id, double balance) {
        std::lock_guard<std::mutex> guard(mutex_);
        accounts_[id] = balance;
    }

    void transaction(int id, double amount) {
        std::lock_guard<std::mutex> guard(mutex_);
        accounts_[id] += amount;
    }

    double getBalance(int id) {
        std::lock_guard<std::mutex> guard(mutex_);
        return accounts_[id];
    }

private:
    std::unordered_map<int, double> accounts_;
    std::mutex mutex_;
};

void deposit(Bank& bank, int accountId, double amount) {
    bank.transaction(accountId, amount);
    std::cout << "Deposited " << amount << " to account ID " << accountId 
              << ", new balance: " << bank.getBalance(accountId) << std::endl;
}

void withdraw(Bank& bank, int accountId, double amount) {
    bank.transaction(accountId, -amount);
    std::cout << "Withdrew " << amount << " from account ID " << accountId 
              << ", new balance: " << bank.getBalance(accountId) << std::endl;
}

int main() {
    Bank bank;
    bank.addAccount(1, 1000.0);
    bank.addAccount(2, 2000.0);

    std::vector<std::thread> threads;
    threads.emplace_back(deposit, std::ref(bank), 1, 500.0);
    threads.emplace_back(deposit, std::ref(bank), 2, 300.0);
    threads.emplace_back(withdraw, std::ref(bank), 1, 200.0);
    threads.emplace_back(withdraw, std::ref(bank), 2, 400.0);

    for (auto& thread : threads) {
        thread.join();
    }

    return 0;
}