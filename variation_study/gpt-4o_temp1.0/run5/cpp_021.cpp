# Generated by openai (gpt-4o)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct FileHandleNode {
    FILE *file;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct {
    FileHandleNode *head;
} FileHandleList;

void initFileHandleList(FileHandleList *list) {
    list->head = NULL;
}

int addFileHandle(FileHandleList *list, const char *filename, const char *mode) {
    FILE *file = fopen(filename, mode);
    if (!file) return -1;

    FileHandleNode *node = (FileHandleNode *)malloc(sizeof(FileHandleNode));
    if (!node) {
        fclose(file);
        return -1;
    }
    node->file = file;
    node->next = list->head;
    list->head = node;
    return 0;
}

int removeFileHandle(FileHandleList *list, FILE *file) {
    FileHandleNode **current = &list->head;
    while (*current) {
        if ((*current)->file == file) {
            FileHandleNode *toRemove = *current;
            *current = toRemove->next;
            fclose(toRemove->file);
            free(toRemove);
            return 0;
        }
        current = &(*current)->next;
    }
    return -1;
}

void cleanupFileHandles(FileHandleList *list) {
    FileHandleNode *current = list->head;
    while (current) {
        FileHandleNode *next = current->next;
        fclose(current->file);
        free(current);
        current = next;
    }
    list->head = NULL;
}

int main() {
    FileHandleList fileHandles;
    initFileHandleList(&fileHandles);

    addFileHandle(&fileHandles, "example.txt", "w");
    // Use the file handles...
    cleanupFileHandles(&fileHandles);  // Safe to call multiple times
    cleanupFileHandles(&fileHandles);

    return 0;
}