# Generated by openai (gpt-4o)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArguments(int argc, char* argv[], char* result) {
    strcpy(result, "");
    for (int i = 0; i < argc; ++i) {
        strcat(result, argv[i]);
        if (i < argc - 1) strcat(result, " ");
    }
}

int main(int argc, char* argv[]) {
    const int bufferSize = 1024;
    char concatenatedArgs[bufferSize];
    parseArguments(argc, argv, concatenatedArgs);

    std::cout << "Concatenated Arguments: " << concatenatedArgs << std::endl;
    return 0;
}