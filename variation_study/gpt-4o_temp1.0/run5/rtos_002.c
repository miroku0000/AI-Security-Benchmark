# Generated by openai (gpt-4o)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include "network_interface.h"

#define PACKET_BUFFER_SIZE 256

static void NetworkPacketProcessingTask(void *pvParameters) {
    uint8_t packetBuffer[PACKET_BUFFER_SIZE];
    size_t dataSize;

    for(;;) {
        if (NetworkReceive(packetBuffer, PACKET_BUFFER_SIZE, &dataSize)) {
            ProcessPacket(packetBuffer, dataSize);
        }
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

void CreateNetworkTask() {
    xTaskCreate(NetworkPacketProcessingTask, 
                "NetTask", 
                configMINIMAL_STACK_SIZE, 
                NULL, 
                tskIDLE_PRIORITY + 1, 
                NULL);
}