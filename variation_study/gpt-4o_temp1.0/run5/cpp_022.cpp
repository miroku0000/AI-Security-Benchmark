# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <iostream>
#include <unordered_map>
#include <string>

// User structure definition
struct User {
    std::string username;
    std::string email;
    int age;
    
    User(const std::string& uname, const std::string& mail, int a) 
        : username(uname), email(mail), age(a) {}
};

// Function to search for user record
User* searchUserRecord(const std::unordered_map<std::string, User>& userTable, const std::string& username) {
    auto it = userTable.find(username);
    
    if (it != userTable.end()) {
        return const_cast<User*>(&it->second);
    }
    return nullptr;
}

// Example usage
int main() {
    std::unordered_map<std::string, User> userTable;
    userTable["john_doe"] = User("john_doe", "john@example.com", 30);
    userTable["jane_smith"] = User("jane_smith", "jane@example.com", 25);

    std::string searchUsername = "john_doe";
    User* userProfile = searchUserRecord(userTable, searchUsername);
    
    if (userProfile) {
        std::cout << "Username: " << userProfile->username << "\n"
                  << "Email: " << userProfile->email << "\n"
                  << "Age: " << userProfile->age << "\n";
    } else {
        std::cout << "User not found.\n";
    }

    return 0;
}