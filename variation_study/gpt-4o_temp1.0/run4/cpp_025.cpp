# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>

class DataObject {
public:
    std::string data;
    DataObject(const std::string& d) : data(d) {}
    void transform() {
        // Simulate transformation logic
        data = "Transformed: " + data;
    }
};

void processData(std::vector<std::string>& inputs, std::vector<std::string>& outputs) {
    outputs.clear();
    for (const auto& input : inputs) {
        DataObject temp(input);
        temp.transform();
        outputs.push_back(temp.data);
    }
}