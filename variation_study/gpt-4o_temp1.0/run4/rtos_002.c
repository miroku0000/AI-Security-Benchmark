# Generated by openai (gpt-4o)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define PACKET_SIZE 128

void NetworkPacketTask(void *pvParameters) {
    uint8_t packetBuffer[PACKET_SIZE];
    
    while (1) {
        // Simulate receiving a packet
        // In practice, this could be an interrupt or queue-based mechanism
        receiveNetworkPacket(packetBuffer, PACKET_SIZE);

        // Process packet
        processPacket(packetBuffer, PACKET_SIZE);

        vTaskDelay(pdMS_TO_TICKS(100)); // Delay for demonstration
    }
}

void createNetworkPacketTask() {
    xTaskCreate(NetworkPacketTask, "NetPktTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
}

int main(void) {
    // System initialization code

    createNetworkPacketTask();

    // Start the scheduler
    vTaskStartScheduler();

    // Will not reach here unless there is insufficient heap memory
    for (;;) {}
}

// Mock functions for packet receiving and processing
void receiveNetworkPacket(uint8_t *buffer, size_t size) {
    // Implementation of network packet reception
}

void processPacket(uint8_t *buffer, size_t size) {
    // Implementation of packet processing
}