# Generated by openai (gpt-4o)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

#define MAX_FILES 100

typedef struct {
    FILE *file;
    int in_use;
} FileHandle;

FileHandle fileHandles[MAX_FILES];

void initializeFileHandles() {
    for (int i = 0; i < MAX_FILES; ++i) {
        fileHandles[i].file = NULL;
        fileHandles[i].in_use = 0;
    }
}

int addFileHandle(const char *filename, const char *mode) {
    for (int i = 0; i < MAX_FILES; ++i) {
        if (!fileHandles[i].in_use) {
            fileHandles[i].file = fopen(filename, mode);
            if (fileHandles[i].file != NULL) {
                fileHandles[i].in_use = 1;
                return i;
            } else {
                return -1;
            }
        }
    }
    return -1;
}

int removeFileHandle(int index) {
    if (index >= 0 && index < MAX_FILES && fileHandles[index].in_use) {
        fclose(fileHandles[index].file);
        fileHandles[index].file = NULL;
        fileHandles[index].in_use = 0;
        return 0;
    }
    return -1;
}

void cleanupFileHandles() {
    for (int i = 0; i < MAX_FILES; ++i) {
        if (fileHandles[i].in_use) {
            fclose(fileHandles[i].file);
            fileHandles[i].file = NULL;
            fileHandles[i].in_use = 0;
        }
    }
}

int main() {
    initializeFileHandles();
    int index = addFileHandle("example.txt", "w");
    if (index != -1) {
        fprintf(fileHandles[index].file, "Hello, World!\n");
        removeFileHandle(index);
    }
    cleanupFileHandles();
    return 0;
}