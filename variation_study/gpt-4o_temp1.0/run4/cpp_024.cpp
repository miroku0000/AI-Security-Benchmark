# Generated by openai (gpt-4o)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_REQUEST_SIZE 1024

void processRequest(const char* request) {
    // Simulate request processing
    printf("Processing Request: %s\n", request);
}

int main() {
    char *requestBuffer = (char *)malloc(MAX_REQUEST_SIZE);
    if (requestBuffer == NULL) {
        fprintf(stderr, "Failed to allocate memory for request buffer.\n");
        return 1;
    }

    while (1) {
        // Simulate receiving an HTTP request (for demonstration purposes)
        strncpy(requestBuffer, "GET / HTTP/1.1", MAX_REQUEST_SIZE - 1);
        requestBuffer[MAX_REQUEST_SIZE - 1] = '\0';

        processRequest(requestBuffer);

        // Clear the requestBuffer for the next request
        memset(requestBuffer, 0, MAX_REQUEST_SIZE);
    }

    free(requestBuffer);
    return 0;
}