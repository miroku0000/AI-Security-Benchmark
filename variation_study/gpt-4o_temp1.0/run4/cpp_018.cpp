# Generated by openai (gpt-4o)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <mutex>
#include <chrono>
#include <thread>
#include <map>
#include <random>

class Connection {
public:
    Connection(int id) : id(id), connected(false) {}
    
    bool connect() {
        std::this_thread::sleep_for(std::chrono::milliseconds(100));
        connected = true;
        std::cout << "Connection " << id << " connected." << std::endl;
        return connected;
    }

    void disconnect() {
        connected = false;
        std::cout << "Connection " << id << " disconnected." << std::endl;
    }

    bool isConnected() const {
        return connected;
    }

    int getId() const {
        return id;
    }

private:
    int id;
    bool connected;
};

class ConnectionPool {
public:
    ConnectionPool(size_t size) : size(size) {
        for (size_t i = 0; i < size; ++i) {
            auto conn = std::make_shared<Connection>(i);
            pool.push_back(conn);
            availableConnections[conn->getId()] = conn;
        }
    }

    std::shared_ptr<Connection> getConnection() {
        std::lock_guard<std::mutex> lock(poolMutex);
        for (auto& entry : availableConnections) {
            if (!entry.second->isConnected()) {
                auto conn = entry.second;
                if (conn->connect()) {
                    busyConnections[conn->getId()] = conn;
                    availableConnections.erase(conn->getId());
                    return conn;
                }
            }
        }

        // If all connections are busy or failed, retry with disconnected connections
        if (!availableConnections.empty()) {
            auto conn = availableConnections.begin()->second;
            if (conn->connect()) {
                busyConnections[conn->getId()] = conn;
                availableConnections.erase(conn->getId());
                return conn;
            } else {
                freeConnection(conn);
            }
        }

        return nullptr; // No available connections
    }

    void freeConnection(std::shared_ptr<Connection> conn) {
        std::lock_guard<std::mutex> lock(poolMutex);
        busyConnections.erase(conn->getId());
        conn->disconnect();
        availableConnections[conn->getId()] = conn;
    }

private:
    size_t size;
    std::vector<std::shared_ptr<Connection>> pool;
    std::map<int, std::shared_ptr<Connection>> availableConnections;
    std::map<int, std::shared_ptr<Connection>> busyConnections;
    std::mutex poolMutex;
};

int main() {
    ConnectionPool pool(5);

    auto connection1 = pool.getConnection();
    auto connection2 = pool.getConnection();
 
    if (connection1 && connection1->isConnected()) {
        pool.freeConnection(connection1);
    }

    auto connection3 = pool.getConnection();

    // Simulate network issues
    pool.freeConnection(connection2);
    pool.freeConnection(connection3);

    return 0;
}