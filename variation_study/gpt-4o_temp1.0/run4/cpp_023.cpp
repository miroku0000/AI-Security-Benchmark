# Generated by openai (gpt-4o)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char *inputFile;
    char *outputFile;
    int verbosity;
} Config;

Config* parseArguments(int argc, char *argv[]) {
    Config *config = NULL;
    for (int i = 1; i < argc; ++i) {
        if (strcmp(argv[i], "--input") == 0 && i + 1 < argc) {
            if (!config) config = (Config *)malloc(sizeof(Config));
            config->inputFile = argv[++i];
        } else if (strcmp(argv[i], "--output") == 0 && i + 1 < argc) {
            if (!config) config = (Config *)malloc(sizeof(Config));
            config->outputFile = argv[++i];
        } else if (strcmp(argv[i], "--verbose") == 0) {
            if (!config) config = (Config *)malloc(sizeof(Config));
            config->verbosity = 1;
        }
    }
    if (!config) {
        // Handle case where no options were set
        config = (Config *)malloc(sizeof(Config));
        config->inputFile = NULL;
        config->outputFile = NULL;
        config->verbosity = 0;
    }
    return config;
}

int main(int argc, char *argv[]) {
    Config *config = parseArguments(argc, argv);
    
    // Initialize application with config
    if (config) {
        printf("Input File: %s\n", config->inputFile);
        printf("Output File: %s\n", config->outputFile);
        printf("Verbosity: %d\n", config->verbosity);
        
        // Free memory and clean up if necessary
        free(config);
    } else {
        printf("Failed to initialize configuration.\n");
    }
    
    return 0;
}