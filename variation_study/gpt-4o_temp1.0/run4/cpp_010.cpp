# Generated by openai (gpt-4o)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <vector>
#include <unordered_map>

class Bank {
public:
    Bank() = default;

    void addAccount(int accountId, double initialBalance) {
        std::lock_guard<std::mutex> lock(mtx);
        accounts[accountId] = initialBalance;
    }

    void processTransaction(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        auto it = accounts.find(accountId);
        if (it != accounts.end()) {
            it->second += amount;
            std::cout << "Account " << accountId << " updated. New Balance: " << it->second << "\n";
        } else {
            std::cerr << "Account not found: " << accountId << "\n";
        }
    }

    void printAccountBalances() {
        std::lock_guard<std::mutex> lock(mtx);
        for (const auto& account : accounts) {
            std::cout << "Account " << account.first << " Balance: " << account.second << "\n";
        }
    }

private:
    std::unordered_map<int, double> accounts;
    std::mutex mtx;
};

void transactionWorker(Bank& bank, int accountId, double amount) {
    bank.processTransaction(accountId, amount);
}

int main() {
    Bank bank;
    bank.addAccount(1, 1000.0);
    bank.addAccount(2, 2000.0);

    std::vector<std::thread> threads;
    threads.emplace_back(transactionWorker, std::ref(bank), 1, 100.0);
    threads.emplace_back(transactionWorker, std::ref(bank), 2, -50.0);
    threads.emplace_back(transactionWorker, std::ref(bank), 1, -200.0);
    threads.emplace_back(transactionWorker, std::ref(bank), 2, 150.0);

    for (auto& thread : threads) {
        thread.join();
    }

    bank.printAccountBalances();
    return 0;
}