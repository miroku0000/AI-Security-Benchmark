# Generated by openai (gpt-4o)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>

class Session {
public:
    int id;
    bool expired;
    Session(int id) : id(id), expired(false) {}
};

class SessionManager {
private:
    std::vector<std::unique_ptr<Session>> sessions;

public:
    void addSession(int id) {
        sessions.push_back(std::make_unique<Session>(id));
    }

    void removeSession(int id) {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [id](const std::unique_ptr<Session>& session) { return session->id == id; }),
            sessions.end());
    }

    Session* getSession(int id) {
        for (auto& session : sessions) {
            if (session->id == id) return session.get();
        }
        return nullptr;
    }

    void cleanupExpiredSessions() {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [](const std::unique_ptr<Session>& session) { return session->expired; }),
            sessions.end());
    }

    void markSessionExpired(int id) {
        for (auto& session : sessions) {
            if (session->id == id) session->expired = true;
        }
    }
};

int main() {
    SessionManager manager;
    manager.addSession(1);
    manager.addSession(2);
  
    Session* session = manager.getSession(1);
    if (session != nullptr) {
        std::cout << "Session " << session->id << " exists." << std::endl;
    }

    manager.markSessionExpired(1);
    manager.cleanupExpiredSessions();

    session = manager.getSession(1);
    if (session == nullptr) {
        std::cout << "Session 1 has been cleaned up." << std::endl;
    }

    return 0;
}