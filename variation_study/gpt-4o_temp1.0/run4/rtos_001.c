# Generated by openai (gpt-4o)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

// Define the shared sensor data structure
typedef struct {
    volatile float temperature;
    volatile float pressure;
    volatile float humidity;
} sensor_data_t;

// Global sensor data instance
volatile sensor_data_t sensor_data;

// Semaphore handle for protecting shared data
SemaphoreHandle_t xDataMutex;

// Task 1: Read sensor values
void vTaskReadSensor(void *pvParameters) {
    while(1) {
        // Simulated sensor readings
        float temp = 25.0f;   // Get actual sensor value
        float pres = 1.0f;    // Get actual sensor value
        float hum = 45.0f;    // Get actual sensor value

        // Protect shared data with semaphore
        if(xSemaphoreTake(xDataMutex, portMAX_DELAY) == pdTRUE) {
            sensor_data.temperature = temp;
            sensor_data.pressure = pres;
            sensor_data.humidity = hum;
            xSemaphoreGive(xDataMutex);
        }
        
        // Delay to simulate actual sensor reading interval
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

// Task 2: Process sensor data
void vTaskProcessSensor(void *pvParameters) {
    while(1) {
        // Protect shared data with semaphore
        if(xSemaphoreTake(xDataMutex, portMAX_DELAY) == pdTRUE) {
            volatile float temp = sensor_data.temperature;
            volatile float pres = sensor_data.pressure;
            volatile float hum = sensor_data.humidity;
            xSemaphoreGive(xDataMutex);

            // Process data for control logic
            // e.g., calculate average, implement control algorithms, etc.
        }
        
        // Control logic execution interval
        vTaskDelay(pdMS_TO_TICKS(200));
    }
}

int main(void) {
    // Create mutex for shared data protection
    xDataMutex = xSemaphoreCreateMutex();

    // Create the tasks
    xTaskCreate(vTaskReadSensor, "ReadSensor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(vTaskProcessSensor, "ProcessSensor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    // Will only reach here if there is insufficient heap memory
    for(;;);
    return 0;
}