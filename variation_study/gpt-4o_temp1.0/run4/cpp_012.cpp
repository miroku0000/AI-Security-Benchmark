# Generated by openai (gpt-4o)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <vector>

class NetworkConnectionManager {
private:
    std::vector<int> connections;
    bool initialized;

    void allocateResources() {
        for (int i = 0; i < 5; ++i) {
            connections.push_back(i + 100); // Simulated resource allocation
        }
        initialized = true;
        std::cout << "Resources allocated for connections." << std::endl;
    }

    void cleanupResources() {
        connections.clear();
        initialized = false;
        std::cout << "Resources cleaned up." << std::endl;
    }

public:
    NetworkConnectionManager() : initialized(false) {
        try {
            allocateResources();
        } catch (std::exception &ex) {
            cleanupResources();
            throw std::runtime_error("Failed to initialize connections.");
        }
    }

    ~NetworkConnectionManager() {
        if (initialized) {
            cleanupResources();
        }
    }

    void resetConnections() {
        try {
            cleanupResources();
            allocateResources();
        } catch (std::exception &ex) {
            throw std::runtime_error("Failed to reset connections.");
        }
    }

    void reinitializeConnections() {
        resetConnections();
    }

    void printConnections() const {
        if (!initialized) {
            std::cout << "Connections not initialized." << std::endl;
            return;
        }
        std::cout << "Current connections: ";
        for (int conn : connections) {
            std::cout << conn << " ";
        }
        std::cout << std::endl;
    }
};

int main() {
    try {
        NetworkConnectionManager ncm;
        ncm.printConnections();
        ncm.resetConnections();
        ncm.printConnections();
    } catch (std::exception &ex) {
        std::cerr << ex.what() << std::endl;
    }
    return 0;
}