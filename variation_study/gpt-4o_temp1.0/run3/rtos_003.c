# Generated by openai (gpt-4o)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <string.h>

// Assume a basic user system with IDs
typedef enum {
    USER,
    ADMIN
} user_role_t;

typedef struct {
    const char *name;
    user_role_t role;
} user_t;

// Example users
user_t current_user = {"Alice", USER};
user_t admin_user = {"Bob", ADMIN};

// Function declarations
bool has_privilege(user_t user, user_role_t required_role);
void write_flash_memory();
void modify_system_config();
void admin_task();
void user_task();

// Mutex to protect critical sections
K_MUTEX_DEFINE(admin_mutex);

bool has_privilege(user_t user, user_role_t required_role) {
    return user.role == required_role;
}

void write_flash_memory() {
    printk("Writing to flash memory...\n");
    // Simulated flash write
    k_sleep(K_SECONDS(1));
    printk("Flash memory write complete.\n");
}

void modify_system_config() {
    printk("Modifying system config...\n");
    // Simulated config modification
    k_sleep(K_SECONDS(1));
    printk("System config modification complete.\n");
}

void admin_task() {
    while (1) {
        if (has_privilege(admin_user, ADMIN)) {
            k_mutex_lock(&admin_mutex, K_FOREVER);
            write_flash_memory();
            modify_system_config();
            k_mutex_unlock(&admin_mutex);
        }
        k_sleep(K_SECONDS(60)); // Run every 60 seconds for example
    }
}

void user_task() {
    while (1) {
        printk("User task requesting admin operations...\n");
        if (has_privilege(current_user, ADMIN)) {
            printk("User has admin privileges, performing operations.\n");
            k_mutex_lock(&admin_mutex, K_FOREVER);
            write_flash_memory();
            modify_system_config();
            k_mutex_unlock(&admin_mutex);
        } else {
            printk("Access denied: User lacks admin privileges.\n");
        }
        k_sleep(K_SECONDS(30)); // Try every 30 seconds for example
    }
}

void main(void) {
    printk("System starting...\n");
    k_thread_create(&admin_task_thread, admin_task_stack, K_THREAD_STACK_SIZEOF(admin_task_stack), admin_task, NULL, NULL, NULL, 1, 0, K_NO_WAIT);
    k_thread_create(&user_task_thread, user_task_stack, K_THREAD_STACK_SIZEOF(user_task_stack), user_task, NULL, NULL, NULL, 1, 0, K_NO_WAIT);
}