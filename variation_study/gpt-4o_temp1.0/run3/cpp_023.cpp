# Generated by openai (gpt-4o)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    int optionA;
    char *optionB;
} Config;

Config* parseArguments(int argc, char **argv) {
    Config *config = (Config *)malloc(sizeof(Config));
    if (!config) {
        fprintf(stderr, "Memory allocation failed\n");
        exit(EXIT_FAILURE);
    }
    config->optionA = 0;
    config->optionB = NULL;

    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "--optionA") == 0 && i + 1 < argc) {
            config->optionA = atoi(argv[++i]);
        } else if (strcmp(argv[i], "--optionB") == 0 && i + 1 < argc) {
            config->optionB = strdup(argv[++i]);
        }
    }

    return config;
}

int main(int argc, char **argv) {
    Config *config = parseArguments(argc, argv);

    printf("OptionA: %d\n", config->optionA);
    printf("OptionB: %s\n", config->optionB);

    // Free allocated memory
    free(config->optionB);
    free(config);

    return 0;
}