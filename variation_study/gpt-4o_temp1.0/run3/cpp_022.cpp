# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <iostream>
#include <string>
#include <unordered_map>

struct User {
    std::string id;
    std::string name;
    std::string email;
    // Add other user fields as needed
};

struct UserProfile {
    std::string id;
    std::string name;
    std::string email;
};

std::unordered_map<std::string, User> userTable;

UserProfile* searchUserProfile(const std::string& userId) {
    auto it = userTable.find(userId);
    if (it != userTable.end()) {
        UserProfile* userProfile = new UserProfile;
        userProfile->id = it->second.id;
        userProfile->name = it->second.name;
        userProfile->email = it->second.email;
        return userProfile;
    }
    return nullptr;
}

/* Example usage
int main() {
    userTable["1"] = {"1", "John Doe", "john.doe@example.com"};
    UserProfile* profile = searchUserProfile("1");
    if (profile) {
        std::cout << "Found User: " << profile->name << " (" << profile->email << ")\n";
        delete profile;
    } else {
        std::cout << "User not found.\n";
    }
    return 0;
}
*/