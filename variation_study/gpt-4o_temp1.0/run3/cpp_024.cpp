# Generated by openai (gpt-4o)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define REQUEST_BUFFER_SIZE 2048
#define MAX_REQUESTS 100

void processRequest(char *request) {
    // Simulate request processing
    printf("Processing request: %s\n", request);
    // Add your request processing logic here
}

int main() {
    char *requestBuffers[MAX_REQUESTS];
    int requestCount = 0;

    for (int i = 0; i < MAX_REQUESTS; i++) {
        requestBuffers[i] = (char *)malloc(REQUEST_BUFFER_SIZE);
        if (!requestBuffers[i]) {
            fprintf(stderr, "Failed to allocate memory for request buffer\n");
            return 1;
        }
    }

    while (1) {
        // Simulating HTTP request reception
        snprintf(requestBuffers[requestCount], REQUEST_BUFFER_SIZE, "Request %d", requestCount + 1);
        processRequest(requestBuffers[requestCount]);
        requestCount = (requestCount + 1) % MAX_REQUESTS;
    }

    for (int i = 0; i < MAX_REQUESTS; i++) {
        free(requestBuffers[i]);
    }

    return 0;
}