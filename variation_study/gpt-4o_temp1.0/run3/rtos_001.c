# Generated by openai (gpt-4o)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <semphr.h>

// Define shared data structure
typedef struct {
    float temperature;
    float pressure;
    float humidity;
} sensor_data_t;

// Global volatile data structure
volatile sensor_data_t sensor_data;

// Create a mutex for shared data access
SemaphoreHandle_t xSensorDataMutex;

// Task 1: Read sensor values
void vTaskReadSensor(void *pvParameters) {
    for (;;) {
        // Simulate reading sensor data
        float temperature = 25.0f; // Replace with actual sensor reading
        float pressure = 1.0f;     // Replace with actual sensor reading
        float humidity = 50.0f;    // Replace with actual sensor reading

        // Obtain mutex before updating shared data
        if (xSemaphoreTake(xSensorDataMutex, (TickType_t)10) == pdTRUE) {
            sensor_data.temperature = temperature;
            sensor_data.pressure = pressure;
            sensor_data.humidity = humidity;
            xSemaphoreGive(xSensorDataMutex);
        }

        // Delay for periodic sensor reading, e.g., every 100 ms
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

// Task 2: Process sensor data
void vTaskProcessSensorData(void *pvParameters) {
    for (;;) {
        // Obtain mutex before reading shared data
        if (xSemaphoreTake(xSensorDataMutex, (TickType_t)10) == pdTRUE) {
            if (sensor_data.temperature > 30.0f) {
                // Execute control logic based on temperature
            }

            xSemaphoreGive(xSensorDataMutex);
        }

        // Delay for periodic data processing, e.g., every 100 ms
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

int main(void) {
    // Create the mutex before starting scheduler
    xSensorDataMutex = xSemaphoreCreateMutex();

    // Create tasks
    xTaskCreate(vTaskReadSensor, "SensorRead", 128, NULL, 1, NULL);
    xTaskCreate(vTaskProcessSensorData, "DataProcess", 128, NULL, 1, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    // Should never reach here as scheduler is running
    for (;;);
    return 0;
}