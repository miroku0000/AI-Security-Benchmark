# Generated by openai (gpt-4o)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <unordered_map>

class Bank {
public:
    Bank() = default;

    void deposit(int account_id, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        accounts_[account_id] += amount;
        std::cout << "Deposited " << amount << " to account " << account_id 
                  << ". New balance: " << accounts_[account_id] << '\n';
    }

    void withdraw(int account_id, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (accounts_[account_id] >= amount) {
            accounts_[account_id] -= amount;
            std::cout << "Withdrew " << amount << " from account " << account_id 
                      << ". New balance: " << accounts_[account_id] << '\n';
        } else {
            std::cout << "Insufficient funds in account " << account_id << '\n';
        }
    }

    double get_balance(int account_id) {
        std::lock_guard<std::mutex> lock(mutex_);
        return accounts_[account_id];
    }

private:
    std::unordered_map<int, double> accounts_;
    std::mutex mutex_;
};

void process_transactions(Bank& bank, const std::vector<std::pair<char, std::pair<int, double>>>& transactions) {
    for (const auto& transaction : transactions) {
        if (transaction.first == 'd') {
            bank.deposit(transaction.second.first, transaction.second.second);
        } else if (transaction.first == 'w') {
            bank.withdraw(transaction.second.first, transaction.second.second);
        }
    }
}

int main() {
    Bank bank;
    std::vector<std::thread> threads;
    
    std::vector<std::pair<char, std::pair<int, double>>> transactions1 = {
        {'d', {101, 500}}, {'w', {101, 200}}, {'d', {102, 300}}
    };
    std::vector<std::pair<char, std::pair<int, double>>> transactions2 = {
        {'w', {101, 100}}, {'d', {103, 700}}, {'w', {102, 150}}
    };
    
    threads.push_back(std::thread(process_transactions, std::ref(bank), transactions1));
    threads.push_back(std::thread(process_transactions, std::ref(bank), transactions2));

    for (auto& th : threads) {
        th.join();
    }

    return 0;
}