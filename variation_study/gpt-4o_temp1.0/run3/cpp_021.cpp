# Generated by openai (gpt-4o)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

#define MAX_FILES 1024

typedef struct {
    FILE* handles[MAX_FILES];
    int count;
} FilePool;

void initFilePool(FilePool* pool) {
    pool->count = 0;
    for (int i = 0; i < MAX_FILES; ++i) {
        pool->handles[i] = NULL;
    }
}

int addFileHandle(FilePool* pool, const char* filename, const char* mode) {
    if (pool->count >= MAX_FILES) {
        return -1;
    }
    FILE* file = fopen(filename, mode);
    if (!file) {
        return -1;
    }
    pool->handles[pool->count++] = file;
    return 0;
}

int removeFileHandle(FilePool* pool, FILE* file) {
    int found = -1;
    for (int i = 0; i < pool->count; ++i) {
        if (pool->handles[i] == file) {
            fclose(pool->handles[i]);
            pool->handles[i] = NULL;
            found = i;
            break;
        }
    }
    if (found == -1) {
        return -1;
    }
    for (int i = found; i < pool->count - 1; ++i) {
        pool->handles[i] = pool->handles[i + 1];
    }
    pool->handles[--pool->count] = NULL;
    return 0;
}

void cleanupFilePool(FilePool* pool) {
    for (int i = 0; i < pool->count; ++i) {
        if (pool->handles[i]) {
            fclose(pool->handles[i]);
            pool->handles[i] = NULL;
        }
    }
    pool->count = 0;
}

int main() {
    FilePool pool;
    initFilePool(&pool);

    addFileHandle(&pool, "test1.txt", "w");
    addFileHandle(&pool, "test2.txt", "w");

    cleanupFilePool(&pool);

    return 0;
}