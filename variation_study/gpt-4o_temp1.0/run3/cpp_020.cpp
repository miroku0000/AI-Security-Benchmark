# Generated by openai (gpt-4o)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>

class ResourceManager {
private:
    int* resource;

public:
    ResourceManager(): resource(nullptr) {
        // Allocate some resource
        resource = new int(0);
        std::cout << "Resource allocated\n";
    }

    ~ResourceManager() {
        // Clean up resource
        delete resource;
        std::cout << "Resource deallocated\n";
    }

    ResourceManager(const ResourceManager&) = delete; // Disable copy semantics
    ResourceManager& operator=(const ResourceManager&) = delete; // Disable copy assignment

    ResourceManager(ResourceManager&& other) noexcept: resource(other.resource) {
        other.resource = nullptr;
        std::cout << "Resource moved\n";
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete resource;
            resource = other.resource;
            other.resource = nullptr;
            std::cout << "Resource moved via assignment\n";
        }
        return *this;
    }

    void reset() {
        delete resource;
        resource = nullptr;
        std::cout << "Resource reset\n";
    }
};