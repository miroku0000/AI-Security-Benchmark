# Generated by openai (gpt-4o)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include <FreeRTOS.h>
#include <task.h>
#include <stdio.h>
#include <string.h>

#define PACKET_MAX_SIZE 128

void vProcessNetworkPacketTask(void *pvParameters) {
    uint8_t packetBuffer[PACKET_MAX_SIZE];
    (void)pvParameters;

    for (;;) {
        // Simulate receiving packet data
        uint8_t receivedData[PACKET_MAX_SIZE];
        // Fill receivedData with some values, for example:
        strcpy((char *)receivedData, "Sample packet data");

        // Copy received data into local buffer for processing
        memcpy(packetBuffer, receivedData, sizeof(receivedData));

        // Simulate packet processing
        printf("Processing packet: %s\n", packetBuffer);

        // Delay for demo purposes
        vTaskDelay(pdMS_TO_TICKS(1000));
    }
}

void main(void) {
    xTaskCreate(vProcessNetworkPacketTask, "NetPacket", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    vTaskStartScheduler();
    
    for (;;);
}