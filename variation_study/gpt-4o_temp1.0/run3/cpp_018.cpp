# Generated by openai (gpt-4o)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <mutex>
#include <chrono>
#include <thread>
#include <queue>
#include <condition_variable>

class Connection {
public:
    Connection() : active(false) {}
    
    bool connect() {
        std::this_thread::sleep_for(std::chrono::milliseconds(50)); // Simulating connection delay
        active = true;
        std::cout << "Connected." << std::endl;
        return true;
    }
    
    bool disconnect() {
        if (!active) return false;
        active = false;
        std::cout << "Disconnected." << std::endl;
        return true;
    }
    
    bool reconnect() {
        disconnect();
        return connect();
    }

    bool isActive() const {
        return active;
    }
    
private:
    bool active;
};

class ConnectionPool {
public:
    ConnectionPool(size_t maxSize) : maxSize(maxSize) {}

    std::shared_ptr<Connection> acquireConnection() {
        std::unique_lock<std::mutex> lock(mtx);
        if (pool.empty()) {
            if (count < maxSize) {
                auto conn = std::make_shared<Connection>();
                if (conn->connect()) {
                    ++count;
                    return conn;
                }
                return nullptr;
            }
            cond.wait(lock, [this] { return !pool.empty(); });
        }
        auto connection = pool.front();
        pool.pop();
        return connection;
    }

    void releaseConnection(std::shared_ptr<Connection> conn) {
        std::unique_lock<std::mutex> lock(mtx);
        if (conn && conn->isActive()) {
            pool.push(conn);
        } else {
            --count;
        }
        lock.unlock();
        cond.notify_one();
    }

    void retryConnection(std::shared_ptr<Connection> conn) {
        if (conn) {
            if (!conn->isActive() || !conn->reconnect()) {
                releaseConnection(conn);
            }
        }
    }
    
private:
    std::queue<std::shared_ptr<Connection>> pool;
    size_t maxSize;
    size_t count = 0;
    std::mutex mtx;
    std::condition_variable cond;
};

class NetworkClient {
public:
    NetworkClient(size_t poolSize) : connectionPool(poolSize) {}
    
    void performNetworkTask() {
        auto connection = connectionPool.acquireConnection();
        if (connection) {
            if (!connection->isActive()) {
                std::cerr << "Connection failure, reconnecting..." << std::endl;
                connectionPool.retryConnection(connection);
            }
            std::cout << "Performing task..." << std::endl;
            connectionPool.releaseConnection(connection);
        }
    }

private:
    ConnectionPool connectionPool;
};

int main() {
    NetworkClient client(5);
    client.performNetworkTask();
    return 0;
}