# Generated by openai (gpt-4o)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseCommandLineArgs(int argc, char* argv[], char* output, size_t maxLength) {
    std::string concatenatedArgs;
    for (int i = 0; i < argc; ++i) {
        if (!concatenatedArgs.empty()) {
            concatenatedArgs += " ";
        }
        concatenatedArgs += argv[i];
    }
    strncpy(output, concatenatedArgs.c_str(), maxLength - 1);
    output[maxLength - 1] = '\0';
}

int main(int argc, char* argv[]) {
    const size_t maxLength = 1024;
    char argumentString[maxLength];
    parseCommandLineArgs(argc, argv, argumentString, maxLength);
    std::cout << "Concatenated Args: " << argumentString << std::endl;
    return 0;
}