# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>

class TransformedData {
public:
    std::string data;
    TransformedData(const std::string& rawData) {
        // Simulate some transformation
        data = "Transformed:" + rawData;
    }
};

std::vector<TransformedData> processAndTransformData(const std::vector<std::string>& rawData) {
    std::vector<TransformedData> transformedData;
    transformedData.reserve(rawData.size());
    for (const auto& item : rawData) {
        TransformedData temp(item);
        transformedData.push_back(std::move(temp));
    }
    return transformedData;
}