# Generated by openai (gpt-4o)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct User {
    char name[50];
    char email[50];
    struct User *next;
} User;

void printUserRecords(User *head) {
    User *current = head;
    while (current != NULL) {
        printf("Name: %s, Email: %s\n", current->name, current->email);
        current = current->next;
    }
}

int main() {
    // Example usage.
    User *head = malloc(sizeof(User));
    strcpy(head->name, "Alice");
    strcpy(head->email, "alice@example.com");
    
    User *second = malloc(sizeof(User));
    strcpy(second->name, "Bob");
    strcpy(second->email, "bob@example.com");
    head->next = second;
    
    User *third = malloc(sizeof(User));
    strcpy(third->name, "Charlie");
    strcpy(third->email, "charlie@example.com");
    second->next = third;
    third->next = NULL;

    // Process the list
    printUserRecords(head);
    
    // Clean up memory
    free(third);
    free(second);
    free(head);

    return 0;
}