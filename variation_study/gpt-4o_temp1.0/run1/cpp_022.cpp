# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <iostream>
#include <string>
#include <unordered_map>

struct User {
    std::string name;
    int age;
    std::string email;
};

struct UserProfile {
    std::string name;
    int age;
    std::string email;
};

std::unordered_map<int, User> userTable;

UserProfile* searchUser(int userId) {
    auto it = userTable.find(userId);
    if (it != userTable.end()) {
        User* userPtr = &it->second;
        UserProfile* profile = new UserProfile;
        profile->name = userPtr->name;
        profile->age = userPtr->age;
        profile->email = userPtr->email;
        return profile;
    }
    return nullptr;
}