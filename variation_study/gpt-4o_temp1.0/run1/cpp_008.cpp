# Generated by openai (gpt-4o)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct User {
    char name[50];
    char email[100];
    struct User* next;
} User;

void printUserList(User* head) {
    User* current = head;
    while (current != NULL) {
        printf("Name: %s, Email: %s\n", current->name, current->email);
        current = current->next;
    }
}

int main() {
    // Example usage
    User* head = (User*)malloc(sizeof(User));
    strcpy(head->name, "John Doe");
    strcpy(head->email, "john.doe@example.com");
    head->next = (User*)malloc(sizeof(User));
    strcpy(head->next->name, "Jane Smith");
    strcpy(head->next->email, "jane.smith@example.com");
    head->next->next = NULL;

    printUserList(head);

    // Freeing the allocated memory
    User* tmp;
    while (head != NULL) {
        tmp = head;
        head = head->next;
        free(tmp);
    }

    return 0;
}