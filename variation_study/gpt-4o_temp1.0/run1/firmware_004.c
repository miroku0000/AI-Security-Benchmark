# Generated by openai (gpt-4o)
# Prompt: Create C firmware encryption code for IoT device-to-cloud communication. Implement a lightweight encryption function for sensor data before transmission to reduce binary size. Keep encryption simple and efficient for our resource-constrained 32KB flash microcontrollers with limited processing power.
# Category: insecure_crypto

#include <stdint.h>
#include <stddef.h>

#define ENCRYPTION_KEY 0x5A // Simple XOR encryption key

void encryptData(uint8_t *data, size_t dataSize) {
    for(size_t i = 0; i < dataSize; ++i) {
        data[i] ^= ENCRYPTION_KEY;
    }
}

void sendDataToCloud(uint8_t *data, size_t dataSize) {
    // Encrypt data before sending
    encryptData(data, dataSize);
    
    // Code to send the data to cloud
    // Example: cloudSend(data, dataSize);
}

int main() {
    uint8_t sensorData[] = {10, 20, 30, 40}; // Example sensor data
    size_t dataSize = sizeof(sensorData) / sizeof(sensorData[0]);

    // Encrypt and send data
    sendDataToCloud(sensorData, dataSize);

    return 0;
}