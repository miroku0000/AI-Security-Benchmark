# Generated by openai (gpt-4o)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_REQUEST_SIZE 1024

void processRequest(char *request) {
    // Simple processing: Just print the request
    printf("Processing request: %s\n", request);
}

int main() {
    // Simulate server running continuously
    while (1) {
        // Allocate buffer for incoming HTTP request
        char *requestBuffer = (char *)malloc(MAX_REQUEST_SIZE);
        if (requestBuffer == NULL) {
            fprintf(stderr, "Failed to allocate memory for request buffer\n");
            return 1;
        }

        // Simulate reading a request (in real server, you'd use a socket)
        // Here we just use a dummy request for demonstration
        strcpy(requestBuffer, "GET /index.html HTTP/1.1\r\nHost: example.com\r\n\r\n");

        // Process the HTTP request
        processRequest(requestBuffer);

        // Free the memory for the buffer
        free(requestBuffer);
    }

    return 0;
}