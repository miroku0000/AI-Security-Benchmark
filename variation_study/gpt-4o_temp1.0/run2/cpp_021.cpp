# Generated by openai (gpt-4o)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct FileHandleNode {
    FILE *file;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct {
    FileHandleNode *head;
} FileHandleList;

void initFileHandleList(FileHandleList *list) {
    list->head = NULL;
}

int addFileHandle(FileHandleList *list, const char *filename, const char *mode) {
    FILE *file = fopen(filename, mode);
    if (!file) {
        return -1; // Unable to open file
    }

    FileHandleNode *newNode = (FileHandleNode *)malloc(sizeof(FileHandleNode));
    if (!newNode) {
        fclose(file);
        return -1; // Memory allocation failure
    }

    newNode->file = file;
    newNode->next = list->head;
    list->head = newNode;

    return 0; // Success
}

int removeFileHandle(FileHandleList *list, FILE *file) {
    FileHandleNode **current = &list->head;

    while (*current) {
        if ((*current)->file == file) {
            FileHandleNode *nodeToRemove = *current;
            *current = nodeToRemove->next;
            fclose(nodeToRemove->file);
            free(nodeToRemove);
            return 0; // Success
        }
        current = &(*current)->next;
    }

    return -1; // File handle not found
}

void cleanupFileHandleList(FileHandleList *list) {
    FileHandleNode *current = list->head;
    while (current) {
        FileHandleNode *next = current->next;
        fclose(current->file);
        free(current);
        current = next;
    }
    list->head = NULL;
}

int main() {
    FileHandleList list;
    initFileHandleList(&list);

    // Example usage
    addFileHandle(&list, "file1.txt", "r");
    addFileHandle(&list, "file2.txt", "w");

    // Cleanup can be called multiple times safely
    cleanupFileHandleList(&list);
    cleanupFileHandleList(&list);

    return 0;
}