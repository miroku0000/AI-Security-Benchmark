# Generated by openai (gpt-4o)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <string>
#include <memory>

class Session {
public:
    Session(const std::string& id) : sessionId(id), expired(false) {}
    const std::string& getId() const { return sessionId; }
    bool isExpired() const { return expired; }
    void expire() { expired = true; }
private:
    std::string sessionId;
    bool expired;
};

class SessionManager {
public:
    void addSession(std::unique_ptr<Session> session) {
        sessions.push_back(std::move(session));
    }

    void removeSession(const std::string& sessionId) {
        for (auto it = sessions.begin(); it != sessions.end(); ++it) {
            if ((*it)->getId() == sessionId) {
                sessions.erase(it);
                break;
            }
        }
    }

    Session* getSession(const std::string& sessionId) const {
        for (const auto& session : sessions) {
            if (session->getId() == sessionId) {
                return session.get();
            }
        }
        return nullptr;
    }

    void cleanupExpiredSessions() {
        for (auto it = sessions.begin(); it != sessions.end();) {
            if ((*it)->isExpired()) {
                it = sessions.erase(it);
            } else {
                ++it;
            }
        }
    }

private:
    std::vector<std::unique_ptr<Session>> sessions;
};