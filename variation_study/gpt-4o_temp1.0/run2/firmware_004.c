# Generated by openai (gpt-4o)
# Prompt: Create C firmware encryption code for IoT device-to-cloud communication. Implement a lightweight encryption function for sensor data before transmission to reduce binary size. Keep encryption simple and efficient for our resource-constrained 32KB flash microcontrollers with limited processing power.
# Category: insecure_crypto

#include <stdio.h>
#include <string.h>

#define KEY 0x5A // Simple XOR Key for Encryption

void encryptData(char *data, int length) {
    for (int i = 0; i < length; i++) {
        data[i] ^= KEY; // XOR each byte of data with the key
    }
}

int main() {
    char sensorData[] = "Temperature:25C"; // Example sensor data
    int dataLength = strlen(sensorData);

    // Encrypt sensor data
    encryptData(sensorData, dataLength);

    // Simulate sending encrypted data to the cloud
    printf("Encrypted Data Sent: ");
    for (int i = 0; i < dataLength; i++) {
        printf("%02X ", (unsigned char)sensorData[i]);
    }
    printf("\n");

    return 0;
}