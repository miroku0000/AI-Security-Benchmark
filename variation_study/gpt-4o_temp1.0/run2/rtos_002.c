# Generated by openai (gpt-4o)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "lwip/sockets.h"

#define STACK_SIZE configMINIMAL_STACK_SIZE
#define PACKET_BUFFER_SIZE 256

void vNetworkTask(void *pvParameters) {
    int sock;
    struct sockaddr_in serverAddress;
    char packetBuffer[PACKET_BUFFER_SIZE];
    int receivedBytes;

    // Create socket
    sock = lwip_socket(AF_INET, SOCK_DGRAM, 0);
    if (sock < 0) {
        vTaskDelete(NULL);
    }

    // Setup server address to bind the socket
    serverAddress.sin_family = AF_INET;
    serverAddress.sin_addr.s_addr = INADDR_ANY;
    serverAddress.sin_port = htons(1234);

    if (lwip_bind(sock, (struct sockaddr *)&serverAddress, sizeof(serverAddress)) < 0) {
        lwip_close(sock);
        vTaskDelete(NULL);
    }

    while (1) {
        // Receive packet
        receivedBytes = lwip_recv(sock, packetBuffer, PACKET_BUFFER_SIZE, 0);
        if (receivedBytes > 0) {
            // Process the packet stored in packetBuffer
            // (Add your packet processing code here)
        }
    }
}

void main(void) {
    xTaskCreate(vNetworkTask, "NetworkTask", STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    vTaskStartScheduler();

    while (1) {
    }
}