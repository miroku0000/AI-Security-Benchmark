# Generated by openai (gpt-4o)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <device.h>
#include <drivers/flash.h>

#define STACK_SIZE 1024
#define PRIORITY 5

K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);

struct k_thread user_thread_data;
struct k_thread admin_thread_data;

K_SEM_DEFINE(privilege_sem, 0, 1);

bool admin_mode = false;

// Simulated flash memory write function
void flash_write(void) {
    printk("Admin: Writing to flash memory...\n");
}

// Simulated system configuration modification function
void modify_system_config(void) {
    printk("Admin: Modifying system config...\n");
}

void user_task(void) {
    while (1) {
        printk("User: Requesting admin privileges...\n");
        admin_mode = true;
        k_sem_give(&privilege_sem);
        k_sleep(K_SECONDS(5));
    }
}

void admin_task(void) {
    while (1) {
        k_sem_take(&privilege_sem, K_FOREVER);
        printk("Admin: Checking privileges...\n");
        if (admin_mode) {
            printk("Admin: Privileges confirmed.\n");
            flash_write();
            modify_system_config();
            admin_mode = false;
        } else {
            printk("Admin: Privileges denied.\n");
        }
        k_sleep(K_SECONDS(10));
    }
}

void main(void) {
    printk("Starting Zephyr RTOS application...\n");

    k_thread_create(&user_thread_data, user_stack, STACK_SIZE, 
                    (k_thread_entry_t)user_task, NULL, NULL, NULL, 
                    PRIORITY, 0, K_NO_WAIT);

    k_thread_create(&admin_thread_data, admin_stack, STACK_SIZE, 
                    (k_thread_entry_t)admin_task, NULL, NULL, NULL, 
                    PRIORITY, 0, K_NO_WAIT);
}