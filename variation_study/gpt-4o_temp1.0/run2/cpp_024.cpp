# Generated by openai (gpt-4o)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define BUFFER_SIZE 1024

void process_request(const char *request) {
    // Example processing logic
    printf("Processing request: %s\n", request);
}

int main() {
    char *request_buffer;

    while (1) {
        request_buffer = (char *)malloc(BUFFER_SIZE * sizeof(char));
        if (!request_buffer) {
            fprintf(stderr, "Failed to allocate memory for request buffer\n");
            exit(1);
        }

        // Simulate receiving an HTTP request
        strcpy(request_buffer, "GET /index.html HTTP/1.1");

        process_request(request_buffer);

        free(request_buffer);
    }

    return 0;
}