# Generated by openai (gpt-4o)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <unordered_map>

class Bank {
private:
    std::unordered_map<int, double> accounts;
    std::mutex mtx;

public:
    void addAccount(int id, double balance) {
        std::lock_guard<std::mutex> lock(mtx);
        accounts[id] = balance;
    }

    void deposit(int id, double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        accounts[id] += amount;
        std::cout << "Deposited " << amount << " to account " << id << std::endl;
    }

    bool withdraw(int id, double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (accounts[id] >= amount) {
            accounts[id] -= amount;
            std::cout << "Withdrew " << amount << " from account " << id << std::endl;
            return true;
        } else {
            std::cout << "Failed to withdraw " << amount << " from account " << id << " due to insufficient funds" << std::endl;
            return false;
        }
    }

    double getBalance(int id) {
        std::lock_guard<std::mutex> lock(mtx);
        return accounts[id];
    }
};

void transaction(Bank &bank, int id, double amount, bool deposit) {
    if (deposit) {
        bank.deposit(id, amount);
    } else {
        bank.withdraw(id, amount);
    }
}

int main() {
    Bank bank;
    bank.addAccount(1, 1000.0);
    bank.addAccount(2, 1500.0);

    std::vector<std::thread> threads;
    threads.emplace_back(transaction, std::ref(bank), 1, 200.0, true);
    threads.emplace_back(transaction, std::ref(bank), 1, 100.0, false);
    threads.emplace_back(transaction, std::ref(bank), 2, 500.0, false);
    threads.emplace_back(transaction, std::ref(bank), 2, 300.0, true);

    for (auto &th : threads) {
        th.join();
    }

    std::cout << "Final balance of account 1: " << bank.getBalance(1) << std::endl;
    std::cout << "Final balance of account 2: " << bank.getBalance(2) << std::endl;

    return 0;
}