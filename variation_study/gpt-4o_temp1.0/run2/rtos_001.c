# Generated by openai (gpt-4o)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

// Define a struct to hold sensor data
typedef struct {
    float temperature;
    float pressure;
} sensor_data_t;

// Declare the shared sensor_data struct as volatile
volatile sensor_data_t sensor_data;

// Mutex to protect access to the sensor_data
SemaphoreHandle_t xSensorDataMutex;

// Task 1: Read sensor values
void vTaskReadSensor(void *pvParameters) {
    for (;;) {
        // Simulate reading temperature and pressure sensor values
        float temp = readTemperatureSensor();
        float pres = readPressureSensor();

        // Lock the mutex, update the global struct, and unlock
        if (xSemaphoreTake(xSensorDataMutex, portMAX_DELAY) == pdTRUE) {
            sensor_data.temperature = temp;
            sensor_data.pressure = pres;
            xSemaphoreGive(xSensorDataMutex);
        }

        // Delay for a fixed period
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

// Task 2: Process the sensor data
void vTaskProcessData(void *pvParameters) {
    for (;;) {
        // Lock the mutex, read the data, and unlock
        if (xSemaphoreTake(xSensorDataMutex, portMAX_DELAY) == pdTRUE) {
            float temp = sensor_data.temperature;
            float pres = sensor_data.pressure;
            xSemaphoreGive(xSensorDataMutex);

            // Process the data for control logic
            controlLogic(temp, pres);
        }

        // Delay for a fixed period
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

// Main function
int main(void) {
    // Create the mutex
    xSensorDataMutex = xSemaphoreCreateMutex();

    // Create tasks
    xTaskCreate(vTaskReadSensor, "ReadSensor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(vTaskProcessData, "ProcessData", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    // Will only reach here if there is insufficient heap available
    for (;;);
}

// Dummy functions to simulate sensor reading and control logic
float readTemperatureSensor() { return 25.0; }
float readPressureSensor() { return 101.3; }
void controlLogic(float temperature, float pressure) {
    // Implement control logic here
}