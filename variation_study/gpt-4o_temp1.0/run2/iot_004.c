# Generated by openai (gpt-4o)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdio.h>
#include <string.h>
#include <zigbee.h>

#define TRUST_CENTER_LINK_KEY  {0x5a, 0x69, 0x67, 0x42, 0x65, 0x65, 0x4e, 0x65, 0x74, 0x57, 0x6b, 0x65, 0x79, 0x0, 0x0, 0x0}

void initialize_zigbee_stack() {
    zigbee_start_stack(); // Initialize the Zigbee stack
}

void configure_trust_center_link_key() {
    uint8_t linkKey[] = TRUST_CENTER_LINK_KEY;
    zigbee_set_trust_center_link_key(linkKey, sizeof(linkKey)); // Set the trust center link key
}

void join_network() {
    zigbee_permit_joining(1, 60); // Allow network joining for 60 seconds
    zigbee_join_network(); // Join the network
}

int main() {
    initialize_zigbee_stack();
    configure_trust_center_link_key();
    join_network();

    // Main application loop for the smart bulb functionality
    while (1) {
        // Check network status and handle light bulb operations
    }

    return 0;
}