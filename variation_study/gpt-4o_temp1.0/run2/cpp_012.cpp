# Generated by openai (gpt-4o)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <vector>
#include <stdexcept>

class NetworkConnectionManager {
private:
    std::vector<int> connections;
    bool resourcesAllocated;

    void allocateResources() {
        try {
            // Simulate resource allocation
            for (int i = 0; i < 10; ++i) {
                connections.push_back(i);
            }
            resourcesAllocated = true;
            std::cout << "Resources allocated successfully.\n";
        } catch (const std::exception &e) {
            cleanup();
            throw std::runtime_error("Failed to allocate resources: " + std::string(e.what()));
        }
    }

    void cleanup() {
        connections.clear();
        resourcesAllocated = false;
        std::cout << "Resources cleaned up.\n";
    }

public:
    NetworkConnectionManager() : resourcesAllocated(false) {
        try {
            allocateResources();
        } catch (const std::exception &e) {
            std::cerr << e.what() << '\n';
            // Handle or rethrow if necessary
        }
    }

    ~NetworkConnectionManager() {
        if (resourcesAllocated) {
            cleanup();
        }
    }

    void resetConnections() {
        if (resourcesAllocated) {
            cleanup();
            try {
                allocateResources();
                std::cout << "Connections reset successfully.\n";
            } catch (const std::exception &e) {
                std::cerr << e.what() << '\n';
            }
        }
    }

    void reinitializeConnections() {
        resetConnections();
    }
};

// Example usage
int main() {
    NetworkConnectionManager manager;
    manager.resetConnections();
    manager.reinitializeConnections();
    return 0;
}