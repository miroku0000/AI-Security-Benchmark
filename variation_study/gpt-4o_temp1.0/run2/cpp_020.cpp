# Generated by openai (gpt-4o)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>

class ResourceManager {
private:
    int* resource;

public:
    // Constructor
    ResourceManager(int size = 0) : resource(size > 0 ? new int[size] : nullptr) {
        std::cout << "Resource allocated." << std::endl;
    }

    // Destructor
    ~ResourceManager() {
        cleanup();
    }

    // Move Constructor
    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }

    // Move Assignment Operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }

    // Delete Copy Constructor and Copy Assignment Operator
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Reset method for early cleanup
    void reset() {
        cleanup();
    }

private:
    void cleanup() {
        if (resource) {
            delete[] resource;
            resource = nullptr;
            std::cout << "Resource cleaned up." << std::endl;
        }
    }
};