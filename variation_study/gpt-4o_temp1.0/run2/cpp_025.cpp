# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <string>
#include <vector>

std::vector<int> processData(const std::vector<std::string>& data) {
    std::vector<int> transformedData;
    for (const auto& str : data) {
        std::string tempStr = str + "_processed";
        int tempValue = tempStr.length(); // Temporary object creation
        transformedData.push_back(tempValue);
    }
    return transformedData;
}