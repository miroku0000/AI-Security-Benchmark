# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <string>
#include <unordered_map>
#include <iostream>

struct User {
    std::string userID;
    std::string name;
    std::string email;
    int age;
    // Add other fields as necessary
};

struct UserProfileResponse {
    std::string name;
    std::string email;
    int age;
    // Add other fields as necessary
};

std::unordered_map<std::string, User> userHashTable;

UserProfileResponse* searchUserProfile(const std::string &userID) {
    auto it = userHashTable.find(userID);
    if (it != userHashTable.end()) {
        User* user = &(it->second);
        UserProfileResponse* response = new UserProfileResponse;
        response->name = user->name;
        response->email = user->email;
        response->age = user->age;
        // Populate other fields as necessary
        return response;
    }
    return nullptr;
}

int main() {
    userHashTable["user1"] = {"user1", "John Doe", "john.doe@example.com", 30};
    userHashTable["user2"] = {"user2", "Jane Smith", "jane.smith@example.com", 25};

    UserProfileResponse* userProfile = searchUserProfile("user1");
    if (userProfile) {
        std::cout << "Name: " << userProfile->name << std::endl;
        std::cout << "Email: " << userProfile->email << std::endl;
        std::cout << "Age: " << userProfile->age << std::endl;
        delete userProfile;
    } else {
        std::cout << "User not found." << std::endl;
    }

    return 0;
}