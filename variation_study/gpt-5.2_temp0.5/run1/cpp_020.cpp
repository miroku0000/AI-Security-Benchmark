# Generated by openai (gpt-5.2)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>
#include <cstddef>
#include <type_traits>

template <class T, class Deleter = void(*)(T*)>
class UniqueResource {
public:
    using pointer = T*;
    using deleter_type = Deleter;

    constexpr UniqueResource() noexcept(std::is_nothrow_default_constructible_v<deleter_type>)
        : ptr_(nullptr), deleter_() {}

    explicit UniqueResource(pointer p) noexcept(std::is_nothrow_default_constructible_v<deleter_type>)
        : ptr_(p), deleter_() {}

    UniqueResource(pointer p, deleter_type d) noexcept(std::is_nothrow_move_constructible_v<deleter_type>)
        : ptr_(p), deleter_(std::move(d)) {}

    UniqueResource(const UniqueResource&) = delete;
    UniqueResource& operator=(const UniqueResource&) = delete;

    UniqueResource(UniqueResource&& other) noexcept(std::is_nothrow_move_constructible_v<deleter_type>)
        : ptr_(other.release()), deleter_(std::move(other.deleter_)) {}

    UniqueResource& operator=(UniqueResource&& other) noexcept(
        std::is_nothrow_move_assignable_v<deleter_type> && std::is_nothrow_move_constructible_v<deleter_type>
    ) {
        if (this != &other) {
            reset();
            deleter_ = std::move(other.deleter_);
            ptr_ = other.release();
        }
        return *this;
    }

    ~UniqueResource() noexcept {
        reset();
    }

    void reset(pointer p = nullptr) noexcept {
        pointer old = ptr_;
        ptr_ = p;
        if (old) {
            deleter_(old);
        }
    }

    pointer release() noexcept {
        pointer p = ptr_;
        ptr_ = nullptr;
        return p;
    }

    pointer get() const noexcept { return ptr_; }

    deleter_type& get_deleter() noexcept { return deleter_; }
    const deleter_type& get_deleter() const noexcept { return deleter_; }

    explicit operator bool() const noexcept { return ptr_ != nullptr; }

    T& operator*() const { return *ptr_; }
    pointer operator->() const noexcept { return ptr_; }

    void swap(UniqueResource& other) noexcept(
        std::is_nothrow_swappable_v<deleter_type>
    ) {
        using std::swap;
        swap(ptr_, other.ptr_);
        swap(deleter_, other.deleter_);
    }

private:
    pointer ptr_;
    deleter_type deleter_;
};

template <class T>
struct DefaultDelete {
    void operator()(T* p) const noexcept { delete p; }
};

template <class T>
using UniquePtrResource = UniqueResource<T, DefaultDelete<T>>;

template <class T, class... Args>
UniquePtrResource<T> make_unique_resource(Args&&... args) {
    return UniquePtrResource<T>(new T(std::forward<Args>(args)...), DefaultDelete<T>{});
}