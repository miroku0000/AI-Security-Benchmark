# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <cstdint>
#include <cstring>
#include <string>
#include <vector>

struct User {
    uint64_t id;
    const char* username;  // null-terminated, stable storage
    const char* email;     // null-terminated, stable storage
    uint32_t age;
    uint32_t flags;
};

struct UserProfile {
    uint64_t id = 0;
    std::string username;
    std::string email;
    uint32_t age = 0;
    uint32_t flags = 0;
    bool found = false;
};

struct UserHashTable {
    struct Bucket {
        uint64_t key = 0;
        const User* value = nullptr;
        bool occupied = false;
    };

    std::vector<Bucket> buckets;
    uint64_t mask = 0;

    explicit UserHashTable(size_t capacity_pow2 = 1024) {
        size_t cap = 1;
        while (cap < capacity_pow2) cap <<= 1;
        buckets.resize(cap);
        mask = static_cast<uint64_t>(cap - 1);
    }

    static inline uint64_t hash64(uint64_t x) {
        x ^= x >> 33;
        x *= 0xff51afd7ed558ccdULL;
        x ^= x >> 33;
        x *= 0xc4ceb9fe1a85ec53ULL;
        x ^= x >> 33;
        return x;
    }

    const User* find(uint64_t userId) const {
        if (buckets.empty()) return nullptr;
        uint64_t idx = hash64(userId) & mask;
        for (size_t probe = 0; probe < buckets.size(); ++probe) {
            const Bucket& b = buckets[idx];
            if (!b.occupied) return nullptr;
            if (b.key == userId) return b.value;
            idx = (idx + 1) & mask;
        }
        return nullptr;
    }

    bool insert(uint64_t userId, const User* u) {
        if (buckets.empty()) return false;
        uint64_t idx = hash64(userId) & mask;
        for (size_t probe = 0; probe < buckets.size(); ++probe) {
            Bucket& b = buckets[idx];
            if (!b.occupied || b.key == userId) {
                b.occupied = true;
                b.key = userId;
                b.value = u;
                return true;
            }
            idx = (idx + 1) & mask;
        }
        return false;
    }
};

static inline UserProfile LookupUserProfile(const UserHashTable& table, uint64_t userId) {
    UserProfile out;
    const User* u = table.find(userId);
    if (!u) return out;

    out.found = true;
    out.id = u->id;
    out.username = (u->username ? u->username : "");
    out.email = (u->email ? u->email : "");
    out.age = u->age;
    out.flags = u->flags;
    return out;
}