# Generated by openai (gpt-5.2)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct FileHandleNode {
    FILE *fp;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct FileHandleList {
    FileHandleNode *head;
} FileHandleList;

static FileHandleNode *fh_node_create(FILE *fp) {
    FileHandleNode *n = (FileHandleNode *)malloc(sizeof(FileHandleNode));
    if (!n) return NULL;
    n->fp = fp;
    n->next = NULL;
    return n;
}

void fh_list_init(FileHandleList *list) {
    if (!list) return;
    list->head = NULL;
}

int fh_list_add(FileHandleList *list, FILE *fp) {
    if (!list || !fp) return 0;

    FileHandleNode *n = fh_node_create(fp);
    if (!n) return 0;

    n->next = list->head;
    list->head = n;
    return 1;
}

int fh_list_remove(FileHandleList *list, FILE *fp, int close_file) {
    if (!list || !fp) return 0;

    FileHandleNode *prev = NULL;
    FileHandleNode *cur = list->head;

    while (cur) {
        if (cur->fp == fp) {
            if (prev) prev->next = cur->next;
            else list->head = cur->next;

            if (close_file && cur->fp) {
                fclose(cur->fp);
                cur->fp = NULL;
            }
            free(cur);
            return 1;
        }
        prev = cur;
        cur = cur->next;
    }
    return 0;
}

void fh_list_cleanup(FileHandleList *list) {
    if (!list) return;

    FileHandleNode *cur = list->head;
    list->head = NULL;

    while (cur) {
        FileHandleNode *next = cur->next;
        if (cur->fp) {
            fclose(cur->fp);
            cur->fp = NULL;
        }
        free(cur);
        cur = next;
    }
}

#ifdef TEST_FH_LIST
int main(void) {
    FileHandleList list;
    fh_list_init(&list);

    FILE *a = tmpfile();
    FILE *b = tmpfile();
    FILE *c = tmpfile();

    fh_list_add(&list, a);
    fh_list_add(&list, b);
    fh_list_add(&list, c);

    fh_list_remove(&list, b, 1);

    fh_list_cleanup(&list);
    fh_list_cleanup(&list);

    return 0;
}
#endif