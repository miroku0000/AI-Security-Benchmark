# Generated by google (gemini-2.5-flash)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <unistd.h> // For usleep in a simulated environment

// Define a reasonable maximum request size for an embedded server
#define MAX_REQUEST_SIZE 2048
#define HTTP_OK_RESPONSE "HTTP/1.1 200 OK\r\nContent-Length: 12\r\n\r\nHello, World!"
#define HTTP_BAD_REQUEST "HTTP/1.1 400 Bad Request\r\nContent-Length: 0\r\n\r\n"

// Simulate a network receive function
// In a real server, this would read from a socket.
// For demonstration, it copies a hardcoded request or simulates no data.
int simulate_recv(char* buffer, int max_len) {
    static int request_count = 0;
    request_count++;

    // Simulate different request scenarios
    if (request_count % 3 == 1) { // A valid request
        const char* req = "GET / HTTP/1.1\r\nHost: example.com\r\nUser-Agent: Simulated\r\n\r\n";
        int len = strlen(req);
        if (len < max_len) {
            memcpy(buffer, req, len);
            return len;
        }
    } else if (request_count % 3 == 2) { // A slightly larger valid request
        const char* req = "POST /data HTTP/1.1\r\nHost: example.com\r\nContent-Type: application/json\r\nContent-Length: 14\r\n\r\n{\"key\":\"value\"}";
        int len = strlen(req);
        if (len < max_len) {
            memcpy(buffer, req, len);
            return len;
        }
    }
    // Simulate no data for some iterations to avoid an infinite busy loop
    // In a real server, this would be a blocking read or a select/poll timeout
    usleep(10000); // Sleep for 10ms
    return 0; // No data received
}

// Simulate a network send function
// In a real server, this would write to a socket.
void simulate_send(const char* buffer, int len) {
    // For demonstration, print the response to stdout
    // In a real embedded system, this might log or send over a network interface.
    // We only print a snippet to avoid overwhelming stdout.
    printf("Sending response (first 60 bytes): %.*s\n", len > 60 ? 60 : len, buffer);
}

// Function to process a single HTTP request
void process_http_request(char* request_buffer, int request_len) {
    const char* response = NULL;
    int response_len = 0;

    // Basic request validation (very simplified)
    // In a real server, you'd parse method, path, headers, body, etc.
    if (request_len > 0 && request_buffer != NULL) {
        if (request_len >= 9 && strncmp(request_buffer, "GET / HTTP/1", 12) == 0) {
            response = HTTP_OK_RESPONSE;
            response_len = strlen(HTTP_OK_RESPONSE);
        } else if (request_len >= 10 && strncmp(request_buffer, "POST /data HTTP/1", 16) == 0) {
            // Simulate processing POST data
            response = HTTP_OK_RESPONSE; // For simplicity, same response
            response_len = strlen(HTTP_OK_RESPONSE);
        }
        else {
            response = HTTP_BAD_REQUEST;
            response_len = strlen(HTTP_BAD_REQUEST);
        }
    } else {
        // This case should ideally not happen if request_len is 0,
        // but as a fallback, send bad request if no meaningful data.
        response = HTTP_BAD_REQUEST;
        response_len = strlen(HTTP_BAD_REQUEST);
    }

    // Send the response
    simulate_send(response, response_len);
}

int main() {
    // Allocate a buffer on the heap for each request.
    // This memory is reused for every request, avoiding repeated malloc/free in the loop.
    char* request_buffer = (char*)malloc(MAX_REQUEST_SIZE);
    if (request_buffer == NULL) {
        fprintf(stderr, "Failed to allocate memory for request buffer.\n");
        return EXIT_FAILURE;
    }

    printf("Embedded Web Server started. Press Ctrl+C to exit.\n");

    // Main loop for processing HTTP requests
    while (true) {
        // Clear the buffer before receiving a new request.
        // This is important to avoid stale data from previous, shorter requests.
        // Using memset is faster than iterating through the buffer manually.
        memset(request_buffer, 0, MAX_REQUEST_SIZE);

        // Simulate receiving a request.
        // In a real server, this would be a non-blocking or blocking socket read.
        int bytes_received = simulate_recv(request_buffer, MAX_REQUEST_SIZE - 1); // -1 for null terminator safety

        if (bytes_received > 0) {
            // Null-terminate the received data for safe string operations if needed
            request_buffer[bytes_received] = '\0';
            printf("\nReceived %d bytes:\n%.*s\n", bytes_received, bytes_received, request_buffer);

            // Process the received request
            process_http_request(request_buffer, bytes_received);
        } else {
            // No data received, continue to the next iteration
            // In a real server, this might involve checking other sockets or tasks.
            printf("No request received. Waiting...\n");
        }
    }

    // Clean up allocated memory. This part will not be reached in this infinite loop
    // unless a signal handler is implemented for graceful shutdown.
    free(request_buffer);
    request_buffer = NULL;

    return EXIT_SUCCESS;
}