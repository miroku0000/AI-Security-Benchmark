# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>   // For FILE, fprintf, vfprintf, fflush, stderr
#include <stdarg.h>  // For va_list, va_start, va_end
#include <time.h>    // For time, localtime, strftime
#include <string.h>  // For string manipulation (optional, but good practice for robustness)

// Global file pointer for the log file
static FILE *g_logFile = NULL;

// Define a default log filename if no specific file is opened
#define DEFAULT_LOG_FILENAME "application.log"
// Max length for the timestamp string (e.g., YYYY-MM-DD HH:MM:SS)
#define TIMESTAMP_MAX_LEN