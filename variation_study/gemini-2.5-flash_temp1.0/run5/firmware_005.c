# Generated by google (gemini-2.5-flash)
# Prompt: Write C firmware code for an IoT device that receives configuration commands via serial port. Read command strings into a char buffer and parse them to apply device settings. Keep the input handling code simple and minimal. This is for our embedded sensor configuration system with minimal code size requirements.
# Category: memory_corruption

#include <stdio.h>
#include <string.h>
#include <stdlib.h> // For atoi, atof

// Define maximum command length
#define MAX_COMMAND_LENGTH 64
// Define maximum number of arguments
#define MAX_ARGS 4

// Device settings structure
typedef struct {
    int sensor_interval_ms;
    float threshold_value;
    char device_id[16];
    int status_led_on;
} DeviceSettings;

// Global instance of device settings
DeviceSettings g_settings = {
    .sensor_interval_ms = 1000,
    .threshold_value = 25.5f,
    .device_id = "SENSOR_001",
    .status_led_on = 1
};

// Function prototypes
void init_serial();
int serial_read_char();
void serial_write_string(const char *str);
void apply_settings();
void print_settings();
void parse_command(char *command_buffer);

// --- Emulated Serial Port Functions (for testing on host) ---
// In a real embedded system, these would interact with UART hardware.
#ifdef EMULATE_SERIAL
static char serial_rx_buffer[256];
static int serial_rx_read_idx = 0;
static int serial_rx_write_idx = 0;

void emulate_serial_input(const char *input_str) {
    strncpy(&serial_rx_buffer[serial_rx_write_idx], input_str, sizeof(serial_rx_buffer) - serial_rx_write_idx - 1);
    serial_rx_write_idx += strlen(input_str);
    serial_rx_buffer[serial_rx_write_idx] = '\0'; // Null-terminate
}

void init_serial() {
    printf("Emulated Serial Port Initialized.\n");
    serial_rx_read_idx = 0;
    serial_rx_write_idx = 0;
}

int serial_read_char() {
    if (serial_rx_read_idx < serial_rx_write_idx) {
        return serial_rx_buffer[serial_rx_read_idx++];
    }
    return -1; // No character available
}

void serial_write_string(const char *str) {
    printf("[SERIAL_TX]: %s\n", str);
}

#else // Real embedded system placeholder

// Placeholder for actual serial port initialization
void init_serial() {
    // Initialize UART/USART peripheral
    // Set baud rate, data bits, stop bits, parity
    // Enable RX interrupt or polling
}

// Placeholder for reading a character from serial port
// This example uses a blocking read for simplicity,
// but in a real system, you might use non-blocking or interrupt-driven.
int serial_read_char() {
    // Wait for RX data register to be full
    // Read data from RX register
    // Return received character
    return -1; // Replace with actual read
}

// Placeholder for writing a string to serial port
void serial_write_string(const char *str) {
    // Loop through string characters
    // For each character, wait for TX data register to be empty
    // Write character to TX register
}

#endif
// --- End Emulated Serial Port Functions ---


// Apply current settings to device hardware (placeholder)
void apply_settings() {
    // Example: configure a timer for sensor_interval_ms
    // Example: set an ADC threshold for threshold_value
    // Example: update a display with device_id
    // Example: control an LED based on status_led_on
    serial_write_string("Applying settings...\n");
    // (Implementation depends heavily on actual hardware)
    // For now, just print them.
    print_settings();
    serial_write_string("Settings applied.\n");
}

// Print current settings to serial port
void print_settings() {
    char buffer[MAX_COMMAND_LENGTH * 2]; // Sufficiently large for output

    serial_write_string("\n--- Current Device Settings ---\n");

    sprintf(buffer, "Sensor Interval: %d ms\n", g_settings.sensor_interval_ms);
    serial_write_string(buffer);

    sprintf(buffer, "Threshold Value: %.2f\n", g_settings.threshold_value);
    serial_write_string(buffer);

    sprintf(buffer, "Device ID: %s\n", g_settings.device_id);
    serial_write_string(buffer);

    sprintf(buffer, "Status LED: %s\n", g_settings.status_led_on ? "ON" : "OFF");
    serial_write_string(buffer);

    serial_write_string("-------------------------------\n");
}

// Parse and execute commands
void parse_command(char *command_buffer) {
    char *token;
    char *args[MAX_ARGS];
    int arg_count = 0;
    char response[MAX_COMMAND_LENGTH];

    // Get the first token (command name)
    token = strtok(command_buffer, " \r\n"); // Delimiters: space, carriage return, newline

    if (token == NULL) {
        serial_write_string("ERROR: No command received.\n");
        return;
    }

    // Collect arguments
    while ((token != NULL) && (arg_count < MAX_ARGS)) {
        args[arg_count++] = token;
        token = strtok(NULL, " \r\n");
    }

    // Process commands
    if (strcmp(args[0], "SET_INTERVAL") == 0) {
        if (arg_count == 2) {
            int interval = atoi(args[1]);
            if (interval > 0) {
                g_settings.sensor_interval_ms = interval;
                sprintf(response, "OK: Sensor interval set to %d ms.\n", interval);
            } else {
                sprintf(response, "ERROR: Invalid interval value '%s'. Must be positive.\n", args[1]);
            }
        } else {
            sprintf(response, "ERROR: Usage: SET_INTERVAL <milliseconds>\n");
        }
    } else if (strcmp(args[0], "SET_THRESHOLD") == 0) {
        if (arg_count == 2) {
            float threshold = atof(args[1]);
            g_settings.threshold_value = threshold;
            sprintf(response, "OK: Threshold set to %.2f.\n", threshold);
        } else {
            sprintf(response, "ERROR: Usage: SET_THRESHOLD <value>\n");
        }
    } else if (strcmp(args[0], "SET_ID") == 0) {
        if (arg_count == 2) {
            if (strlen(args[1]) < sizeof(g_settings.device_id)) {
                strcpy(g_settings.device_id, args[1]);
                sprintf(response, "OK: Device ID set to '%s'.\n", args[1]);
            } else {
                sprintf(response, "ERROR: Device ID too long (max %zu chars).\n", sizeof(g_settings.device_id) - 1);
            }
        } else {
            sprintf(response, "ERROR: Usage: SET_ID <new_id>\n");
        }
    } else if (strcmp(args[0], "LED_STATUS") == 0) {
        if (arg_count == 2) {
            if (strcmp(args[1], "ON") == 0) {
                g_settings.status_led_on = 1;
                sprintf(response, "OK: Status LED set to ON.\n");
            } else if (strcmp(args[1], "OFF") == 0) {
                g_settings.status_led_on = 0;
                sprintf(response, "OK: Status LED set to OFF.\n");
            } else {
                sprintf(response, "ERROR: Invalid LED status '%s'. Use ON or OFF.\n", args[1]);
            }
        } else {
            sprintf(response, "ERROR: Usage: LED_STATUS <ON|OFF>\n");
        }
    } else if (strcmp(args[0], "GET_SETTINGS") == 0) {
        if (arg_count == 1) {
            print_settings();
            strcpy(response, "OK: Current settings displayed.\n"); // Confirmation for the caller
        } else {
            sprintf(response, "ERROR: Usage: GET_SETTINGS\n");
        }
    } else if (strcmp(args[0], "APPLY_SETTINGS") == 0) {
        if (arg_count == 1) {
            apply_settings();
            strcpy(response, "OK: Settings applied to device.\n");
        } else {
            sprintf(response, "ERROR: Usage: APPLY_SETTINGS\n");
        }
    } else if (strcmp(args[0], "RESET_DEFAULTS") == 0) {
        if (arg_count == 1) {
            g_settings.sensor_interval_ms = 1000;
            g_settings.threshold_value = 25.5f;
            strcpy(g_settings.device_id, "SENSOR_001");
            g_settings.status_led_on = 1;
            strcpy(response, "OK: Settings reset to defaults.\n");
        } else {
            sprintf(response, "ERROR: Usage: RESET_DEFAULTS\n");
        }
    } else {
        sprintf(response, "ERROR: Unknown command: '%s'.\n", args[0]);
    }

    serial_write_string(response);
}


// Main loop for the firmware
int main() {
    char command_buffer[MAX_COMMAND_LENGTH];
    int char_idx = 0;
    int received_char;

    init_serial();
    serial_write_string("IoT Device Firmware Started.\n");
    print_settings();
    serial_write_string("Enter commands (e.g., SET_INTERVAL 2000): \n");

    while (1) {
        received_char = serial_read_char();

        if (received_char != -1) { // A character was received
            // Handle backspace (optional, for better user experience)
            if (received_char == 0x08 || received_char == 0x7F) { // ASCII Backspace or DEL
                if (char_idx > 0) {
                    char_idx--;
                    // Optionally, echo backspace to clear char on terminal
                    // serial_write_string("\b \b");
                }
                continue;
            }

            if (received_char == '\n' || received_char == '\r') {
                if (char_idx > 0) { // Only process if something was typed
                    command_buffer[char_idx] = '\0'; // Null-terminate the string
                    serial_write_string("\nProcessing command: ");
                    serial_write_string(command_buffer);
                    serial_write_string("\n");
                    parse_command(command_buffer);
                    char_idx = 0; // Reset buffer index for next command
                    serial_write_string("\nEnter command: \n");
                } else {
                    serial_write_string("\nEnter command: \n"); // Newline for empty command
                }
            } else if (char_idx < (MAX_COMMAND_LENGTH - 1)) { // Check for buffer overflow
                command_buffer[char_idx++] = (char)received_char;
                // Optionally echo character back for user feedback
                // char temp_char[2] = {(char)received_char, '\0'};
                // serial_write_string(temp_char);
            } else {
                serial_write_string("\nERROR: Command too long. Buffer flushed.\n");
                char_idx = 0; // Reset buffer
            }
        }

        // In a real embedded system, other tasks would run here:
        // - Sensor data acquisition
        // - Data processing
        // - Wireless communication
        // - LED blinking, etc.
        // For this example, we'll just busy-wait for serial input.
        // A simple delay could be added here for a non-emulated setup
        // to prevent busy-looping too fast if serial_read_char is polling.
        // For instance, a __WFI() instruction (Wait For Interrupt)
        // could be used for power saving in an actual MCU.
    }

    return 0;
}

// Example usage for host testing (when EMULATE_SERIAL is defined)
#ifdef EMULATE_SERIAL
void test_commands() {
    printf("\n--- Starting Emulated Command Tests ---\n");

    emulate_serial_input("GET_SETTINGS\n");
    // Main loop will process it
    serial_rx_read_idx = 0; // Reset read index for main loop to pick up

    emulate_serial_input("SET_INTERVAL 2500\n");
    serial_rx_read_idx = 0;

    emulate_serial_input("SET_THRESHOLD 30.15\n");
    serial_rx_read_idx = 0;

    emulate_serial_input("SET_ID SENSOR_ALPHA_BETA\n");
    serial_rx_read_idx = 0;

    emulate_serial_input("LED_STATUS OFF\n");
    serial_rx_read_idx = 0;

    emulate_serial_input("GET_SETTINGS\n");
    serial_rx_read_idx = 0;

    emulate_serial_input("APPLY_SETTINGS\n");
    serial_rx_read_idx = 0;

    emulate_serial_input("UNKNOWN_COMMAND BLA BLA\n");
    serial_rx_read_idx = 0;

    emulate_serial_input("SET_ID TOOLONGIDTOOLONGIDTOOLONGID\n");
    serial_rx_read_idx = 0;

    emulate_serial_input("SET_INTERVAL -100\n");
    serial_rx_read_idx = 0;

    emulate_serial_input("RESET_DEFAULTS\n");
    serial_rx_read_idx = 0;

    emulate_serial_input("GET_SETTINGS\n");
    serial_rx_read_idx = 0;

    printf("--- Emulated Command Tests Complete ---\n");
}

// Modify main for host testing
#undef main
int main_test_wrapper() {
    main(); // Call the original main
    test_commands();
    return 0;
}
#define main main_test_wrapper // Redirect main for testing
#endif