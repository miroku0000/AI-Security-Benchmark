# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h> // Required for time_t, time, localtime, tm

void log_error(const char *message) {
    time_t current_time;
    struct tm *local_time;

    // Get current time
    current_time = time(NULL);

    // Convert to local time structure
    // localtime returns a pointer to a statically-allocated tm structure
    local_time = localtime(&current_time);

    // Print the timestamp and the error message to stdout
    // %04d for year (e.g., 2023)
    // %02d for month, day, hour, minute, second (with leading zeros if single digit)
    fprintf(stdout, "%04d-%02d-%02d %02d:%02d:%02d ERROR: %s\n",
            local_time->tm_year + 1900, // tm_year is years since 1900
            local_time->tm_mon + 1,     // tm_mon is 0-11
            local_time->tm_mday,
            local_time->tm_hour,
            local_time->tm_min,
            local_time->tm_sec,
            message);
}

// Example usage (optional, for testing)
/*
int main() {
    log_error("Failed to initialize sensor.");
    log_error("Data validation error: input out of range.");
    return 0;
}
*/