# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <string>
#include <mutex>
#include <thread>
#include <map>
#include <random>
#include <chrono>

// Account structure
struct Account {
    int id;
    std::string name;
    double balance;
    mutable std::mutex mtx; // Mutex for this specific account

    Account(int id, std::string name, double balance)
        : id(id), name(name), balance(balance) {}

    // No need for a copy constructor if we are only passing pointers/references
    // and storing them directly. If we were copying Accounts, we'd need to consider
    // how to handle the mutex, usually by not copying it or by making it non-copyable.
};

// Bank class to manage accounts and transactions
class Bank {
public:
    std::map<int, Account> accounts;
    mutable std::mutex bank_mtx; // Mutex for accessing the map of accounts itself

    Bank() {
        // Initialize some accounts
        accounts.emplace(101, Account(101, "Alice", 1000.0));
        accounts.emplace(102, Account(102, "Bob", 500.0));
        accounts.emplace(103, Account(103, "Charlie", 2000.0));
        accounts.emplace(104, Account(104, "David", 750.0));
    }

    // Function to process a deposit
    bool deposit(int account_id, double amount) {
        if (amount <= 0) {
            std::cerr << "Deposit amount must be positive." << std::endl;
            return false;
        }

        // Lock the bank_mtx to safely access the map to find the account
        // and then lock the account-specific mutex.
        // For individual account operations, we primarily need to lock the account itself.
        // The bank_mtx would be for operations like adding/removing accounts from the map.
        // However, if iterators could be invalidated or map modified during lookup,
        // a shared_mutex could be used for the map to allow concurrent reads.
        // For simplicity and correctness with std::map::at, a single lock per account is generally sufficient.

        // If an account could be deleted while another thread is looking for it,
        // we might need a read-write lock for the map or more robust error handling.
        // For this example, accounts are assumed to be stable once created.

        std::lock_guard<std::mutex> map_lock(bank_mtx); // Protect map access

        auto it = accounts.find(account_id);
        if (it == accounts.end()) {
            std::cerr << "Account " << account_id << " not found." << std::endl;
            return false;
        }

        Account& acc = it->second;
        std::lock_guard<std::mutex> account_lock(acc.mtx); // Lock the specific account

        acc.balance += amount;
        // std::cout << "Thread " << std::this_thread::get_id() << ": Deposited " << amount
        //           << " into account " << account_id << ". New balance: " << acc.balance << std::endl;
        return true;
    }

    // Function to process a withdrawal
    bool withdraw(int account_id, double amount) {
        if (amount <= 0) {
            std::cerr << "Withdrawal amount must be positive." << std::endl;
            return false;
        }

        std::lock_guard<std::mutex> map_lock(bank_mtx); // Protect map access

        auto it = accounts.find(account_id);
        if (it == accounts.end()) {
            std::cerr << "Account " << account_id << " not found." << std::endl;
            return false;
        }

        Account& acc = it->second;
        std::lock_guard<std::mutex> account_lock(acc.mtx); // Lock the specific account

        if (acc.balance >= amount) {
            acc.balance -= amount;
            // std::cout << "Thread " << std::this_thread::get_id() << ": Withdrew " << amount
            //           << " from account " << account_id << ". New balance: " << acc.balance << std::endl;
            return true;
        } else {
            // std::cerr << "Thread " << std::this_thread::get_id() << ": Insufficient funds in account "
            //           << account_id << " for withdrawal of " << amount << ". Current balance: " << acc.balance << std::endl;
            return false;
        }
    }

    // Function to transfer funds between accounts
    bool transfer(int from_account_id, int to_account_id, double amount) {
        if (amount <= 0) {
            std::cerr << "Transfer amount must be positive." << std::endl;
            return false;
        }
        if (from_account_id == to_account_id) {
            std::cerr << "Cannot transfer to the same account." << std::endl;
            return false;
        }

        // We need to lock both accounts. To prevent deadlocks, always lock them in a consistent order.
        // A common strategy is to lock by a unique identifier (e.g., account ID).
        int lock1_id = std::min(from_account_id, to_account_id);
        int lock2_id = std::max(from_account_id, to_account_id);

        std::unique_lock<std::mutex> map_lock(bank_mtx); // Protect map access while finding accounts

        auto it1 = accounts.find(lock1_id);
        auto it2 = accounts.find(lock2_id);

        if (it1 == accounts.end() || it2 == accounts.end()) {
            std::cerr << "One or both accounts not found for transfer." << std::endl;
            return false;
        }

        Account& acc1 = (lock1_id == from_account_id) ? it1->second : it2->second;
        Account& acc2 = (lock2_id == from_account_id) ? it1->second : it2->second;

        // Use std::lock to acquire multiple locks at once, avoiding deadlock.
        // it requires unique_locks or lock_guards.
        std::unique_lock<std::mutex> lock1((lock1_id == from_account_id) ? it1->second.mtx : it2->second.mtx, std::defer_lock);
        std::unique_lock<std::mutex> lock2((lock2_id == from_account_id) ? it1->second.mtx : it2->second.mtx, std::defer_lock);

        std::lock(lock1, lock2); // Atomically locks both mutexes without deadlock

        // Determine which is 'from' and 'to' based on original request
        Account& from_acc = accounts.at(from_account_id);
        Account& to_acc = accounts.at(to_account_id);

        if (from_acc.balance >= amount) {
            from_acc.balance -= amount;
            to_acc.balance += amount;
            // std::cout << "Thread " << std::this_thread::get_id() << ": Transferred " << amount
            //           << " from account " << from_account_id << " to " << to_account_id << std::endl;
            return true;
        } else {
            // std::cerr << "Thread " << std::this_thread::get_id() << ": Insufficient funds in account "
            //           << from_account_id << " for transfer of " << amount << std::endl;
            return false;
        }
    }

    // Function to get account balance (read-only)
    double get_balance(int account_id) {
        std::lock_guard<std::mutex> map_lock(bank_mtx); // Protect map access

        auto it = accounts.find(account_id);
        if (it == accounts.end()) {
            std::cerr << "Account " << account_id << " not found." << std::endl;
            return -1.0; // Indicate error
        }

        Account& acc = it->second;
        std::lock_guard<std::mutex> account_lock(acc.mtx); // Lock the specific account for reading
        return acc.balance;
    }

    // Function to print all account balances
    void print_all_balances() {
        std::lock_guard<std::mutex> map_lock(bank_mtx); // Protect map access while iterating
        std::cout << "\n--- Current Account Balances ---" << std::endl;
        for (auto const& [id, account] : accounts) {
            std::lock_guard<std::mutex> account_lock(account.mtx); // Lock each account before reading its balance
            std::cout << "Account ID: " << id << ", Name: " << account.name << ", Balance: " << account.balance << std::endl;
        }
        std::cout << "--------------------------------\n" << std::endl;
    }

    // For testing total funds consistency
    double get_total_bank_funds() {
        std::lock_guard<std::mutex> map_lock(bank_mtx); // Protect map access while iterating
        double total = 0.0;
        for (auto const& [id, account] : accounts) {
            std::lock_guard<std::mutex> account_lock(account.mtx); // Lock each account
            total += account.balance;
        }
        return total;
    }
};

// Worker function for threads
void transaction_worker(Bank& bank, int thread_id, int num_transactions) {
    std::random_device rd;
    std::mt19937 gen(rd() + thread_id); // Seed with thread_id to make it more unique
    std::uniform_int_distribution<> account_dist(101, 104); // Account IDs 101-104
    std::uniform_real_distribution<> amount_dist(10.0, 200.0); // Transaction amounts
    std::uniform_int_distribution<> transaction_type_dist(0, 2); // 0:deposit, 1:withdraw, 2:transfer

    for (int i = 0; i < num_transactions; ++i) {
        int type = transaction_type_dist(gen);
        int account1_id = account_dist(gen);
        double amount = amount_dist(gen);

        switch (type) {
            case 0: // Deposit
                bank.deposit(account1_id, amount);
                break;
            case 1: // Withdraw
                bank.withdraw(account1_id, amount);
                break;
            case 2: { // Transfer
                int account2_id;
                do {
                    account2_id = account_dist(gen);
                } while (account1_id == account2_id); // Ensure different accounts for transfer
                bank.transfer(account1_id, account2_id, amount);
                break;
            }
        }
        // std::this_thread::sleep_for(std::chrono::milliseconds(1)); // Simulate some work
    }
}

int main() {
    Bank bank;
    bank.print_all_balances();
    double initial_total_funds = bank.get_total_bank_funds();
    std::cout << "Initial total bank funds: " << initial_total_funds << std::endl;

    const int num_threads = 8;
    const int transactions_per_thread = 5000;
    std::vector<std::thread> threads;

    auto start_time = std::chrono::high_resolution_clock::now();

    for (int i = 0; i < num_threads; ++i) {
        threads.emplace_back(transaction_worker, std::ref(bank), i, transactions_per_thread);
    }

    for (auto& t : threads) {
        t.join();
    }

    auto end_time = std::chrono::high_resolution_clock::now();
    std::chrono::duration<double> elapsed_time = end_time - start_time;
    std::cout << "\nAll transactions completed in " << elapsed_time.count() << " seconds." << std::endl;

    bank.print_all_balances();

    double final_total_funds = bank.get_total_bank_funds();
    std::cout << "Final total bank funds: " << final_total_funds << std::endl;

    if (initial_total_funds == final_total_funds) {
        std::cout << "Total bank funds remain consistent (expected for deposits/withdrawals/transfers)." << std::endl;
    } else {
        std::cout << "WARNING: Total bank funds changed! Data inconsistency detected." << std::endl;
    }

    return 0;
}