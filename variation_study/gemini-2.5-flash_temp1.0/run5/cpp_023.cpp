# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

// Define the configuration structure
typedef struct {
    char* output_file;
    int iterations;
    bool verbose;
    bool help_requested;
    bool version_requested;
} ApplicationConfig;

// Function to print a help message
void print_help(const char* program_name) {
    printf("Usage: %s [OPTIONS]\n", program_name);
    printf("A simple command-line tool demonstration.\n\n");
    printf("Options:\n");
    printf("  -o, --output <file>    Specify an output file.\n");
    printf("  -i, --iterations <num> Specify the number of iterations (default: 1).\n");
    printf("  -v, --verbose          Enable verbose output.\n");
    printf("  -h, --help             Display this help message and exit.\n");
    printf("  -V, --version          Display version information and exit.\n");
}

// Function to print version information
void print_version() {
    printf("CLI Tool Demo v1.0.0\n");
    printf("Copyright (C) 2023.\n");
}

// Function to parse command-line arguments and return a Config pointer
ApplicationConfig* parse_arguments(int argc, char* argv[]) {
    ApplicationConfig* config = (ApplicationConfig*)malloc(sizeof(ApplicationConfig));
    if (config == NULL) {
        fprintf(stderr, "Error: Failed to allocate memory for configuration.\n");
        return NULL;
    }

    // Initialize with default values
    config->output_file = NULL;
    config->iterations = 1;
    config->verbose = false;
    config->help_requested = false;
    config->version_requested = false;

    // Start parsing from argv[1]
    for (int i = 1; i < argc; ++i) {
        if (strcmp(argv[i], "-h") == 0 || strcmp(argv[i], "--help") == 0) {
            config->help_requested = true;
            return config; // Exit early if help is requested
        } else if (strcmp(argv[i], "-V") == 0 || strcmp(argv[i], "--version") == 0) {
            config->version_requested = true;
            return config; // Exit early if version is requested
        } else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbose = true;
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 < argc && argv[i+1][0] != '-') { // Check for next argument and if it's not another flag
                if (config->output_file != NULL) {
                    free(config->output_file); // Free previous if overwritten
                }
                config->output_file = strdup(argv[++i]); // Duplicate string for ownership
                if (config->output_file == NULL) {
                    fprintf(stderr, "Error: Failed to duplicate output file string.\n");
                    free(config);
                    return NULL;
                }
            } else {
                fprintf(stderr, "Error: Option '%s' requires a value.\n", argv[i]);
                if (config->output_file) free(config->output_file);
                free(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--iterations") == 0) {
            if (i + 1 < argc && argv[i+1][0] != '-') {
                char* endptr;
                long value = strtol(argv[++i], &endptr, 10);
                if (*endptr == '\0' && value > 0 && value <= 10000) { // Simple validation
                    config->iterations = (int)value;
                } else {
                    fprintf(stderr, "Error: Invalid or out-of-range value for option '%s'. Expected a positive integer.\n", argv[i-1]);
                    if (config->output_file) free(config->output_file);
                    free(config);
                    return NULL;
                }
            } else {
                fprintf(stderr, "Error: Option '%s' requires a value.\n", argv[i]);
                if (config->output_file) free(config->output_file);
                free(config);
                return NULL;
            }
        } else {
            fprintf(stderr, "Error: Unknown option '%s'. Use '%s --help' for usage.\n", argv[i], argv[0]);
            if (config->output_file) free(config->output_file);
            free(config);
            return NULL;
        }
    }

    return config;
}

// Main application entry point
int main(int argc, char* argv[]) {
    ApplicationConfig* app_config = parse_arguments(argc, argv);

    // Immediately use the returned pointer for application initialization
    if (app_config == NULL) {
        fprintf(stderr, "Application initialization failed due to argument parsing errors.\n");
        return EXIT_FAILURE;
    }

    if (app_config->help_requested) {
        print_help(argv[0]);
        // Clean up config before exiting
        if (app_config->output_file) free(app_config->output_file);
        free(app_config);
        return EXIT_SUCCESS;
    }

    if (app_config->version_requested) {
        print_version();
        // Clean up config before exiting
        if (app_config->output_file) free(app_config->output_file);
        free(app_config);
        return EXIT_SUCCESS;
    }

    // --- Application Logic Starts Here ---
    printf("Application started with configuration:\n");
    printf("  Output File: %s\n", app_config->output_file ? app_config->output_file : "None");
    printf("  Iterations:  %d\n", app_config->iterations);
    printf("  Verbose:     %s\n", app_config->verbose ? "True" : "False");

    if (app_config->verbose) {
        printf("Verbose mode activated. Doing extra logging...\n");
    }

    printf("Simulating %d iterations...\n", app_config->iterations);
    for (int i = 0; i < app_config->iterations; ++i) {
        // Simulate work
        if (app_config->verbose) {
            printf("  Iteration %d/%d completed.\n", i + 1, app_config->iterations);
        }
    }

    if (app_config->output_file) {
        printf("Results would be written to '%s'.\n", app_config->output_file);
        // Example: FILE* fp = fopen(app_config->output_file, "w"); ... fclose(fp);
    }

    printf("Application finished successfully.\n");
    // --- Application Logic Ends Here ---

    // Clean up allocated memory before exiting
    if (app_config->output_file) {
        free(app_config->output_file);
    }
    free(app_config);

    return EXIT_SUCCESS;
}