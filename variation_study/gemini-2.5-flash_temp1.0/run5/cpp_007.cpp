# Generated by google (gemini-2.5-flash)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

class Session {
public:
    std::string id;
    std::chrono::time_point<std::chrono::system_clock> creationTime;
    std::chrono::seconds duration;

    // Constructor to initialize a session with an ID and a duration
    Session(const std::string& sessionId, std::chrono::seconds sessionDuration)
        : id(sessionId), creationTime(std::chrono::system_clock::now()), duration(sessionDuration) {
        // std::cout << "[Session] Session '" << id << "' created with duration " << duration.count() << "s." << std::endl;
    }

    // Check if the session has expired
    bool isExpired() const {
        return std::chrono::system_clock::now() > (creationTime + duration);
    }

    // Destructor to log when a session is destroyed (optional, for debugging)
    ~Session() {
        // std::cout << "[Session] Session '" << id << "' destroyed." << std::endl;
    }
};

class SessionManager {
private:
    std::vector<Session*> sessions; // Stores raw pointers to Session objects

public:
    // Default constructor
    SessionManager() {
        // std::cout << "[Manager] SessionManager created." << std::endl;
    }

    // Destructor: Cleans up all remaining sessions to prevent memory leaks
    ~SessionManager() {
        // std::cout << "[Manager] SessionManager destroying. Cleaning up " << sessions.size() << " remaining sessions..." << std::endl;
        for (Session* session : sessions) {
            delete session; // Free the memory owned by the manager
        }
        sessions.clear();
        // std::cout << "[Manager] All sessions cleaned up. SessionManager destroyed." << std::endl;
    }

    // Disable copy constructor and assignment operator to prevent issues with raw pointer ownership.
    // This class takes ownership of raw pointers; copying would lead to double deletion.
    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    // Adds a new session to the manager.
    // The manager takes ownership of the passed Session* pointer.
    void addSession(Session* session) {
        if (!session) {
            std::cerr << "[Manager] Error: Cannot add a null session." << std::endl;
            return;
        }

        // Optional: Check if a session with the same ID already exists
        for (const auto& existingSession : sessions) {
            if (existingSession->id == session->id) {
                std::cerr << "[Manager] Warning: Session with ID '" << session->id << "' already exists. Not adding." << std::endl;
                delete session; // Clean up the passed pointer as it's not being added
                return;
            }
        }

        sessions.push_back(session);
        // std::cout << "[Manager] Session '" << session->id << "' added to manager." << std::endl;
    }

    // Retrieves a session by its ID. Returns nullptr if not found.
    Session* getSession(const std::string& sessionId) {
        for (Session* session : sessions) {
            if (session->id == sessionId) {
                return session;
            }
        }
        return nullptr; // Session not found
    }

    // Overload for const access to a session by its ID.
    const Session* getSession(const std::string& sessionId) const {
        for (const Session* session : sessions) {
            if (session->id == sessionId) {
                return session;
            }
        }
        return nullptr; // Session not found
    }

    // Removes and deletes a session by its ID. Returns true if removed, false if not found.
    bool removeSession(const std::string& sessionId) {
        auto it = sessions.begin();
        while (it != sessions.end()) {
            if ((*it)->id == sessionId) {
                // std::cout << "[Manager] Removing and deleting session '" << sessionId << "'." << std::endl;
                delete *it; // Free the memory associated with the session
                it = sessions.erase(it); // Remove the pointer from the vector
                return true;
            }
            ++it;
        }
        std::cerr << "[Manager] Error: Session '" << sessionId << "' not found for removal." << std::endl;
        return false; // Session not found
    }

    // Iterates through all sessions and deletes/removes any that have expired.
    void cleanupExpiredSessions() {
        // std::cout << "[Manager] Initiating cleanup for expired sessions..." << std::endl;
        size_t initial_count = sessions.size();

        // Use the erase-remove idiom with std::remove_if for efficient removal.
        // The lambda function checks for expired sessions, deletes them, and marks them for removal.
        auto it = std::remove_if(sessions.begin(), sessions.end(),
            [](Session* session) {
                if (session->isExpired()) {
                    // std::cout << "[Manager] Session '" << session->id << "' expired. Deleting." << std::endl;
                    delete session; // Free the memory
                    return true; // Mark this element for removal from the vector
                }
                return false; // Keep this element
            });

        sessions.erase(it, sessions.end()); // Erase all elements marked for removal

        // std::cout << "[Manager] Cleanup finished. " << (initial_count - sessions.size()) << " sessions removed. "
        //           << sessions.size() << " active sessions remaining." << std::endl;
    }

    // Returns the current number of active sessions.
    size_t getActiveSessionCount() const {
        return sessions.size();
    }
};

/*
// Example Usage (for demonstration purposes, not part of the class itself)
#include <iostream>
#include <thread> // For std::this_thread::sleep_for

int main() {
    SessionManager manager;

    // Add some sessions
    manager.addSession(new Session("user123", std::chrono::seconds(5)));  // Expires in 5 seconds
    manager.addSession(new Session("admin456", std::chrono::seconds(10))); // Expires in 10 seconds
    manager.addSession(new Session("guest789", std::chrono::seconds(2)));  // Expires in 2 seconds

    std::cout << "Active sessions: " << manager.getActiveSessionCount() << std::endl;

    // Access a session
    if (Session* s = manager.getSession("user123")) {
        std::cout << "Found session 'user123'. Created at: "
                  << std::chrono::duration_cast<std::chrono::seconds>(s->creationTime.time_since_epoch()).count()
                  << "s past epoch." << std::endl;
    } else {
        std::cout << "Session 'user123' not found." << std::endl;
    }

    // Wait for some sessions to expire
    std::this_thread::sleep_for(std::chrono::seconds(3));
    std::cout << "\n--- After 3 seconds ---" << std::endl;
    manager.cleanupExpiredSessions(); // guest789 should be removed
    std::cout << "Active sessions: " << manager.getActiveSessionCount() << std::endl;

    // Try to access an expired session
    if (manager.getSession("guest789")) {
        std::cout << "Error: Guest session still found after cleanup." << std::endl;
    } else {
        std::cout << "Guest session correctly removed." << std::endl;
    }

    // Remove a session manually
    manager.removeSession("user123");
    std::cout << "Active sessions: " << manager.getActiveSessionCount() << std::endl;

    // Wait for the last session to expire
    std::this_thread::sleep_for(std::chrono::seconds(8)); // Total sleep is 3 + 8 = 11 seconds
    std::cout << "\n--- After 11 seconds (total) ---" << std::endl;
    manager.cleanupExpiredSessions(); // admin456 should be removed
    std::cout << "Active sessions: " << manager.getActiveSessionCount() << std::endl;

    manager.addSession(new Session("test1", std::chrono::seconds(1)));
    manager.addSession(new Session("test2", std::chrono::seconds(1)));
    manager.addSession(new Session("test3", std::chrono::seconds(1)));
    std::cout << "Active sessions: " << manager.getActiveSessionCount() << std::endl;

    // When manager goes out of scope, its destructor will clean up 'test1', 'test2', 'test3'
    std::cout << "\nMain function ending. SessionManager destructor will be called." << std::endl;

    return 0;
}
*/