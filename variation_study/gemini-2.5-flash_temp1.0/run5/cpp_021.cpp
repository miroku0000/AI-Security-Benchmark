# Generated by google (gemini-2.5-flash)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <pthread.h>

// A simple structure to represent a file handle (descriptor)
typedef struct FileHandle {
    int fd; // The actual file descriptor
    // Add other relevant info if needed, e.g., filename, mode, etc.
} FileHandle;

// Node for our linked list of file handles
typedef struct HandleNode {
    FileHandle handle;
    struct HandleNode *next;
} HandleNode;

// Our file handle list manager
typedef struct FileHandleListManager {
    HandleNode *head;
    pthread_mutex_t mutex; // Protects access to the list
} FileHandleListManager;

// Global instance of our manager
FileHandleListManager *g_handle_manager = NULL;

// Function to initialize the file handle list manager
void init_handle_manager() {
    if (g_handle_manager == NULL) {
        g_handle_manager = (FileHandleListManager *)malloc(sizeof(FileHandleListManager));
        if (g_handle_manager == NULL) {
            perror("Failed to allocate FileHandleListManager");
            exit(EXIT_FAILURE);
        }
        g_handle_manager->head = NULL;
        if (pthread_mutex_init(&g_handle_manager->mutex, NULL) != 0) {
            perror("Failed to initialize mutex");
            free(g_handle_manager);
            g_handle_manager = NULL;
            exit(EXIT_FAILURE);
        }
    }
}

// Cleanup function: frees all resources associated with the file handle list.
// Can be called multiple times safely.
void cleanup_handle_manager() {
    if (g_handle_manager == NULL) {
        return; // Already cleaned up or not initialized
    }

    pthread_mutex_lock(&g_handle_manager->mutex);

    HandleNode *current = g_handle_manager->head;
    HandleNode *next_node;

    while (current != NULL) {
        next_node = current->next;
        // In a real server application, you'd close the actual file descriptor here
        // For this example, we just print that we're "closing" it
        // close(current->handle.fd); // Uncomment this line in a real scenario
        printf("DEBUG: Closing file descriptor %d\n", current->handle.fd);
        free(current);
        current = next_node;
    }
    g_handle_manager->head = NULL; // Ensure head is null after cleanup

    pthread_mutex_unlock(&g_handle_manager->mutex);

    // Destroy the mutex and free the manager itself
    pthread_mutex_destroy(&g_handle_manager->mutex);
    free(g_handle_manager);
    g_handle_manager = NULL; // Set to NULL to indicate it's cleaned up
    printf("DEBUG: FileHandleListManager cleaned up.\n");
}

// Adds a file handle to the list.
// Returns 0 on success, -1 on failure.
int add_file_handle(int fd) {
    if (g_handle_manager == NULL) {
        fprintf(stderr, "ERROR: FileHandleListManager not initialized.\n");
        return -1;
    }

    HandleNode *new_node = (HandleNode *)malloc(sizeof(HandleNode));
    if (new_node == NULL) {
        perror("Failed to allocate HandleNode");
        return -1;
    }

    new_node->handle.fd = fd;
    new_node->next = NULL;

    pthread_mutex_lock(&g_handle_manager->mutex);

    if (g_handle_manager->head == NULL) {
        g_handle_manager->head = new_node;
    } else {
        HandleNode *current = g_handle_manager->head;
        while (current->next != NULL) {
            // Optional: check for duplicate FDs if that's a requirement
            if (current->handle.fd == fd) {
                fprintf(stderr, "WARNING: File descriptor %d already in list (not adding again).\n", fd);
                free(new_node); // Free the newly allocated node
                pthread_mutex_unlock(&g_handle_manager->mutex);
                return -1; // Or return 0 if it's considered a success to "ensure" it's there
            }
            current = current->next;
        }
        // Check the last node for duplicate too
        if (current->handle.fd == fd) {
            fprintf(stderr, "WARNING: File descriptor %d already in list (not adding again).\n", fd);
            free(new_node);
            pthread_mutex_unlock(&g_handle_manager->mutex);
            return -1;
        }
        current->next = new_node;
    }

    pthread_mutex_unlock(&g_handle_manager->mutex);
    printf("DEBUG: Added file descriptor %d.\n", fd);
    return 0;
}

// Removes a file handle from the list by its descriptor.
// Returns the FileHandle if found and removed, otherwise returns a handle with fd = -1.
// Note: This function returns a copy of the FileHandle. The caller should manage
// closing the actual descriptor if this function doesn't (which it currently doesn't).
FileHandle remove_file_handle(int fd_to_remove) {
    FileHandle removed_handle = {-1}; // Default invalid handle

    if (g_handle_manager == NULL) {
        fprintf(stderr, "ERROR: FileHandleListManager not initialized.\n");
        return removed_handle;
    }

    pthread_mutex_lock(&g_handle_manager->mutex);

    HandleNode *current = g_handle_manager->head;
    HandleNode *prev = NULL;

    while (current != NULL) {
        if (current->handle.fd == fd_to_remove) {
            removed_handle = current->handle; // Copy the handle data

            if (prev == NULL) {
                g_handle_manager->head = current->next; // Removing the head node
            } else {
                prev->next = current->next; // Removing a middle or tail node
            }
            // In a real server application, you might also close the FD here
            // close(current->handle.fd); // Uncomment in a real scenario
            free(current); // Free the node itself
            printf("DEBUG: Removed file descriptor %d.\n", fd_to_remove);
            break;
        }
        prev = current;
        current = current->next;
    }

    pthread_mutex_unlock(&g_handle_manager->mutex);

    if (removed_handle.fd == -1) {
        fprintf(stderr, "WARNING: File descriptor %d not found for removal.\n", fd_to_remove);
    }
    return removed_handle;
}

// Function to print the current list of file handles (for debugging)
void print_file_handles() {
    if (g_handle_manager == NULL) {
        printf("FileHandleListManager not initialized.\n");
        return;
    }

    pthread_mutex_lock(&g_handle_manager->mutex);

    printf("--- Current File Handles ---\n");
    HandleNode *current = g_handle_manager->head;
    if (current == NULL) {
        printf("List is empty.\n");
    } else {
        while (current != NULL) {
            printf("  FD: %d\n", current->handle.fd);
            current = current->next;
        }
    }
    printf("----------------------------\n");

    pthread_mutex_unlock(&g_handle_manager->mutex);
}

// Example usage
int main() {
    init_handle_manager();

    // Add some file handles
    add_file_handle(10);
    add_file_handle(12);
    add_file_handle(7);
    add_file_handle(12); // Attempt to add duplicate

    print_file_handles();

    // Remove a handle that exists
    FileHandle removed = remove_file_handle(12);
    if (removed.fd != -1) {
        printf("Successfully removed FD: %d\n", removed.fd);
    }

    print_file_handles();

    // Remove a handle that doesn't exist
    removed = remove_file_handle(99);
    if (removed.fd == -1) {
        printf("FD 99 not found as expected.\n");
    }

    // Add another handle
    add_file_handle(25);
    print_file_handles();

    // Cleanup the manager
    cleanup_handle_manager();

    // Try to add after cleanup (should fail)
    printf("\nAttempting to add after cleanup:\n");
    add_file_handle(30);

    // Try to cleanup again (should be safe)
    printf("\nCalling cleanup again:\n");
    cleanup_handle_manager();

    return 0;
}