# Generated by google (gemini-2.5-flash)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdio.h>  // For printf
#include <stdint.h> // For fixed-width integers
#include <stdlib.h> // For rand()

// Define the sensor data structure
typedef struct
{
    volatile uint32_t sequence_before;
    volatile int32_t  temperature_c;
    volatile int32_t  pressure_pa;
    volatile uint32_t sequence_after;
} sensor_data_t;

// Global volatile struct for shared sensor data
sensor_data_t g_sensor_data = {0, 0, 0, 0};

// Static variables for task-internal use to manage data updates/reads
static volatile uint32_t s_sensor_update_sequence = 0;
static uint32_t s_last_processed_sequence = 0;

// Task 1: Reads sensor values and updates the global struct
void vSensorReadTask(void *pvParameters)
{
    (void)pvParameters; // Cast to void to suppress unused parameter warning

    int32_t current_temp = 25;
    int32_t current_pressure = 101325;

    for (;;)
    {
        // Simulate sensor reading
        current_temp += (rand() % 5) - 2; // Simulate temp fluctuation
        current_pressure += (rand() % 1000) - 500; // Simulate pressure fluctuation

        // Increment the sequence number for this update
        s_sensor_update_sequence++;

        // Update the global struct using a sequence number pattern to detect tearing
        g_sensor_data.sequence_before = s_sensor_update_sequence;
        g_sensor_data.temperature_c = current_temp;
        g_sensor_data.pressure_pa = current_pressure;
        g_sensor_data.sequence_after = s_sensor_update_sequence;

        printf("Sensor Read: Seq=%lu, Temp=%ldC, Press=%ldPa\n",
               s_sensor_update_sequence, current_temp, current_pressure);

        vTaskDelay(pdMS_TO_TICKS(100)); // Read every 100ms
    }
}

// Task 2: Processes the data for control logic
void vDataProcessTask(void *pvParameters)
{
    (void)pvParameters; // Cast to void to suppress unused parameter warning

    uint32_t seq_before, seq_after;
    int32_t temp, pressure;

    for (;;)
    {
        // Read the global struct using the sequence number pattern
        seq_before = g_sensor_data.sequence_before;
        temp = g_sensor_data.temperature_c;
        pressure = g_sensor_data.pressure_pa;
        seq_after = g_sensor_data.sequence_after;

        // Check for data consistency and if new data is available
        if (seq_before == seq_after && seq_before > s_last_processed_sequence)
        {
            // Data is consistent and new, process it
            s_last_processed_sequence = seq_before;

            printf("Control Logic: Processed Seq=%lu, Temp=%ldC, Press=%ldPa\n",
                   seq_before, temp, pressure);

            // Example control logic:
            if (temp > 30)
            {
                printf("  -> WARNING: High Temperature! Activate Cooling.\n");
            }
            else if (temp < 10)
            {
                printf("  -> WARNING: Low Temperature! Activate Heating.\n");
            }

            if (pressure > 102000)
            {
                printf("  -> INFO: High Pressure detected.\n");
            }
        }
        else if (seq_before != seq_after)
        {
            // Data was torn during read - log an error or retry
            printf("Control Logic: Data inconsistent (Seq_before=%lu, Seq_after=%lu). Skipping processing.\n",
                   seq_before, seq_after);
        }
        // If (seq_before == seq_after && seq_before == s_last_processed_sequence), then data is not new, do nothing.

        vTaskDelay(pdMS_TO_TICKS(200)); // Process data every 200ms
    }
}

// Main function - entry point for the application
int main(void)
{
    // Create the sensor reading task
    xTaskCreate(vSensorReadTask,              // Function that implements the task
                "SensorRead",                 // Text name for the task
                configMINIMAL_STACK_SIZE,     // Stack size in words
                NULL,                         // Parameter passed to the task
                tskIDLE_PRIORITY + 1,         // Task priority (higher than idle)
                NULL);                        // Handle to the created task

    // Create the data processing task
    xTaskCreate(vDataProcessTask,             // Function that implements the task
                "DataProcess",                // Text name for the task
                configMINIMAL_STACK_SIZE,     // Stack size in words
                NULL,                         // Parameter passed to the task
                tskIDLE_PRIORITY + 2,         // Task priority (higher than sensor read)
                NULL);                        // Handle to the created task

    // Start the scheduler - this will never return
    vTaskStartScheduler();

    // Should never get here unless there's not enough heap memory
    // for FreeRTOS objects
    for (;;) {}
}

// Implement FreeRTOS required hook functions if not already defined elsewhere
// (e.g., in a FreeRTOSConfig.h or specific port files)
void vApplicationMallocFailedHook(void)
{
    taskDISABLE_INTERRUPTS();
    for (;;) {}
}

void vApplicationIdleHook(void)
{
}

void vApplicationStackOverflowHook(TaskHandle_t pxTask, char *pcTaskName)
{
    (void)pcTaskName;
    (void)pxTask;
    taskDISABLE_INTERRUPTS();
    for (;;) {}
}

void vApplicationTickHook(void)
{
}