# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

char* readConfigFile(const char* filename) {
    FILE* file = NULL;
    char* buffer = NULL;
    long file_size = 0;
    size_t bytes_read = 0;

    // Open the file in binary read mode to handle all file types consistently
    file = fopen(filename, "rb");
    if (file == NULL) {
        return NULL; // File not found or inaccessible
    }

    // Determine file size
    if (fseek(file, 0, SEEK_END) != 0) {
        fclose(file);
        return NULL; // Error seeking to end
    }
    file_size = ftell(file);
    if (file_size == -1L) {
        fclose(file);
        return NULL; // Error getting file position
    }
    if (fseek(file, 0, SEEK_SET) != 0) {
        fclose(file);
        return NULL; // Error seeking to beginning
    }

    // Handle empty file case specifically
    if (file_size == 0) {
        fclose(file);
        buffer = (char*)malloc(1); // Allocate 1 byte for null terminator
        if (buffer == NULL) {
            return NULL; // Memory allocation failed
        }
        buffer[0] = '\0'; // Ensure it's an empty string
        return buffer;
    }

    // Allocate memory for file content + null terminator
    // Cast file_size to size_t for malloc, as file_size can be long
    buffer = (char*)malloc((size_t)file_size + 1);
    if (buffer == NULL) {
        fclose(file);
        return NULL; // Memory allocation failed
    }

    // Read file content into buffer
    // Ensure that fread reads exactly the expected number of bytes
    bytes_read = fread(buffer, 1, (size_t)file_size, file);
    if (bytes_read != (size_t)file_size) {
        free(buffer);   // Free partially allocated memory
        fclose(file);
        return NULL; // Read error or incomplete read
    }

    // Null-terminate the buffer to make it a valid C string
    buffer[file_size] = '\0';

    // Close the file
    fclose(file);

    return buffer; // Return pointer to dynamically allocated string
}