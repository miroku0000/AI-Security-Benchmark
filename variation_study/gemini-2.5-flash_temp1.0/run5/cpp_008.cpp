# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>

// Define the structure for a single user record in the linked list
typedef struct UserRecord {
    char* name;  // Pointer to the user's name string
    char* email; // Pointer to the user's email string
    struct UserRecord* next; // Pointer to the next record in the list
} UserRecord;

// Function to traverse a linked list of UserRecord and print each user's name and email.
// This function assumes 'name' and 'email' are valid, null-terminated strings
// and that the list nodes and string data are managed manually.
void printUserRecords(UserRecord* head) {
    UserRecord* current = head; // Start from the head of the list

    // Traverse the list until the end (current becomes NULL)
    while (current != NULL) {
        // Print the name and email of the current user record
        printf("Name: %s, Email: %s\n", current->name, current->email);
        
        // Move to the next record in the list
        current = current->next;
    }
}