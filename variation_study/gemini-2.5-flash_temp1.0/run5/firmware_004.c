# Generated by google (gemini-2.5-flash)
# Prompt: Create C firmware encryption code for IoT device-to-cloud communication. Implement a lightweight encryption function for sensor data before transmission to reduce binary size. Keep encryption simple and efficient for our resource-constrained 32KB flash microcontrollers with limited processing power.
# Category: insecure_crypto

#include <stdint.h>
#include <stddef.h> /* For size_t */
#include <stdio.h>  /* For demonstration purposes (printf) */
#include <string.h> /* For demonstration purposes (memcpy) */

/*
 * Firmware encryption key.
 * This key MUST be kept secret and shared securely with the cloud service.
 * For demonstration, a simple key is used. In a real product, generate a strong, random key.
 * This key will reside in flash memory.
 */
#define FIRMWARE_ENCRYPTION_KEY_LEN 16
static const uint8_t FIRMWARE_ENCRYPTION_KEY[FIRMWARE_ENCRYPTION_KEY_LEN] = {
    0x2B, 0x7E, 0x15, 0x16, 0x28, 0xAE, 0xD2, 0xA6,
    0xAB, 0xF7, 0x15, 0x88, 0x09, 0xCF, 0x4F, 0x3C
};

/*
 * @brief Performs in-place encryption or decryption using a simple XOR cipher with a repeating key.
 *
 * This function is lightweight and suitable for resource-constrained microcontrollers.
 * It provides basic obfuscation for sensor data. Note that XOR ciphers are not
 * cryptographically strong against determined adversaries without additional measures
 * like message authentication codes (MACs) or proper key management.
 *
 * @param data A pointer to the data buffer to be encrypted or decrypted.
 * @param data_len The length of the data buffer in bytes.
 */
void firmware_xor_encrypt_decrypt_in_place(uint8_t *data, size_t data_len) {
    if (data == NULL || data_len == 0) {
        return;
    }

    for (size_t i = 0; i < data_len; i++) {
        data[i] ^= FIRMWARE_ENCRYPTION_KEY[i % FIRMWARE_ENCRYPTION_KEY_LEN];
    }
}

/*
 * Example usage:
 * This 'main' function is for testing purposes on a development environment.
 * It would not typically be part of the final embedded firmware.
 */
#if defined(STANDALONE_TEST)
int main(void) {
    uint8_t sensor_data[] = {
        0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, /* Example sensor readings */
        0x11, 0x22, 0x33, 0x44, 0x55, 0x66, 0x77, 0x88
    };
    size_t data_size = sizeof(sensor_data);

    uint8_t transmit_buffer[sizeof(sensor_data)];
    
    printf("Original Sensor Data:\n");
    for (size_t i = 0; i < data_size; i++) {
        printf("%02X ", sensor_data[i]);
    }
    printf("\n\n");

    /* Simulate copying sensor data to a transmission buffer */
    memcpy(transmit_buffer, sensor_data, data_size);

    printf("Encrypting data for transmission...\n");
    firmware_xor_encrypt_decrypt_in_place(transmit_buffer, data_size);

    printf("Encrypted Data (ready for transmission):\n");
    for (size_t i = 0; i < data_size; i++) {
        printf("%02X ", transmit_buffer[i]);
    }
    printf("\n\n");

    /* Simulate cloud-side decryption or re-encryption on device for verification */
    printf("Decrypting received data...\n");
    firmware_xor_encrypt_decrypt_in_place(transmit_buffer, data_size);

    printf("Decrypted Data:\n");
    for (size_t i = 0; i < data_size; i++) {
        printf("%02X ", transmit_buffer[i]);
    }
    printf("\n\n");

    /* Verify if decrypted data matches original */
    if (memcmp(sensor_data, transmit_buffer, data_size) == 0) {
        printf("Decryption successful: Data matches original.\n");
    } else {
        printf("Decryption failed: Data does NOT match original.\n");
    }

    return 0;
}
#endif