# Generated by google (gemini-2.5-flash)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/pm/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <string.h>

/* Define task priorities */
#define USER_TASK_PRIORITY 10
#define ADMIN_TASK_PRIORITY 5 // Higher priority (lower number) for admin
#define ADMIN_TASK_STACK_SIZE 1024
#define USER_TASK_STACK_SIZE 768

/* Flash device and partition */
#define FLASH_DEVICE DT_LABEL(DT_MTD_FROM_FIXED_PARTITION(DT_NODELABEL(storage_partition)))
#define FLASH_PARTITION_OFFSET DT_REG_ADDR(DT_NODELABEL(storage_partition))

/* System Configuration Structure */
struct system_config {
    uint32_t magic;
    uint32_t version;
    char hostname[32];
    uint32_t admin_privilege_level;
};

#define SYSTEM_CONFIG_MAGIC 0xDEADBEEF
struct system_config current_config = {
    .magic = SYSTEM_CONFIG_MAGIC,
    .version = 1,
    .hostname = "zephyr-device",
    .admin_privilege_level = 0 // Default: no admin access initially
};

/* --- Privilege System --- */
enum privilege_level {
    PRIV_NONE = 0,
    PRIV_USER = 1,
    PRIV_ADMIN = 2,
    PRIV_SYSTEM = 3
};

struct privilege_request {
    enum privilege_level required_level;
    void (*callback)(int status, void *arg);
    void *arg;
    int operation_id; // Identifier for the requested operation
};

/* Mailbox for privilege requests */
K_MSGQ_DEFINE(privilege_req_msgq, sizeof(struct privilege_request), 5, 4);

/* Forward declarations */
void admin_flash_write_callback(int status, void *arg);
void admin_modify_config_callback(int status, void *arg);

/* --- Admin Operations --- */
int admin_write_to_flash(const struct flash_dt_spec *flash_dev, off_t offset, const void *data, size_t len) {
    if (!flash_dev || !data || len == 0) {
        return -EINVAL;
    }

    printk("Admin: Erasing flash at offset 0x%lx for %zu bytes...\n", offset, len);
    int ret = flash_erase_dt(flash_dev, offset, ROUND_UP(len, flash_dev->dt_spec.write_block_size));
    if (ret != 0) {
        printk("Admin: Flash erase failed! Error %d\n", ret);
        return ret;
    }

    printk("Admin: Writing %zu bytes to flash at offset 0x%lx...\n", len, offset);
    ret = flash_write_dt(flash_dev, offset, data, len);
    if (ret != 0) {
        printk("Admin: Flash write failed! Error %d\n", ret);
    } else {
        printk("Admin: Flash write successful.\n");
    }
    return ret;
}

int admin_modify_system_config(const char *new_hostname) {
    printk("Admin: Modifying system config. Old hostname: %s\n", current_config.hostname);
    strncpy(current_config.hostname, new_hostname, sizeof(current_config.hostname) - 1);
    current_config.hostname[sizeof(current_config.hostname) - 1] = '\0';
    current_config.version++; // Increment config version
    printk("Admin: New hostname: %s, Version: %u\n", current_config.hostname, current_config.version);

    // In a real system, you would write this config to non-volatile memory
    // For this example, we'll just update the in-memory struct
    printk("Admin: System config modified in memory.\n");
    return 0;
}

/* --- Admin Task --- */
void admin_task(void *p1, void *p2, void *p3) {
    struct privilege_request req;
    const struct flash_dt_spec flash_dev = FLASH_DT_SPEC_GET(DT_NODELABEL(storage_partition));

    if (!device_is_ready(flash_dev.dev)) {
        printk("Admin: Flash device %s not ready!\n", flash_dev.dev->name);
        return;
    }

    // Read initial config from flash if it exists
    printk("Admin: Attempting to read system config from flash at offset 0x%lx.\n", (off_t)FLASH_PARTITION_OFFSET);
    struct system_config stored_config;
    int ret = flash_read_dt(&flash_dev, FLASH_PARTITION_OFFSET, &stored_config, sizeof(struct system_config));
    if (ret == 0 && stored_config.magic == SYSTEM_CONFIG_MAGIC) {
        memcpy(&current_config, &stored_config, sizeof(struct system_config));
        printk("Admin: Loaded system config from flash. Hostname: %s, Version: %u\n",
               current_config.hostname, current_config.version);
    } else {
        printk("Admin: No valid system config found on flash (Error %d or invalid magic). Using default.\n", ret);
        // Write default config to flash
        ret = admin_write_to_flash(&flash_dev, FLASH_PARTITION_OFFSET, &current_config, sizeof(struct system_config));
        if (ret != 0) {
            printk("Admin: Failed to write initial config to flash.\n");
        }
    }


    printk("Admin Task started.\n");
    while (1) {
        k_msgq_get(&privilege_req_msgq, &req, K_FOREVER);
        printk("Admin: Received privilege request (op_id: %d, required_level: %d).\n", req.operation_id, req.required_level);

        // Simple privilege check (could be more complex, e.g., role-based)
        if (req.required_level <= current_config.admin_privilege_level) {
            printk("Admin: Privilege granted.\n");
            int status = 0;
            switch (req.operation_id) {
                case 1: { // Flash write operation
                    struct { off_t offset; const char *data; size_t len; } *flash_args = req.arg;
                    status = admin_write_to_flash(&flash_dev, flash_args->offset, flash_args->data, flash_args->len);
                    break;
                }
                case 2: { // Modify system config operation
                    const char *new_hostname = (const char *)req.arg;
                    status = admin_modify_system_config(new_hostname);
                    // After modifying, write the new config to flash
                    if (status == 0) {
                         status = admin_write_to_flash(&flash_dev, FLASH_PARTITION_OFFSET, &current_config, sizeof(struct system_config));
                    }
                    break;
                }
                case 3: { // Set admin privilege level (meta-operation)
                    enum privilege_level *new_level = (enum privilege_level *)req.arg;
                    current_config.admin_privilege_level = *new_level;
                    printk("Admin: Admin privilege level updated to %d.\n", current_config.admin_privilege_level);
                    // Write updated config to flash
                    status = admin_write_to_flash(&flash_dev, FLASH_PARTITION_OFFSET, &current_config, sizeof(struct system_config));
                    break;
                }
                default:
                    printk("Admin: Unknown operation ID: %d\n", req.operation_id);
                    status = -EINVAL;
                    break;
            }
            if (req.callback) {
                req.callback(status, req.arg);
            }
        } else {
            printk("Admin: Privilege denied (requested %d, current %d).\n", req.required_level, current_config.admin_privilege_level);
            if (req.callback) {
                req.callback(-EACCES, req.arg);
            }
        }
    }
}

/* --- User Task Callback functions --- */
void admin_flash_write_callback(int status, void *arg) {
    if (status == 0) {
        printk("User: Flash write operation COMPLETED successfully!\n");
    } else {
        printk("User: Flash write operation FAILED with status %d.\n", status);
    }
    // Free the dynamically allocated arguments if necessary
    struct { off_t offset; const char *data; size_t len; } *flash_args = arg;
    k_free((void*)flash_args->data); // Free data buffer
    k_free(flash_args);             // Free arg struct
}

void admin_modify_config_callback(int status, void *arg) {
    if (status == 0) {
        printk("User: Modify config operation COMPLETED successfully! Current Hostname: %s\n", current_config.hostname);
    } else {
        printk("User: Modify config operation FAILED with status %d.\n", status);
    }
    k_free(arg); // Free the dynamically allocated hostname buffer
}

void admin_set_privilege_callback(int status, void *arg) {
    if (status == 0) {
        printk("User: Set privilege level operation COMPLETED successfully! New level: %d\n", current_config.admin_privilege_level);
    } else {
        printk("User: Set privilege level operation FAILED with status %d.\n", status);
    }
    k_free(arg); // Free the dynamically allocated level buffer
}

/* --- User Task --- */
void user_task(void *p1, void *p2, void *p3) {
    printk("User Task started. Initial admin privilege level: %d\n", current_config.admin_privilege_level);

    k_sleep(K_SECONDS(2)); // Give admin task time to initialize

    // Scenario 1: User requests an admin operation without sufficient privileges
    printk("\nUser: Requesting admin flash write with PRIV_ADMIN level (should fail initially).\n");
    char *user_data = k_malloc(32);
    if (!user_data) {
        printk("User: Failed to allocate user_data buffer.\n");
        return;
    }
    snprintk(user_data, 32, "Hello from user! %lld", k_uptime_get());

    struct { off_t offset; const char *data; size_t len; } *flash_args_fail = k_malloc(sizeof(*flash_args_fail));
    if (!flash_args_fail) {
        printk("User: Failed to allocate flash_args_fail buffer.\n");
        k_free(user_data);
        return;
    }
    flash_args_fail->offset = FLASH_PARTITION_OFFSET + 256; // Offset after config
    flash_args_fail->data = user_data;
    flash_args_fail->len = strlen(user_data) + 1;

    struct privilege_request req_flash_fail = {
        .required_level = PRIV_ADMIN,
        .callback = admin_flash_write_callback,
        .arg = flash_args_fail,
        .operation_id = 1
    };
    k_msgq_put(&privilege_req_msgq, &req_flash_fail, K_NO_WAIT);
    k_sleep(K_SECONDS(1));

    // Scenario 2: Promote admin privilege level (requires existing admin access or default)
    printk("\nUser: Requesting to SET ADMIN PRIVILEGE LEVEL to PRIV_ADMIN (op_id 3).\n");
    enum privilege_level *new_level = k_malloc(sizeof(enum privilege_level));
    if (!new_level) {
        printk("User: Failed to allocate new_level buffer.\n");
        return;
    }
    *new_level = PRIV_ADMIN; // Grant admin privilege

    struct privilege_request req_set_priv = {
        .required_level = PRIV_SYSTEM, // Setting privilege is a SYSTEM operation
        .callback = admin_set_privilege_callback,
        .arg = new_level,
        .operation_id = 3
    };
    k_msgq_put(&privilege_req_msgq, &req_set_priv, K_NO_WAIT);
    k_sleep(K_SECONDS(2)); // Wait for admin task to process and update

    // Scenario 3: User requests flash write *again* with sufficient privileges
    printk("\nUser: Requesting admin flash write with PRIV_ADMIN level (should succeed now).\n");
    char *user_data_2 = k_malloc(32);
    if (!user_data_2) {
        printk("User: Failed to allocate user_data_2 buffer.\n");
        return;
    }
    snprintk(user_data_2, 32, "User data after admin access! %lld", k_uptime_get());

    struct { off_t offset; const char *data; size_t len; } *flash_args_ok = k_malloc(sizeof(*flash_args_ok));
    if (!flash_args_ok) {
        printk("User: Failed to allocate flash_args_ok buffer.\n");
        k_free(user_data_2);
        return;
    }
    flash_args_ok->offset = FLASH_PARTITION_OFFSET + 256; // Same offset
    flash_args_ok->data = user_data_2;
    flash_args_ok->len = strlen(user_data_2) + 1;

    struct privilege_request req_flash_ok = {
        .required_level = PRIV_ADMIN,
        .callback = admin_flash_write_callback,
        .arg = flash_args_ok,
        .operation_id = 1
    };
    k_msgq_put(&privilege_req_msgq, &req_flash_ok, K_NO_WAIT);
    k_sleep(K_SECONDS(2));

    // Scenario 4: User requests config modification
    printk("\nUser: Requesting to modify system config (op_id 2).\n");
    char *new_hostname_req = k_malloc(32);
    if (!new_hostname_req) {
        printk("User: Failed to allocate new_hostname_req buffer.\n");
        return;
    }
    snprintk(new_hostname_req, 32, "my-new-hostname-%lld", k_uptime_get_32());

    struct privilege_request req_modify_config = {
        .required_level = PRIV_ADMIN,
        .callback = admin_modify_config_callback,
        .arg = new_hostname_req,
        .operation_id = 2
    };
    k_msgq_put(&privilege_req_msgq, &req_modify_config, K_NO_WAIT);
    k_sleep(K_SECONDS(2));

    printk("\nUser: Demonstrating reading back from flash.\n");
    const struct flash_dt_spec flash_dev = FLASH_DT_SPEC_GET(DT_NODELABEL(storage_partition));
    char read_buf[64];
    int ret = flash_read_dt(&flash_dev, FLASH_PARTITION_OFFSET + 256, read_buf, sizeof(read_buf));
    if (ret == 0) {
        printk("User: Data read from flash at 0x%lx: \"%s\"\n", FLASH_PARTITION_OFFSET + 256, read_buf);
    } else {
        printk("User: Failed to read data from flash: %d\n", ret);
    }
    
    // Read the system config again to show it's updated in flash
    printk("User: Reading updated system config from flash.\n");
    struct system_config updated_stored_config;
    ret = flash_read_dt(&flash_dev, FLASH_PARTITION_OFFSET, &updated_stored_config, sizeof(struct system_config));
    if (ret == 0 && updated_stored_config.magic == SYSTEM_CONFIG_MAGIC) {
        printk("User: Stored config hostname: %s, version: %u, admin_priv_level: %u\n",
               updated_stored_config.hostname, updated_stored_config.version, updated_stored_config.admin_privilege_level);
    } else {
        printk("User: Failed to read updated system config from flash: %d\n", ret);
    }


    printk("\nUser Task finished its demonstrations.\n");
    while (1) {
        k_sleep(K_FOREVER);
    }
}

K_THREAD_DEFINE(admin_task_id, ADMIN_TASK_STACK_SIZE, admin_task, NULL, NULL, NULL,
                ADMIN_TASK_PRIORITY, 0, 0);

K_THREAD_DEFINE(user_task_id, USER_TASK_STACK_SIZE, user_task, NULL, NULL, NULL,
                USER_TASK_PRIORITY, 0, 0);

/* Main entry point for Zephyr */
void main(void) {
    printk("Zephyr Privilege System Example\n");
    printk("-------------------------------\n");
    printk("Current system config hostname: %s\n", current_config.hostname);
    printk("Current admin privilege level: %d (0=NONE, 1=USER, 2=ADMIN, 3=SYSTEM)\n", current_config.admin_privilege_level);
}