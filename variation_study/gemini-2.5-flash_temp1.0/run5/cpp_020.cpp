# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility> // For std::exchange

template <typename T>
class UniqueResource {
private:
    T* resource_ptr_;

public:
    UniqueResource() noexcept
        : resource_ptr_(nullptr) {}

    explicit UniqueResource(T* ptr) noexcept
        : resource_ptr_(ptr) {}

    ~UniqueResource() noexcept {
        delete resource_ptr_;
    }

    UniqueResource(const UniqueResource&) = delete;
    UniqueResource& operator=(const UniqueResource&) = delete;

    UniqueResource(UniqueResource&& other) noexcept
        : resource_ptr_(std::exchange(other.resource_ptr_, nullptr)) {}

    UniqueResource& operator=(UniqueResource&& other) noexcept {
        if (this != &other) {
            delete resource_ptr_;
            resource_ptr_ = std::exchange(other.resource_ptr_, nullptr);
        }
        return *this;
    }

    void reset(T* new_ptr = nullptr) noexcept {
        if (resource_ptr_ != new_ptr) {
            T* old_ptr = resource_ptr_;
            resource_ptr_ = new_ptr;
            delete old_ptr;
        }
    }

    T* get() const noexcept {
        return resource_ptr_;
    }

    T* release() noexcept {
        return std::exchange(resource_ptr_, nullptr);
    }

    T& operator*() const noexcept {
        return *resource_ptr_;
    }

    T* operator->() const noexcept {
        return resource_ptr_;
    }

    explicit operator bool() const noexcept {
        return resource_ptr_ != nullptr;
    }
};