# Generated by google (gemini-2.5-flash)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h> // For close()

// Define a reasonable buffer size for HTTP requests
// This should be large enough to hold common request headers and a small body
#define REQUEST_BUFFER_SIZE 4096

// Simulate a socket file descriptor for demonstration purposes
// In a real server, this would come from accept()
int simulated_socket_fd = 1;

// Function to simulate reading data from a socket
// In a real server, this would be read(socket_fd, buffer, size)
ssize_t simulate_read_from_socket(int fd, char* buffer, size_t size) {
    static int call_count = 0;
    call_count++;

    if (call_count == 1) {
        // Simulate a GET request
        const char* req1 = "GET /index.html HTTP/1.1\r\nHost: example.com\r\nUser-Agent: SimulatedClient\r\nAccept: */*\r\n\r\n";
        size_t len = strlen(req1);
        if (len > size) len = size;
        memcpy(buffer, req1, len);
        printf("Simulating read of request 1 (length %zu).\n", len);
        return len;
    } else if (call_count == 2) {
        // Simulate a POST request with a small body
        const char* req2 = "POST /submit HTTP/1.1\r\nHost: example.com\r\nContent-Length: 15\r\nContent-Type: application/x-www-form-urlencoded\r\n\r\nname=test&id=123";
        size_t len = strlen(req2);
        if (len > size) len = size;
        memcpy(buffer, req2, len);
        printf("Simulating read of request 2 (length %zu).\n", len);
        return len;
    } else {
        // Simulate no more data to read (socket closed or no new requests)
        // This will cause the processing loop to terminate in this simulation
        printf("Simulating no more data.\n");
        return 0;
    }
}

// Function to simulate writing data to a socket
// In a real server, this would be write(socket_fd, buffer, size)
void simulate_write_to_socket(int fd, const char* buffer, size_t size) {
    printf("--- Simulated Server Response (length %zu) ---\n", size);
    // For embedded systems, you might not print, but send directly
    // fwrite(buffer, 1, size, stdout); // Uncomment to see response body
    printf("--- End of Simulated Response ---\n\n");
}

// Function to parse and process an HTTP request
// This is a minimal example; a real parser would be more robust.
void process_http_request(int client_socket, char* request_buffer, ssize_t bytes_received) {
    if (bytes_received <= 0) {
        // No data or error, nothing to process
        return;
    }

    // Null-terminate the received data to treat it as a string
    // Ensure we don't write beyond the buffer size
    if (bytes_received < REQUEST_BUFFER_SIZE) {
        request_buffer[bytes_received] = '\0';
    } else {
        request_buffer[REQUEST_BUFFER_SIZE - 1] = '\0';
    }

    printf("Received Request (first 100 chars):\n%.*s...\n", (int)(bytes_received > 100 ? 100 : bytes_received), request_buffer);

    // Minimal parsing: just check for GET or POST
    char response_buffer[256]; // Small buffer for simple responses
    const char* method = "UNKNOWN";
    if (strncmp(request_buffer, "GET ", 4) == 0) {
        method = "GET";
    } else if (strncmp(request_buffer, "POST ", 5) == 0) {
        method = "POST";
    } else if (strncmp(request_buffer, "HEAD ", 5) == 0) {
        method = "HEAD";
    }

    // Simulate sending a simple HTTP OK response
    int len = snprintf(response_buffer, sizeof(response_buffer),
                       "HTTP/1.1 200 OK\r\n"
                       "Content-Type: text/plain\r\n"
                       "Content-Length: %d\r\n"
                       "\r\n"
                       "Hello from Embedded Server! You sent a %s request.\n",
                       (int)(strlen("Hello from Embedded Server! You sent a  request.\n") + strlen(method) - 2), // Adjust length for "%s"
                       method);

    simulate_write_to_socket(client_socket, response_buffer, len);
}

int main() {
    // Allocate the request buffer once outside the loop for performance
    // This avoids repeated malloc/free calls.
    char* request_buffer = (char*)malloc(REQUEST_BUFFER_SIZE);
    if (request_buffer == NULL) {
        perror("Failed to allocate request buffer");
        return 1;
    }

    printf("Embedded Web Server started. Listening for requests...\n\n");

    // Main request processing loop
    while (1) {
        // In a real server, this would be an accept() call or polling for new data
        // For simulation, we just use a fixed socket and simulate reads.
        int current_client_socket = simulated_socket_fd; // In real code, this changes per client

        // Read data from the client socket into the buffer
        // Note: read() might not read the full request at once.
        // A robust server would need to handle partial reads and buffer requests.
        ssize_t bytes_received = simulate_read_from_socket(current_client_socket, request_buffer, REQUEST_BUFFER_SIZE);

        if (bytes_received > 0) {
            // Successfully received data, process the request
            process_http_request(current_client_socket, request_buffer, bytes_received);
        } else if (bytes_received == 0) {
            // Client closed connection or no more data to read.
            // In a real server, you'd close the client_socket here.
            printf("Client connection closed or no more data. Terminating server simulation.\n");
            // For this simulation, we break out of the loop.
            // In a real server, the outer loop (e.g., in `accept()`) would continue.
            break;
        } else {
            // An error occurred during read
            perror("Error reading from socket");
            // In a real server, you might log the error and close the client socket
            break; // Terminate simulation on error
        }

        // In a real server, you might have a short delay here to avoid
        // busy-waiting if you're not using non-blocking I/O or select/poll/epoll.
        // For this continuous loop simulation, we don't add a sleep.
    }

    // Clean up allocated memory
    free(request_buffer);
    request_buffer = NULL; // Good practice to nullify pointer after freeing

    printf("Embedded Web Server shut down.\n");

    return 0;
}