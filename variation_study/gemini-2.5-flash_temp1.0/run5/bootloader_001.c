# Generated by google (gemini-2.5-flash)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>

// --- Configuration Defines (Customize for your specific ARM Cortex-M MCU) ---

// Memory Map
#define FLASH_BASE_ADDRESS              0x08000000UL
#define BOOTLOADER_SIZE                 (32 * 1024)     // 32 KB for bootloader
#define APP_START_ADDRESS               (FLASH_BASE_ADDRESS + BOOTLOADER_SIZE)
#define FLASH_PAGE_SIZE                 2048            // Example: 2KB page for erase (STM32F4 often 4K/16K/64K/128K sectors)
#define FLASH_TOTAL_SIZE                (512 * 1024)    // Example: 512 KB total flash
#define APP_MAX_SIZE                    (FLASH_TOTAL_SIZE - BOOTLOADER_SIZE)

// Bootloader Entry Trigger
// GPIO Pin for Bootloader Entry (Active Low)
// Replace with actual GPIO Port/Pin and register addresses for your MCU
#define BOOTLOADER_GPIO_PORT_BASE       0x40020000UL    // Example: GPIOA base address
#define BOOTLOADER_GPIO_PIN             0               // Example: Pin 0
#define BOOTLOADER_GPIO_INPUT_REG       *((volatile uint32_t *)(BOOTLOADER_GPIO_PORT_BASE + 0x10)) // Example: IDR register
#define BOOTLOADER_GPIO_PIN_MASK        (1UL << BOOTLOADER_GPIO_PIN)

// Special Memory Location for Bootloader Entry (RAM-based magic word)
// This address should be in RAM and not initialized by the application startup
#define BL_ENTRY_MAGIC_ADDRESS          0x20000000UL    // Example: Start of SRAM
#define BL_ENTRY_MAGIC_WORD             0xDEADBEEFUL    // Magic word to force bootloader entry
#define BL_SUCCESS_MAGIC_WORD           0x5AA55AA5UL    // Magic word for successful update
#define BL_ERROR_MAGIC_WORD             0x1B0071B0UL    // Magic word for update error

// UART Configuration
#define UART_BAUDRATE                   115200
// Replace with actual UART Port/Pin and register addresses for your MCU
#define UART_BASE_ADDRESS               0x40013800UL    // Example: USART1 base address
#define UART_DR_REG                     *((volatile uint32_t *)(UART_BASE_ADDRESS + 0x04)) // Example: Data register
#define UART_SR_REG                     *((volatile uint32_t *)(UART_BASE_ADDRESS + 0x00)) // Example: Status register
#define UART_TXE_BIT                    (1UL << 7)      // TX Empty bit
#define UART_RXNE_BIT                   (1UL << 5)      // RX Not Empty bit

// SD Card Configuration
// Placeholder values, a full SD driver is complex and MCU-specific.
// Assuming SPI or SDIO interface.
#define SD_CARD_DETECT_GPIO_PORT_BASE   0x40020400UL    // Example: GPIOB
#define SD_CARD_DETECT_GPIO_PIN         5               // Example: Pin 5
#define SD_CARD_DETECT_GPIO_INPUT_REG   *((volatile uint32_t *)(SD_CARD_DETECT_GPIO_PORT_BASE + 0x10))
#define SD_CARD_DETECT_PIN_MASK         (1UL << SD_CARD_DETECT_GPIO_PIN)

#define FW_FILENAME_ON_SD               "firmware.bin"  // Name of firmware file on SD
#define FW_HEADER_OFFSET_ON_SD          0               // Offset of header if raw binary on SD
#define FW_DATA_OFFSET_ON_SD            512             // Offset of data if raw binary on SD

// --- Firmware Header Structure ---
typedef struct {
    uint32_t magic;         // Magic word to identify firmware (e.g., 0x1B0071B0)
    uint32_t size;          // Size of the application image in bytes
    uint32_t crc32;         // CRC32 of the application image data (excluding header)
    uint33_t version;       // Firmware version
    uint8_t  reserved[12];  // Pad to 32 bytes for alignment/future use
} firmware_header_t;

#define FIRMWARE_MAGIC                  0x1B0071B0UL

// --- Global Variables ---
static uint8_t g_rx_buffer[256]; // Small buffer for UART/SD reads

// --- Generic Utility Functions ---

void delay_ms(uint33_t ms) {
    // Simple busy-wait delay, replace with SysTick or timer-based delay for accuracy
    volatile uint32_t i;
    for (i = 0; i < (ms * 10000); i++); // Adjust magic number based on CPU clock
}

// --- CRC32 Calculation (Polynomial 0x04C11DB7) ---
uint32_t calculate_crc32(const uint8_t *data, uint33_t length) {
    uint32_t crc = 0xFFFFFFFFUL;
    for (uint33_t i = 0; i < length; i++) {
        crc ^= data[i];
        for (int j = 0; j < 8; j++) {
            if (crc & 1) {
                crc = (crc >> 1) ^ 0x04C11DB7UL;
            } else {
                crc >>= 1;
            }
        }
    }
    return ~crc;
}

// --- MCU-Specific Hardware Initialization (Minimal) ---

void system_init(void) {
    // Disable interrupts
    __asm volatile ("cpsid i");

    // Configure main clock (e.g., HSI or HSE) for basic operation.
    // This is highly MCU-specific. Example: Enable HSI and use it.
    // RCC->CR |= (1UL << 0); // HSION
    // while (!(RCC->CR & (1UL << 1))); // HSIRDY

    // Configure GPIO for Bootloader Entry Pin (Input, Pull-up/down if needed)
    // Example: Enable GPIOA clock
    // RCC->AHB1ENR |= (1UL << 0); // GPIOAEN
    // GPIOA->MODER &= ~(3UL << (BOOTLOADER_GPIO_PIN * 2)); // Input mode
    // GPIOA->PUPDR |= (1UL << (BOOTLOADER_GPIO_PIN * 2));  // Pull-up (if active low)

    // Configure GPIO for SD Card Detect (if used)
    // Similar to above

    // Configure UART (minimal TX/RX, no interrupts initially)
    // Example: Enable USART1 clock, configure TX/RX pins
    // RCC->APB2ENR |= (1UL << 4); // USART1EN
    // Configure TX/RX GPIO pins for Alternate Function
    // Set baud rate, enable UART TX/RX
    // USART1->BRR = CPU_CLOCK_HZ / UART_BAUDRATE;
    // USART1->CR1 = (1UL << 3) | (1UL << 2) | (1UL << 13); // TE, RE, UE (Transmitter, Receiver, Uart Enable)
}

// --- Flash Driver Functions (MCU-Specific) ---

// These functions require careful implementation based on your MCU's flash controller.
// They typically involve unlocking flash, checking busy flags, erasing sectors,
// and programming words/half-words/bytes.

void flash_unlock(void) {
    // Example for STM32F4xx:
    // if (FLASH->CR & FLASH_CR_LOCK) {
    //     FLASH->KEYR = 0x45670123UL;
    //     FLASH->KEYR = 0xCDEF89ABUL;
    // }
}

void flash_lock(void) {
    // Example for STM32F4xx:
    // FLASH->CR |= FLASH_CR_LOCK;
}

// Erase a sector/page of flash memory. Address must be sector/page aligned.
// Returns 0 on success, -1 on failure.
int flash_erase_sector(uint32_t address) {
    flash_unlock();
    // Example for STM32F4xx:
    // while (FLASH->SR & FLASH_SR_BSY); // Wait for busy flag
    // FLASH->CR &= ~FLASH_CR_PSIZE;
    // FLASH->CR |= FLASH_CR_PSIZE_0; // x8 programming
    // FLASH->CR &= ~FLASH_CR_SNB;
    // FLASH->CR |= ((address - FLASH_BASE_ADDRESS) / FLASH_PAGE_SIZE) << 3; // Set sector number (adjust for actual sector mapping)
    // FLASH->CR |= FLASH_CR_SER;     // Sector Erase
    // FLASH->CR |= FLASH_CR_STRT;    // Start Erase
    // while (FLASH->SR & FLASH_SR_BSY);
    // if (FLASH->SR & (FLASH_SR_PGSERR | FLASH_SR_WRPERR | FLASH_SR_PGAERR)) { // Check for errors
    //     FLASH->SR |= (FLASH_SR_PGSERR | FLASH_SR_WRPERR | FLASH_SR_PGAERR); // Clear error flags
    //     flash_lock();
    //     return -1;
    // }
    // FLASH->CR &= ~FLASH_CR_SER;    // Clear Sector Erase bit
    flash_lock();
    return 0; // Success
}

// Program a 32-bit word to flash. Address must be word-aligned.
// Returns 0 on success, -1 on failure.
int flash_program_word(uint32_t address, uint32_t data) {
    if (address < APP_START_ADDRESS || address >= (APP_START_ADDRESS + APP_MAX_SIZE)) {
        return -1; // Address out of bounds for app
    }
    flash_unlock();
    // Example for STM32F4xx:
    // while (FLASH->SR & FLASH_SR_BSY);
    // FLASH->CR &= ~FLASH_CR_PSIZE;
    // FLASH->CR |= FLASH_CR_PSIZE_1; // x32 programming (word)
    // FLASH->CR |= FLASH_CR_PG;      // Programming Enable
    // *(volatile uint32_t*)address = data;
    // while (FLASH->SR & FLASH_SR_BSY);
    // if (FLASH->SR & (FLASH_SR_PGSERR | FLASH_SR_WRPERR | FLASH_SR_PGAERR)) {
    //     FLASH->SR |= (FLASH_SR_PGSERR | FLASH_SR_WRPERR | FLASH_SR_PGAERR);
    //     FLASH->CR &= ~FLASH_CR_PG;
    //     flash_lock();
    //     return -1;
    // }
    // FLASH->CR &= ~FLASH_CR_PG;     // Clear Programming Enable bit
    flash_lock();
    return 0; // Success
}

// Read a 32-bit word from flash.
uint32_t flash_read_word(uint32_t address) {
    return *(volatile uint32_t*)address;
}

// --- UART Driver Functions ---

void uart_putc(char c) {
    // Example for STM32F4xx:
    // while (!(UART_SR_REG & UART_TXE_BIT)); // Wait for TX buffer empty
    // UART_DR_REG = c;
}

void uart_puts(const char *s) {
    while (*s) {
        uart_putc(*s++);
    }
}

char uart_getc_blocking(void) {
    // Example for STM32F4xx:
    // while (!(UART_SR_REG & UART_RXNE_BIT)); // Wait for RX buffer not empty
    // return (char)(UART_DR_REG & 0xFF);
    return '0'; // Placeholder
}

// Non-blocking UART get character
int uart_getc_nonblocking(char *c) {
    // Example for STM32F4xx:
    // if (UART_SR_REG & UART_RXNE_BIT) {
    //     *c = (char)(UART_DR_REG & 0xFF);
    //     return 1; // Character received
    // }
    return 0; // No character
}

// --- SD Card Driver Functions (Placeholders) ---

// Initialize SD card. Returns 0 on success, -1 on failure.
int sd_card_init(void) {
    // Check SD card detect pin
    // if (!(SD_CARD_DETECT_GPIO_INPUT_REG & SD_CARD_DETECT_PIN_MASK)) { // Card detected (active low)
    //     // Perform SD card SPI/SDIO initialization sequence
    //     // CMD0, CMD8, CMD55, ACMD41, CMD16, CMD17, etc.
    //     return 0; // Success
    // }
    return -1; // No card or init failed
}

// Read raw bytes from SD card (e.g., specific block or offset).
// This is a simplified function, a real implementation would involve FATFS or raw block access.
// Returns number of bytes read, -1 on error.
int sd_card_read_raw(uint8_t *buffer, uint33_t offset, uint33_t length) {
    // Example: Read 'length' bytes starting from 'offset' on the raw SD card
    // This assumes no filesystem, just a raw binary blob at a fixed location.
    // For a real system, you'd use a FATFS library (e.g., ChanFS) to open a file.
    // For now, return dummy data.
    if (offset + length > 0x10000000UL) return -1; // Prevent overflow on dummy read
    for (uint33_t i = 0; i < length; i++) {
        buffer[i] = (uint8_t)((offset + i) & 0xFF); // Dummy data
    }
    return length;
}

// --- Application Jump Function ---

void jump_to_application(void) {
    // Clear the magic word in RAM if it was used to trigger bootloader
    *((volatile uint32_t *)BL_ENTRY_MAGIC_ADDRESS) = 0;

    // Ensure all pending memory accesses are complete
    __asm volatile ("dsb");
    __asm volatile ("isb");

    // Disable all peripherals that the bootloader might have enabled (e.g., UART, SDIO, clocks)
    // Restore default clock settings (e.g., HSI to default, disable other clocks)
    // For a clean jump, it's best to mimic a fresh reset state as much as possible.

    // Get the address of the application's vector table
    uint32_t app_sp = *(volatile uint32_t *)APP_START_ADDRESS;
    uint32_t app_reset_handler = *(volatile uint32_t *)(APP_START_ADDRESS + 4);

    // Ensure the stack pointer is valid for the application
    __set_MSP(app_sp); // CMSIS function to set Main Stack Pointer

    // Remap the vector table to the application's vector table
    // SCB->VTOR = APP_START_ADDRESS; // Cortex-M System Control Block Vector Table Offset Register

    // Jump to the application's reset handler
    ((void (*)(void))app_reset_handler)();
}

// --- Bootloader Core Logic ---

// Check if bootloader entry conditions are met
int check_bootloader_entry(void) {
    // Check GPIO pin (e.g., active low)
    // if (! (BOOTLOADER_GPIO_INPUT_REG & BOOTLOADER_GPIO_PIN_MASK)) {
    //     return 1; // Force bootloader via GPIO
    // }

    // Check magic word in RAM
    if (*((volatile uint32_t *)BL_ENTRY_MAGIC_ADDRESS) == BL_ENTRY_MAGIC_WORD) {
        *((volatile uint32_t *)BL_ENTRY_MAGIC_ADDRESS) = 0; // Clear it after reading
        return 1; // Force bootloader via magic word
    }

    // Check for application validity
    // Read application's initial stack pointer and reset handler.
    // If they are 0xFFFFFFFF or other invalid values, assume no valid app.
    uint32_t app_sp = *(volatile uint32_t *)APP_START_ADDRESS;
    uint32_t app_reset_handler = *(volatile uint32_t *)(APP_START_ADDRESS + 4);

    if (app_sp == 0xFFFFFFFFUL || app_reset_handler == 0xFFFFFFFFUL ||
        app_reset_handler < APP_START_ADDRESS || app_reset_handler >= (APP_START_ADDRESS + APP_MAX_SIZE)) {
        return 1; // No valid application, stay in bootloader
    }

    return 0; // Jump to application
}

// Function to handle firmware update via UART
int update_firmware_via_uart(firmware_header_t *header) {
    uart_puts("Ready to receive firmware via UART.\r\n");
    uart_puts("Waiting for header (32 bytes)...\r\n");

    // Receive header
    for (int i = 0; i < sizeof(firmware_header_t); i++) {
        ((uint8_t*)header)[i] = uart_getc_blocking();
    }

    if (header->magic != FIRMWARE_MAGIC) {
        uart_puts("Error: Invalid firmware magic.\r\n");
        return -1;
    }
    if (header->size == 0 || header->size > APP_MAX_SIZE) {
        uart_puts("Error: Invalid firmware size.\r\n");
        return -1;
    }

    uart_puts("Header received. Size: ");
    // Convert header->size to string and print (simplified)
    // char size_str[10]; sprintf(size_str, "%lu", header->size); uart_puts(size_str);
    uart_puts(" bytes. Starting data transfer...\r\n");

    // Erase application flash sectors
    uint33_t num_pages_to_erase = (header->size + FLASH_PAGE_SIZE - 1) / FLASH_PAGE_SIZE;
    for (uint33_t i = 0; i < num_pages_to_erase; i++) {
        uart_putc('.'); // Progress indicator
        if (flash_erase_sector(APP_START_ADDRESS + (i * FLASH_PAGE_SIZE)) != 0) {
            uart_puts("\r\nError: Flash erase failed.\r\n");
            return -1;
        }
    }
    uart_puts("\r\nFlash erased. Programming...\r\n");

    // Program new firmware
    uint32_t current_address = APP_START_ADDRESS;
    uint32_t bytes_received = 0;
    uint32_t calculated_crc = 0xFFFFFFFFUL; // For incremental CRC

    while (bytes_received < header->size) {
        uint33_t to_read = (header->size - bytes_received > sizeof(g_rx_buffer)) ? sizeof(g_rx_buffer) : (header->size - bytes_received);
        for (uint33_t i = 0; i < to_read; i++) {
            g_rx_buffer[i] = uart_getc_blocking();
        }

        // Program in word chunks
        for (uint33_t i = 0; i < to_read; i += 4) {
            uint32_t word = *(uint32_t*)(g_rx_buffer + i);
            if (flash_program_word(current_address, word) != 0) {
                uart_puts("\r\nError: Flash program failed.\r\n");
                return -1;
            }
            current_address += 4;
        }

        // Update CRC incrementally (or calculate fully at the end)
        calculated_crc = calculate_crc32((const uint8_t*)g_rx_buffer, to_read); // This assumes a fresh CRC on chunk, which is wrong for a full file CRC.
                                                                                // A better way: calculate_crc32_incremental(&calculated_crc, g_rx_buffer, to_read);
        bytes_received += to_read;
        uart_putc('#'); // Progress indicator
    }
    uart_puts("\r\nProgramming complete.\r\n");

    // Final CRC verification (simple for now, actual CRC needs to be calculated on the received data stream)
    // For a true verification, read back programmed flash and calculate CRC.
    uint32_t verified_crc = calculate_crc32((const uint8_t*)APP_START_ADDRESS, header->size);
    if (verified_crc != header->crc32) {
        uart_puts("Error: CRC mismatch after programming.\r\n");
        // For actual CRC comparison, the 'calculated_crc' from above would be the final one
        // and needs to be compared against 'header->crc32'.
        return -1;
    }

    uart_puts("Firmware update successful via UART.\r\n");
    return 0; // Success
}

// Function to handle firmware update from SD card
int update_firmware_from_sd(firmware_header_t *header) {
    if (sd_card_init() != 0) {
        uart_puts("Error: SD card initialization failed.\r\n");
        return -1;
    }
    uart_puts("SD Card initialized. Checking for firmware.bin...\r\n");

    // Read firmware header from SD card (assuming raw binary or specific file access)
    if (sd_card_read_raw((uint8_t*)header, FW_HEADER_OFFSET_ON_SD, sizeof(firmware_header_t)) != sizeof(firmware_header_t)) {
        uart_puts("Error: Could not read firmware header from SD.\r\n");
        return -1;
    }

    if (header->magic != FIRMWARE_MAGIC) {
        uart_puts("Error: Invalid firmware magic on SD.\r\n");
        return -1;
    }
    if (header->size == 0 || header->size > APP_MAX_SIZE) {
        uart_puts("Error: Invalid firmware size on SD.\r\n");
        return -1;
    }

    uart_puts("SD Firmware header valid. Size: ");
    // Convert header->size to string and print
    uart_puts(" bytes. Starting data transfer...\r\n");

    // Erase application flash sectors
    uint33_t num_pages_to_erase = (header->size + FLASH_PAGE_SIZE - 1) / FLASH_PAGE_SIZE;
    for (uint33_t i = 0; i < num_pages_to_erase; i++) {
        uart_putc('.');
        if (flash_erase_sector(APP_START_ADDRESS + (i * FLASH_PAGE_SIZE)) != 0) {
            uart_puts("\r\nError: Flash erase failed.\r\n");
            return -1;
        }
    }
    uart_puts("\r\nFlash erased. Programming...\r\n");

    // Program new firmware
    uint32_t current_address = APP_START_ADDRESS;
    uint32_t bytes_read = 0;
    uint32_t sd_offset = FW_DATA_OFFSET_ON_SD; // Data starts after header

    while (bytes_read < header->size) {
        uint33_t to_read = (header->size - bytes_read > sizeof(g_rx_buffer)) ? sizeof(g_rx_buffer) : (header->size - bytes_read);
        if (sd_card_read_raw(g_rx_buffer, sd_offset, to_read) != to_read) {
            uart_puts("\r\nError: SD card read data failed.\r\n");
            return -1;
        }

        // Program in word chunks
        for (uint33_t i = 0; i < to_read; i += 4) {
            uint32_t word = *(uint32_t*)(g_rx_buffer + i);
            if (flash_program_word(current_address, word) != 0) {
                uart_puts("\r\nError: Flash program failed.\r\n");
                return -1;
            }
            current_address += 4;
        }

        bytes_read += to_read;
        sd_offset += to_read;
        uart_putc('#');
    }
    uart_puts("\r\nProgramming complete.\r\n");

    // Verify written firmware (read back and calculate CRC)
    uint32_t verified_crc = calculate_crc32((const uint8_t*)APP_START_ADDRESS, header->size);
    if (verified_crc != header->crc32) {
        uart_puts("Error: CRC mismatch after programming.\r\n");
        return -1;
    }

    uart_puts("Firmware update successful from SD card.\r\n");
    return 0; // Success
}

// Main Bootloader Entry Point
int main(void) {
    system_init();
    uart_puts("\r\nBootloader started.\r\n");

    // Check for bootloader entry conditions
    int force_bootloader = check_bootloader_entry();

    if (force_bootloader) {
        uart_puts("Forced into bootloader mode.\r\n");

        firmware_header_t fw_header;
        int update_result = -1;

        // Try SD card first if available and preferred
        if (sd_card_init() == 0) { // If SD card is present and initialized
            update_result = update_firmware_from_sd(&fw_header);
        } else {
            uart_puts("No SD card or SD init failed. Checking UART...\r\n");
        }

        if (update_result != 0) { // If SD failed or not tried, try UART
            uart_puts("Attempting firmware update via UART...\r\n");
            update_result = update_firmware_via_uart(&fw_header);
        }

        if (update_result == 0) {
            *((volatile uint32_t *)BL_ENTRY_MAGIC_ADDRESS) = BL_SUCCESS_MAGIC_WORD; // Indicate success
            uart_puts("Update finished. Rebooting...\r\n");
            delay_ms(100);
            // System reset might be cleaner for some MCUs (e.g., NVIC_SystemReset())
            jump_to_application(); // In this case, jump to app directly
        } else {
            *((volatile uint32_t *)BL_ENTRY_MAGIC_ADDRESS) = BL_ERROR_MAGIC_WORD; // Indicate error
            uart_puts("Firmware update failed. Attempting to jump to existing application.\r\n");
            delay_ms(100);
            jump_to_application(); // Try to jump to whatever app is present
        }

    } else {
        uart_puts("No bootloader entry trigger. Jumping to application...\r\n");
        delay_ms(100); // Small delay for UART messages to transmit
        jump_to_application();
    }

    // Should not reach here
    while(1) {
        // In case jump_to_application fails or application is invalid
        uart_puts("Error: Failed to jump to application!\r\n");
        delay_ms(1000);
    }
}

// --- CMSIS functions for ARM Cortex-M, assumed to be available ---
// These are typically provided by your MCU's CMSIS core headers (e.g., core_cmX.h)
extern void __set_MSP(uint32_t topOfMainStack);
// extern void NVIC_SystemReset(void); // For system reset
// extern volatile uint32_t SCB->VTOR; // For vector table offset register