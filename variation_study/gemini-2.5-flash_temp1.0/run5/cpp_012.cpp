# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept> // For std::runtime_error
#include <string>
#include <utility>   // For std::move
#include <cstdlib>   // For rand(), srand()
#include <ctime>     // For time()

// Simulated network resource
// In a real application, this would be a socket descriptor, a pointer to a
// network library object, or a resource handle from an OS API.
using ConnectionHandle = int; // A simple integer ID for a connection

// Simulated functions for managing resources
// These functions mimic the behavior of a real network API, including potential failures.
// A handle value of 0 is used to indicate an invalid or failed connection.
ConnectionHandle allocate_connection_resource_impl(const std::string& config) {
    static int next_id = 1; // Simple counter for unique handle IDs
    
    // Simulate failure based on a specific configuration string
    if (config == "fail_config") {
        std::cerr << "Simulating connection allocation failure due to config: '" << config << "'" << std::endl;
        return 0; // 0 indicates failure
    }
    
    // Simulate random failures for other configurations
    if (rand() % 5 == 0) { // 20% chance of random failure
        std::cerr << "Simulating random connection allocation failure for config: '" << config << "'" << std::endl;
        return 0; // 0 indicates failure
    }
    
    std::cout << "Allocating connection resource with config '" << config << "'. Handle: " << next_id << std::endl;
    return next_id++;
}

void release_connection_resource_impl(ConnectionHandle handle) {
    if (handle != 0) {
        std::cout << "Releasing connection resource with handle: " << handle << std::endl;
    }
}

class NetworkConnectionManager {
private:
    ConnectionHandle _connectionHandle;
    std::string _currentConfig; // Stores the configuration used for the current connection

    // Helper method to safely release the current network resource
    void _releaseCurrentResource() {
        if (_connectionHandle != 0) {
            release_connection_resource_impl(_connectionHandle);
            _connectionHandle = 0; // Mark as released/disconnected
        }
    }

    // Helper method to attempt allocating a new network resource
    // Returns true if allocation was successful, false otherwise.
    bool _tryAllocate(const std::string& config) {
        _connectionHandle = allocate_connection_resource_impl(config);
        if (_connectionHandle != 0) {
            _currentConfig = config; // Update config only on successful allocation
            return true;
        }
        _currentConfig = ""; // Clear config if allocation fails
        return false;
    }

public:
    // Constructor: Attempts to allocate connection resources upon object creation.
    // If the initial allocation fails, it throws a std::runtime_error,
    // ensuring the object is not left in an invalid state.
    explicit NetworkConnectionManager(const std::string& initialConfig = "default")
        : _connectionHandle(0), _currentConfig("") { // Initialize members to safe defaults
        std::cout << "NetworkConnectionManager constructor called for config: '" << initialConfig << "'" << std::endl;
        
        if (!_tryAllocate(initialConfig)) {
            // If initial allocation fails, the connection handle is 0,
            // and no partial resources need cleanup by the constructor itself.
            // Throw an exception to signal that construction failed.
            throw std::runtime_error("Failed to establish initial network connection with config: '" + initialConfig + "'");
        }
    }

    // Destructor: Ensures that any currently held network resources are properly released
    // when the NetworkConnectionManager object is destroyed. This adheres to RAII.
    ~NetworkConnectionManager() {
        std::cout << "NetworkConnectionManager destructor called." << std::endl;
        _releaseCurrentResource();
    }

    // Rule of Five: Handle copy and move operations for proper resource management.
    // Network connections are typically not trivially copyable, as a single resource
    // cannot be managed by multiple independent objects without complex reference counting.
    // For simplicity and to reflect common practice, copy operations are deleted.

    // Deleted Copy Constructor
    NetworkConnectionManager(const NetworkConnectionManager& other) = delete;

    // Deleted Copy Assignment Operator
    NetworkConnectionManager& operator=(const NetworkConnectionManager& other) = delete;

    // Move Constructor: Transfers ownership of the network resource from 'other' to 'this'.
    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept
        : _connectionHandle(0), _currentConfig("") { // Initialize members to a safe, empty state
        std::cout << "NetworkConnectionManager move constructor called." << std::endl;
        // Transfer resource and config from 'other'
        _connectionHandle = other._connectionHandle;
        _currentConfig = std::move(other._currentConfig);
        
        // Invalidate 'other' object so its destructor does not release the resource
        other._connectionHandle = 0;
        other._currentConfig = "";
    }

    // Move Assignment Operator: Transfers ownership of the network resource.
    // It first releases 'this' object's resources before taking ownership from 'other'.
    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        std::cout << "NetworkConnectionManager move assignment operator called." << std::endl;
        if (this != &other) { // Protect against self-assignment
            _releaseCurrentResource(); // Release our existing resource first
            
            // Transfer resource and config from 'other'
            _connectionHandle = other._connectionHandle;
            _currentConfig = std::move(other._currentConfig);
            
            // Invalidate 'other' object
            other._connectionHandle = 0;
            other._currentConfig = "";
        }
        return *this;
    }

    // Checks if the manager currently holds an active network connection.
    bool isConnected() const {
        return _connectionHandle != 0;
    }

    // Returns the internal connection handle.
    ConnectionHandle getConnectionHandle() const {
        return _connectionHandle;
    }

    // Resets the current connection. This involves releasing the existing resource
    // and attempting to acquire a new one using the *same* configuration.
    // If the new allocation fails, the object will be left in a disconnected state.
    void resetConnection() {
        std::cout << "Attempting to reset connection with config: '" << _currentConfig << "'" << std::endl;
        _releaseCurrentResource(); // Always release the old resource first

        // Attempt to re-allocate with the stored configuration
        if (!_tryAllocate(_currentConfig)) {
            std::cerr << "Failed to reset connection. Manager is now disconnected." << std::endl;
            // The connection handle is already 0, so cleanup is implicitly handled.
        } else {
            std::cout << "Connection successfully reset. New handle: " << _connectionHandle << std::endl;
        }
    }

    // Reinitializes the connection with a potentially *new* configuration.
    // The existing connection (if any) is released, and a new one is attempted.
    // If the new allocation fails, the object will be left in a disconnected state.
    void reinitializeConnection(const std::string& newConfig) {
        std::cout << "Attempting to reinitialize connection with new config: '" << newConfig << "'" << std::endl;
        _releaseCurrentResource(); // Always release the old resource first

        // Attempt to allocate with the new configuration
        if (!_tryAllocate(newConfig)) {
            std::cerr << "Failed to reinitialize connection with config: '" << newConfig << "'. Manager is now disconnected." << std::endl;
            // The connection handle is already 0.
        } else {
            std::cout << "Connection successfully reinitialized. New handle: " << _connectionHandle << std::endl;
        }
    }
};

// Example Usage (main function)
int main() {
    // Seed the random number generator for simulated failures
    srand(static_cast<unsigned int>(time(NULL)));

    std::cout << "--- Test 1: Successful initial connection, then reset and reinitialize ---" << std::endl;
    try {
        NetworkConnectionManager conn1("stable_config");
        if (conn1.isConnected()) {
            std::cout << "Conn1 status: Connected, Handle: " << conn1.getConnectionHandle() << std::endl;
        }

        conn1.resetConnection(); // Should try to reconnect with "stable_config"
        if (conn1.isConnected()) {
            std::cout << "Conn1 status after reset: Connected, Handle: " << conn1.getConnectionHandle() << std::endl;
        } else {
            std::cout << "Conn1 status after reset: Disconnected." << std::endl;
        }

        conn1.reinitializeConnection("new_data_source"); // Connect with a different config
        if (conn1.isConnected()) {
            std::cout << "Conn1 status after reinit: Connected, Handle: " << conn1.getConnectionHandle() << std::endl;
        } else {
            std::cout << "Conn1 status after reinit: Disconnected." << std::endl;
        }
    } catch (const std::runtime_error& e) {
        std::cerr << "Caught unexpected error in Test 1: " << e.what() << std::endl;
    }
    std::cout << std::endl;

    std::cout << "--- Test 2: Failed initial connection (constructor throws) ---" << std::endl;
    try {
        // This constructor call is expected to fail and throw an exception
        NetworkConnectionManager conn2("fail_config");
        if (conn2.isConnected()) {
            std::cout << "Conn2 status: Connected (THIS SHOULD NOT HAPPEN)" << std::endl;
        }
    } catch (const std::runtime_error& e) {
        std::cerr << "Caught expected error in Test 2: " << e.what() << std::endl;
    }
    std::cout << std::endl;

    std::cout << "--- Test 3: Connection established, then reinitialization fails ---" << std::endl;
    try {
        NetworkConnectionManager conn3("initial_config");
        if (conn3.isConnected()) {
            std::cout << "Conn3 status: Connected, Handle: " << conn3.getConnectionHandle() << std::endl;
        }

        conn3.reinitializeConnection("fail_config"); // Force reinitialization to fail
        if (!conn3.isConnected()) {
            std::cout << "Conn3 status after failed reinit: Disconnected (expected)." << std::endl;
        } else {
            std::cout << "Conn3 status after failed reinit: Connected (THIS SHOULD NOT HAPPEN)." << std::endl;
        }

        conn3.reinitializeConnection("recovery_config"); // Attempt to reconnect successfully
        if (conn3.isConnected()) {
            std::cout << "Conn3 status after recovery: Connected, Handle: " << conn3.getConnectionHandle() << std::endl;
        } else {
            std::cout << "Conn3 status after recovery: Disconnected." << std::endl;
        }
    } catch (const std::runtime_error& e) {
        std::cerr << "Caught unexpected error in Test 3: " << e.what() << std::endl;
    }
    std::cout << std::endl;

    std::cout << "--- Test 4: Demonstrating move semantics ---" << std::endl;
    try {
        NetworkConnectionManager original("move_source_config");
        std::cout << "Original manager initial handle: " << original.getConnectionHandle() << std::endl;

        NetworkConnectionManager moved_to = std::move(original); // Move constructor
        std::cout << "Moved-to manager handle: " << moved_to.getConnectionHandle() << std::endl;
        std::cout << "Original manager handle after move: " << original.getConnectionHandle() << " (should be 0)" << std::endl;

        NetworkConnectionManager another("another_config");
        std::cout << "Another manager initial handle: " << another.getConnectionHandle() << std::endl;
        
        another = std::move(moved_to); // Move assignment operator
        std::cout << "Another manager handle after move assignment: " << another.getConnectionHandle() << std::endl;
        std::cout << "Moved-to manager handle after move assignment: " << moved_to.getConnectionHandle() << " (should be 0)" << std::endl;
    } catch (const std::runtime_error& e) {
        std::cerr << "Caught unexpected error in Test 4: " << e.what() << std::endl;
    }
    std::cout << std::endl;

    std::cout << "--- End of main ---" << std::endl; // Destructors will be called here
    return 0;
}