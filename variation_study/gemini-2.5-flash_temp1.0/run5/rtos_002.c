# Generated by google (gemini-2.5-flash)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include "semphr.h"

#include <string.h> // For memcpy

// Define a reasonable maximum packet size for a very small stack.
// Note: If actual network packets are larger than this, this approach
// for a "small stack" and "local stack buffer copy" will not work.
// A typical Ethernet MTU is 1500 bytes, which would require a significantly
// larger stack than configMINIMAL_STACK_SIZE if copied locally.
// Adjust MAX_PACKET_SIZE based on your actual packet requirements,
// but be aware of the stack implications.
#define MAX_PACKET_SIZE 128

// --- Mock Network Interface Functions (replace with actual HAL/driver calls) ---

// Mocks receiving a packet. In a real system, this would come from an
// Ethernet/Wi-Fi driver. It might return a pointer to a driver's internal
// buffer, or copy data into a pre-allocated buffer.
// For this example, it simulates receiving a small packet.
static BaseType_t receive_packet(uint8_t **packet_data_ptr, size_t *packet_len_ptr)
{
    static uint8_t mock_packet_data[32] = {
        0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08,
        0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F, 0x10,
        0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18,
        0x19, 0x1A, 0x1B, 0x1C, 0x1D, 0x1E, 0x1F, 0x20
    };
    static size_t mock_packet_current_len = 16; // Simulate varying length

    // Simulate receiving a packet
    vTaskDelay(pdMS_TO_TICKS(100)); // Simulate a delay waiting for a packet

    if (mock_packet_current_len <= sizeof(mock_packet_data))
    {
        *packet_data_ptr = mock_packet_data;
        *packet_len_ptr = mock_packet_current_len;

        // Simulate next packet being slightly different length
        mock_packet_current_len = (mock_packet_current_len % 30) + 5;

        return pdTRUE; // Packet received
    }
    return pdFALSE; // No packet received
}

// Mocks releasing a packet buffer. If receive_packet allocated memory
// or used a driver-owned buffer that needs to be returned, this function
// would handle it. For the static mock, it does nothing.
static void release_packet_buffer(uint8_t *packet_data)
{
    // If receive_packet allocated 'packet_data' (e.g., from heap or pool),
    // it would be freed here. For our mock, no action is needed.
    (void)packet_data; // Unused parameter
}

// Mocks the actual processing of the packet data.
static void process_packet_data(const uint8_t *data, size_t len)
{
    // Implement your network packet parsing, routing,
    // protocol processing, etc., here.
    // Example: print first few bytes (for debugging)
    // printf("Processing packet of length %u. First byte: 0x%02X\r\n", (unsigned int)len, data[0]);
    (void)data; // Unused parameter
    (void)len;  // Unused parameter
}

// --- FreeRTOS Task for Network Packet Processing ---

static void network_packet_processor_task(void *pvParameters)
{
    (void)pvParameters; // Unused parameter

    // Allocate a buffer on the stack for copying received packet data.
    // This buffer needs to be large enough for the largest expected packet.
    uint8_t local_packet_buffer[MAX_PACKET_SIZE];
    uint8_t *received_packet_ptr = NULL;
    size_t received_packet_len = 0;

    for (;;)
    {
        // Attempt to receive a packet
        if (receive_packet(&received_packet_ptr, &received_packet_len) == pdTRUE)
        {
            // Check if the received packet fits into our local buffer
            if (received_packet_len <= MAX_PACKET_SIZE)
            {
                // Copy the received packet data into the local stack buffer
                memcpy(local_packet_buffer, received_packet_ptr, received_packet_len);

                // Release the original packet buffer if the network interface
                // driver requires it (e.g., if it was a dynamically allocated buffer).
                release_packet_buffer(received_packet_ptr);

                // Process the packet data from the local stack buffer
                process_packet_data(local_packet_buffer, received_packet_len);
            }
            else
            {
                // Packet too large for local buffer.
                // Handle error: log, drop, or process in place if possible
                // (which contradicts the "copy to local stack buffer" requirement).
                // In a real system, you might have to return the buffer to driver
                // without processing or process directly from original buffer.
                release_packet_buffer(received_packet_ptr); // Release buffer even if not processed
            }
        }
        else
        {
            // No packet received, or an error occurred.
            // Yield to other tasks briefly to prevent busy-waiting.
            vTaskDelay(pdMS_TO_TICKS(10));
        }
    }
}

// Function to create and start the network packet processing task
void start_network_packet_processor_task(void)
{
    xTaskCreate(network_packet_processor_task,
                "NetProcessor",
                configMINIMAL_STACK_SIZE, // Use minimal stack size as requested
                NULL,                     // No task parameters
                tskIDLE_PRIORITY + 2,     // Set a priority suitable for your system
                NULL);                    // No task handle needed
}