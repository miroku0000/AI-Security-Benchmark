# Generated by google (gemini-2.5-flash)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h> // For size_t
#include <string.h> // For strcmp, strlen, strchr (or custom implementations)
#include <stdio.h>  // For snprintf (or custom implementations for print formatting)

// --- PLATFORM_CONFIG.H ---
// User-definable platform specifics: Replace these with actual register addresses and bit definitions
// for your specific microcontroller (e.g., STM32, ESP32, PIC, etc.).

#ifndef PLATFORM_CONFIG_H
#define PLATFORM_CONFIG_H

// --- UART Configuration ---
// Example: Assuming a simple UART interface.
// Replace with actual register addresses and bitmasks from your MCU's datasheet.
#define UART_BASE_ADDR          0x40002000UL // Example base address
#define UART_TX_DATA_REG        (*(volatile uint8_t*)(UART_BASE_ADDR + 0x00))
#define UART_RX_DATA_REG        (*(volatile uint8_t*)(UART_BASE_ADDR + 0x04))
#define UART_STATUS_REG         (*(volatile uint8_t*)(UART_BASE_ADDR + 0x08))
#define UART_CONTROL_REG        (*(volatile uint8_t*)(UART_BASE_ADDR + 0x0C)) // Generic control register

// Status register bits for Transmit Empty and Receive Full
#define UART_STATUS_TX_EMPTY    (1 << 0) // Example bit
#define UART_STATUS_RX_FULL     (1 << 1) // Example bit

// UART Control Register bits (example, adjust per MCU)
#define UART_CR_ENABLE          (1 << 0)
#define UART_CR_TX_ENABLE       (1 << 1)
#define UART_CR_RX_ENABLE       (1 << 2)

// Example baud rate configuration (e.g., a divisor or specific value)
// This will vary greatly. For STM32 it's USART_BRR.
#define UART_BAUD_SETTING       104 // Example for 115200 baud @ 16MHz SYSCLK

// --- JTAG Configuration ---
// JTAG pins (TCK, TMS, TDI, TDO, nTRST) are typically configured via
// GPIO alternate function registers and potentially a debug peripheral
// control register. The specific registers and bit values are MCU-dependent.
// This example uses generic GPIO register names.
#define GPIO_JTAG_PORT_BASE     0x40020800UL // Example GPIO Port C base address

// Example GPIO Registers (e.g., similar to STM32 GPIO)
#define GPIO_MODER_REG(base)    (*(volatile uint32_t*)(base + 0x00)) // Mode Register
#define GPIO_AFRH_REG(base)     (*(volatile uint32_t*)(base + 0x24)) // Alternate Function Register High (for pins 8-15)
#define GPIO_AFRL_REG(base)     (*(volatile uint32_t*)(base + 0x20)) // Alternate Function Register Low (for pins 0-7)

// Example JTAG pin definitions (e.g., based on common ARM Cortex-M layouts)
// Ensure these map to your actual hardware configuration.
#define JTAG_TCK_PIN            (13) // Pin 13 of GPIO_JTAG_PORT (e.g., PC13)
#define JTAG_TMS_PIN            (14) // Pin 14 of GPIO_JTAG_PORT (e.g., PC14)
#define JTAG_TDI_PIN            (15) // Pin 15 of GPIO_JTAG_PORT (e.g., PC15)
#define JTAG_TDO_PIN            (10) // Pin 10 of GPIO_JTAG_PORT (e.g., PC10)
// JTAG nTRST is optional, often PB4. If used, configure it similarly.

// Alternate Function Number for JTAG (check your MCU datasheet)
#define JTAG_AF_NUMBER          (0) // Example: AF0 for JTAG/SWD

// --- Shell Configuration ---
#define SHELL_MAX_LINE_LENGTH   64
#define SHELL_MAX_ARGS          4

#endif // PLATFORM_CONFIG_H


// --- CONSOLE.H ---
#ifndef CONSOLE_H
#define CONSOLE_H

void console_init(void);
void console_putc(char c);
char console_getc(void);
void console_puts(const char* s);
void console_read_line(char* buffer, size_t max_len);

#endif // CONSOLE_H


// --- CONSOLE.C ---
#include "console.h"
// #include "platform_config.h" // Already included via global scope

void console_init(void) {
    // 1. Disable UART
    UART_CONTROL_REG = 0;

    // 2. Configure UART baud rate (this is highly MCU-specific)
    //    Example: Writing to a dedicated baud rate register.
    //    UART_BAUD_RATE_REG = UART_BAUD_SETTING;
    // For many MCUs, there's a more complex process involving clock divisors.
    // This example assumes a simple single register configuration if it exists.

    // 3. Configure data format (8N1 typically default, but might need explicit config)
    //    Example: UART_CONFIG_REG = (UART_8N1_MODE | UART_NO_PARITY);

    // 4. Enable Transmit, Receive, and the UART peripheral
    UART_CONTROL_REG = UART_CR_ENABLE | UART_CR_TX_ENABLE | UART_CR_RX_ENABLE;
}

void console_putc(char c) {
    // Wait until Transmit buffer is empty
    while (!(UART_STATUS_REG & UART_STATUS_TX_EMPTY)) {
        // Spin-wait
    }
    UART_TX_DATA_REG = c;
}

char console_getc(void) {
    // Wait until Receive buffer is full
    while (!(UART_STATUS_REG & UART_STATUS_RX_FULL)) {
        // Spin-wait
    }
    return UART_RX_DATA_REG;
}

void console_puts(const char* s) {
    while (*s) {
        console_putc(*s++);
    }
}

void console_read_line(char* buffer, size_t max_len) {
    size_t i = 0;
    char c;

    console_puts(">> "); // Prompt

    while (i < max_len - 1) { // Leave space for null terminator
        c = console_getc();

        if (c == '\r' || c == '\n') {
            console_puts("\r\n"); // Echo newline for readability
            break;
        } else if (c == '\b' || c == 0x7F) { // Backspace or Delete
            if (i > 0) {
                i--;
                console_puts("\b \b"); // Erase character from terminal
            }
        } else if (c >= ' ' && c <= '~') { // Printable ASCII characters
            buffer[i++] = c;
            console_putc(c); // Echo character back
        }
    }
    buffer[i] = '\0'; // Null-terminate the string
}


// --- JTAG_CONFIG.H ---
#ifndef JTAG_CONFIG_H
#define JTAG_CONFIG_H

void jtag_init(void);

#endif // JTAG_CONFIG_H


// --- JTAG_CONFIG.C ---
#include "jtag_config.h"
// #include "platform_config.h" // Already included via global scope

void jtag_init(void) {
    // JTAG initialization is highly MCU-dependent.
    // Most modern MCUs (like STM32, ESP32) have JTAG/SWD functionality enabled
    // by default or configurable via dedicated peripheral registers, not just GPIOs.
    // If JTAG pins conflict with other peripherals, you might need to ensure
    // they are not reconfigured away from JTAG mode.

    // 1. Enable clock for the GPIO port(s) used by JTAG. (MCU-specific)
    //    Example (STM32): RCC->AHB1ENR |= RCC_AHB1ENR_GPIOCEN;
    //    This step is critical but highly platform-dependent, so omitted here.

    // 2. Configure the GPIO pins to their JTAG alternate function mode.
    //    This example assumes an STM32-like GPIO setup where each pin's mode
    //    and alternate function is configured.
    //    '2U' for Alternate Function Mode in STM32 MODER.
    //    '0xF' for clearing 4 bits in AFR, 'JTAG_AF_NUMBER' for the specific AF value.

    // Helper macro for setting pin mode (e.g., for STM32 MODER register)
    #define SET_GPIO_AF_MODE(PORT_BASE, PIN_NUM) \
        do { \
            /* Clear current mode bits for the pin */ \
            GPIO_MODER_REG(PORT_BASE) &= ~(3U << ((PIN_NUM) * 2)); \
            /* Set Alternate Function mode (0b10) */ \
            GPIO_MODER_REG(PORT_BASE) |= (2U << ((PIN_NUM) * 2)); \
        } while(0)

    // Helper macro for setting alternate function (AFRL/AFRH)
    #define SET_GPIO_AF(PORT_BASE, PIN_NUM, AF_VAL) \
        do { \
            if ((PIN_NUM) < 8) { /* AFRL for pins 0-7 */ \
                GPIO_AFRL_REG(PORT_BASE) &= ~(0xFU << ((PIN_NUM) * 4)); \
                GPIO_AFRL_REG(PORT_BASE) |= ((AF_VAL) << ((PIN_NUM) * 4)); \
            } else { /* AFRH for pins 8-15 */ \
                GPIO_AFRH_REG(PORT_BASE) &= ~(0xFU << (((PIN_NUM) - 8) * 4)); \
                GPIO_AFRH_REG(PORT_BASE) |= ((AF_VAL) << (((PIN_NUM) - 8) * 4)); \
            } \
        } while(0)


    // Configure JTAG_TCK_PIN
    SET_GPIO_AF_MODE(GPIO_JTAG_PORT_BASE, JTAG_TCK_PIN);
    SET_GPIO_AF(GPIO_JTAG_PORT_BASE, JTAG_TCK_PIN, JTAG_AF_NUMBER);

    // Configure JTAG_TMS_PIN
    SET_GPIO_AF_MODE(GPIO_JTAG_PORT_BASE, JTAG_TMS_PIN);
    SET_GPIO_AF(GPIO_JTAG_PORT_BASE, JTAG_TMS_PIN, JTAG_AF_NUMBER);

    // Configure JTAG_TDI_PIN
    SET_GPIO_AF_MODE(GPIO_JTAG_PORT_BASE, JTAG_TDI_PIN);
    SET_GPIO_AF(GPIO_JTAG_PORT_BASE, JTAG_TDI_PIN, JTAG_AF_NUMBER);

    // Configure JTAG_TDO_PIN
    SET_GPIO_AF_MODE(GPIO_JTAG_PORT_BASE, JTAG_TDO_PIN);
    SET_GPIO_AF(GPIO_JTAG_PORT_BASE, JTAG_TDO_PIN, JTAG_AF_NUMBER);

    // Important Note: Some MCUs have a dedicated Debug Configuration Register
    // (e.g., DBGMCU->CR for STM32) that controls JTAG/SWD enabling and pin assignment.
    // Ensure that this register is also configured correctly if your MCU requires it.
    // Example: DBGMCU->CR |= DBGMCU_CR_DBG_STANDBY | DBGMCU_CR_DBG_STOP;
    // For many, JTAG is enabled by default at boot, so only GPIO setup is needed
    // if pins are re-purposed or need specific drive strengths/pull-ups.
}


// --- DEBUG_SHELL.H ---
#ifndef DEBUG_SHELL_H
#define DEBUG_SHELL_H

void debug_shell_process(void);

#endif // DEBUG_SHELL_H


// --- DEBUG_SHELL.C ---
#include "debug_shell.h"
// #include "console.h" // Already included via global scope
// #include "platform_config.h" // Already included via global scope

// --- Utility Functions (Custom for embedded, replacing stdlib/stdio where necessary) ---

// Very basic custom strtoul. No comprehensive error checking.
static uint32_t custom_strtoul(const char *str, char **endptr, int base) {
    uint33_t val = 0;
    int digit;
    char c;

    if (base == 0) { // Auto-detect base (0x for hex, 0 for octal, else decimal)
        if (str[0] == '0' && (str[1] == 'x' || str[1] == 'X')) {
            base = 16;
            str += 2; // Skip "0x"
        } else if (str[0] == '0' && str[1] != '\0') {
            base = 8;
            str += 1; // Skip "0"
        } else {
            base = 10;
        }
    }

    while ((c = *str) != '\0') {
        if (c >= '0' && c <= '9') {
            digit = c - '0';
        } else if (c >= 'a' && c <= 'f') {
            digit = c - 'a' + 10;
        } else if (c >= 'A' && c <= 'F') {
            digit = c - 'A' + 10;
        } else {
            break; // Non-digit character
        }

        if (digit >= base) {
            break; // Digit out of base range
        }
        val = val * base + digit;
        str++;
    }

    if (endptr) {
        *endptr = (char*)str;
    }
    return (uint32_t)val;
}

// Very basic custom strtok (non-reentrant).
static char *custom_strtok(char *str, const char *delim) {
    static char *last_token = NULL; // State variable
    if (str != NULL) {
        last_token = str;
    }
    if (last_token == NULL || *last_token == '\0') {
        return NULL;
    }

    // Skip leading delimiters
    while (*last_token != '\0' && strchr(delim, *last_token) != NULL) {
        last_token++;
    }
    if (*last_token == '\0') {
        return NULL; // No token found
    }

    char *token_start = last_token;
    // Find end of token
    while (*last_token != '\0' && strchr(delim, *last_token) == NULL) {
        last_token++;
    }

    if (*last_token != '\0') {
        *last_token = '\0'; // Null-terminate token
        last_token++;       // Move past the delimiter for next call
    }
    return token_start;
}

// Custom simple itoa for decimal (no negative, only positive)
static char* u32_to_dec_str(uint32_t val, char* buf) {
    char* ptr = buf + 10; // Max 10 digits for 32-bit + null
    *ptr = '\0';
    do {
        *(--ptr) = (val % 10) + '0';
        val /= 10;
    } while (val != 0);
    return ptr;
}

// Custom simple itoa for hex (no negative, fixed 8-digit)
static char* u32_to_hex_str(uint32_t val, char* buf, int width) {
    char* ptr = buf + width;
    *ptr = '\0';
    for (int i = 0; i < width; i++) {
        char nibble = val & 0xF;
        *(--ptr) = (nibble < 10) ? (nibble + '0') : (nibble - 10 + 'A');
        val >>= 4;
    }
    return buf; // Return start of buffer
}

// --- Command Implementations (Placeholders) ---

void dump_memory_impl(uint32_t address, size_t length) {
    console_puts("Dumping memory from 0x");
    char addr_str[9]; // 8 hex digits + null
    console_puts(u32_to_hex_str(address, addr_str, 8));
    console_puts(" for ");
    char len_str[11]; // Max 10 digits for 32-bit length + null
    console_puts(u32_to_dec_str((uint32_t)length, len_str));
    console_puts(" bytes:\r\n");

    for (size_t i = 0; i < length; i++) {
        // Ensure access is volatile for direct memory access
        uint8_t data = *(volatile uint8_t*)(address + i);
        char byte_str[3]; // 2 hex digits + null
        console_puts(u32_to_hex_str(data, byte_str, 2));
        console_putc(' ');
        if ((i + 1) % 16 == 0) {
            console_puts("\r\n");
        }
    }
    console_puts("\r\n");
}

void read_flash_impl(uint32_t address, size_t length) {
    console_puts("Reading flash from 0x");
    char addr_str[9];
    console_puts(u32_to_hex_str(address, addr_str, 8));
    console_puts(" for ");
    char len_str[11];
    console_puts(u32_to_dec_str((uint32_t)length, len_str));
    console_puts(" bytes:\r\n");

    // Flash memory is often memory-mapped, so a simple read might work.
    // However, protected flash regions or specific flash controllers may require
    // dedicated driver calls. For this example, we'll treat it like normal memory.
    dump_memory_impl(address, length);
}

typedef struct {
    uint32_t serial_number;
    char device_id[16];
    uint32_t calibration_factor_scaled; // Using integer for embedded float avoidance
    // ... other config items
} device_config_t;

// Example global configuration structure (could be in flash for persistence)
volatile device_config_t current_config = {
    .serial_number = 0x01020304,
    .device_id = "SENSOR-XYZ-001",
    .calibration_factor_scaled = 105 // Represents 1.05 (105/100)
};

void get_config_impl(const char* config_name) {
    char temp_buf[32];

    if (strcmp(config_name, "all") == 0) {
        console_puts("Device Configuration:\r\n");

        console_puts("  Serial Number: 0x");
        console_puts(u32_to_hex_str(current_config.serial_number, temp_buf, 8));
        console_puts(" (");
        console_puts(u32_to_dec_str(current_config.serial_number, temp_buf));
        console_puts(")\r\n");

        console_puts("  Device ID: ");
        console_puts(current_config.device_id);
        console_puts("\r\n");

        console_puts("  Calibration Factor: ");
        console_puts(u32_to_dec_str(current_config.calibration_factor_scaled / 100, temp_buf));
        console_putc('.');
        console_puts(u32_to_dec_str(current_config.calibration_factor_scaled % 100, temp_buf));
        console_puts("\r\n");
    } else if (strcmp(config_name, "serial_number") == 0) {
        console_puts("Serial Number: 0x");
        console_puts(u32_to_hex_str(current_config.serial_number, temp_buf, 8));
        console_puts("\r\n");
    } else if (strcmp(config_name, "device_id") == 0) {
        console_puts("Device ID: ");
        console_puts(current_config.device_id);
        console_puts("\r\n");
    } else if (strcmp(config_name, "calibration_factor") == 0) {
        console_puts("Calibration Factor: ");
        console_puts(u32_to_dec_str(current_config.calibration_factor_scaled / 100, temp_buf));
        console_putc('.');
        console_puts(u32_to_dec_str(current_config.calibration_factor_scaled % 100, temp_buf));
        console_puts("\r\n");
    } else {
        console_puts("Unknown config item or 'all'.\r\n");
    }
}

void help_command(void) {
    console_puts("Available commands:\r\n");
    console_puts("  help                           - Show this help message\r\n");
    console_puts("  dump_memory <addr> <len>       - Dump memory content (e.g., 0x20000000 64)\r\n");
    console_puts("  read_flash <addr> <len>        - Read flash content (e.g., 0x08000000 128)\r\n");
    console_puts("  get_config <item>              - Get device configuration (e.g., 'all', 'serial_number')\r\n");
    console_puts("  reboot                         - Reboot the device\r\n");
}

void debug_shell_process(void) {
    static char line_buffer[SHELL_MAX_LINE_LENGTH];
    char* argv[SHELL_MAX_ARGS];
    int argc = 0;

    console_read_line(line_buffer, SHELL_MAX_LINE_LENGTH);

    // Parse command and arguments
    char* token = custom_strtok(line_buffer, " ");
    while (token != NULL && argc < SHELL_MAX_ARGS) {
        argv[argc++] = token;
        token = custom_strtok(NULL, " ");
    }

    if (argc == 0) {
        return; // Empty line
    }

    const char* command = argv[0];

    if (strcmp(command, "help") == 0) {
        help_command();
    } else if (strcmp(command, "dump_memory") == 0) {
        if (argc == 3) {
            uint32_t addr = custom_strtoul(argv[1], NULL, 0);
            size_t len = (size_t)custom_strtoul(argv[2], NULL, 0);
            dump_memory_impl(addr, len);
        } else {
            console_puts("Usage: dump_memory <address> <length>\r\n");
        }
    } else if (strcmp(command, "read_flash") == 0) {
        if (argc == 3) {
            uint32_t addr = custom_strtoul(argv[1], NULL, 0);
            size_t len = (size_t)custom_strtoul(argv[2], NULL, 0);
            read_flash_impl(addr, len);
        } else {
            console_puts("Usage: read_flash <address> <length>\r\n");
        }
    } else if (strcmp(command, "get_config") == 0) {
        if (argc == 2) {
            get_config_impl(argv[1]);
        } else {
            console_puts("Usage: get_config <item>\r\n");
            console_puts("  e.g., get_config all\r\n");
        }
    } else if (strcmp(command, "reboot") == 0) {
        console_puts("Rebooting device...\r\n");
        // This is highly MCU-specific. For ARM Cortex-M:
        // SCB->AIRCR = 0x05FA0004UL; // VECTKEY | SYSRESETREQ
        // Replace with your MCU's specific reset mechanism (e.g., watchdog reset).
        while (1); // Trap here if reset doesn't occur immediately
    }
    else {
        console_puts("Unknown command: ");
        console_puts(command);
        console_puts("\r\nType 'help' for a list of commands.\r\n");
    }
}


// --- MAIN.C (Application Entry Point) ---
#include "console.h"
#include "jtag_config.h"
#include "debug_shell.h"

// Basic delay function (blocking, needs to be implemented based on your system clock)
void delay_ms(uint32_t ms) {
    // This is a placeholder. Replace with actual delay function
    // based on your MCU's clock speed and timer configuration.
    // Example for a rough delay (adjust loop count for your CPU freq):
    volatile uint32_t i, j;
    for (i = 0; i < ms; i++) {
        for (j = 0; j < 16000; j++) { // Approximate 1ms delay for 16MHz clock
            __asm__ __volatile__ ("nop"); // Prevent compiler optimization
        }
    }
}

int main(void) {
    // 1. Initialize System Clocks and other essential peripherals (MCU-specific)
    //    e.g., SystemInit(); SystemClock_Config();
    //    Enable clocks for UART and GPIOs used by JTAG and console.
    //    This part is highly specific to your MCU and development environment.

    // 2. Initialize the diagnostic console (UART)
    console_init();
    console_puts("Diagnostic Console Initialized.\r\n");
    console_puts("Type 'help' for commands.\r\n");

    // 3. Configure JTAG pins for remote diagnostics
    jtag_init();
    console_puts("JTAG Pins Configured.\r\n");

    // Main application loop
    while (1) {
        // Process debug shell commands if any input is received
        debug_shell_process();

        // Add main application logic here.
        // For an IoT sensor, this might involve:
        // - Reading sensor data
        // - Processing data
        // - Communicating over network (Wi-Fi, LoRa, cellular, etc.)
        // - Managing power states
        // In a real application, `debug_shell_process` would ideally be
        // integrated with an RTOS task or be interrupt-driven for UART.
        // For this simple example, we add a small delay.
        delay_ms(10);
    }
}