# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility> // Required for std::move and std::forward

template <typename T>
class UniqueResource {
private:
    T* resourcePtr;

public:
    // Default constructor: owns nothing
    UniqueResource() : resourcePtr(nullptr) {}

    // Constructor with an existing resource pointer
    // Takes ownership of the provided pointer.
    explicit UniqueResource(T* ptr) : resourcePtr(ptr) {}

    // Destructor: cleans up the owned resource
    // Avoids raw delete if T is an array or specific deleter is needed.
    // For simplicity, assuming 'T' is a single object and 'delete' is appropriate.
    ~UniqueResource() {
        if (resourcePtr != nullptr) {
            delete resourcePtr;
            resourcePtr = nullptr; // Defensive programming
        }
    }

    // Delete copy constructor and copy assignment operator
    // UniqueResource is non-copyable to enforce unique ownership.
    UniqueResource(const UniqueResource&) = delete;
    UniqueResource& operator=(const UniqueResource&) = delete;

    // Move constructor
    // Transfers ownership from 'other' to 'this'.
    UniqueResource(UniqueResource&& other) noexcept : resourcePtr(other.resourcePtr) {
        other.resourcePtr = nullptr; // 'other' no longer owns the resource
    }

    // Move assignment operator
    // Transfers ownership from 'other' to 'this', cleaning up 'this' current resource first.
    UniqueResource& operator=(UniqueResource&& other) noexcept {
        if (this != &other) { // Handle self-assignment
            // Clean up current resource first
            if (resourcePtr != nullptr) {
                delete resourcePtr;
            }

            // Transfer ownership
            resourcePtr = other.resourcePtr;
            other.resourcePtr = nullptr; // 'other' no longer owns the resource
        }
        return *this;
    }

    // Dereference operator (const and non-const)
    // Allows accessing the underlying resource.
    T& operator*() const {
        return *resourcePtr;
    }

    // Arrow operator (const and non-const)
    // Allows accessing members of the underlying resource.
    T* operator->() const {
        return resourcePtr;
    }

    // Get the raw pointer (non-const)
    // Allows obtaining the raw pointer. Use with caution.
    T* get() const {
        return resourcePtr;
    }

    // Release ownership
    // Returns the raw pointer and gives up ownership.
    // The caller is responsible for deleting the returned pointer.
    T* release() {
        T* temp = resourcePtr;
        resourcePtr = nullptr;
        return temp;
    }

    // Reset current resource and optionally take ownership of a new one.
    // If a new pointer is provided, it replaces the old resource.
    void reset(T* newPtr = nullptr) {
        if (resourcePtr != nullptr) {
            delete resourcePtr;
        }
        resourcePtr = newPtr;
    }

    // Explicit bool conversion for checking if it owns a resource.
    explicit operator bool() const {
        return resourcePtr != nullptr;
    }

    // Swap function
    void swap(UniqueResource& other) noexcept {
        std::swap(resourcePtr, other.resourcePtr);
    }
};

// Global swap function for ADL
template <typename T>
void swap(UniqueResource<T>& lhs, UniqueResource<T>& rhs) noexcept {
    lhs.swap(rhs);
}