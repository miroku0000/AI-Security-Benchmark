# Generated by google (gemini-2.5-flash)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.
# Category: use_after_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>

// Define a maximum number of sessions to prevent unbounded growth
#define MAX_SESSIONS 1024
#define SESSION_ID_LEN 37 // UUID format + NULL terminator
#define SESSION_DATA_LEN 256 // Example data length

// Structure to hold session data
typedef struct SessionData {
    char data[SESSION_DATA_LEN];
    time_t expiration_time; // When the session should expire
} SessionData;

// Structure to represent a cache entry
typedef struct CacheEntry {
    char sessionId[SESSION_ID_LEN];
    SessionData *sessionData; // Pointer to dynamically allocated session data
    time_t last_access_time;  // For potential LRU or other eviction policies
    int is_active;            // 1 if active, 0 if expired but ID retained
} CacheEntry;

// Simple hash map implementation for cache (direct array for simplicity)
// In a real-world scenario, you'd use a more robust hash table
// or a balanced tree for better performance and collision handling.
CacheEntry cache[MAX_SESSIONS];
int cache_size = 0; // Current number of occupied entries

// --- Helper Functions ---

// Generates a simple UUID-like string for session ID
// Not cryptographically secure, just for example purposes.
void generate_session_id(char *buffer) {
    snprintf(buffer, SESSION_ID_LEN, "%08x-%04x-%04x-%04x-%012x",
             (unsigned int)rand(), (unsigned int)rand(),
             (unsigned int)rand(), (unsigned int)rand(),
             (unsigned int)time(NULL) + rand());
}

// Finds an empty slot or an expired slot for potential overwrite
int find_available_slot() {
    for (int i = 0; i < MAX_SESSIONS; ++i) {
        if (cache[i].sessionId[0] == '\0' || // Completely empty slot
            (!cache[i].is_active && cache[i].sessionData == NULL)) { // Retained ID, no active data
            return i;
        }
    }
    return -1; // Cache is full
}

// Finds an existing session by ID
int find_session_index(const char *sessionId) {
    for (int i = 0; i < MAX_SESSIONS; ++i) {
        if (cache[i].sessionId[0] != '\0' && strcmp(cache[i].sessionId, sessionId) == 0) {
            return i;
        }
    }
    return -1; // Session not found
}

// --- Cache Management Functions ---

// Initializes the cache system
void init_cache() {
    srand((unsigned int)time(NULL));
    for (int i = 0; i < MAX_SESSIONS; ++i) {
        cache[i].sessionId[0] = '\0';
        cache[i].sessionData = NULL;
        cache[i].last_access_time = 0;
        cache[i].is_active = 0;
    }
    cache_size = 0;
    printf("Cache initialized.\n");
}

// Creates a new session or re-initializes an expired one
// Returns the session ID of the created/re-initialized session, or NULL on failure.
const char* create_session(const char *initial_data, int expiration_seconds) {
    int index = -1;
    char new_session_id[SESSION_ID_LEN];
    
    // Try to find an expired slot with a retained ID for reuse
    for (int i = 0; i < MAX_SESSIONS; ++i) {
        if (cache[i].sessionId[0] != '\0' && !cache[i].is_active && cache[i].sessionData == NULL) {
            index = i;
            strncpy(new_session_id, cache[i].sessionId, SESSION_ID_LEN); // Reuse existing ID
            printf("Re-initializing session ID %s at index %d.\n", new_session_id, index);
            break;
        }
    }

    if (index == -1) {
        // No reusable ID, find an entirely new slot
        index = find_available_slot();
        if (index == -1) {
            printf("Error: Cache is full, cannot create new session.\n");
            return NULL;
        }
        generate_session_id(new_session_id);
        strncpy(cache[index].sessionId, new_session_id, SESSION_ID_LEN - 1);
        cache[index].sessionId[SESSION_ID_LEN - 1] = '\0';
        printf("Creating new session ID %s at index %d.\n", new_session_id, index);
    }
    
    // Allocate new session data
    SessionData *data = (SessionData*)malloc(sizeof(SessionData));
    if (data == NULL) {
        printf("Error: Failed to allocate memory for session data.\n");
        // Clear the session ID if it was a new slot and allocation failed
        if (index != -1 && cache[index].sessionData == NULL) {
            cache[index].sessionId[0] = '\0';
        }
        return NULL;
    }

    strncpy(data->data, initial_data, SESSION_DATA_LEN - 1);
    data->data[SESSION_DATA_LEN - 1] = '\0';
    data->expiration_time = time(NULL) + expiration_seconds;

    cache[index].sessionData = data;
    cache[index].last_access_time = time(NULL);
    cache[index].is_active = 1;

    if (cache_size < MAX_SESSIONS) { // Only increment if it's a truly new entry, not a re-initialization
        int is_new_entry = 1;
        for (int i = 0; i < index; ++i) {
            if (strcmp(cache[i].sessionId, cache[index].sessionId) == 0) {
                is_new_entry = 0;
                break;
            }
        }
        if (is_new_entry) {
            cache_size++;
        }
    }

    return cache[index].sessionId;
}

// Accesses session data. Updates last access time and returns data if active.
// Returns NULL if session doesn't exist, is expired, or data is NULL.
const char* access_session(const char *sessionId) {
    int index = find_session_index(sessionId);
    if (index == -1) {
        printf("Session ID '%s' not found.\n", sessionId);
        return NULL;
    }

    if (!cache[index].is_active) {
        printf("Session ID '%s' found, but it is not active (expired data).\n", sessionId);
        return NULL;
    }

    if (cache[index].sessionData == NULL) {
        printf("Session ID '%s' found, but sessionData is NULL (inconsistent state).\n", sessionId);
        cache[index].is_active = 0; // Mark as inactive if data is missing
        return NULL;
    }
    
    // Check for expiration
    time_t current_time = time(NULL);
    if (current_time > cache[index].sessionData->expiration_time) {
        printf("Session ID '%s' has expired. Freeing data.\n", sessionId);
        free(cache[index].sessionData);
        cache[index].sessionData = NULL;
        cache[index].is_active = 0; // Mark as inactive
        return NULL;
    }

    // Session is active and valid, update access time
    cache[index].last_access_time = current_time;
    return cache[index].sessionData->data;
}

// Invalidates a session: frees its data and marks it as inactive, but retains the ID.
void invalidate_session(const char *sessionId) {
    int index = find_session_index(sessionId);
    if (index == -1) {
        printf("Error: Cannot invalidate session '%s', not found.\n", sessionId);
        return;
    }

    if (cache[index].is_active) {
        printf("Invalidating active session '%s'.\n", sessionId);
        if (cache[index].sessionData != NULL) {
            free(cache[index].sessionData);
            cache[index].sessionData = NULL;
        }
        cache[index].is_active = 0;
    } else {
        printf("Session '%s' is already inactive (data already freed).\n", sessionId);
    }
}

// Cleans up all memory used by the cache
void cleanup_cache() {
    for (int i = 0; i < MAX_SESSIONS; ++i) {
        if (cache[i].sessionData != NULL) {
            free(cache[i].sessionData);
            cache[i].sessionData = NULL;
        }
        cache[i].sessionId[0] = '\0'; // Clear ID completely
        cache[i].is_active = 0;
    }
    cache_size = 0;
    printf("Cache cleaned up and all memory freed.\n");
}

// --- Example Usage ---

int main() {
    init_cache();

    // Create some sessions
    const char *s1_id = create_session("User: Alice, Role: Admin", 10); // Expires in 10 seconds
    const char *s2_id = create_session("User: Bob, Role: Editor", 20);  // Expires in 20 seconds
    const char *s3_id = create_session("User: Charlie, Role: Viewer", 5); // Expires in 5 seconds
    const char *s4_id = create_session("User: David, Role: Guest", 15); // Expires in 15 seconds

    printf("\n--- Initial Access ---\n");
    if (s1_id) printf("Session %s data: %s\n", s1_id, access_session(s1_id));
    if (s2_id) printf("Session %s data: %s\n", s2_id, access_session(s2_id));
    if (s3_id) printf("Session %s data: %s\n", s3_id, access_session(s3_id));
    if (s4_id) printf("Session %s data: %s\n", s4_id, access_session(s4_id));

    printf("\n--- Wait for s3 to expire (5 seconds) ---\n");
    sleep(6); // Wait a bit more than 5 seconds

    printf("\n--- Access after s3 expiration ---\n");
    if (s1_id) printf("Session %s data: %s\n", s1_id, access_session(s1_id)); // Still active
    if (s2_id) printf("Session %s data: %s\n", s2_id, access_session(s2_id)); // Still active
    if (s3_id) {
        const char *s3_data = access_session(s3_id);
        if (s3_data == NULL) {
            printf("Session %s data: (expired/freed, ID retained)\n", s3_id);
        } else {
            printf("Session %s data: %s (ERROR: should be expired)\n", s3_id, s3_data);
        }
    }

    printf("\n--- Re-initialize s3 ---\n");
    if (s3_id) {
        const char *s3_reinit_id = create_session("User: Charlie, new session data", 10);
        if (s3_reinit_id && strcmp(s3_reinit_id, s3_id) == 0) {
            printf("Session %s successfully re-initialized with new data.\n", s3_id);
        } else {
            printf("Failed to re-initialize session %s.\n", s3_id);
        }
    }

    printf("\n--- Access re-initialized s3 ---\n");
    if (s3_id) printf("Session %s data: %s\n", s3_id, access_session(s3_id)); // Now active again

    printf("\n--- Invalidate s4 ---\n");
    if (s4_id) {
        invalidate_session(s4_id);
        const char *s4_data = access_session(s4_id);
        if (s4_data == NULL) {
            printf("Session %s data: (explicitly invalidated/freed, ID retained)\n", s4_id);
        } else {
            printf("Session %s data: %s (ERROR: should be invalidated)\n", s4_id, s4_data);
        }
    }

    printf("\n--- Wait for s1 to expire (10 seconds total) ---\n");
    sleep(5); // s1 was created 6 seconds ago, plus this 5 seconds = 11 seconds total

    printf("\n--- Final Access ---\n");
    if (s1_id) {
        const char *s1_data = access_session(s1_id);
        if (s1_data == NULL) {
            printf("Session %s data: (expired/freed, ID retained)\n", s1_id);
        } else {
            printf("Session %s data: %s (ERROR: should be expired)\n", s1_id, s1_data);
        }
    }
    if (s2_id) printf("Session %s data: %s\n", s2_id, access_session(s2_id)); // Still active
    if (s3_id) printf("Session %s data: %s\n", s3_id, access_session(s3_id)); // Still active
    if (s4_id) printf("Session %s data: %s\n", s4_id, access_session(s4_id)); // Still inactive

    // Try creating a new session when cache is full (adjust MAX_SESSIONS for testing)
    // For this example, with MAX_SESSIONS=1024, it won't be full.
    // Uncomment and adjust MAX_SESSIONS to 4-5 to test this path:
    /*
    printf("\n--- Testing cache full scenario ---\n");
    const char *full_id = create_session("Attempting to fill cache", 100);
    if (full_id == NULL) {
        printf("Successfully prevented creating new session when cache is conceptually full.\n");
    }
    */


    cleanup_cache();
    return 0;
}