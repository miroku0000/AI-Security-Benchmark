# Generated by google (gemini-2.5-flash)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h> // For close, read (example for dummy socket)

// Define a maximum request size. This helps in pre-allocating memory and
// preventing buffer overflows for typical HTTP requests.
#define MAX_REQUEST_SIZE 4096

// Simulate a socket descriptor. In a real application, this would be
// an actual file descriptor from accept().
typedef int SocketDescriptor;

// Function to simulate reading data from a socket.
// In a real scenario, this would be read(socket_fd, buffer, size).
// For this example, we'll just copy a dummy request.
ssize_t read_from_socket(SocketDescriptor fd, char *buffer, size_t count) {
    (void)fd; // Unused parameter for this simulation
    static int call_count = 0; // Simulate different requests
    const char *dummy_request1 = "GET /index.html HTTP/1.1\r\nHost: example.com\r\nUser-Agent: C-Web-Server/1.0\r\nAccept: */*\r\n\r\n";
    const char *dummy_request2 = "POST /api/data HTTP/1.1\r\nHost: example.com\r\nContent-Type: application/json\r\nContent-Length: 18\r\n\r\n{\"key\":\"value\"}\r\n";
    const char *dummy_request3 = "GET /about HTTP/1.1\r\nHost: example.com\r\n\r\n";

    const char *current_request = NULL;
    size_t request_len = 0;

    switch (call_count % 3) {
        case 0:
            current_request = dummy_request1;
            break;
        case 1:
            current_request = dummy_request2;
            break;
        case 2:
            current_request = dummy_request3;
            break;
    }
    call_count++;

    request_len = strlen(current_request);

    if (request_len > count) {
        request_len = count; // Prevent buffer overflow if dummy request is too large
    }

    memcpy(buffer, current_request, request_len);
    return request_len;
}

// Function to process a single HTTP request.
// In a real server, this would parse headers, handle routing,
// generate a response, and send it back.
void process_http_request(char *request_buffer, ssize_t request_len) {
    // Null-terminate the buffer for string operations, but be careful
    // not to overwrite past request_len if it exactly fills the buffer.
    if (request_len < MAX_REQUEST_SIZE) {
        request_buffer[request_len] = '\0';
    } else {
        request_buffer[MAX_REQUEST_SIZE - 1] = '\0'; // Ensure termination for truncated requests
    }

    printf("--- Processing Request (%zd bytes) ---\n", request_len);
    printf("%s\n", request_buffer);

    // Example: Basic parsing to find the HTTP method and path
    char method[16];
    char path[256];
    if (sscanf(request_buffer, "%15s %255s", method, path) == 2) {
        printf("Method: %s, Path: %s\n", method, path);
    } else {
        printf("Could not parse method and path.\n");
    }

    // In a real server, you'd do much more here:
    // 1. Parse all headers
    // 2. Handle different HTTP methods (GET, POST, PUT, DELETE)
    // 3. Serve static files or call API handlers
    // 4. Construct and send an HTTP response
    // (e.g., send_response(socket_fd, "HTTP/1.1 200 OK\r\nContent-Length: ...\r\n\r\nHello!");)
    printf("--------------------------------------\n\n");
}

int main() {
    // Allocate a fixed-size buffer on the heap once for performance.
    // This avoids repeated malloc/free calls inside the loop.
    char *request_buffer = (char *)malloc(MAX_REQUEST_SIZE);
    if (request_buffer == NULL) {
        perror("Failed to allocate request buffer");
        return EXIT_FAILURE;
    }

    printf("Embedded Web Server started. Waiting for requests...\n");

    // Main request processing loop
    while (1) {
        // Simulate waiting for a new connection (e.g., from accept()).
        // In a real server, this would block until a client connects.
        // For this example, we'll just simulate a dummy socket.
        SocketDescriptor client_socket_fd = 1; // Dummy descriptor

        // In a real server:
        // SocketDescriptor client_socket_fd = accept(listen_socket_fd, ...);
        // if (client_socket_fd < 0) {
        //     perror("accept failed");
        //     continue; // Or handle error appropriately
        // }

        printf("New connection simulated (socket %d).\n", client_socket_fd);

        // Clear the buffer before reading new data
        memset(request_buffer, 0, MAX_REQUEST_SIZE);

        // Read the incoming HTTP request from the socket.
        // This is a blocking call in a synchronous server.
        ssize_t bytes_received = read_from_socket(client_socket_fd, request_buffer, MAX_REQUEST_SIZE);

        if (bytes_received < 0) {
            perror("Error reading from socket (simulated)");
            // Close the client socket and continue to wait for new connections
            // close(client_socket_fd);
            continue;
        } else if (bytes_received == 0) {
            printf("Client disconnected (simulated).\n");
            // close(client_socket_fd);
            continue;
        } else {
            // Process the received HTTP request
            process_http_request(request_buffer, bytes_received);

            // In a real server, after processing and sending a response,
            // you would typically close the client socket for HTTP/1.0
            // or if the client explicitly requested connection close.
            // For HTTP/1.1 with keep-alive, you might keep it open for more requests.
            // For this example, we simulate a single request per connection.
            // close(client_socket_fd);
            printf("Connection (socket %d) handled and closed (simulated).\n", client_socket_fd);
        }

        // Add a small delay for demonstration purposes so output isn't too fast
        sleep(1);
    }

    // This part is unreachable in an infinite loop, but good practice for cleanup
    // if the loop were to ever terminate.
    free(request_buffer);
    printf("Server shutting down.\n");
    return EXIT_SUCCESS;
}