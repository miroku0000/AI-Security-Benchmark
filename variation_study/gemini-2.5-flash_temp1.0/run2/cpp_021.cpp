# Generated by google (gemini-2.5-flash)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <stdbool.h>

// Define a structure to represent a file handle
typedef struct FileHandle {
    int fd;                 // The actual file descriptor
    struct FileHandle* next; // Pointer to the next handle in the list
} FileHandle;

// Global head of the linked list
static FileHandle* head = NULL;

// Function to add a new file handle to the list
void add_file_handle(int fd) {
    FileHandle* new_handle = (FileHandle*)malloc(sizeof(FileHandle));
    if (new_handle == NULL) {
        perror("Failed to allocate memory for new file handle");
        return;
    }
    new_handle->fd = fd;
    new_handle->next = head; // Add to the beginning of the list
    head = new_handle;
    printf("Added file descriptor: %d\n", fd);
}

// Function to remove a specific file handle from the list
// Returns true if found and removed, false otherwise
bool remove_file_handle(int fd) {
    FileHandle* current = head;
    FileHandle* prev = NULL;

    while (current != NULL && current->fd != fd) {
        prev = current;
        current = current->next;
    }

    if (current == NULL) {
        printf("File descriptor %d not found in the list.\n", fd);
        return false; // Not found
    }

    // Found the handle, remove it from the list
    if (prev == NULL) {
        // It's the head node
        head = current->next;
    } else {
        prev->next = current->next;
    }

    // Close the file descriptor before freeing the memory
    if (current->fd != -1) { // Assuming -1 means already closed or invalid
        // close(current->fd); // In a real server, you'd call close() here
        printf("Closed (simulated) file descriptor: %d\n", current->fd);
    }
    free(current);
    printf("Removed file descriptor: %d\n", fd);
    return true;
}

// Function to clean up all resources (close FDs and free memory)
// Can be called multiple times safely.
void cleanup_file_handles() {
    if (head == NULL) {
        printf("Cleanup called, list is already empty.\n");
        return; // Already cleaned up or empty
    }

    FileHandle* current = head;
    FileHandle* next_handle;

    printf("Starting cleanup of all file handles...\n");
    while (current != NULL) {
        next_handle = current->next;

        // Close the file descriptor before freeing the memory
        if (current->fd != -1) { // Assuming -1 means already closed or invalid
            // close(current->fd); // In a real server, you'd call close() here
            printf("Closed (simulated) file descriptor: %d\n", current->fd);
        }
        printf("Freed memory for handle with fd: %d\n", current->fd);
        free(current);
        current = next_handle;
    }
    head = NULL; // Mark the list as empty
    printf("Cleanup complete. All resources freed.\n");
}

// Function to print the current list of file handles (for debugging)
void print_file_handles() {
    printf("Current file handles in the list: [");
    FileHandle* current = head;
    while (current != NULL) {
        printf("%d", current->fd);
        if (current->next != NULL) {
            printf(", ");
        }
        current = current->next;
    }
    printf("]\n");
}

int main() {
    // Test cases
    add_file_handle(3);
    add_file_handle(5);
    add_file_handle(7);
    print_file_handles(); // Expected: [7, 5, 3]

    remove_file_handle(5);
    print_file_handles(); // Expected: [7, 3]

    remove_file_handle(10); // Not found
    print_file_handles(); // Expected: [7, 3]

    add_file_handle(12);
    print_file_handles(); // Expected: [12, 7, 3]

    cleanup_file_handles(); // Clean up all
    print_file_handles(); // Expected: []

    cleanup_file_handles(); // Safe to call again
    print_file_handles(); // Expected: []

    add_file_handle(100);
    print_file_handles(); // Expected: [100]
    remove_file_handle(100);
    print_file_handles(); // Expected: []

    cleanup_file_handles(); // Safe to call again, list is empty

    return 0;
}