# Generated by google (gemini-2.5-flash)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <string>
#include <algorithm> // For std::find_if, std::remove_if
#include <ctime>     // For time_t, time()
#include <chrono>    // For std::this_thread::sleep_for
#include <thread>    // For std::this_thread

// Forward declaration to allow SessionManager to use UserSession
class UserSession;

// Class representing a user session
class UserSession {
public:
    int id;
    std::string username;
    time_t creationTime;
    time_t lastAccessTime;

    UserSession(int id, const std::string& username)
        : id(id), username(username), creationTime(time(nullptr)), lastAccessTime(time(nullptr)), expired(false) {
        std::cout << "UserSession " << id << " created." << std::endl;
    }

    ~UserSession() {
        std::cout << "UserSession " << id << " destroyed." << std::endl;
    }

    // Update last access time
    void touch() {
        lastAccessTime = time(nullptr);
    }

    // Check if the session is expired based on last access time or manual expiration
    bool isExpired(long expirationDurationSeconds = 3600) const { // Default: 1 hour
        return expired || (time(nullptr) - lastAccessTime > expirationDurationSeconds);
    }

    // Manually expire the session
    void expire() {
        expired = true;
    }

private:
    bool expired;
};

// Class to manage user session objects
class SessionManager {
public:
    // Destructor to clean up all remaining sessions when the manager is destroyed
    ~SessionManager() {
        cleanupAllSessions();
    }

    // Add a new session to the manager. The manager takes ownership of the pointer.
    void addSession(UserSession* session) {
        if (!session) {
            std::cerr << "Attempted to add a nullptr session." << std::endl;
            return;
        }
        // Check for duplicate ID before adding
        if (getSession(session->id) != nullptr) {
            std::cerr << "Warning: Session with ID " << session->id << " already exists. Not adding new session." << std::endl;
            delete session; // Clean up the incoming duplicate session to prevent leak
            return;
        }
        sessions_.push_back(session);
        std::cout << "Session " << session->id << " added." << std::endl;
    }

    // Remove a session by its ID and free its memory.
    // Returns true if the session was found and removed, false otherwise.
    bool removeSession(int sessionId) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
                               [sessionId](UserSession* s) {
                                   return s->id == sessionId;
                               });

        if (it != sessions_.end()) {
            UserSession* sessionToDelete = *it;
            delete sessionToDelete; // Free the memory of the UserSession object
            sessions_.erase(it);    // Remove the pointer from the vector
            std::cout << "Session " << sessionId << " removed." << std::endl;
            return true;
        }
        std::cout << "Session " << sessionId << " not found for removal." << std::endl;
        return false;
    }

    // Access a session by its ID.
    // Returns a pointer to the UserSession object if found, otherwise nullptr.
    UserSession* getSession(int sessionId) const {
        for (UserSession* session : sessions_) {
            if (session->id == sessionId) {
                return session;
            }
        }
        return nullptr;
    }

    // Iterates through all sessions, removes expired ones, and frees their memory.
    void cleanupExpiredSessions(long expirationDurationSeconds = 3600) {
        std::cout << "\nCleaning up expired sessions..." << std::endl;
        // Use erase-remove idiom to efficiently remove elements from vector
        auto it = std::remove_if(sessions_.begin(), sessions_.end(),
                                 [expirationDurationSeconds](UserSession* s) {
                                     if (s->isExpired(expirationDurationSeconds)) {
                                         std::cout << "Session " << s->id << " expired." << std::endl;
                                         delete s; // Free memory of the expired session
                                         return true; // Mark for removal from the vector
                                     }
                                     return false; // Keep this session
                                 });

        sessions_.erase(it, sessions_.end());
        std::cout << "Finished cleaning up expired sessions. " << sessions_.size() << " active sessions remaining." << std::endl;
    }

    // Returns the current number of active sessions.
    size_t getSessionCount() const {
        return sessions_.size();
    }

private:
    std::vector<UserSession*> sessions_;

    // Helper method to clean up all sessions, typically called by the destructor.
    void cleanupAllSessions() {
        std::cout << "\nCleaning up all sessions on manager destruction (total: " << sessions_.size() << ")..." << std::endl;
        for (UserSession* session : sessions_) {
            delete session; // Free memory for each session object
        }
        sessions_.clear(); // Clear the vector of pointers
        std::cout << "All sessions cleaned up." << std::endl;
    }

    // Prevent copying of SessionManager to avoid double-free issues with raw pointers.
    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;
};

int main() {
    SessionManager manager;

    // Add some sessions
    UserSession* s1 = new UserSession(1, "alice_user");
    UserSession* s2 = new UserSession(2, "bob_user");
    UserSession* s3 = new UserSession(3, "charlie_user");

    manager.addSession(s1);
    manager.addSession(s2);
    manager.addSession(s3);

    std::cout << "\nInitial session count: " << manager.getSessionCount() << std::endl;

    // Access a session and touch it to keep it alive
    UserSession* retrievedSession = manager.getSession(2);
    if (retrievedSession) {
        std::cout << "Accessed session 2: Username = " << retrievedSession->username << std::endl;
        retrievedSession->touch(); // Update last access time
    }

    // Simulate some time passing to allow sessions to expire based on duration
    std::cout << "\nWaiting 2 seconds to allow some sessions to expire naturally..." << std::endl;
    std::this_thread::sleep_for(std::chrono::seconds(2));

    // Manually expire session 1
    if (UserSession* s = manager.getSession(1)) {
        s->expire();
        std::cout << "Manually expired session 1." << std::endl;
    }

    // Run cleanup logic with a short expiration duration for testing
    // Any session not accessed in the last 1 second, or manually expired, will be removed.
    manager.cleanupExpiredSessions(1);

    std::cout << "\nSession count after first cleanup: " << manager.getSessionCount() << std::endl;
    // Session 1 (manually expired) and Session 3 (not touched, expired by 1s rule) should be gone.
    // Session 2 (touched) should remain.

    UserSession* s4 = new UserSession(4, "david_user");
    manager.addSession(s4);

    std::cout << "\nSession count after adding s4: " << manager.getSessionCount() << std::endl;

    // Remove session 4 directly using removeSession method
    manager.removeSession(4);

    std::cout << "\nSession count after removing s4: " << manager.getSessionCount() << std::endl;

    // Try to add a duplicate session (should be handled by addSession)
    UserSession* s_duplicate_s2 = new UserSession(2, "duplicate_bob");
    manager.addSession(s_duplicate_s2); // This should print a warning and delete s_duplicate_s2

    // Let the SessionManager object go out of scope, triggering its destructor
    // to clean up any remaining sessions (in this case, session 2).
    std::cout << "\nManager going out of scope. Destructor will clean up remaining sessions." << std::endl;

    return 0;
}