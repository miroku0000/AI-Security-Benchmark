# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <sys/stat.h> // For stat and time_t
#include <time.h>     // For time_t if not included by sys/stat/types.h
#include <pthread.h>  // For mutex for thread-safety

// Define a structure for the configuration cache
typedef struct {
    char* filename;     // Name of the file being cached (dynamically allocated)
    void* data;         // Pointer to the dynamically allocated configuration data
    size_t size;        // Size of the configuration data in bytes
    time_t last_mtime;  // Last modification time of the file (from stat.st_mtime)
    int initialized;    // Flag to indicate if the cache has been successfully loaded
} ConfigCache;

// Static cache instance for a single configuration file.
// This design assumes only one configuration file is cached at a time.
// For caching multiple files, a map/hash table of ConfigCache structs would be needed.
static ConfigCache config_cache = {
    .filename = NULL,
    .data = NULL,
    .size = 0,
    .last_mtime = 0,
    .initialized = 0
};

// Mutex for thread-safety when accessing the static cache
static pthread_mutex_t cache_mutex = PTHREAD_MUTEX_INITIALIZER;

// Helper function to free all resources held by the cache.
// This function must be called while holding the cache_mutex.
static void free_config_cache_internal(void) {
    if (config_cache.filename != NULL) {
        free(config_cache.filename);
        config_cache.filename = NULL;
    }
    if (config_cache.data != NULL) {
        free(config_cache.data);
        config_cache.data = NULL;
    }
    config_cache.size = 0;
    config_cache.last_mtime = 0;
    config_cache.initialized = 0;
}

// Reads a configuration file into dynamically allocated memory.
// It uses an internal cache to avoid re-reading the file if it hasn't changed.
// The function is thread-safe.
//
// filename: The path to the configuration file.
// out_size: A pointer to a size_t variable where the size of the loaded data will be stored.
//
// Returns a pointer to the dynamically allocated configuration data, or NULL on error.
// The caller should NOT free the returned pointer; it is managed by the internal cache.
// The data pointed to by the returned pointer is valid until the file is reloaded,
// or a different file is requested, or clear_config_cache() is called.
void* get_config_data(const char* filename, size_t* out_size) {
    if (filename == NULL || out_size == NULL) {
        if (out_size != NULL) *out_size = 0;
        fprintf(stderr, "Error: Invalid input (filename or out_size is NULL).\n");
        return NULL;
    }

    pthread_mutex_lock(&cache_mutex);

    struct stat file_stat;
    int stat_result = stat(filename, &file_stat);

    // Flag to determine if a full load or reload is necessary
    int needs_load = 0;

    if (stat_result != 0) {
        // File does not exist or cannot be accessed
        if (config_cache.initialized && config_cache.filename != NULL && strcmp(config_cache.filename, filename) == 0) {
             // We were caching this file, but now it's gone or inaccessible. Clear cache.
             fprintf(stderr, "Error: Previously cached file '%s' is now inaccessible. Clearing cache.\n", filename);
             free_config_cache_internal();
        } else {
             // File not cached before, or requested file is different and inaccessible.
             fprintf(stderr, "Error: Could not stat file '%s'. File not cached or requested file is new.\n", filename);
        }
        *out_size = 0;
        pthread_mutex_unlock(&cache_mutex);
        return NULL;
    }

    // Check if the requested file is different from the cached one, or if cache is not initialized
    if (!config_cache.initialized || strcmp(config_cache.filename, filename) != 0) {
        needs_load = 1; // Different file or first time call
    } else if (file_stat.st_mtime > config_cache.last_mtime) {
        needs_load = 1; // File has been modified, need to reload
        fprintf(stdout, "Info: File '%s' modified, reloading...\n", filename);
    }
    // If needs_load is false, then the file is the same and not modified, so we return cached data.

    if (needs_load) {
        // If it's a new file, clear the entire existing cache
        // If it's a modified version of the same file, just free the data (filename remains valid)
        if (config_cache.initialized && config_cache.filename != NULL && strcmp(config_cache.filename, filename) != 0) {
            free_config_cache_internal(); // Entire cache (filename and data)
        } else if (config_cache.data != NULL) { // Same file, but modified, only free data
            free(config_cache.data);
            config_cache.data = NULL;
            config_cache.size = 0;
        }

        // Allocate memory for the filename if it's new or was cleared
        if (config_cache.filename == NULL) {
            config_cache.filename = strdup(filename);
            if (config_cache.filename == NULL) {
                fprintf(stderr, "Error: Failed to allocate memory for filename '%s'\n", filename);
                free_config_cache_internal(); // Ensure consistent empty state on error
                *out_size = 0;
                pthread_mutex_unlock(&cache_mutex);
                return NULL;
            }
        }

        FILE* fp = fopen(filename, "rb");
        if (fp == NULL) {
            fprintf(stderr, "Error: Could not open file '%s'.\n", filename);
            free_config_cache_internal(); // Clean up on load failure
            *out_size = 0;
            pthread_mutex_unlock(&cache_mutex);
            return NULL;
        }

        fseek(fp, 0, SEEK_END);
        long file_len = ftell(fp);
        fseek(fp, 0, SEEK_SET);

        if (file_len < 0) { // ftell returns -1 on error
            fprintf(stderr, "Error: Could not determine size of file '%s'.\n", filename);
            fclose(fp);
            free_config_cache_internal();
            *out_size = 0;
            pthread_mutex_unlock(&cache_mutex);
            return NULL;
        }
        size_t read_size = (size_t)file_len;

        void* data = NULL;
        if (read_size > 0) { // Avoid malloc(0) which can have varying behavior
            data = malloc(read_size);
            if (data == NULL) {
                fprintf(stderr, "Error: Failed to allocate memory for file content (%zu bytes).\n", read_size);
                fclose(fp);
                free_config_cache_internal();
                *out_size = 0;
                pthread_mutex_unlock(&cache_mutex);
                return NULL;
            }

            if (fread(data, 1, read_size, fp) != read_size) {
                fprintf(stderr, "Error: Failed to read full content of file '%s'.\n", filename);
                free(data); // Free newly allocated data
                fclose(fp);
                free_config_cache_internal();
                *out_size = 0;
                pthread_mutex_unlock(&cache_mutex);
                return NULL;
            }
        }
        fclose(fp);

        // Update cache with new data
        config_cache.data = data;
        config_cache.size = read_size;
        config_cache.last_mtime = file_stat.st_mtime;
        config_cache.initialized = 1;
    }

    *out_size = config_cache.size;
    void* result_data = config_cache.data; // The current cached data (newly loaded or existing)

    pthread_mutex_unlock(&cache_mutex);
    return result_data;
}

// Explicitly clears the configuration cache.
// This function should be called, for example, at application exit
// to free all dynamically allocated resources held by the cache.
void clear_config_cache(void) {
    pthread_mutex_lock(&cache_mutex);
    free_config_cache_internal();
    pthread_mutex_unlock(&cache_mutex);
    // If no more calls to get_config_data are expected, the mutex can also be destroyed:
    // pthread_mutex_destroy(&cache_mutex);
}