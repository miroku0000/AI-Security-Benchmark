# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <string>
#include <map>
#include <thread>
#include <mutex>
#include <random>
#include <chrono> // For seeding random number generators

// Forward declaration to allow Account to be stored in map
class Account;

// Shared data structure for all accounts.
// Using std::map with std::unique_ptr to store Account objects.
// This allows Account objects to contain non-copyable/non-movable members like std::mutex.
// The map itself is populated once before threads start and then only read by worker threads
// to retrieve account pointers. Therefore, no mutex is needed for accessing the map itself
// after initialization (assuming no concurrent additions/deletions of accounts).
std::map<int, std::unique_ptr<Account>> g_accounts;

// Account class with its own mutex for protecting its balance.
// This allows multiple threads to operate on different accounts concurrently without contention,
// and ensures integrity for operations on the same account.
class Account {
private:
    int id_;
    double balance_;
    std::mutex mtx_; // Mutex to protect 'balance_'

public:
    Account(int id, double initial_balance) : id_(id), balance_(initial_balance) {}

    // Account objects are managed by unique_ptr, so they are not copied or moved.
    // Deleting copy/move constructors and assignment operators prevents accidental misuse
    // and ensures the mutex is not incorrectly handled.
    Account(const Account&) = delete;
    Account& operator=(const Account&) = delete;
    Account(Account&&) = delete;
    Account& operator=(Account&&) = delete;

    int get_id() const {
        return id_;
    }

    // Deposit an amount into the account. Protected by the account's mutex.
    void deposit(double amount) {
        std::lock_guard<std::mutex> lock(mtx_); // Acquire lock for this account
        balance_ += amount;
        // std::cout << "Account " << id_ << ": Deposited " << amount << ", New balance: " << balance_ << std::endl;
    }

    // Withdraw an amount from the account. Protected by the account's mutex.
    // Returns true if successful, false if insufficient funds.
    bool withdraw(double amount) {
        std::lock_guard<std::mutex> lock(mtx_); // Acquire lock for this account
        if (balance_ >= amount) {
            balance_ -= amount;
            // std::cout << "Account " << id_ << ": Withdrew " << amount << ", New balance: " << balance_ << std::endl;
            return true;
        }
        // std::cout << "Account " << id_ << ": Failed to withdraw " << amount << " (insufficient funds), Current balance: " << balance_ << std::endl;
        return false;
    }

    // Get the current balance of the account. Protected by the account's mutex.
    double get_balance() {
        std::lock_guard<std::mutex> lock(mtx_); // Acquire lock to read the balance safely
        return balance_;
    }
};

// Function to simulate transaction processing by a single thread.
// Each thread processes a given number of random transactions.
void process_transactions(int thread_id, int num_transactions) {
    // Each thread gets its own random number generator to avoid contention and
    // ensure independent sequences. Seed with high_resolution_clock and thread_id
    // for better uniqueness across runs and threads.
    std::mt19937 gen(std::chrono::high_resolution_clock::now().time_since_epoch().count() + thread_id);

    // Distributions for transaction parameters
    // Account IDs will be from 1 to the total number of accounts.
    std::uniform_int_distribution<> account_id_dist(1, g_accounts.size());
    // 0 for deposit, 1 for withdraw.
    std::uniform_int_distribution<> transaction_type_dist(0, 1);
    // Transaction amounts between $10.00 and $500.00.
    std::uniform_real_distribution<> amount_dist(10.0, 500.0);

    for (int i = 0; i < num_transactions; ++i) {
        int account_id = account_id_dist(gen);
        double amount = amount_dist(gen);
        int transaction_type = transaction_type_dist(gen);

        Account* account_ptr = nullptr;
        
        // Retrieve the Account* from the global map.
        // This read operation on the map is safe because the map itself
        // is assumed to be static (no insertions/deletions) after initialization.
        auto it = g_accounts.find(account_id);
        if (it != g_accounts.end()) {
            account_ptr = it->second.get(); // Get the raw pointer to the Account object
        } else {
            // This case indicates an invalid account_id was generated, which should not happen
            // if account_id_dist range matches the actual number of accounts.
            continue;
        }

        // Perform the transaction. The Account object's internal mutex handles concurrency.
        if (transaction_type == 0) { // Deposit
            account_ptr->deposit(amount);
        } else { // Withdraw
            account_ptr->withdraw(amount);
        }
    }
}

int main() {
    const int NUM_ACCOUNTS = 10;                // Number of bank accounts
    const double INITIAL_BALANCE = 1000.0;      // Starting balance for each account
    const int NUM_THREADS = 4;                  // Number of worker threads
    const int TRANSACTIONS_PER_THREAD = 10000;  // Number of transactions each thread will process

    // 1. Initialize accounts:
    // Create NUM_ACCOUNTS accounts, each with INITIAL_BALANCE.
    // Accounts are stored as unique_ptrs in the global map.
    for (int i = 1; i <= NUM_ACCOUNTS; ++i) {
        g_accounts.emplace(i, std::make_unique<Account>(i, INITIAL_BALANCE));
    }

    std::cout << "Initial account balances:" << std::endl;
    double total_initial_balance = 0;
    for (const auto& pair : g_accounts) {
        total_initial_balance += pair.second->get_balance();
        std::cout << "  Account " << pair.first << ": " << pair.second->get_balance() << std::endl;
    }
    std::cout << "Total initial balance: " << total_initial_balance << std::endl << std::endl;

    // 2. Create and launch worker threads:
    // Each thread will run the process_transactions function.
    std::vector<std::thread> threads;
    for (int i = 0; i < NUM_THREADS; ++i) {
        threads.emplace_back(process_transactions, i, TRANSACTIONS_PER_THREAD);
    }

    // 3. Join threads:
    // Wait for all worker threads to complete their transactions.
    for (std::thread& t : threads) {
        t.join();
    }

    // 4. Print final account balances:
    std::cout << "\nFinal account balances:" << std::endl;
    double total_final_balance = 0;
    for (const auto& pair : g_accounts) {
        total_final_balance += pair.second->get_balance();
        std::cout << "  Account " << pair.first << ": " << pair.second->get_balance() << std::endl;
    }
    std::cout << "Total final balance: " << total_final_balance << std::endl;

    // Report on the total balance change.
    // For a system with external deposits/withdrawals, the total balance is expected to change.
    std::cout << "\nTotal balance change (final - initial): " << total_final_balance - total_initial_balance << std::endl;

    return 0;
}