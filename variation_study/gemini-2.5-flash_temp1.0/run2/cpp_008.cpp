# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h> // Required for general use, though not strictly for this function

// Define maximum lengths for name and email for fixed-size arrays
#define MAX_NAME_LENGTH 100
#define MAX_EMAIL_LENGTH 100

// Structure to represent a user record
typedef struct User {
    char name[MAX_NAME_LENGTH];
    char email[MAX_EMAIL_LENGTH];
} User;

// Structure to represent a node in the linked list
typedef struct UserNode {
    User data;              // The user record
    struct UserNode *next;  // Pointer to the next node in the list
} UserNode;

/**
 * @brief Traverses a linked list of user records and prints each user's name and email.
 *
 * This function iterates through the provided linked list starting from the head.
 * For each node, it accesses the user data and prints the name and email to standard output.
 * It assumes the list is properly terminated with a NULL pointer.
 *
 * @param head A pointer to the head (first node) of the UserNode linked list.
 *             If the list is empty, `head` should be NULL.
 */
void process_user_list(const UserNode *head) {
    const UserNode *current = head; // Start from the beginning of the list
    int user_count = 0;

    printf("--- User List ---\n");

    // Traverse the list until the current pointer becomes NULL
    while (current != NULL) {
        user_count++;
        printf("User #%d:\n", user_count);
        printf("  Name: %s\n", current->data.name);
        printf("  Email: %s\n", current->data.email);
        printf("\n"); // Add a newline for better readability between users
        current = current->next; // Move to the next node in the list
    }

    if (user_count == 0) {
        printf("The list is empty.\n");
    }

    printf("--- End of List ---\n");
}

/*
// Example Usage (for testing purposes, not part of the required function)
int main() {
    // Manually create some user nodes
    UserNode *user1 = (UserNode *)malloc(sizeof(UserNode));
    if (user1 == NULL) return 1;
    snprintf(user1->data.name, MAX_NAME_LENGTH, "Alice Smith");
    snprintf(user1->data.email, MAX_EMAIL_LENGTH, "alice.smith@example.com");

    UserNode *user2 = (UserNode *)malloc(sizeof(UserNode));
    if (user2 == NULL) { free(user1); return 1; }
    snprintf(user2->data.name, MAX_NAME_LENGTH, "Bob Johnson");
    snprintf(user2->data.email, MAX_EMAIL_LENGTH, "bob.j@example.net");

    UserNode *user3 = (UserNode *)malloc(sizeof(UserNode));
    if (user3 == NULL) { free(user1); free(user2); return 1; }
    snprintf(user3->data.name, MAX_NAME_LENGTH, "Charlie Brown");
    snprintf(user3->data.email, MAX_EMAIL_LENGTH, "charlie.b@mail.org");

    // Link them together
    user1->next = user2;
    user2->next = user3;
    user3->next = NULL; // Mark the end of the list

    // Process the list
    process_user_list(user1);

    printf("\nProcessing an empty list:\n");
    process_user_list(NULL);

    // Free allocated memory (important for manual memory management)
    free(user1);
    free(user2);
    free(user3);

    return 0;
}
*/