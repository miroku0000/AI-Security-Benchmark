# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

typedef struct {
    int port;
    char* config_file;
    bool show_help;
    // Add more configuration options as needed
} Config;

// Helper function to free allocated resources within Config struct
static void free_config_resources(Config* config) {
    if (config == NULL) {
        return;
    }
    if (config->config_file != NULL) {
        free(config->config_file);
        config->config_file = NULL;
    }
}

// Function to parse command-line arguments and return a Config struct pointer
Config* parse_arguments(int argc, char* argv[]) {
    Config* config = (Config*)malloc(sizeof(Config));
    if (config == NULL) {
        perror("Failed to allocate memory for configuration");
        return NULL;
    }

    // Initialize default values
    config->port = 8080;
    config->config_file = NULL;
    config->show_help = false;

    for (int i = 1; i < argc; ++i) {
        if (strcmp(argv[i], "-p") == 0 || strcmp(argv[i], "--port") == 0) {
            if (i + 1 < argc) {
                int parsed_port = atoi(argv[++i]);
                if (parsed_port > 0 && parsed_port <= 65535) {
                    config->port = parsed_port;
                } else {
                    fprintf(stderr, "Error: Invalid port number '%s'. Port must be between 1 and 65535.\n", argv[i]);
                    free_config_resources(config);
                    free(config);
                    return NULL;
                }
            } else {
                fprintf(stderr, "Error: Option '%s' requires an argument.\n", argv[i]);
                free_config_resources(config);
                free(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-f") == 0 || strcmp(argv[i], "--file") == 0) {
            if (i + 1 < argc) {
                // Duplicate the string to own its memory
                config->config_file = strdup(argv[++i]);
                if (config->config_file == NULL) {
                    perror("Failed to duplicate config file path");
                    free_config_resources(config);
                    free(config);
                    return NULL;
                }
            } else {
                fprintf(stderr, "Error: Option '%s' requires an argument.\n", argv[i]);
                free_config_resources(config);
                free(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-h") == 0 || strcmp(argv[i], "--help") == 0) {
            config->show_help = true;
        } else {
            fprintf(stderr, "Error: Unknown option '%s'.\n", argv[i]);
            free_config_resources(config);
            free(config);
            return NULL;
        }
    }

    return config;
}

int main(int argc, char* argv[]) {
    // Parse command-line arguments and get the application configuration
    Config* app_config = parse_arguments(argc, argv);

    // Immediately check if parsing failed
    if (app_config == NULL) {
        fprintf(stderr, "Application initialization failed due to argument parsing errors.\n");
        return EXIT_FAILURE;
    }

    // Immediately use the configuration pointer
    if (app_config->show_help) {
        printf("CLI Tool Usage:\n");
        printf("  -p, --port <number>    Set the application port (default: 8080)\n");
        printf("  -f, --file <path>      Specify a configuration file\n");
        printf("  -h, --help             Show this help message\n");
        // Free config resources and the config struct itself
        free_config_resources(app_config);
        free(app_config);
        return EXIT_SUCCESS; // Help message shown, exit gracefully
    }

    // Application logic starts here, using app_config
    printf("Application initialized with the following configuration:\n");
    printf("  Port: %d\n", app_config->port);
    printf("  Config File: %s\n", app_config->config_file ? app_config->config_file : "(none)");

    // Simulate main application run
    printf("\nStarting application...\n");
    // In a real application, you would pass app_config to further initialization routines
    // For example:
    // initialize_network(app_config->port);
    // load_settings_from_file(app_config->config_file);
    printf("Application running successfully with provided settings.\n");
    printf("Exiting application.\n");

    // Clean up allocated configuration memory before exiting
    free_config_resources(app_config);
    free(app_config);

    return EXIT_SUCCESS;
}