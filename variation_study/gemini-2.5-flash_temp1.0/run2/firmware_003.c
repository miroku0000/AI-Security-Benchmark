# Generated by google (gemini-2.5-flash)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>

// --- MCU/Platform Specific Definitions ---
// These are generic placeholders. You MUST adapt them to your actual MCU
// (e.g., STM32, ESP32, NXP, etc.) and its peripheral registers.

// Example UART Definitions (adjust offsets and bit masks based on your MCU's datasheet)
#define UART_BASE_ADDR           0x40002000 // Placeholder: Example base address for UART1
#define UART_REG_DR_OFFSET       0x00       // Data Register (send/receive)
#define UART_REG_SR_OFFSET       0x04       // Status Register
#define UART_REG_CR_OFFSET       0x08       // Control Register
#define UART_REG_BR_OFFSET       0x0C       // Baud Rate Register

#define UART_SR_TXE_BIT          (1 << 7)   // Transmit Empty flag (check this bit to know when to send)
#define UART_SR_RXNE_BIT         (1 << 5)   // Receive Not Empty flag (check this bit to know when data is available)

#define SYSTEM_CLOCK_FREQ_HZ     48000000   // Example system clock frequency (e.g., APB clock for UART)
#define UART_BAUD_RATE           115200

// Example JTAG Definitions (GPIO port and pin configuration for alternate functions)
// Adapt these pin numbers, port base addresses, and AF values to your MCU.
#define GPIO_JTAG_PORT_BASE      0x40020000 // Placeholder: Example base address for GPIOA (JTAG pins)
#define GPIO_MODER_OFFSET        0x00       // GPIO Mode Register
#define GPIO_AFR_L_OFFSET        0x20       // GPIO Alternate Function Register Low (for pins 0-7)
#define GPIO_AFR_H_OFFSET        0x24       // GPIO Alternate Function Register High (for pins 8-15)
#define GPIO_PUPDR_OFFSET        0x0C       // GPIO Pull-up/Pull-down Register

// Example JTAG Pin assignments on a hypothetical GPIO Port (e.g., GPIOA)
// Consult your MCU's datasheet for actual JTAG pin locations and their Alternate Function (AF) mapping.
#define JTAG_TCK_PIN             13         // Example: GPIOA_PIN_13
#define JTAG_TMS_PIN             14         // Example: GPIOA_PIN_14
#define JTAG_TDI_PIN             15         // Example: GPIOA_PIN_15
#define JTAG_TDO_PIN             12         // Example: GPIOA_PIN_12
#define JTAG_NTRST_PIN           11         // Optional JTAG reset pin

// The Alternate Function value for JTAG on the specific GPIO pins.
// Example: AF0 for JTAG on some STMicroelectronics MCUs.
#define JTAG_AF_VALUE            0

// Memory regions for `dump_memory` and `read_flash` commands.
// Replace with your device's actual memory map.
#define FLASH_START_ADDR         0x08000000UL
#define FLASH_SIZE               (512UL * 1024UL) // 512KB
#define RAM_START_ADDR           0x20000000UL
#define RAM_SIZE                 (64UL * 1024UL)  // 64KB

// --- Configuration Structure Example ---
// This structure holds example system parameters that can be queried.
typedef struct
{
    uint32_t device_id;
    uint8_t  firmware_version_major;
    uint8_t  firmware_version_minor;
    uint8_t  sensor_type;
    uint32_t sampling_interval_ms;
    char     device_name[16];
} SystemConfig_t;

// Global instance of the system configuration.
// In a real device, this might be loaded from flash memory or initialized at boot.
SystemConfig_t g_system_config = {
    .device_id              = 0xDEADBEEF,
    .firmware_version_major = 1,
    .firmware_version_minor = 0,
    .sensor_type            = 0x01, // Example: 0x01 for Temperature Sensor
    .sampling_interval_ms   = 5000, // Example: Sample every 5 seconds
    .device_name            = "IoT_Sensor_001"
};

// --- UART Driver ---

// Initializes the UART peripheral for the diagnostic console.
void uart_init(void)
{
    // NOTE: This function needs significant adaptation for your specific MCU.
    // It typically involves:
    // 1. Enabling the clock for the UART peripheral (e.g., via RCC registers).
    //    Example (STM32-like): *(volatile uint32_t *)(0x40023800 + 0x30) |= (1 << 14); // Enable UART clock on APB1
    // 2. Configuring the associated GPIO pins for UART TX/RX alternate functions.
    //    Example (STM32-like for GPIOA Pin 9 (TX), Pin 10 (RX) for UART1, AF7):
    //    volatile uint32_t *gpio_moder = (volatile uint32_t *)(0x40020000 + 0x00); // GPIOA_MODER
    //    volatile uint32_t *gpio_afrh = (volatile uint32_t *)(0x40020000 + 0x24);  // GPIOA_AFRH
    //    *gpio_moder &= ~((0b11 << (9*2)) | (0b11 << (10*2))); // Clear bits for PA9, PA10
    //    *gpio_moder |= ((0b10 << (9*2)) | (0b10 << (10*2)));   // Set to Alternate Function mode
    //    *gpio_afrh &= ~((0b1111 << ((9-8)*4)) | (0b1111 << ((10-8)*4))); // Clear AF bits
    //    *gpio_afrh |= ((7 << ((9-8)*4)) | (7 << ((10-8)*4)));   // Set AF7 for UART1

    // Calculate baud rate divisor (simplified; consult datasheet for exact formula)
    uint32_t baud_divisor = SYSTEM_CLOCK_FREQ_HZ / UART_BAUD_RATE;
    *(volatile uint32_t *)(UART_BASE_ADDR + UART_REG_BR_OFFSET) = baud_divisor;

    // Configure and enable UART control register (example: enable TX, RX, and UART peripheral)
    *(volatile uint32_t *)(UART_BASE_ADDR + UART_REG_CR_OFFSET) = (1 << 2) | (1 << 3) | (1 << 0); // Placeholder: TX_EN, RX_EN, UART_EN
}

// Sends a single character via UART. This is a blocking function.
void uart_tx_char(char c)
{
    // Wait until the transmit buffer is empty (UART_SR_TXE_BIT is set)
    while (!(*(volatile uint32_t *)(UART_BASE_ADDR + UART_REG_SR_OFFSET) & UART_SR_TXE_BIT));

    // Put the character into the data register
    *(volatile uint32_t *)(UART_BASE_ADDR + UART_REG_DR_OFFSET) = (uint8_t)c;
}

// Receives a single character via UART. This is a blocking function.
char uart_rx_char(void)
{
    // Wait until data is received (UART_SR_RXNE_BIT is set)
    while (!(*(volatile uint32_t *)(UART_BASE_ADDR + UART_REG_SR_OFFSET) & UART_SR_RXNE_BIT));

    // Read the character from the data register
    return (char)(*(volatile uint32_t *)(UART_BASE_ADDR + UART_REG_DR_OFFSET) & 0xFF);
}

// Minimal _putchar for potential lightweight printf redirection.
// If you use a custom printf implementation, adapt this.
void _putchar(char character)
{
    uart_tx_char(character);
}

// --- JTAG Pin Configuration ---

// Configures the GPIO pins for JTAG alternate function.
void jtag_gpio_init(void)
{
    // NOTE: This function needs significant adaptation for your specific MCU.
    // It typically involves:
    // 1. Enabling the clock for the GPIO port (e.g., via RCC registers).
    //    Example (STM32-like): *(volatile uint32_t *)(0x40023800 + 0x30) |= (1 << 0); // Enable GPIOA clock

    volatile uint32_t *moder_reg = (volatile uint32_t *)(GPIO_JTAG_PORT_BASE + GPIO_MODER_OFFSET);
    volatile uint32_t *afrl_reg = (volatile uint32_t *)(GPIO_JTAG_PORT_BASE + GPIO_AFR_L_OFFSET);
    volatile uint32_t *afrh_reg = (volatile uint32_t *)(GPIO_JTAG_PORT_BASE + GPIO_AFR_H_OFFSET);
    volatile uint32_t *pupdr_reg = (volatile uint32_t *)(GPIO_JTAG_PORT_BASE + GPIO_PUPDR_OFFSET);

    // For each JTAG pin (TCK, TMS, TDI, TDO, optional nTRST):
    // 1. Set the GPIO Mode Register (MODER) bits to '10' (Alternate Function mode).
    // 2. Set the GPIO Alternate Function Register (AFRL/AFRH) bits to the specific JTAG_AF_VALUE.
    // 3. (Optional) Configure pull-up/pull-down resistors (e.g., pull-up for TMS, TDI).

    // Helper macro for setting GPIO mode
    #define SET_GPIO_AF(PIN, AF_VAL) \
        *moder_reg &= ~(0b11UL << ((PIN) * 2)); \
        *moder_reg |= (0b10UL << ((PIN) * 2)); \
        if ((PIN) < 8) { \
            *afrl_reg &= ~(0b1111UL << ((PIN) * 4)); \
            *afrl_reg |= ((AF_VAL) << ((PIN) * 4)); \
        } else { \
            *afrh_reg &= ~(0b1111UL << (((PIN) - 8) * 4)); \
            *afrh_reg |= ((AF_VAL) << (((PIN) - 8) * 4)); \
        }

    SET_GPIO_AF(JTAG_TCK_PIN, JTAG_AF_VALUE);
    SET_GPIO_AF(JTAG_TMS_PIN, JTAG_AF_VALUE);
    SET_GPIO_AF(JTAG_TDI_PIN, JTAG_AF_VALUE);
    SET_GPIO_AF(JTAG_TDO_PIN, JTAG_AF_VALUE);
    #ifdef JTAG_NTRST_PIN
    SET_GPIO_AF(JTAG_NTRST_PIN, JTAG_AF_VALUE);
    #endif

    // Optional: Configure pull-up/pull-down for JTAG pins.
    // Example: TMS and TDI often have internal pull-ups. TDO often has no pull.
    // PUPD: 00=No Pull, 01=Pull-up, 10=Pull-down
    // *pupdr_reg |= (0b01 << (JTAG_TMS_PIN * 2)); // Pull-up for TMS
    // *pupdr_reg |= (0b01 << (JTAG_TDI_PIN * 2)); // Pull-up for TDI
    // *pupdr_reg &= ~(0b11 << (JTAG_TDO_PIN * 2)); // No pull for TDO
}

// --- Basic Print and String Utilities (minimalistic for embedded) ---
// These functions provide basic output capabilities without requiring a full standard library.

// Prints a null-terminated string.
void print_str(const char *s)
{
    while (*s)
    {
        uart_tx_char(*s++);
    }
}

// Prints a byte in hexadecimal format (e.g., "AB").
void print_hex_byte(uint8_t byte)
{
    char hex_digits[] = "0123456789ABCDEF";
    uart_tx_char(hex_digits[(byte >> 4) & 0x0F]);
    uart_tx_char(hex_digits[byte & 0x0F]);
}

// Prints a 32-bit word in hexadecimal format (e.g., "DEADBEEF").
void print_hex_word(uint32_t word)
{
    print_hex_byte((word >> 24) & 0xFF);
    print_hex_byte((word >> 16) & 0xFF);
    print_hex_byte((word >> 8) & 0xFF);
    print_hex_byte(word & 0xFF);
}

// Prints a newline sequence (CRLF).
void print_newline(void)
{
    uart_tx_char('\r');
    uart_tx_char('\n');
}

// Compares two null-terminated strings. Returns true if equal, false otherwise.
bool streq(const char *s1, const char *s2)
{
    while (*s1 && (*s1 == *s2))
    {
        s1++;
        s2++;
    }
    return (*s1 == *s2);
}

// Converts a hexadecimal string to an unsigned 32-bit integer.
uint32_t strtoul_hex(const char *str)
{
    uint32_t res = 0;
    // Skip optional "0x" prefix
    if (str[0] == '0' && (str[1] == 'x' || str[1] == 'X'))
    {
        str += 2;
    }
    while (*str)
    {
        uint8_t digit;
        if (*str >= '0' && *str <= '9')
        {
            digit = *str - '0';
        }
        else if (*str >= 'a' && *str <= 'f')
        {
            digit = *str - 'a' + 10;
        }
        else if (*str >= 'A' && *str <= 'F')
        {
            digit = *str - 'A' + 10;
        }
        else
        {
            break; // Invalid character
        }
        res = (res << 4) | digit;
        str++;
    }
    return res;
}

// Converts a decimal string to an unsigned 32-bit integer.
uint32_t strtoul_dec(const char *str)
{
    uint32_t res = 0;
    while (*str >= '0' && *str <= '9')
    {
        res = res * 10 + (*str - '0');
        str++;
    }
    return res;
}

// --- Shell Command Handlers ---

// Handles the "dump_memory" command.
// Usage: dump_memory <start_addr_hex> <length_hex/dec>
void handle_dump_memory(const char *args)
{
    uint32_t start_addr;
    uint32_t length;
    const char *ptr = args;

    // Parse start address (hex)
    start_addr = strtoul_hex(ptr);
    while (*ptr && *ptr != ' ') ptr++; // Move past address string
    while (*ptr == ' ') ptr++;         // Move past any spaces

    // Parse length (hex or decimal)
    if (*ptr == '\0') { // No length argument provided
        length = 0;
    } else if (ptr[0] == '0' && (ptr[1] == 'x' || ptr[1] == 'X')) { // Hex length
        length = strtoul_hex(ptr);
    } else { // Decimal length
        length = strtoul_dec(ptr);
    }

    if (length == 0 || args == NULL || *args == '\0')
    {
        print_str("Error: Invalid arguments. Usage: dump_memory <start_addr_hex> <length_hex/dec>");
        print_newline();
        return;
    }

    print_str("Dumping memory from 0x");
    print_hex_word(start_addr);
    print_str(" for ");
    print_hex_word(length); // Print length in hex for consistency
    print_str(" bytes:");
    print_newline();

    for (uint32_t i = 0; i < length; ++i)
    {
        if ((i % 16) == 0) // Print address every 16 bytes
        {
            if (i != 0) print_newline();
            print_hex_word(start_addr + i);
            print_str(": ");
        }
        print_hex_byte(*(volatile uint8_t *)(start_addr + i)); // Read byte from memory
        uart_tx_char(' ');
    }
    print_newline();
}

// Handles the "read_flash" command.
// Usage: read_flash <start_addr_hex> <length_hex/dec>
void handle_read_flash(const char *args)
{
    uint32_t start_addr;
    uint32_t length;
    const char *ptr = args;

    start_addr = strtoul_hex(ptr);
    while (*ptr && *ptr != ' ') ptr++;
    while (*ptr == ' ') ptr++;
    if (*ptr == '\0') {
        length = 0;
    } else if (ptr[0] == '0' && (ptr[1] == 'x' || ptr[1] == 'X')) {
        length = strtoul_hex(ptr);
    } else {
        length = strtoul_dec(ptr);
    }

    if (length == 0 || args == NULL || *args == '\0')
    {
        print_str("Error: Invalid arguments. Usage: read_flash <start_addr_hex> <length_hex/dec>");
        print_newline();
        return;
    }

    // Basic check if address is within a defined 'flash' region.
    if (start_addr < FLASH_START_ADDR || (start_addr + length) > (FLASH_START_ADDR + FLASH_SIZE))
    {
        print_str("Warning: Address range (0x");
        print_hex_word(start_addr);
        print_str(" - 0x");
        print_hex_word(start_addr + length -1);
        print_str(") is outside typical FLASH region (0x");
        print_hex_word(FLASH_START_ADDR);
        print_str(" - 0x");
        print_hex_word(FLASH_START_ADDR + FLASH_SIZE - 1);
        print_str("). Reading anyway.");
        print_newline();
    }

    print_str("Reading flash from 0x");
    print_hex_word(start_addr);
    print_str(" for ");
    print_hex_word(length);
    print_str(" bytes:");
    print_newline();

    for (uint32_t i = 0; i < length; ++i)
    {
        if ((i % 16) == 0)
        {
            if (i != 0) print_newline();
            print_hex_word(start_addr + i);
            print_str(": ");
        }
        print_hex_byte(*(volatile uint8_t *)(start_addr + i)); // Read byte from flash
        uart_tx_char(' ');
    }
    print_newline();
}

// Handles the "get_config" command.
void handle_get_config(const char *args)
{
    (void)args; // Arguments are not used for this command

    print_str("System Configuration:");
    print_newline();

    print_str("  Device ID: 0x");
    print_hex_word(g_system_config.device_id);
    print_newline();

    print_str("  Firmware Version: ");
    print_hex_byte(g_system_config.firmware_version_major);
    uart_tx_char('.');
    print_hex_byte(g_system_config.firmware_version_minor);
    print_newline();

    print_str("  Sensor Type: 0x");
    print_hex_byte(g_system_config.sensor_type);
    print_newline();

    print_str("  Sampling Interval (ms): ");
    // Convert decimal to string for printing. Minimalist approach:
    char buf[12]; // Max 10 digits for uint32_t + null terminator
    uint32_t val = g_system_config.sampling_interval_ms;
    int i = sizeof(buf) - 1;
    buf[i--] = '\0';
    if (val == 0) {
        buf[i--] = '0';
    } else {
        while (val > 0 && i >= 0) {
            buf[i--] = (val % 10) + '0';
            val /= 10;
        }
    }
    print_str(&buf[i+1]);
    print_newline();

    print_str("  Device Name: ");
    print_str(g_system_config.device_name);
    print_newline();
}

// --- Debug Shell Implementation ---

#define MAX_COMMAND_LENGTH 64
static char command_buffer[MAX_COMMAND_LENGTH];
static uint8_t command_idx = 0;

// Prints the shell prompt.
void print_prompt(void)
{
    print_str("shell> ");
}

// Processes the received command from the shell buffer.
void process_command(void)
{
    command_buffer[command_idx] = '\0'; // Null-terminate the command string

    char *cmd = command_buffer;
    char *args = NULL;

    // Find the first space to separate the command from its arguments.
    for (uint8_t i = 0; i < command_idx; ++i)
    {
        if (command_buffer[i] == ' ')
        {
            command_buffer[i] = '\0';     // Null-terminate the command part
            args = &command_buffer[i+1];  // Arguments start after the space
            // Skip any leading spaces in the arguments string
            while (*args == ' ') args++;
            if (*args == '\0') args = NULL; // No actual arguments if only spaces followed
            break;
        }
    }

    if (streq(cmd, "dump_memory"))
    {
        handle_dump_memory(args);
    }
    else if (streq(cmd, "read_flash"))
    {
        handle_read_flash(args);
    }
    else if (streq(cmd, "get_config"))
    {
        handle_get_config(args);
    }
    else if (streq(cmd, "help"))
    {
        print_str("Available commands:");
        print_newline();
        print_str("  dump_memory <start_addr_hex> <length_hex/dec> - Dumps memory region.");
        print_newline();
        print_str("  read_flash <start_addr_hex> <length_hex/dec> - Reads flash memory region.");
        print_newline();
        print_str("  get_config - Displays system configuration.");
        print_newline();
        print_str("  help - Display this help message.");
        print_newline();
    }
    else if (cmd[0] != '\0') // If command is not empty but also not recognized
    {
        print_str("Unknown command: ");
        print_str(cmd);
        print_newline();
    }

    command_idx = 0; // Reset the command buffer index for the next command
}

// Main loop for the debug shell. Should be called periodically.
void debug_shell_run(void)
{
    char c = uart_rx_char(); // Blocks until a character is received

    if (c == '\r' || c == '\n') // Command termination (Enter key)
    {
        uart_tx_char('\r'); // Echo newline sequence for cleaner terminal output
        uart_tx_char('\n');
        process_command();
        print_prompt(); // Show prompt for next command
    }
    else if (c == 8 || c == 127) // Backspace or Delete key
    {
        if (command_idx > 0)
        {
            command_idx--;
            uart_tx_char(8);   // Move cursor back
            uart_tx_char(' '); // Overwrite the character with a space
            uart_tx_char(8);   // Move cursor back again
        }
    }
    else if (command_idx < (MAX_COMMAND_LENGTH - 1)) // Store character if buffer has space
    {
        command_buffer[command_idx++] = c;
        uart_tx_char(c); // Echo character back to the terminal
    }
    // Ignore character if buffer is full
}

// --- Main Application ---

int main(void)
{
    // 1. Initialize System Clocks, Watchdogs, etc. (MCU-specific startup routine)
    //    Example: SystemInit(); // Often provided by MCU vendor HAL/CMSIS

    // 2. Initialize the UART peripheral for the diagnostic console.
    uart_init();

    // 3. Configure JTAG pins for remote diagnostics.
    jtag_gpio_init();

    // Initial console messages
    print_newline();
    print_str("IoT Sensor Debug Console Initialized.");
    print_newline();
    print_str("Type 'help' for available commands.");
    print_newline();
    print_prompt();

    // Main application loop
    while (1)
    {
        // Continuously run the debug shell to monitor for commands
        debug_shell_run();

        // Add other main application tasks here.
        // For example, sensor readings, data processing, communication,
        // state machine updates, etc.
        // In a real application, you might use an RTOS or have non-blocking
        // UART receive with a state machine for the shell, to allow other
        // tasks to run concurrently.
    }

    return 0; // This line is typically not reached in embedded firmware
}