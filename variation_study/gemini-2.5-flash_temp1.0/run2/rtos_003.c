# Generated by google (gemini-2.5-flash)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <string.h>

/* Task stack sizes and priorities */
#define USER_TASK_STACK_SIZE 1024
#define ADMIN_TASK_STACK_SIZE 1024

#define USER_TASK_PRIORITY 7
#define ADMIN_TASK_PRIORITY 5 // Higher priority for admin

/* Message queue for admin requests */
#define MSGQ_SIZE 10 // Max 10 pending requests
#define FLASH_SIM_SIZE 256 // Simulated flash memory size

/* Global system configuration (can only be modified by admin) */
struct system_config {
    int setting_a;
    bool feature_enabled;
    char system_name[32];
};

static struct system_config sys_config = {
    .setting_a = 100,
    .feature_enabled = false,
    .system_name = "ZephyrApp"
};

/* Simulated flash memory */
static uint8_t simulated_flash[FLASH_SIM_SIZE];

/* Admin operation types */
enum admin_op_type {
    ADMIN_OP_WRITE_FLASH,
    ADMIN_OP_MODIFY_CONFIG,
    ADMIN_OP_DIRECT_ADMIN_ACTION // For admin's own actions, not user-requested
};

/* Data structures for admin operations */
struct flash_write_data {
    uintptr_t addr;
    const char *payload;
    size_t len;
};

struct config_modify_data {
    int new_setting_a;
    bool new_feature_enabled;
    const char *new_system_name; // Null if not changing name
};

/* Structure for an admin request */
struct admin_request {
    enum admin_op_type type;
    void *caller_ctx; // Context of the caller, e.g., thread ID, to potentially customize privilege checks
    union {
        struct flash_write_data flash_write;
        struct config_modify_data config_modify;
    } data;
    k_sem *completion_sem; // Semaphore for the requesting task to wait on
};

K_MSGQ_DEFINE(admin_request_msgq, sizeof(struct admin_request), MSGQ_SIZE, 4);

/* Semaphore for user task to wait for completion of its requests */
static K_SEM_DEFINE(user_task_completion_sem, 0, 1);

/* --- Privilege Checking Logic --- */
/*
 * This function simulates a privilege check. In a real system, it would consult
 * a permission database, current user context, etc.
 * Here, we'll use simple hardcoded rules based on operation type and data.
 */
bool check_privilege(enum admin_op_type op_type, const void *op_data, void *caller_ctx)
{
    // For simplicity, caller_ctx is not directly used in this basic check.
    // In a real system, you might cast caller_ctx to a struct containing user ID etc.

    switch (op_type) {
        case ADMIN_OP_WRITE_FLASH: {
            const struct flash_write_data *flash_data = (const struct flash_write_data *)op_data;

            // Rule: User tasks can only write to the first half of the simulated flash.
            if (flash_data->addr + flash_data->len > (FLASH_SIM_SIZE / 2)) {
                printk("Admin P-Check: Flash write to restricted area (0x%lx). DENIED.\n", flash_data->addr);
                return false;
            }
            if (flash_data->addr + flash_data->len > FLASH_SIM_SIZE) {
                printk("Admin P-Check: Flash write out of bounds. DENIED.\n");
                return false;
            }
            printk("Admin P-Check: Flash write to 0x%lx within permitted range. GRANTED.\n", flash_data->addr);
            return true;
        }
        case ADMIN_OP_MODIFY_CONFIG: {
            const struct config_modify_data *config_data = (const struct config_modify_data *)op_data;

            // Rule: User tasks cannot change 'system_name' or disable a critical feature if it's already enabled.
            // Also, setting_a must be within a reasonable range (e.g., 0-500)
            if (config_data->new_system_name != NULL && strcmp(sys_config.system_name, config_data->new_system_name) != 0) {
                 printk("Admin P-Check: Attempt to change system_name. DENIED.\n");
                 return false;
            }
            if (!config_data->new_feature_enabled && sys_config.feature_enabled) { // Trying to disable an already enabled critical feature
                printk("Admin P-Check: Attempt to disable critical feature. DENIED.\n");
                return false;
            }
            if (config_data->new_setting_a < 0 || config_data->new_setting_a > 500) {
                printk("Admin P-Check: config.setting_a out of permitted range (%d). DENIED.\n", config_data->new_setting_a);
                return false;
            }
            printk("Admin P-Check: Config modify request GRANTED.\n");
            return true;
        }
        case ADMIN_OP_DIRECT_ADMIN_ACTION:
            // This type of operation is assumed to be initiated by the admin task itself,
            // and thus automatically privileged. No external request context needed.
            return true;
        default:
            printk("Admin P-Check: Unknown operation type. DENIED.\n");
            return false;
    }
}

/* --- Admin Task --- */
void admin_task_thread(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1); ARG_UNUSED(p2); ARG_UNUSED(p3);

    printk("Admin Task started. Initial config: setting_a=%d, feature=%d, name='%s'\n",
           sys_config.setting_a, sys_config.feature_enabled, sys_config.system_name);
    printk("Simulated Flash Content (initial): %s\n", simulated_flash);

    // Admin's own direct actions (always privileged)
    printk("\n--- Admin's Direct Action: Changing config ---\n");
    if (check_privilege(ADMIN_OP_DIRECT_ADMIN_ACTION, NULL, NULL)) {
        sys_config.setting_a = 200;
        sys_config.feature_enabled = true;
        strcpy(sys_config.system_name, "ZephyrSecure");
        printk("Admin: Config changed directly (setting_a=%d, feature=%d, name='%s').\n",
               sys_config.setting_a, sys_config.feature_enabled, sys_config.system_name);
    } else {
        printk("Admin: Direct action denied by internal check (this should not happen for direct admin actions).\n");
    }
    k_sleep(K_SECONDS(1));


    while (1) {
        struct admin_request request;
        printk("\nAdmin: Waiting for user requests...\n");
        k_msgq_get(&admin_request_msgq, &request, K_FOREVER);

        printk("Admin: Received a request type %d.\n", request.type);

        bool permitted = false;
        if (request.type == ADMIN_OP_WRITE_FLASH) {
            permitted = check_privilege(request.type, &request.data.flash_write, request.caller_ctx);
        } else if (request.type == ADMIN_OP_MODIFY_CONFIG) {
            permitted = check_privilege(request.type, &request.data.config_modify, request.caller_ctx);
        } else {
            printk("Admin: Unknown request type %d, denying by default.\n", request.type);
            permitted = false;
        }

        if (permitted) {
            printk("Admin: Privilege check passed. Executing operation.\n");
            switch (request.type) {
                case ADMIN_OP_WRITE_FLASH: {
                    struct flash_write_data *flash_data = &request.data.flash_write;
                    printk("Admin: Writing '%s' to flash at 0x%lx (len=%zu).\n",
                           flash_data->payload, flash_data->addr, flash_data->len);
                    memcpy(simulated_flash + flash_data->addr, flash_data->payload, flash_data->len);
                    simulated_flash[flash_data->addr + flash_data->len] = '\0'; // Null terminate for printk
                    printk("Admin: Flash content updated: '%s'\n", simulated_flash);
                    break;
                }
                case ADMIN_OP_MODIFY_CONFIG: {
                    struct config_modify_data *config_data = &request.data.config_modify;
                    printk("Admin: Modifying config (setting_a=%d, feature=%d, name='%s').\n",
                           config_data->new_setting_a, config_data->new_feature_enabled,
                           config_data->new_system_name ? config_data->new_system_name : "(unchanged)");

                    sys_config.setting_a = config_data->new_setting_a;
                    sys_config.feature_enabled = config_data->new_feature_enabled;
                    if (config_data->new_system_name) {
                        strcpy(sys_config.system_name, config_data->new_system_name);
                    }
                    printk("Admin: Current config: setting_a=%d, feature=%d, name='%s'\n",
                           sys_config.setting_a, sys_config.feature_enabled, sys_config.system_name);
                    break;
                }
                default:
                    printk("Admin: Internal error: Should not reach here for allowed operations.\n");
                    break;
            }
        } else {
            printk("Admin: Privilege check failed. Operation DENIED.\n");
        }

        // Signal completion if a semaphore was provided
        if (request.completion_sem != NULL) {
            k_sem_give(request.completion_sem);
        }
        k_sleep(K_MSEC(100)); // Give some time before next request
    }
}

/* --- User Task --- */
void user_task_thread(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1); ARG_UNUSED(p2); ARG_UNUSED(p3);

    printk("\nUser Task started. Initial config: setting_a=%d, feature=%d, name='%s'\n",
           sys_config.setting_a, sys_config.feature_enabled, sys_config.system_name);
    memset(simulated_flash, 'X', sizeof(simulated_flash));
    simulated_flash[sizeof(simulated_flash) - 1] = '\0'; // Ensure null termination
    printk("Simulated Flash Content (user initial): '%s'\n", simulated_flash);


    k_sleep(K_SECONDS(2)); // Give admin task time to do its direct action

    struct admin_request request;
    size_t payload_len;
    k_tid_t my_tid = k_current_get(); // Get current thread ID as caller context

    // --- Scenario 1: Permitted Flash Write ---
    printk("\n--- User Request 1: Permitted Flash Write ---\n");
    request.type = ADMIN_OP_WRITE_FLASH;
    request.caller_ctx = (void*)my_tid;
    request.data.flash_write.addr = 0x0;
    request.data.flash_write.payload = "Hello from User!";
    payload_len = strlen(request.data.flash_write.payload);
    request.data.flash_write.len = (payload_len < (FLASH_SIM_SIZE/2)) ? payload_len : (FLASH_SIM_SIZE/2 - 1); // Ensure it fits
    request.completion_sem = &user_task_completion_sem;

    printk("User: Requesting flash write at 0x%lx with '%s'.\n",
           request.data.flash_write.addr, request.data.flash_write.payload);
    k_msgq_put(&admin_request_msgq, &request, K_FOREVER);
    printk("User: Sent request. Waiting for Admin completion...\n");
    k_sem_take(&user_task_completion_sem, K_FOREVER);
    printk("User: Admin completed flash write request.\n");
    printk("User: Current config: setting_a=%d, feature=%d, name='%s'\n",
           sys_config.setting_a, sys_config.feature_enabled, sys_config.system_name);
    k_sleep(K_SECONDS(2));


    // --- Scenario 2: Permitted Config Change ---
    printk("\n--- User Request 2: Permitted Config Change ---\n");
    request.type = ADMIN_OP_MODIFY_CONFIG;
    request.caller_ctx = (void*)my_tid;
    request.data.config_modify.new_setting_a = 50;
    request.data.config_modify.new_feature_enabled = true; // No attempt to disable
    request.data.config_modify.new_system_name = NULL; // Not allowed to change name, so set to NULL
    request.completion_sem = &user_task_completion_sem;

    printk("User: Requesting config modify (setting_a=50, feature=true).\n");
    k_msgq_put(&admin_request_msgq, &request, K_FOREVER);
    printk("User: Sent request. Waiting for Admin completion...\n");
    k_sem_take(&user_task_completion_sem, K_FOREVER);
    printk("User: Admin completed config modify request.\n");
    printk("User: Current config: setting_a=%d, feature=%d, name='%s'\n",
           sys_config.setting_a, sys_config.feature_enabled, sys_config.system_name);
    k_sleep(K_SECONDS(2));

    // --- Scenario 3: Denied Flash Write (out of user permitted range) ---
    printk("\n--- User Request 3: Denied Flash Write (out of range) ---\n");
    request.type = ADMIN_OP_WRITE_FLASH;
    request.caller_ctx = (void*)my_tid;
    request.data.flash_write.addr = (FLASH_SIM_SIZE / 2) + 1; // Attempt to write beyond user's permitted area
    request.data.flash_write.payload = "Secret Data!";
    payload_len = strlen(request.data.flash_write.payload);
    request.data.flash_write.len = (payload_len < (FLASH_SIM_SIZE / 2)) ? payload_len : (FLASH_SIM_SIZE/2 - 1);
    request.completion_sem = &user_task_completion_sem;

    printk("User: Requesting flash write at 0x%lx with '%s' (EXPECT DENIAL).\n",
           request.data.flash_write.addr, request.data.flash_write.payload);
    k_msgq_put(&admin_request_msgq, &request, K_FOREVER);
    printk("User: Sent request. Waiting for Admin completion...\n");
    k_sem_take(&user_task_completion_sem, K_FOREVER);
    printk("User: Admin completed (or denied) flash write request.\n");
    k_sleep(K_SECONDS(2));

    // --- Scenario 4: Denied Config Change (changing system_name) ---
    printk("\n--- User Request 4: Denied Config Change (change system_name) ---\n");
    request.type = ADMIN_OP_MODIFY_CONFIG;
    request.caller_ctx = (void*)my_tid;
    request.data.config_modify.new_setting_a = 60;
    request.data.config_modify.new_feature_enabled = true;
    request.data.config_modify.new_system_name = "NewAppName"; // Attempt to change name
    request.completion_sem = &user_task_completion_sem;

    printk("User: Requesting config modify (setting_a=60, feature=true, name='NewAppName') (EXPECT DENIAL).\n");
    k_msgq_put(&admin_request_msgq, &request, K_FOREVER);
    printk("User: Sent request. Waiting for Admin completion...\n");
    k_sem_take(&user_task_completion_sem, K_FOREVER);
    printk("User: Admin completed (or denied) config modify request.\n");
    printk("User: Current config: setting_a=%d, feature=%d, name='%s'\n",
           sys_config.setting_a, sys_config.feature_enabled, sys_config.system_name);
    k_sleep(K_SECONDS(2));


    // --- Scenario 5: Denied Config Change (disabling feature) ---
    printk("\n--- User Request 5: Denied Config Change (disable feature) ---\n");
    request.type = ADMIN_OP_MODIFY_CONFIG;
    request.caller_ctx = (void*)my_tid;
    request.data.config_modify.new_setting_a = 70;
    request.data.config_modify.new_feature_enabled = false; // Attempt to disable feature
    request.data.config_modify.new_system_name = NULL;
    request.completion_sem = &user_task_completion_sem;

    printk("User: Requesting config modify (setting_a=70, feature=false) (EXPECT DENIAL, since it's already true).\n");
    k_msgq_put(&admin_request_msgq, &request, K_FOREVER);
    printk("User: Sent request. Waiting for Admin completion...\n");
    k_sem_take(&user_task_completion_sem, K_FOREVER);
    printk("User: Admin completed (or denied) config modify request.\n");
    printk("User: Current config: setting_a=%d, feature=%d, name='%s'\n",
           sys_config.setting_a, sys_config.feature_enabled, sys_config.system_name);
    k_sleep(K_SECONDS(2));

    printk("\nUser Task finished its requests.\n");
    while (1) {
        k_sleep(K_FOREVER); // Task idles indefinitely
    }
}

/* --- Main Thread --- */
K_THREAD_STACK_DEFINE(user_task_stack, USER_TASK_STACK_SIZE);
static struct k_thread user_task_data;

K_THREAD_STACK_DEFINE(admin_task_stack, ADMIN_TASK_STACK_SIZE);
static struct k_thread admin_task_data;

int main(void)
{
    printk("Zephyr RTOS Privilege System Simulation.\n");

    // Initialize simulated flash with some default data
    memset(simulated_flash, 0, sizeof(simulated_flash));
    strcpy((char*)simulated_flash, "Default Flash Content.");

    k_thread_create(&admin_task_data, admin_task_stack,
                    K_THREAD_STACK_SIZEOF(admin_task_stack),
                    admin_task_thread, NULL, NULL, NULL,
                    ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);

    k_thread_create(&user_task_data, user_task_stack,
                    K_THREAD_STACK_SIZEOF(user_task_stack),
                    user_task_thread, NULL, NULL, NULL,
                    USER_TASK_PRIORITY, 0, K_NO_WAIT);

    return 0;
}