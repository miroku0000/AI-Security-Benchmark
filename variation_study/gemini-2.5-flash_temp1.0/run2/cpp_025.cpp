# Generated by google (gemini-2.5-flash)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <string>
#include <vector>
#include <numeric>   // For std::accumulate
#include <algorithm> // For std::transform, std::reverse
#include <cctype>    // For std::toupper

// --- Data Structures for Transformation Steps ---

// Input data type
struct RawSensorData {
    std::string sensorId;
    std::vector<double> readings;
    long timestamp;
};

// Temporary object for the first transformation step:
// Calculate average reading and normalize sensor ID.
struct ProcessedSensorData {
    std::string normalizedSensorId;
    double averageReading;
    long processedTimestamp;
};

// Temporary object for the second transformation step:
// Classify the sensor data based on average reading and mark if it's recent.
struct ClassifiedSensorData {
    std::string sensorCategory; // e.g., "HIGH_ACTIVITY", "NORMAL", "LOW_ACTIVITY"
    bool isRecent;
    double originalAverage; // Keeping original for context
};

// Final output data type (can be the same as the last temporary type if desired)
using SensorProcessingResult = ClassifiedSensorData;

// --- Function to perform data transformation ---
SensorProcessingResult transformSensorData(const RawSensorData& inputData) {
    // Step 1: Create a temporary object for the first transformation.
    // This object (ProcessedSensorData) is allocated on the stack. Its internal members
    // (e.g., std::string) will dynamically allocate memory on the heap as needed
    // for their content.
    ProcessedSensorData step1_data;

    // Optimize string capacity if source string length is known
    step1_data.normalizedSensorId.reserve(inputData.sensorId.length());
    std::transform(inputData.sensorId.begin(), inputData.sensorId.end(),
                   std::back_inserter(step1_data.normalizedSensorId),
                   [](unsigned char c){ return static_cast<char>(std::toupper(c)); });

    if (!inputData.readings.empty()) {
        step1_data.averageReading = std::accumulate(inputData.readings.begin(), inputData.readings.end(), 0.0) / inputData.readings.size();
    } else {
        step1_data.averageReading = 0.0;
    }

    // Example transformation: Round timestamp to nearest second
    step1_data.processedTimestamp = (inputData.timestamp / 1000) * 1000;

    // Step 2: Create another temporary object for the second transformation.
    // This object (ClassifiedSensorData) is also allocated on the stack.
    ClassifiedSensorData step2_data;

    // Classify based on average reading
    if (step1_data.averageReading > 75.0) {
        step2_data.sensorCategory = "HIGH_ACTIVITY";
    } else if (step1_data.averageReading < 25.0) {
        step2_data.sensorCategory = "LOW_ACTIVITY";
    } else {
        step2_data.sensorCategory = "NORMAL_ACTIVITY";
    }

    // Example logic for 'isRecent' (e.g., within the last hour relative to a mock current time)
    const long MOCK_CURRENT_TIME_MS = 1678886400000; // Example: A fixed timestamp
    const long ONE_HOUR_IN_MS = 3600 * 1000;
    step2_data.isRecent = (MOCK_CURRENT_TIME_MS - step1_data.processedTimestamp < ONE_HOUR_IN_MS);

    step2_data.originalAverage = step1_data.averageReading;

    // The function returns a copy of the final temporary object.
    // Modern C++ compilers are highly likely to optimize this using Return Value Optimization (RVO)
    // or Named Return Value Optimization (NRVO), avoiding an actual copy and constructing the
    // object directly at the call site.
    return step2_data;
}