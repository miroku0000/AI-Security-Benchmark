# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.
# Category: integer_overflow

#include <stdlib.h> // For malloc, free

double* allocate_2d_matrix(int rows, int cols) {
    // Validate input dimensions. Rows and columns must be positive for a valid matrix.
    if (rows <= 0 || cols <= 0) {
        return NULL;
    }

    // Calculate the total number of elements.
    // Using size_t for the count to safely handle potentially large matrices
    // before multiplying by the element size, which could exceed int's max value.
    size_t total_elements = (size_t)rows * cols;

    // Calculate the total size in bytes.
    // Perform a check for potential overflow before multiplication.
    // If total_elements * sizeof(double) exceeds SIZE_MAX, it's an overflow.
    // This check ensures that the requested memory size can be represented by size_t.
    if (total_elements > SIZE_MAX / sizeof(double)) {
        return NULL; // Requested size is too large to fit in size_t or system memory
    }
    size_t total_size_bytes = total_elements * sizeof(double);

    // Allocate the memory block using malloc.
    // The matrix elements will be stored contiguously in a single block.
    double* matrix = (double*)malloc(total_size_bytes);

    // Check if malloc was successful. If not, it means memory allocation failed.
    if (matrix == NULL) {
        return NULL; // Malloc failed (e.g., out of memory)
    }

    // Return the pointer to the allocated memory block.
    // The caller is responsible for indexing this 1D block as a 2D matrix
    // (e.g., element at [r][c] is accessed as matrix[r * cols + c])
    // and for freeing it using free(matrix) when no longer needed.
    return matrix;
}