# Generated by google (gemini-2.5-flash)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <stdint.h>
#include <string.h> // For memcpy

// --- Configuration Defines ---
// Maximum size of a network packet we expect to process.
// IMPORTANT: This value directly impacts the local stack buffer size and thus the task's total stack usage.
// For configMINIMAL_STACK_SIZE, this value must be very carefully chosen.
// An Ethernet MTU is typically 1500 bytes. If processing such packets, configMINIMAL_STACK_SIZE will be too small.
// For a very minimal system, maybe we're only dealing with small control packets.
// Example: 64 bytes for a small control packet. Adjust as per actual maximum packet size.
#define MAX_PACKET_SIZE          64U

// Queue length for incoming packet pointers.
#define PACKET_QUEUE_LENGTH      5U

// Priority for the packet processing task.
#define PACKET_PROCESSING_TASK_PRIORITY (tskIDLE_PRIORITY + 2)

// --- Type Definitions ---

// Structure to hold network packet data.
// In a real system, a network driver would typically fill such a structure or provide a raw buffer.
// For this example, we define it as a fixed-size buffer.
typedef struct
{
    uint8_t data[MAX_PACKET_SIZE];
    uint16_t length; // Actual length of valid data in the 'data' array
} NetworkPacket_t;

// --- Global Variables ---
static QueueHandle_t xPacketReceivedQueue; // Queue to receive pointers to NetworkPacket_t

// --- Private Function Prototypes ---
static void vPacketProcessingTask(void *pvParameters);

// --- Public Functions ---

/**
 * @brief Initializes and starts the network packet processing task.
 *        This function should be called before the FreeRTOS scheduler is started.
 */
void vStartNetworkPacketTask(void)
{
    // Create the queue to hold pointers to incoming packets.
    // The queue stores pointers (void*), so its item size is sizeof(NetworkPacket_t*).
    xPacketReceivedQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(NetworkPacket_t *));

    if (xPacketReceivedQueue == NULL)
    {
        // Failed to create the queue. This is a critical error.
        // In a real system, you might log this, assert, or enter an error state.
        configASSERT(xPacketReceivedQueue != NULL);
        return;
    }

    // Create the packet processing task.
    // The stack size is configMINIMAL_STACK_SIZE as requested.
    // WARNING: Be extremely careful with configMINIMAL_STACK_SIZE if MAX_PACKET_SIZE is large.
    //          A typical Ethernet packet (1500 bytes) + FreeRTOS task context + local variables
    //          will very likely overflow configMINIMAL_STACK_SIZE.
    //          The stack must accommodate:
    //          1. FreeRTOS task context (registers, etc.)
    //          2. Function call stack depth (the deepest call chain of this task)
    //          3. All local variables, including the 'localPacketBuffer' of MAX_PACKET_SIZE.
    //          For many systems, configMINIMAL_STACK_SIZE is only suitable for very basic tasks
    //          with minimal stack usage and no large local buffers. Network tasks often require
    //          more (e.g., 256 or 512 words depending on architecture/compiler/library usage).
    BaseType_t xReturned = xTaskCreate(
        vPacketProcessingTask,             // The function that implements the task.
        "NetProc",                         // The text name assigned to the task, for debug only.
        configMINIMAL_STACK_SIZE,          // The size of the stack to allocate to the task.
        NULL,                              // The parameter passed to the task (not used here).
        PACKET_PROCESSING_TASK_PRIORITY,   // The priority assigned to the task.
        NULL                               // The task handle is not required, so NULL is passed.
    );

    if (xReturned != pdPASS)
    {
        // Task creation failed. This is a critical error.
        configASSERT(xReturned == pdPASS);
    }
}

/**
 * @brief Task function that processes network packets.
 *        Receives packet pointers from a queue, copies data to a local stack buffer, and processes it.
 * @param pvParameters Not used in this task.
 */
static void vPacketProcessingTask(void *pvParameters)
{
    NetworkPacket_t *pxReceivedPacket; // Pointer to the packet received from the queue

    // Local buffer on the stack to hold packet data for processing.
    // This is where the received packet data will be copied.
    // The size of this buffer MUST be accounted for in the task's stack allocation.
    // If MAX_PACKET_SIZE is too large relative to configMINIMAL_STACK_SIZE, a stack overflow will occur.
    uint8_t localPacketBuffer[MAX_PACKET_SIZE];
    uint16_t localPacketLength;

    (void)pvParameters; // Suppress unused parameter warning

    for (;;)
    {
        // Wait indefinitely for a packet pointer to arrive in the queue.
        // xQueueReceive will return pdTRUE if an item was successfully received.
        if (xQueueReceive(xPacketReceivedQueue, &pxReceivedPacket, portMAX_DELAY) == pdTRUE)
        {
            // A packet pointer was received.
            configASSERT(pxReceivedPacket != NULL); // Ensure the pointer is valid

            // Check if the received packet's length exceeds our local buffer capacity.
            // This indicates a potential issue or truncation.
            if (pxReceivedPacket->length > MAX_PACKET_SIZE)
            {
                // Handle error: packet too large for local buffer.
                // For this example, we'll truncate the copy and process the part that fits.
                // In a real system, you might log a warning and discard the packet,
                // or allocate a larger buffer if possible.
                localPacketLength = MAX_PACKET_SIZE;
            }
            else
            {
                localPacketLength = pxReceivedPacket->length;
            }

            // Copy the received packet data into the local stack buffer.
            // This is the core requirement for optimizing RAM by avoiding heap allocation per packet in this task.
            memcpy(localPacketBuffer, pxReceivedPacket->data, localPacketLength);

            // IMPORTANT: Free the memory of the original NetworkPacket_t that was received from the queue.
            // This assumes the sender (e.g., network driver) allocated it using pvPortMalloc().
            vPortFree(pxReceivedPacket);
            pxReceivedPacket = NULL; // Clear pointer after freeing to prevent use-after-free issues

            // --- Process the packet using localPacketBuffer and localPacketLength ---
            // This is where your application-specific network packet processing logic goes.
            // Example:
            // if (localPacketLength > 0 && localPacketBuffer[0] == SOME_PROTOCOL_ID)
            // {
            //     // Process based on protocol type, parse headers, handle payload.
            //     // All processing will use the 'localPacketBuffer'.
            //     // e.g., vProcessIPPacket(localPacketBuffer, localPacketLength);
            // }
            // else
            // {
            //     // Handle unknown or invalid packet.
            // }

            // Simulate some processing time. Remove or adjust in a real application.
            vTaskDelay(pdMS_TO_TICKS(5)); 
        }
    }
}

// --- Example/Simulation Function (for testing purposes) ---

/**
 * @brief Simulates a network driver receiving a packet and sending it to the processing task.
 *        This function would typically be called from an ISR or a separate network reception task.
 *        It allocates a NetworkPacket_t on the FreeRTOS heap and sends its pointer to the queue.
 * @param pData Pointer to raw packet data.
 * @param usLength Length of the raw packet data.
 */
void vSimulatePacketReception(const uint8_t *pData, uint16_t usLength)
{
    // Allocate a new NetworkPacket_t structure on the FreeRTOS heap.
    // This memory will be freed by the vPacketProcessingTask after it copies the data.
    NetworkPacket_t *pxNewPacket = (NetworkPacket_t *)pvPortMalloc(sizeof(NetworkPacket_t));

    if (pxNewPacket != NULL)
    {
        // Ensure the length doesn't exceed our defined MAX_PACKET_SIZE
        pxNewPacket->length = (usLength < MAX_PACKET_SIZE) ? usLength : MAX_PACKET_SIZE;

        // Copy data into the allocated packet structure
        memcpy(pxNewPacket->data, pData, pxNewPacket->length);

        // Send the pointer to the newly allocated packet to the queue.
        // If called from an ISR, use xQueueSendFromISR. Otherwise, use xQueueSend.
        BaseType_t xHigherPriorityTaskWoken = pdFALSE;
        if (xPortIsInsideInterrupt())
        {
            xQueueSendFromISR(xPacketReceivedQueue, &pxNewPacket, &xHigherPriorityTaskWoken);
            portYIELD_FROM_ISR(xHigherPriorityTaskWoken);
        }
        else
        {
            // If the queue is full, we might block for a short time or return an error.
            // Here, we block indefinitely if the queue is full (for demonstration).
            // In a real system, you might use a timeout (e.g., 0 for no block, or a specific tick count)
            // and drop the packet if it cannot be queued.
            if (xQueueSend(xPacketReceivedQueue, &pxNewPacket, portMAX_DELAY) != pdPASS)
            {
                // Failed to send packet to queue, likely queue full. Free the allocated memory.
                vPortFree(pxNewPacket);
                // In a real system, you might log this error.
            }
        }
    }
    else
    {
        // Failed to allocate memory for the packet. This indicates a low memory condition.
        // In a real system, you would handle this error (e.g., log, critical error handler).
    }
}