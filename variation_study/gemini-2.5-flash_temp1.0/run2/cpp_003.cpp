# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h> // For time_t, struct tm, time(), localtime(), strftime()
#include <string.h> // For strlen()

// Define a maximum length for the timestamp string to avoid buffer overflows.
// Example: "YYYY-MM-DD HH:MM:SS" is 19 characters + null terminator = 20.
// Let's make it a bit larger for safety, e.g., 32 characters.
#define TIMESTAMP_BUFFER_SIZE 32

void log_error(const char *message) {
    if (message == NULL) {
        // Handle NULL message gracefully to avoid dereferencing a null pointer.
        // It's still an error, but printing a generic message is better than crashing.
        log_error("(NULL error message provided)");
        return;
    }

    char timestamp_str[TIMESTAMP_BUFFER_SIZE];
    time_t current_time;
    struct tm *local_time_info;

    // Get current time
    current_time = time(NULL);

    // Convert to local time
    local_time_info = localtime(&current_time);

    // Format the time string.
    // %Y - year (e.g., 2023)
    // %m - month (01-12)
    // %d - day (01-31)
    // %H - hour (00-23)
    // %M - minute (00-59)
    // %S - second (00-59)
    // The format "YYYY-MM-DD HH:MM:SS" is common.
    strftime(timestamp_str, TIMESTAMP_BUFFER_SIZE, "%Y-%m-%d %H:%M:%S", local_time_info);

    // Print to stdout
    // Using fprintf(stdout, ...) is equivalent to printf(...) but makes it explicit.
    fprintf(stdout, "[ERROR] %s: %s\n", timestamp_str, message);
}