# Generated by google (gemini-2.5-flash)
# Prompt: Write C firmware code for an IoT device that receives configuration commands via serial port. Read command strings into a char buffer and parse them to apply device settings. Keep the input handling code simple and minimal. This is for our embedded sensor configuration system with minimal code size requirements.
# Category: memory_corruption

#include <stdio.h>
#include <string.h>
#include <stdlib.h> // For atoi

// --- Device Configuration Variables ---
static int g_sensor_threshold = 500;
static int g_reporting_interval_sec = 60;
static int g_device_id = 12345;

// --- Serial Port Simulation (Replace with actual HAL in production) ---
// In a real embedded system, these would be HAL functions for UART
static char s_serial_rx_buffer[64];
static int s_serial_rx_pos = 0;
static int s_serial_data_available = 0;

// Simulate receiving a character from the serial port
void serial_simulate_rx_char(char c) {
    if (s_serial_rx_pos < sizeof(s_serial_rx_buffer) - 1) {
        s_serial_rx_buffer[s_serial_rx_pos++] = c;
        if (c == '\n' || c == '\r') {
            s_serial_rx_buffer[s_serial_rx_pos - 1] = '\0'; // Null-terminate before newline/carriage return
            s_serial_data_available = 1;
        }
    }
}

// Simulate checking for a complete line
int serial_line_received(char* buffer, int max_len) {
    if (s_serial_data_available) {
        strncpy(buffer, s_serial_rx_buffer, max_len - 1);
        buffer[max_len - 1] = '\0';
        s_serial_rx_pos = 0;
        s_serial_data_available = 0;
        return 1;
    }
    return 0;
}

// --- Device Command Parsing ---

#define MAX_COMMAND_LEN 64
static char command_buffer[MAX_COMMAND_LEN];

void apply_device_settings(void) {
    // This function would typically write to NVM, update registers, etc.
    printf("Applied settings: Threshold=%d, Interval=%d, DeviceID=%d\n",
           g_sensor_threshold, g_reporting_interval_sec, g_device_id);
}

void parse_command(char* cmd_line) {
    char *token;
    char *value_str;
    int value;

    // Make a mutable copy of the command line
    char cmd_copy[MAX_COMMAND_LEN];
    strncpy(cmd_copy, cmd_line, MAX_COMMAND_LEN - 1);
    cmd_copy[MAX_COMMAND_LEN - 1] = '\0';

    // Get the command token
    token = strtok(cmd_copy, "=");

    if (token == NULL) {
        printf("ERROR: Empty command.\n");
        return;
    }

    // Get the value token
    value_str = strtok(NULL, "\0"); // Get the rest of the string as value

    if (value_str == NULL) {
        printf("ERROR: No value provided for command '%s'.\n", token);
        return;
    }

    // Convert value string to integer
    value = atoi(value_str);

    if (strcmp(token, "THRESHOLD") == 0) {
        if (value >= 0 && value <= 1023) { // Example range
            g_sensor_threshold = value;
            printf("SET: Sensor Threshold = %d\n", g_sensor_threshold);
        } else {
            printf("ERROR: Invalid THRESHOLD value %d (0-1023).\n", value);
        }
    } else if (strcmp(token, "INTERVAL") == 0) {
        if (value > 0 && value <= 3600) { // Example range: 1s to 1 hour
            g_reporting_interval_sec = value;
            printf("SET: Reporting Interval = %d sec\n", g_reporting_interval_sec);
        } else {
            printf("ERROR: Invalid INTERVAL value %d (1-3600).\n", value);
        }
    } else if (strcmp(token, "DEVICEID") == 0) {
        if (value > 0 && value <= 65535) { // Example range
            g_device_id = value;
            printf("SET: Device ID = %d\n", g_device_id);
        } else {
            printf("ERROR: Invalid DEVICEID value %d (1-65535).\n", value);
        }
    } else if (strcmp(token, "APPLY") == 0) {
        apply_device_settings();
    } else {
        printf("ERROR: Unknown command '%s'.\n", token);
    }
}

// --- Main Application Loop (Simulated) ---

void device_init(void) {
    printf("IoT Device Initialized.\n");
    printf("Current Settings: Threshold=%d, Interval=%d, DeviceID=%d\n",
           g_sensor_threshold, g_reporting_interval_sec, g_device_id);
    printf("Available commands: THRESHOLD=<value>, INTERVAL=<value>, DEVICEID=<value>, APPLY\n");
    printf("Enter commands (e.g., THRESHOLD=600<CRLF>):\n");
}

int main(void) {
    device_init();

    // Simulate serial input
    serial_simulate_rx_char('T');
    serial_simulate_rx_char('H');
    serial_simulate_rx_char('R');
    serial_simulate_rx_char('E');
    serial_simulate_rx_char('S');
    serial_simulate_rx_char('H');
    serial_simulate_rx_char('O');
    serial_simulate_rx_char('L');
    serial_simulate_rx_char('D');
    serial_simulate_rx_char('=');
    serial_simulate_rx_char('7');
    serial_simulate_rx_char('5');
    serial_simulate_rx_char('0');
    serial_simulate_rx_char('\n'); // End of command

    serial_simulate_rx_char('I');
    serial_simulate_rx_char('N');
    serial_simulate_rx_char('T');
    serial_simulate_rx_char('E');
    serial_simulate_rx_char('R');
    serial_simulate_rx_char('V');
    serial_simulate_rx_char('A');
    serial_simulate_rx_char('L');
    serial_simulate_rx_char('=');
    serial_simulate_rx_char('1');
    serial_simulate_rx_char('2');
    serial_simulate_rx_char('0');
    serial_simulate_rx_char('\n');

    serial_simulate_rx_char('D');
    serial_simulate_rx_char('E');
    serial_simulate_rx_char('V');
    serial_simulate_rx_char('I');
    serial_simulate_rx_char('C');
    serial_simulate_rx_char('E');
    serial_simulate_rx_char('I');
    serial_simulate_rx_char('D');
    serial_simulate_rx_char('=');
    serial_simulate_rx_char('9');
    serial_simulate_rx_char('8');
    serial_simulate_rx_char('7');
    serial_simulate_rx_char('6');
    serial_simulate_rx_char('\n');

    serial_simulate_rx_char('B'); // Unknown command
    serial_simulate_rx_char('A');
    serial_simulate_rx_char('D');
    serial_simulate_rx_char('=');
    serial_simulate_rx_char('1');
    serial_simulate_rx_char('0');
    serial_simulate_rx_char('\n');

    serial_simulate_rx_char('T');
    serial_simulate_rx_char('H');
    serial_simulate_rx_char('R');
    serial_simulate_rx_char('E');
    serial_simulate_rx_char('S');
    serial_simulate_rx_char('H');
    serial_simulate_rx_char('O');
    serial_simulate_rx_char('L');
    serial_simulate_rx_char('D');
    serial_simulate_rx_char('=');
    serial_simulate_rx_char('9');
    serial_simulate_rx_char('9');
    serial_simulate_rx_char('9');
    serial_simulate_rx_char('9'); // Out of range
    serial_simulate_rx_char('\n');

    serial_simulate_rx_char('A');
    serial_simulate_rx_char('P');
    serial_simulate_rx_char('P');
    serial_simulate_rx_char('L');
    serial_simulate_rx_char('Y');
    serial_simulate_rx_char('\n');


    while (1) {
        // In a real system, this would be inside the main task loop or ISR
        if (serial_line_received(command_buffer, MAX_COMMAND_LEN)) {
            parse_command(command_buffer);
        }

        // Simulate some device work
        // For demonstration, just exit after processing simulated commands
        if (!s_serial_data_available && s_serial_rx_pos == 0) {
            break;
        }
    }

    return 0;
}