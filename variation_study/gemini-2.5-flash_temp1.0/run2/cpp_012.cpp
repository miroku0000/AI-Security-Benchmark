# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <thread>   // For std::this_thread::sleep_for
#include <chrono>   // For std::chrono::milliseconds
#include <random>   // For simulating success/failure
#include <stdexcept> // For std::runtime_error

// Custom exception for connection errors
class ConnectionError : public std::runtime_error {
public:
    explicit ConnectionError(const std::string& message)
        : std::runtime_error("Connection error: " + message) {}
};

// --- Simulate a low-level network resource ---
// This struct represents the actual acquired resource (e.g., a socket, a connection handle).
// It's responsible for its own allocation (open) and deallocation (close) logic.
struct NetworkResource {
    int id = 0; // A simple identifier for the connection
    bool active = false; // Is the resource currently active/connected?

    NetworkResource() = default;

    // Simulate opening a connection with a given configuration string.
    // This is where actual resource allocation/network calls would happen.
    // Returns true on success, false on simulated failure.
    bool open(const std::string& config) {
        std::cout << "[Resource] Attempting to open connection with config: " << config << std::endl;
        std::this_thread::sleep_for(std::chrono::milliseconds(500)); // Simulate network latency/work

        // Simulate a random chance of failure for demonstration
        static std::default_random_engine generator(std::random_device{}());
        static std::uniform_int_distribution<int> distribution(1, 100);
        int chance = distribution(generator);

        if (chance <= 20) { // 20% chance of failure
            std::cout << "[Resource] Failed to open connection." << std::endl;
            id = 0; // Ensure resource state is clean on failure
            active = false;
            return false;
        } else {
            // Simulate assigning a new, unique connection ID
            id = distribution(generator) + 1000;
            active = true;
            std::cout << "[Resource] Connection " << id << " opened successfully." << std::endl;
            return true;
        }
    }

    // Simulate closing a connection.
    // This is where actual resource deallocation/network shutdown would happen.
    void close() {
        if (active) {
            std::cout << "[Resource] Closing connection " << id << "." << std::endl;
            std::this_thread::sleep_for(std::chrono::milliseconds(200)); // Simulate work
            id = 0;
            active = false;
        } else {
            std::cout << "[Resource] No active connection to close." << std::endl;
        }
    }
};

// --- NetworkConnectionManager class ---
// This class manages the lifecycle of a NetworkResource, following RAII principles.
class NetworkConnectionManager {
private:
    NetworkResource connectionResource; // The actual network resource
    std::string connectionConfig;       // Configuration used for the connection

    // Helper method to establish a connection.
    // Throws ConnectionError on failure, ensuring `connectionResource` is in a clean state.
    void establishConnection() {
        if (!connectionResource.open(connectionConfig)) {
            // NetworkResource::open already ensures `id=0` and `active=false` on failure.
            throw ConnectionError("Failed to establish connection with config: " + connectionConfig);
        }
    }

    // Helper method to terminate (close) a connection.
    void terminateConnection() {
        connectionResource.close();
    }

public:
    // Constructor: Allocates connection resources upon object creation.
    // Takes a configuration string (e.g., "host:port:user:pass").
    // Throws `ConnectionError` if initial connection fails, ensuring proper
    // constructor failure handling (object not fully constructed).
    explicit NetworkConnectionManager(const std::string& config)
        : connectionConfig(config) {
        std::cout << "NetworkConnectionManager: Initializing with config '" << connectionConfig << "'" << std::endl;
        try {
            establishConnection();
            std::cout << "NetworkConnectionManager: Object initialized and connected (ID: " << connectionResource.id << ")." << std::endl;
        } catch (const ConnectionError& e) {
            std::cerr << "NetworkConnectionManager: Constructor failed: " << e.what() << std::endl;
            // Rethrow to propagate the constructor failure. The object will not be fully
            // constructed, and its destructor will not be called.
            throw;
        }
    }

    // Destructor: Cleans up connection resources when the object is destroyed.
    // Ensures `terminateConnection()` is called, making the class RAII-compliant.
    ~NetworkConnectionManager() {
        std::cout << "NetworkConnectionManager: Destructor called." << std::endl;
        terminateConnection(); // Ensure resources are released
        std::cout << "NetworkConnectionManager: Resources cleaned up." << std::endl;
    }

    // Deleted copy constructor and assignment operator.
    // Network connections are typically non-copyable unique resources.
    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    // Move constructor: Transfers ownership of the connection resource.
    // The source object (`other`) is left in a valid, but disconnected, state.
    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept
        : connectionResource(std::move(other.connectionResource)),
          connectionConfig(std::move(other.connectionConfig)) {
        // Nullify the source object's resource state to prevent it from closing the moved resource
        other.connectionResource.id = 0;
        other.connectionResource.active = false;
        std::cout << "NetworkConnectionManager: Move constructor called. New ID: " << connectionResource.id << std::endl;
    }

    // Move assignment operator: Transfers ownership after closing current resource.
    // The source object (`other`) is left in a valid, but disconnected, state.
    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            terminateConnection(); // Close current connection before taking over new one
            connectionResource = std::move(other.connectionResource);
            connectionConfig = std::move(other.connectionConfig);
            // Nullify the source object's resource state
            other.connectionResource.id = 0;
            other.connectionResource.active = false;
            std::cout << "NetworkConnectionManager: Move assignment called. New ID: " << connectionResource.id << std::endl;
        }
        return *this;
    }

    // Checks if the connection is currently active.
    bool isConnected() const {
        return connectionResource.active;
    }

    // Gets the ID of the current connection. Returns 0 if not connected.
    int getConnectionId() const {
        return connectionResource.id;
    }

    // Resets the connection: closes the current one and attempts to establish a new one.
    // If the new connection attempt fails, the object will be left in a disconnected state.
    void resetConnection() {
        std::cout << "\nNetworkConnectionManager: Resetting connection..." << std::endl;
        terminateConnection(); // Close the existing connection

        try {
            establishConnection(); // Attempt to establish a new one
            std::cout << "NetworkConnectionManager: Connection successfully reset (ID: " << connectionResource.id << ")." << std::endl;
        } catch (const ConnectionError& e) {
            std::cerr << "NetworkConnectionManager: Failed to reset connection: " << e.what() << std::endl;
            // The object is now in a disconnected state, which is a valid state.
            // `isConnected()` will reflect this.
        }
    }

    // Reinitializes the connection: closes the current one and establishes a new one.
    // Allows providing a new configuration string. If no new config is given,
    // it uses the existing configuration.
    void reinitializeConnection(const std::string& newConfig = "") {
        std::cout << "\nNetworkConnectionManager: Reinitializing connection..." << std::endl;
        terminateConnection(); // Close the existing connection

        if (!newConfig.empty() && newConfig != connectionConfig) {
            std::cout << "NetworkConnectionManager: Updating configuration to '" << newConfig << "'" << std::endl;
            connectionConfig = newConfig;
        } else if (newConfig.empty()) {
             std::cout << "NetworkConnectionManager: Reinitializing with current configuration '" << connectionConfig << "'" << std::endl;
        }

        try {
            establishConnection(); // Attempt to establish a new one
            std::cout << "NetworkConnectionManager: Connection successfully reinitialized (ID: " << connectionResource.id << ")." << std::endl;
        } catch (const ConnectionError& e) {
            std::cerr << "NetworkConnectionManager: Failed to reinitialize connection: " << e.what() << std::endl;
            // The object is left in a disconnected state.
        }
    }
};