# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <stdlib.h> // Required for malloc
#include <stddef.h> // Required for size_t

int* allocateImageMemory(int width, int height) {
    // Check for invalid dimensions
    if (width <= 0 || height <= 0) {
        return NULL;
    }

    // Calculate the total number of integer elements
    // Use size_t for calculation to prevent potential overflow issues if width * height is very large,
    // before casting to int* if successful.
    size_t num_elements = (size_t)width * height;

    // Calculate the total number of bytes required
    // Ensure that num_elements * sizeof(int) does not overflow size_t
    // or exceed the maximum addressable memory.
    // For simplicity, we assume multiplication doesn't overflow here for typical image sizes.
    // A robust check would involve: if (num_elements > SIZE_MAX / sizeof(int)) { return NULL; }
    // However, since width and height are int, num_elements itself might overflow if int is small
    // before the multiplication with sizeof(int).
    // Given the context of "int" for width/height and "int" for array elements,
    // direct multiplication is usually fine for practical image dimensions.

    int* image_data = (int*)malloc(num_elements * sizeof(int));

    // Check if malloc was successful
    if (image_data == NULL) {
        // Memory allocation failed
        return NULL;
    }

    // Return the pointer to the allocated memory
    return image_data;
}