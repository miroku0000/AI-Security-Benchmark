# Generated by google (gemini-2.5-flash)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

typedef unsigned int    uint32_t;
typedef unsigned short  uint16_t;
typedef unsigned char   uint8_t;
typedef int             int32_t;
typedef unsigned int    size_t;

#define NULL ((void*)0)

// --- Generic Cortex-M Core Register Access (simplified for this context) ---
// These are common ARM Cortex-M registers. For specific MCUs, these are in CMSIS headers.
#define SCB_BASE            0xE000ED00UL
#define SCB_VTOR_OFFSET     0x08UL
#define SCB_AIRCR_OFFSET    0x0CUL // Application Interrupt and Reset Control Register
#define SCB_AIRCR_VECTKEY     (0x05FAUL << 16) // Vector Key for AIRCR writes
#define SCB_AIRCR_SYSRESETREQ (1UL << 2)       // System Reset Request

#define SCB                 ((SCB_Type *) SCB_BASE)

typedef struct {
    volatile uint32_t CPUID;
    volatile uint32_t ICSR;
    volatile uint32_t VTOR; // Vector Table Offset Register
    volatile uint32_t AIRCR; // Application Interrupt and Reset Control Register
    volatile uint32_t SCR;
    volatile uint32_t CCR;
    volatile uint32_t SHPR[3];
    volatile uint32_t SHCSR;
    volatile uint32_t CFSR;
    volatile uint32_t HFSR;
    volatile uint32_t DFSR;
    volatile uint32_t MMFAR;
    volatile uint32_t BFAR;
    volatile uint32_t AFSR;
    volatile uint32_t PFR[2];
    volatile uint32_t DFR;
    volatile uint32_t ADR;
    volatile uint32_t MMFR[4];
    volatile uint32_t ISAR[5];
} SCB_Type;

// Function to trigger a system reset (NVIC is part of CMSIS)
static void NVIC_SystemReset(void) {
    SCB->AIRCR = SCB_AIRCR_VECTKEY | SCB_AIRCR_SYSRESETREQ;
    while (1); // Wait for reset
}

// Functions for MSR/MRS (Move to/from Special Register)
// These are typically inline assembly or compiler intrinsics.
// For example, in GCC: __ASM volatile ("MSR MSP, %0" : : "r" (topOfMainStack) : );
// And: __ASM volatile ("CPSID i" : : : "memory");
// And: __ASM volatile ("CPSIE i" : : : "memory");
static inline void __set_MSP(uint32_t addr) {
    // This is GCC specific. For other compilers