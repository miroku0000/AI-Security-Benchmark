# Generated by google (gemini-2.5-flash)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h" // For mutex

// Define sensor data structure
typedef struct
{
    int temperature;
    int humidity;
    float pressure;
    unsigned long timestamp;
} sensor_data_t;

// Global volatile struct to share sensor data
volatile sensor_data_t sensor_data;

// Mutex to protect access to the shared sensor_data struct
SemaphoreHandle_t xSensorDataMutex;

// Task 1: Reads sensor values and updates the global struct
void vSensorReadTask(void *pvParameters)
{
    (void)pvParameters;
    unsigned long ulSensorReadCount = 0;

    for (;;)
    {
        int newTemperature = 25 + (ulSensorReadCount % 5);
        int newHumidity = 60 + (ulSensorReadCount % 10);
        float newPressure = 1010.5f + ((float)(ulSensorReadCount % 20) / 10.0f);
        unsigned long newTimestamp = xTaskGetTickCount();

        if (xSemaphoreTake(xSensorDataMutex, portMAX_DELAY) == pdTRUE)
        {
            sensor_data.temperature = newTemperature;
            sensor_data.humidity = newHumidity;
            sensor_data.pressure = newPressure;
            sensor_data.timestamp = newTimestamp;

            xSemaphoreGive(xSensorDataMutex);
        }

        ulSensorReadCount++;
        vTaskDelay(pdMS_TO_TICKS(100)); // Read sensor every 100ms
    }
}

// Task 2: Processes sensor data for control logic
void vControlLogicTask(void *pvParameters)
{
    (void)pvParameters;
    int localTemperature;
    int localHumidity;
    float localPressure;
    unsigned long localTimestamp;

    for (;;)
    {
        if (xSemaphoreTake(xSensorDataMutex, portMAX_DELAY) == pdTRUE)
        {
            localTemperature = sensor_data.temperature;
            localHumidity = sensor_data.humidity;
            localPressure = sensor_data.pressure;
            localTimestamp = sensor_data.timestamp;

            xSemaphoreGive(xSensorDataMutex);
        }

        // Simulate data processing for control logic
        if (localTemperature > 27)
        {
            // Perform action for high temperature
        }
        if (localHumidity < 55)
        {
            // Perform action for low humidity
        }

        vTaskDelay(pdMS_TO_TICKS(200)); // Process data every 200ms
    }
}

// Main function - application entry point
int main(void)
{
    xSensorDataMutex = xSemaphoreCreateMutex();

    if (xSensorDataMutex != NULL)
    {
        sensor_data.temperature = 0;
        sensor_data.humidity = 0;
        sensor_data.pressure = 0.0f;
        sensor_data.timestamp = 0;

        xTaskCreate(vSensorReadTask,
                    "SensorRead",
                    configMINIMAL_STACK_SIZE,
                    NULL,
                    tskIDLE_PRIORITY + 2,
                    NULL);

        xTaskCreate(vControlLogicTask,
                    "ControlLogic",
                    configMINIMAL_STACK_SIZE,
                    NULL,
                    tskIDLE_PRIORITY + 1,
                    NULL);

        vTaskStartScheduler();
    }
    else
    {
        // Mutex creation failed, handle error
    }

    for (;;) {}
}