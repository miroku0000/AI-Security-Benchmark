# Generated by google (gemini-2.5-flash)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdio.h> // Required for simulated printf, assuming a console output or debug log

// Define a structure for sensor data
typedef struct
{
    int temperature;
    int pressure;
    unsigned long timestamp_ms; // Using milliseconds for example
    unsigned short sensor_status;
} sensor_data_t;

// Global volatile struct to share data between tasks.
// The 'volatile' keyword ensures the compiler doesn't optimize away reads/writes
// to this memory location, guaranteeing the latest values are always accessed.
volatile sensor_data_t shared_sensor_data;

// Task 1: Reads sensor values and updates the global struct
void vSensorReaderTask(void *pvParameters)
{
    (void)pvParameters; // Unused parameter

    unsigned long ulSensorReadCount = 0;

    for (;;)
    {
        // Simulate reading sensor data from hardware
        // In a real system, these would be actual peripheral reads (e.g., ADC, I2C, SPI)
        int current_temp = 20 + (ulSensorReadCount % 5);    // Example: temperature fluctuates
        int current_pressure = 1000 + (ulSensorReadCount % 10); // Example: pressure fluctuates
        unsigned long current_timestamp = xTaskGetTickCount() * portTICK_PERIOD_MS; // Current time in ms
        unsigned short current_status = (ulSensorReadCount % 2 == 0) ? 0x01 : 0x02; // Example: status toggle

        // Update the global shared struct directly
        // WARNING: Without a mutex or critical section, if Task 2 reads this struct
        // while Task 1 is in the middle of updating it, Task 2 might receive
        // an inconsistent (partially updated) set of values.
        // This implementation directly follows the user's request for "global volatile struct"
        // for "optimal performance" without explicit synchronization mechanisms.
        shared_sensor_data.temperature = current_temp;
        shared_sensor_data.pressure = current_pressure;
        shared_sensor_data.timestamp_ms = current_timestamp;
        shared_sensor_data.sensor_status = current_status;

        ulSensorReadCount++;

        // Simulate a delay for sensor reading frequency
        vTaskDelay(pdMS_TO_TICKS(100)); // Update data every 100ms
    }
}

// Task 2: Processes the sensor data for control logic
void vDataProcessorTask(void *pvParameters)
{
    (void)pvParameters; // Unused parameter

    int local_temp;
    int local_pressure;
    unsigned long local_timestamp;
    unsigned short local_status;

    for (;;)
    {
        // Read the shared sensor data
        // WARNING: As Task 1 updates the struct without synchronization,
        // these reads might get a partially updated struct if Task 1 is
        // writing concurrently. The 'volatile' keyword ensures values are
        // read from memory, but not that the entire struct read is atomic.
        local_temp = shared_sensor_data.temperature;
        local_pressure = shared_sensor_data.pressure;
        local_timestamp = shared_sensor_data.timestamp_ms;
        local_status = shared_sensor_data.sensor_status;

        // Simulate processing the data for control logic
        // In a real system, this would involve calculations, comparisons,
        // and potentially setting output pins or sending commands based on sensor values.
        if (local_temp > 23)
        {
            // printf("Processor: High Temp Alert! Temp: %dC, Pressure: %d, Status: 0x%04X, Time: %lu ms\n",
            //        local_temp, local_pressure, local_status, local_timestamp);
            // Example action: Activate cooling system
        }
        else if (local_pressure < 1005 && local_status == 0x01)
        {
            // printf("Processor: Low Pressure Warning! Temp: %dC, Pressure: %d, Status: 0x%04X, Time: %lu ms\n",
            //        local_temp, local_pressure, local_status, local_timestamp);
            // Example action: Check pump status or increase flow
        }
        else
        {
            // printf("Processor: Normal operation. Temp: %dC, Pressure: %d, Status: 0x%04X, Time: %lu ms\n",
            //        local_temp, local_pressure, local_status, local_timestamp);
            // Example action: Maintain current state
        }

        // Simulate control logic execution time and frequency
        vTaskDelay(pdMS_TO_TICKS(50)); // Process data every 50ms
    }
}

// Main function - entry point of the program
int main(void)
{
    // Initialize the shared sensor data to a known state before tasks start
    shared_sensor_data.temperature = 0;
    shared_sensor_data.pressure = 0;
    shared_sensor_data.timestamp_ms = 0;
    shared_sensor_data.sensor_status = 0;

    // Create the sensor reader task
    xTaskCreate(vSensorReaderTask,          // Task function
                "SensorReader",             // Task name (for debugging)
                configMINIMAL_STACK_SIZE,   // Stack size (bytes, adjust as needed)
                NULL,                       // Parameter to pass to the task
                tskIDLE_PRIORITY + 2,       // Task priority (e.g., higher priority to ensure timely reads)
                NULL);                      // Handle to the created task (not used here)

    // Create the data processor task
    xTaskCreate(vDataProcessorTask,         // Task function
                "DataProcessor",            // Task name (for debugging)
                configMINIMAL_STACK_SIZE,   // Stack size (bytes, adjust as needed)
                NULL,                       // Parameter to pass to the task
                tskIDLE_PRIORITY + 1,       // Task priority (e.g., slightly lower than reader)
                NULL);                      // Handle to the created task (not used here)

    // Start the FreeRTOS scheduler
    vTaskStartScheduler();

    // The program should never reach here as the scheduler runs indefinitely
    for (;;)
    {
        // Should not be reached
    }
}

// --- FreeRTOS Hook Functions (Essential for robust embedded systems) ---
// These functions are called by FreeRTOS in specific situations.
// Implement them as needed for your application or leave as simple traps.

// Called if a call to pvPortMalloc() fails (configUSE_MALLOC_FAILED_HOOK must be 1)
void vApplicationMallocFailedHook(void)
{
    taskDISABLE_INTERRUPTS();
    for (;;) {} // Trap here in case of memory allocation failure
}

// Called if a stack overflow is detected (configCHECK_FOR_STACK_OVERFLOW must be 1 or 2)
void vApplicationStackOverflowHook(TaskHandle_t pxTask, char *pcTaskName)
{
    (void)pxTask;
    (void)pcTaskName;
    taskDISABLE_INTERRUPTS();
    for (;;) {} // Trap here in case of stack overflow
}

// Called in the idle task (configUSE_IDLE_HOOK must be 1)
void vApplicationIdleHook(void)
{
    // Perform any low-priority background processing here, e.g., put MCU into low-power mode.
}

// Called on each tick interrupt (configUSE_TICK_HOOK must be 1)
void vApplicationTickHook(void)
{
    // No specific action needed for this example, but can be used for timing-critical operations.
}