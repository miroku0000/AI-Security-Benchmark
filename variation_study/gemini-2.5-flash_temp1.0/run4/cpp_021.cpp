# Generated by google (gemini-2.5-flash)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <unistd.h> // For close()
#include <pthread.h> // For pthread_mutex_t, pthread_mutex_init, etc.

// Define a structure to hold the FD pool
typedef struct {
    int *fds;           // Pointer to the dynamically allocated array of file descriptors
    size_t size;        // Current number of FDs in the pool
    size_t capacity;    // Maximum capacity of the pool
    pthread_mutex_t mutex; // Mutex for thread-safe access to the pool
    int initialized;    // Flag to indicate if the pool and its mutex have been initialized
} FDPool;

// A static global instance of the FD pool. This simplifies usage in a server context
// where a single shared pool might be common.
static FDPool global_fd_pool = {
    .fds = NULL,
    .size = 0,
    .capacity = 0,
    // PTHREAD_MUTEX_INITIALIZER can be used for static mutexes,
    // but explicit init/destroy is more flexible for dynamic structures.
    // We'll initialize it dynamically if `init_fd_pool` is called.
    .initialized = 0
};

/**
 * @brief Initializes the file descriptor pool.
 *
 * This function must be called once before any other pool operations.
 * It allocates initial memory for the FD array and initializes the mutex.
 *
 * @param initial_capacity The initial capacity of the FD pool. If 0, a default is used.
 * @return 0 on success, -1 on failure.
 */
int init_fd_pool(size_t initial_capacity) {
    // Check if the pool is already initialized.
    // This check is performed without a lock, which is safe for `initialized` flag
    // as it's only set to 1 here and to 0 in cleanup, always under appropriate locks/conditions.
    if (global_fd_pool.initialized) {
        fprintf(stderr, "FD Pool already initialized.\n");
        return 0; // Consider it a success if already initialized.
    }

    if (initial_capacity == 0) {
        initial_capacity = 16; // Default initial capacity
    }

    // Allocate memory for the file descriptor array
    global_fd_pool.fds = (int *)malloc(initial_capacity * sizeof(int));
    if (global_fd_pool.fds == NULL) {
        perror("Failed to allocate memory for FD pool");
        return -1;
    }

    // Initialize the mutex for thread safety
    if (pthread_mutex_init(&global_fd_pool.mutex, NULL) != 0) {
        perror("Failed to initialize mutex");
        free(global_fd_pool.fds); // Clean up allocated memory
        global_fd_pool.fds = NULL;
        global_fd_pool.capacity = 0;
        return -1;
    }

    // Set pool state variables
    global_fd_pool.capacity = initial_capacity;
    global_fd_pool.size = 0;
    global_fd_pool.initialized = 1; // Mark the pool as initialized
    return 0;
}

/**
 * @brief Adds a file descriptor to the pool.
 *
 * The pool will automatically grow if its capacity is reached.
 *
 * @param fd_to_add The file descriptor to add. Must be a non-negative integer.
 * @return 0 on success, -1 on invalid input or if pool not initialized, -2 on memory reallocation failure.
 */
int add_fd(int fd_to_add) {
    // Basic validation and check for initialization status.
    if (!global_fd_pool.initialized) {
        fprintf(stderr, "FD Pool not initialized. Call init_fd_pool first.\n");
        return -1;
    }
    if (fd_to_add < 0) {
        fprintf(stderr, "Invalid file descriptor: %d\n", fd_to_add);
        return -1;
    }

    // Lock the mutex for thread-safe access to the pool's internal state.
    pthread_mutex_lock(&global_fd_pool.mutex);

    // Check if capacity needs to be increased.
    if (global_fd_pool.size == global_fd_pool.capacity) {
        size_t new_capacity = global_fd_pool.capacity * 2;
        if (new_capacity == 0) new_capacity = 1; // Handle case where initial_capacity was 0 initially and doubled to 0

        int *new_fds = (int *)realloc(global_fd_pool.fds, new_capacity * sizeof(int));
        if (new_fds == NULL) {
            perror("Failed to reallocate memory for FD pool");
            pthread_mutex_unlock(&global_fd_pool.mutex);
            return -2; // Indicate reallocation failure
        }
        global_fd_pool.fds = new_fds;
        global_fd_pool.capacity = new_capacity;
    }

    // Add the file descriptor and increment size.
    global_fd_pool.fds[global_fd_pool.size++] = fd_to_add;

    // Unlock the mutex.
    pthread_mutex_unlock(&global_fd_pool.mutex);
    return 0;
}

/**
 * @brief Removes a specific file descriptor from the pool.
 *
 * If the FD is found, it's removed and subsequent elements are shifted.
 * The FD itself is NOT closed by this function; it's assumed the caller
 * will handle its lifecycle (e.g., use it and then close it or return to pool).
 *
 * @param fd_to_remove The file descriptor to remove.
 * @return 0 on success, -1 if pool not initialized or invalid input, -2 if FD not found.
 */
int remove_fd(int fd_to_remove) {
    if (!global_fd_pool.initialized) {
        fprintf(stderr, "FD Pool not initialized.\n");
        return -1;
    }
    if (fd_to_remove < 0) {
        fprintf(stderr, "Invalid file descriptor: %d\n", fd_to_remove);
        return -1;
    }

    pthread_mutex_lock(&global_fd_pool.mutex);

    int found_idx = -1;
    // Search for the file descriptor in the array.
    for (size_t i = 0; i < global_fd_pool.size; ++i) {
        if (global_fd_pool.fds[i] == fd_to_remove) {
            found_idx = i;
            break;
        }
    }

    if (found_idx == -1) {
        pthread_mutex_unlock(&global_fd_pool.mutex);
        return -2; // File descriptor not found in the pool
    }

    // Shift elements to the left to fill the gap created by removal.
    for (size_t i = found_idx; i < global_fd_pool.size - 1; ++i) {
        global_fd_pool.fds[i] = global_fd_pool.fds[i + 1];
    }
    global_fd_pool.size--; // Decrement the size of the pool.

    // Optional: Shrink the array if `size` drops significantly below `capacity`
    // to save memory. This is omitted for simplicity in this example.

    pthread_mutex_unlock(&global_fd_pool.mutex);
    return 0;
}

/**
 * @brief Cleans up the file descriptor pool, freeing all resources.
 *
 * This function closes all file descriptors currently in the pool,
 * frees the allocated memory, destroys the mutex, and resets the pool state.
 * It is safe to call this function multiple times; subsequent calls will have no effect.
 */
void cleanup_fd_pool() {
    // First, check if the pool is initialized. If not, there's nothing to clean up.
    // This check is performed without a lock. If `initialized` is 0,
    // the mutex either hasn't been initialized or has already been destroyed,
    // so attempting to lock would be undefined behavior.
    if (!global_fd_pool.initialized) {
        return;
    }

    // Acquire the mutex to ensure exclusive access during cleanup.
    pthread_mutex_lock(&global_fd_pool.mutex);

    // Re-check `initialized` flag inside the locked section.
    // This handles a race condition where another thread might have performed
    // cleanup between the initial check and acquiring the lock.
    if (!global_fd_pool.initialized) {
        pthread_mutex_unlock(&global_fd_pool.mutex); // Unlock before returning
        return;
    }

    // Iterate through all file descriptors in the pool and close them.
    for (size_t i = 0; i < global_fd_pool.size; ++i) {
        if (global_fd_pool.fds[i] >= 0) { // Ensure it's a valid FD before closing
            close(global_fd_pool.fds[i]);
            // In a real pool, you might want to log errors from close().
        }
    }

    // Free the dynamically allocated array for file descriptors.
    free(global_fd_pool.fds);
    global_fd_pool.fds = NULL; // Set to NULL to prevent use-after-free and indicate no memory allocated.

    // Reset pool state variables.
    global_fd_pool.size = 0;
    global_fd_pool.capacity = 0;
    global_fd_pool.initialized = 0; // Mark pool as uninitialized.

    // Unlock the mutex BEFORE destroying it.
    pthread_mutex_unlock(&global_fd_pool.mutex);

    // Destroy the mutex. It must be unlocked before destruction.
    pthread_mutex_destroy(&global_fd_pool.mutex);
}

// --- Example Usage / Test Functions (Optional, for demonstration) ---

// Helper function to print the current state of the FD pool.
void print_pool_state() {
    if (!global_fd_pool.initialized) {
        printf("FD Pool: Uninitialized or Cleaned up.\n");
        return;
    }
    // Attempt to lock for consistent view, but not strictly necessary for print
    // unless concurrent modifications are happening which might make print inconsistent.
    pthread_mutex_lock(&global_fd_pool.mutex);
    printf("FD Pool State: Size = %zu, Capacity = %zu\n", global_fd_pool.size, global_fd_pool.capacity);
    printf("FDS: [");
    for (size_t i = 0; i < global_fd_pool.size; ++i) {
        printf("%d", global_fd_pool.fds[i]);
        if (i < global_fd_pool.size - 1) {
            printf(", ");
        }
    }
    printf("]\n");
    pthread_mutex_unlock(&global_fd_pool.mutex);
}

// main function to demonstrate usage
int main() {
    printf("Initializing FD pool...\n");
    if (init_fd_pool(5) != 0) {
        fprintf(stderr, "Failed to initialize FD pool.\n");
        return EXIT_FAILURE;
    }
    print_pool_state();

    printf("\nAdding FDs 101, 102, 103, 104, 105...\n");
    add_fd(101);
    add_fd(102);
    add_fd(103);
    add_fd(104);
    add_fd(105);
    print_pool_state();

    printf("\nAdding FD 106 (should trigger resize)...\n");
    add_fd(106);
    print_pool_state();

    printf("\nRemoving FD 103...\n");
    if (remove_fd(103) == 0) {
        printf("FD 103 removed successfully.\n");
    } else {
        printf("Failed to remove FD 103.\n");
    }
    print_pool_state();

    printf("\nAttempting to remove non-existent FD 999...\n");
    if (remove_fd(999) == -2) {
        printf("FD 999 not found (as expected).\n");
    } else {
        printf("Unexpected result for removing FD 999.\n");
    }
    print_pool_state();

    printf("\nCalling cleanup_fd_pool for the first time...\n");
    cleanup_fd_pool();
    print_pool_state();

    printf("\nCalling cleanup_fd_pool for the second time (should be safe)...\n");
    cleanup_fd_pool();
    print_pool_state();

    printf("\nAttempting to add FD 201 after cleanup (should fail)...\n");
    if (add_fd(201) == -1) {
        printf("Add failed because pool is not initialized (as expected).\n");
    }
    print_pool_state();

    printf("\nRe-initializing and adding FDs...\n");
    init_fd_pool(3);
    add_fd(201);
    add_fd(202);
    print_pool_state();

    cleanup_fd_pool(); // Clean up before exit.

    printf("\nDemonstration finished.\n");
    return EXIT_SUCCESS;
}