# Generated by google (gemini-2.5-flash)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <algorithm>
#include <sstream>
#include <utility> // For std::move

// Input data structure
struct DataIn {
    int id;
    double value;
};

// Output data structure
struct DataOut {
    std::string description;
    double processed_value;

    // Constructor to set values
    DataOut(std::string desc, double val) : description(std::move(desc)), processed_value(val) {}
};

// Function to perform data transformation
std::vector<DataOut> transformData(const std::vector<DataIn>& input_data, double factor) {
    // --- Step 1: Filter Data ---
    // Creates a temporary std::vector to store filtered items.
    // Its internal buffer is allocated on the heap as needed and freed when 'filtered_data' goes out of scope.
    std::vector<DataIn> filtered_data;
    // Reserve capacity to reduce reallocations during push_back, optimizing heap usage.
    filtered_data.reserve(input_data.size()); 

    for (const auto& item : input_data) {
        // Example filter: only include items with an even ID
        if (item.id % 2 == 0) {
            filtered_data.push_back(item);
        }
    }

    // --- Step 2: Process Values ---
    // Creates another temporary std::vector to store intermediate processed double values.
    // Its internal buffer is allocated on the heap as needed and freed when 'processed_values' goes out of scope.
    std::vector<double> processed_values;
    // Reserve capacity to reduce reallocations.
    processed_values.reserve(filtered_data.size()); 

    for (const auto& item : filtered_data) {
        // 'temp_processed_value' is a stack-allocated temporary double.
        // It is created "as needed" for each iteration and destroyed immediately after use.
        double temp_processed_value = item.value * factor + 10.0; 
        processed_values.push_back(temp_processed_value);
    }

    // --- Step 3: Format Output ---
    // Creates the final std::vector of DataOut objects.
    // Its internal buffer is allocated on the heap.
    // Each DataOut contains a std::string, which might also involve heap allocation
    // if its content is large (exceeding Small String Optimization capacity).
    std::vector<DataOut> output_data;
    // Reserve capacity to reduce reallocations.
    output_data.reserve(filtered_data.size()); 

    for (size_t i = 0; i < filtered_data.size(); ++i) {
        const auto& original_item = filtered_data[i];
        double final_processed_value = processed_values[i];

        // 'oss' is a stack-allocated temporary std::ostringstream object.
        // It is created "as needed" for each iteration and destroyed immediately.
        std::ostringstream oss;
        oss << "ID_" << original_item.id;
        
        // 'temp_description' is a temporary std::string object.
        // It is created "as needed" to hold the formatted ID, potentially involving heap allocation for its buffer.
        // It is then moved into the DataOut object, avoiding a copy.
        std::string temp_description = oss.str(); 

        // A DataOut object is constructed directly in the vector's allocated memory (using emplace_back).
        // This is a temporary object that lives within the vector's scope.
        output_data.emplace_back(std::move(temp_description), final_processed_value);
    }

    // Return the final transformed data.
    // Modern C++ compilers (C++11 and later) typically apply Return Value Optimization (RVO/NRVO)
    // or use move semantics to construct 'output_data' directly in the caller's memory or
    // move it efficiently, avoiding a deep copy of the vector.
    return output_data;
}