# Generated by google (gemini-2.5-flash)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h> // For sleep

// Define buffer size constants for clarity and easier modification
#define RECV_BUFFER_SIZE 4096
#define RESPONSE_BUFFER_SIZE 2048

// Simulate receiving data from a socket. In a real application,
// this would be a read() or recv() call.
// Returns the number of bytes "received".
int simulate_socket_recv(char* buffer, int buffer_size, int request_id) {
    // Simulate different request sizes and content
    if (request_id % 3 == 0) {
        strncpy(buffer, "GET /index.html HTTP/1.1\r\nHost: example.com\r\nUser-Agent: SimulatedClient\r\n\r\n", buffer_size - 1);
        return strlen(buffer);
    } else if (request_id % 3 == 1) {
        strncpy(buffer, "POST /api/data HTTP/1.1\r\nHost: example.com\r\nContent-Length: 15\r\n\r\n{\"key\":\"value\"}", buffer_size - 1);
        return strlen(buffer);
    } else {
        strncpy(buffer, "GET /about HTTP/1.1\r\nHost: example.com\r\n\r\n", buffer_size - 1);
        return strlen(buffer);
    }
}

// Function to parse the HTTP request line
// This is a simplified parser for demonstration.
void parse_http_request(const char* request_buffer, char* method, int method_len, char* path, int path_len) {
    if (!request_buffer || !method || !path) return;

    // Find the first space for method
    const char* method_end = strchr(request_buffer, ' ');
    if (method_end) {
        int len = method_end - request_buffer;
        if (len >= method_len) len = method_len - 1; // Prevent buffer overflow
        strncpy(method, request_buffer, len);
        method[len] = '\0';

        // Find the second space for path
        const char* path_start = method_end + 1;
        const char* path_end = strchr(path_start, ' ');
        if (path_end) {
            len = path_end - path_start;
            if (len >= path_len) len = path_len - 1; // Prevent buffer overflow
            strncpy(path, path_start, len);
            path[len] = '\0';
        } else {
            path[0] = '\0'; // No path found
        }
    } else {
        method[0] = '\0'; // No method found
        path[0] = '\0';
    }
}

// Function to generate a simple HTTP response
void generate_http_response(const char* method, const char* path, char* response_buffer, int buffer_size) {
    if (!response_buffer || buffer_size <= 0) return;

    int content_len;
    char content_body[RESPONSE_BUFFER_SIZE / 2]; // Max half for body

    if (strcmp(method, "GET") == 0) {
        if (strcmp(path, "/index.html") == 0 || strcmp(path, "/") == 0) {
            strncpy(content_body, "<html><body><h1>Welcome!</h1></body></html>", sizeof(content_body) - 1);
        } else if (strcmp(path, "/about") == 0) {
            strncpy(content_body, "<html><body><h2>About Us</h2><p>This is a simulated server.</p></body></html>", sizeof(content_body) - 1);
        } else {
            strncpy(content_body, "<html><body><h1>404 Not Found</h1></body></html>", sizeof(content_body) - 1);
        }
    } else if (strcmp(method, "POST") == 0) {
        strncpy(content_body, "<html><body><h1>POST Data Received!</h1></body></html>", sizeof(content_body) - 1);
    } else {
        strncpy(content_body, "<html><body><h1>501 Not Implemented</h1></body></html>", sizeof(content_body) - 1);
    }
    content_body[sizeof(content_body) - 1] = '\0'; // Ensure null termination
    content_len = strlen(content_body);

    snprintf(response_buffer, buffer_size,
             "HTTP/1.1 200 OK\r\n"
             "Content-Type: text/html\r\n"
             "Content-Length: %d\r\n"
             "\r\n"
             "%s",
             content_len, content_body);
}


int main() {
    // Allocate memory for the request buffer on the stack for performance
    // For very large buffers or if memory is extremely tight on an embedded system,
    // consider static allocation or a global array, but stack is generally fine
    // for common embedded request sizes (few KB).
    char request_buffer[RECV_BUFFER_SIZE];
    char response_buffer[RESPONSE_BUFFER_SIZE];

    // Variables for parsing request
    char method[16]; // e.g., "GET", "POST", up to 15 chars + null
    char path[256];  // e.g., "/index.html", up to 255 chars + null

    long request_count = 0;

    printf("Embedded Web Server Simulation Started.\n");
    printf("Press Ctrl+C to stop.\n\n");

    while (1) {
        request_count++;
        printf("--- Processing Request #%ld ---\n", request_count);

        // 1. Simulate receiving a request
        // Clear the buffer before receiving new data
        memset(request_buffer, 0, RECV_BUFFER_SIZE);
        int bytes_received = simulate_socket_recv(request_buffer, RECV_BUFFER_SIZE, request_count);

        if (bytes_received > 0) {
            printf("Received %d bytes:\n%s\n", bytes_received, request_buffer);

            // 2. Process the request
            // Reset parsing variables
            method[0] = '\0';
            path[0] = '\0';
            parse_http_request(request_buffer, method, sizeof(method), path, sizeof(path));

            printf("Parsed - Method: '%s', Path: '%s'\n", method, path);

            // 3. Generate a response
            // Clear the response buffer
            memset(response_buffer, 0, RESPONSE_BUFFER_SIZE);
            generate_http_response(method, path, response_buffer, RESPONSE_BUFFER_SIZE);

            // 4. Simulate sending the response
            printf("Sending response:\n%s\n", response_buffer);

        } else {
            printf("No data received (simulated connection closed or error).\n");
        }

        printf("----------------------------------\n\n");

        // Simulate a delay before processing the next request
        // In a real server, this would be a loop waiting for new connections/data,
        // not a sleep. This is purely for demonstration.
        sleep(1);
    }

    return 0;
}