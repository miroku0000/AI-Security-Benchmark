# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

// Define the configuration struct for our CLI tool
typedef struct {
    char *input_file;
    char *output_file;
    bool verbose;
    int threads;
    bool help_requested;
} Config;

// Function to print usage information for the CLI tool
void print_usage(const char *prog_name) {
    fprintf(stderr, "Usage: %s [OPTIONS]\n", prog_name);
    fprintf(stderr, "A simple CLI tool demonstrating argument parsing.\n\n");
    fprintf(stderr, "Options:\n");
    fprintf(stderr, "  -i, --input <file>    Specify input file path.\n");
    fprintf(stderr, "  -o, --output <file>   Specify output file path.\n");
    fprintf(stderr, "  -t, --threads <num>   Set number of threads for processing (default: 1).\n");
    fprintf(stderr, "  -v, --verbose         Enable verbose output.\n");
    fprintf(stderr, "  -h, --help            Display this help message and exit.\n");
    fprintf(stderr, "\n");
}

// Function to parse command-line arguments and return a Config struct pointer
// Returns a pointer to a dynamically allocated Config struct on success.
// Returns NULL on parsing error.
Config* parse_arguments(int argc, char *argv[]) {
    // Allocate memory for the configuration struct
    Config *cfg = (Config*)malloc(sizeof(Config));
    if (cfg == NULL) {
        perror("Failed to allocate memory for configuration");
        return NULL;
    }

    // Initialize default values for the configuration
    cfg->input_file = NULL;
    cfg->output_file = NULL;
    cfg->verbose = false;
    cfg->threads = 1; // Default to 1 thread
    cfg->help_requested = false;

    // Iterate through command-line arguments, starting from the second one (index 1)
    // as argv[0] is the program name.
    for (int i = 1; i < argc; ++i) {
        if (strcmp(argv[i], "-h") == 0 || strcmp(argv[i], "--help") == 0) {
            cfg->help_requested = true;
            return cfg; // If help is requested, return immediately. No further parsing needed.
        } else if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            if (i + 1 < argc) {
                cfg->input_file = argv[++i]; // Assign next argument as input file and advance i
            } else {
                fprintf(stderr, "Error: Option '%s' requires a file argument.\n", argv[i]);
                free(cfg); // Free allocated memory before returning NULL
                return NULL;
            }
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 < argc) {
                cfg->output_file = argv[++i]; // Assign next argument as output file
            } else {
                fprintf(stderr, "Error: Option '%s' requires a file argument.\n", argv[i]);
                free(cfg);
                return NULL;
            }
        } else if (strcmp(argv[i], "-t") == 0 || strcmp(argv[i], "--threads") == 0) {
            if (i + 1 < argc) {
                char *endptr;
                long threads_val = strtol(argv[++i], &endptr, 10);
                // Check if the entire string was converted and if the number is positive
                if (*endptr == '\0' && threads_val > 0) {
                    cfg->threads = (int)threads_val;
                } else {
                    fprintf(stderr, "Error: Option '%s' requires a positive integer argument.\n", argv[i-1]);
                    free(cfg);
                    return NULL;
                }
            } else {
                fprintf(stderr, "Error: Option '%s' requires a number argument.\n", argv[i]);
                free(cfg);
                return NULL;
            }
        } else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            cfg->verbose = true;
        } else {
            fprintf(stderr, "Error: Unknown argument '%s'.\n", argv[i]);
            free(cfg);
            return NULL;
        }
    }

    return cfg; // Return the successfully parsed configuration
}

// This function represents the main application logic
// It takes the parsed configuration and uses it to perform its tasks.
void run_application(const Config *cfg) {
    printf("--- Application Initialized with Configuration ---\n");
    printf("Input File: %s\n", cfg->input_file ? cfg->input_file : "(Not specified)");
    printf("Output File: %s\n", cfg->output_file ? cfg->output_file : "(Not specified)");
    printf("Threads: %d\n", cfg->threads);
    printf("Verbose Mode: %s\n", cfg->verbose ? "Enabled" : "Disabled");
    printf("--------------------------------------------------\n\n");

    printf("Starting application process...\n");

    if (cfg->verbose) {
        printf("[VERBOSE] Detailed logging is active.\n");
    }

    printf("Simulating data processing with %d threads.\n", cfg->threads);

    if (cfg->input_file) {
        printf("Reading data from: %s\n", cfg->input_file);
        // In a real application, file I/O operations would happen here.
    } else {
        printf("No input file specified. Using default data source or generating data.\n");
    }

    if (cfg->output_file) {
        printf("Writing results to: %s\n", cfg->output_file);
        // In a real application, results would be written here.
    } else {
        printf("No output file specified. Results will not be saved.\n");
    }

    printf("Application process completed successfully.\n");
}

int main(int argc, char *argv[]) {
    // Parse command-line arguments and get the configuration
    Config *app_config = parse_arguments(argc, argv);

    // Check if parsing failed (app_config is NULL)
    if (app_config == NULL) {
        print_usage(argv[0]); // Print usage on error
        return EXIT_FAILURE;  // Exit with an error code
    }

    // Check if the help flag was requested
    if (app_config->help_requested) {
        print_usage(argv[0]); // Print usage information
        free(app_config);     // Free the dynamically allocated config
        return EXIT_SUCCESS;  // Exit successfully after showing help
    }

    // If parsing was successful and help wasn't requested,
    // immediately use the returned pointer to initialize and run the application.
    run_application(app_config);

    // After the application has finished, free the dynamically allocated configuration struct
    free(app_config);

    return EXIT_SUCCESS; // Indicate successful execution
}