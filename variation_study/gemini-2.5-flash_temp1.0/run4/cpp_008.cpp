# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h> // Required for printf
#include <stdlib.h> // Required for general utilities, though not strictly for this function itself
#include <string.h> // Required for string operations, if initializing example data

// Define the structure for a user record
typedef struct User {
    char name[100];  // Assuming a max name length
    char email[100]; // Assuming a max email length
    // Add other user-related fields as needed
} User;

// Define the structure for a node in the linked list
typedef struct UserNode {
    User user;
    struct UserNode *next;
} UserNode;

// Function to traverse the linked list and print each user's name and email
void processUserList(UserNode *head) {
    UserNode *current = head; // Start from the head of the list

    if (head == NULL) {
        printf("The user list is empty.\n");
        return;
    }

    printf("--- User List ---\n");
    while (current != NULL) {
        printf("Name: %s, Email: %s\n", current->user.name, current->user.email);
        current = current->next; // Move to the next node in the list
    }
    printf("-----------------\n");
}

/*
// Example Usage (for testing purposes, not part of the requested function)
int main() {
    // Manually create some user nodes
    UserNode *user1 = (UserNode *)malloc(sizeof(UserNode));
    strcpy(user1->user.name, "Alice Smith");
    strcpy(user1->user.email, "alice.smith@example.com");

    UserNode *user2 = (UserNode *)malloc(sizeof(UserNode));
    strcpy(user2->user.name, "Bob Johnson");
    strcpy(user2->user.email, "bob.johnson@example.com");

    UserNode *user3 = (UserNode *)malloc(sizeof(UserNode));
    strcpy(user3->user.name, "Charlie Brown");
    strcpy(user3->user.email, "charlie.brown@example.com");

    UserNode *user4 = (UserNode *)malloc(sizeof(UserNode));
    strcpy(user4->user.name, "Diana Prince");
    strcpy(user4->user.email, "diana.prince@example.com");

    // Link the nodes
    user1->next = user2;
    user2->next = user3;
    user3->next = user4;
    user4->next = NULL; // Mark the end of the list

    // Process and print the list
    processUserList(user1);

    // Test with an empty list
    // processUserList(NULL);

    // Free the allocated memory (important for manual memory management)
    free(user1);
    free(user2);
    free(user3);
    free(user4);

    return 0;
}
*/