# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>

char* readConfigFile(const char* filename) {
    FILE* file = NULL;
    char* buffer = NULL;
    long file_size = 0;
    size_t bytes_read = 0;

    // Open the file in binary read mode
    file = fopen(filename, "rb");
    if (file == NULL) {
        // File could not be opened (e.g., not found, permissions)
        return NULL;
    }

    // Determine file size by seeking to the end
    if (fseek(file, 0, SEEK_END) != 0) {
        fclose(file);
        return NULL;
    }
    file_size = ftell(file);
    if (file_size == -1L) { // ftell returns -1L on error
        fclose(file);
        return NULL;
    }

    // Allocate memory for the file content plus one byte for the null terminator
    buffer = (char*)malloc((size_t)file_size + 1);
    if (buffer == NULL) {
        fclose(file);
        // Memory allocation failed
        return NULL;
    }

    // Seek back to the beginning of the file
    if (fseek(file, 0, SEEK_SET) != 0) {
        free(buffer);
        fclose(file);
        return NULL;
    }

    // Read the entire file content into the buffer
    bytes_read = fread(buffer, 1, (size_t)file_size, file);
    if (bytes_read != (size_t)file_size) {
        // Read error or partial read
        free(buffer);
        fclose(file);
        return NULL;
    }

    // Null-terminate the buffer to make it a valid C string
    buffer[file_size] = '\0';

    // Close the file
    fclose(file);

    // Return the dynamically allocated buffer
    return buffer;
}

/*
// Example Usage (for testing purposes, not part of the required function)
int main() {
    // Create a dummy config file for testing
    FILE* test_file = fopen("config.txt", "w");
    if (test_file) {
        fprintf(test_file, "setting1=value1\n");
        fprintf(test_file, "setting2=value2\n");
        fclose(test_file);
    }

    char* config_data = NULL;

    // First call
    printf("Calling readConfigFile for the first time...\n");
    config_data = readConfigFile("config.txt");
    if (config_data != NULL) {
        printf("Config Content:\n%s\n", config_data);
        free(config_data); // Important: free the allocated memory
        config_data = NULL; // Clear pointer after freeing
    } else {
        printf("Failed to read config.txt\n");
    }

    // Second call (simulating frequent calls)
    printf("\nCalling readConfigFile for the second time...\n");
    config_data = readConfigFile("config.txt");
    if (config_data != NULL) {
        printf("Config Content:\n%s\n", config_data);
        free(config_data); // Important: free the allocated memory
        config_data = NULL;
    } else {
        printf("Failed to read config.txt\n");
    }

    // Test with a non-existent file
    printf("\nCalling readConfigFile for a non-existent file...\n");
    config_data = readConfigFile("non_existent.txt");
    if (config_data != NULL) {
        printf("This should not be printed for a non-existent file.\n");
        free(config_data);
    } else {
        printf("Correctly failed to read non_existent.txt\n");
    }

    return 0;
}
*/