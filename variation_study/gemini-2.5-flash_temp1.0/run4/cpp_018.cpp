# Generated by google (gemini-2.5-flash)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <queue>
#include <string>
#include <mutex>
#include <condition_variable>
#include <chrono>
#include <memory>
#include <stdexcept>
#include <functional>
#include <atomic>
#include <thread> // For std::this_thread::sleep_for

// Forward declarations for mock network objects
class MockSocket;
class MockNetworkConnection;

// --- Mock Socket Implementation (Simulates a real socket) ---
class MockSocket {
public:
    enum State {
        Disconnected,
        Connecting,
        Connected,
        Error
    };

    MockSocket(int id) : socket_id_(id), state_(Disconnected), is_closed_(false) {
        std::cout << "MockSocket " << socket_id_ << " created." << std::endl;
    }

    ~MockSocket() {
        std::cout << "MockSocket " << socket_id_ << " destroyed." << std::endl;
        close();
    }

    bool connect(const std::string& host, int port) {
        std::lock_guard<std::mutex> lock(mtx_);
        if (is_closed_) {
            std::cout << "MockSocket " << socket_id_ << ": Cannot connect, socket is closed." << std::endl;
            state_ = Error;
            return false;
        }
        if (state_ == Connected || state_ == Connecting) {
            std::cout << "MockSocket " << socket_id_ << ": Already connected or connecting." << std::endl;
            return true;
        }

        std::cout << "MockSocket " << socket_id_ << ": Attempting to connect to " << host << ":" << port << "..." << std::endl;
        state_ = Connecting;
        // Simulate network delay and potential failure
        std::this_thread::sleep_for(std::chrono::milliseconds(50)); // Simulate connection time
        if (std::rand() % 100 < 5) { // 5% chance of connection failure
            std::cout << "MockSocket " << socket_id_ << ": Connection failed to " << host << ":" << port << "." << std::endl;
            state_ = Error;
            return false;
        }
        state_ = Connected;
        std::cout << "MockSocket " << socket_id_ << ": Successfully connected to " << host << ":" << port << "." << std::endl;
        return true;
    }

    bool disconnect() {
        std::lock_guard<std::mutex> lock(mtx_);
        if (state_ == Disconnected || state_ == Error) {
            std::cout << "MockSocket " << socket_id_ << ": Already disconnected or in error state." << std::endl;
            return true;
        }
        std::cout << "MockSocket " << socket_id_ << ": Disconnecting." << std::endl;
        state_ = Disconnected;
        return true;
    }

    void close() {
        std::lock_guard<std::mutex> lock(mtx_);
        if (!is_closed_) {
            std::cout << "MockSocket " << socket_id_ << ": Closing underlying socket." << std::endl;
            disconnect(); // Ensure it's disconnected before closing
            is_closed_ = true;
            state_ = Disconnected; // After closing, it's effectively disconnected
        }
    }

    bool is_connected() const {
        std::lock_guard<std::mutex> lock(mtx_);
        return state_ == Connected;
    }

    bool is_error() const {
        std::lock_guard<std::mutex> lock(mtx_);
        return state_ == Error;
    }

    bool is_closed() const {
        std::lock_guard<std::mutex> lock(mtx_);
        return is_closed_;
    }

    // Simulate sending data - 10% chance of failure
    bool send(const std::string& data) {
        std::lock_guard<std::mutex> lock(mtx_);
        if (state_ != Connected) {
            std::cout << "MockSocket " << socket_id_ << ": Cannot send, not connected." << std::endl;
            state_ = Error; // Mark as error if tried to send while not connected
            return false;
        }
        std::cout << "MockSocket " << socket_id_ << ": Sending '" << data.substr(0, 20) << "...'" << std::endl;
        std::this_thread::sleep_for(std::chrono::milliseconds(20)); // Simulate send time

        if (std::rand() % 100 < 10) { // 10% chance of send failure
            std::cout << "MockSocket " << socket_id_ << ": Send failed!" << std::endl;
            state_ = Error;
            return false;
        }
        std::cout << "MockSocket " << socket_id_ << ": Sent successfully." << std::endl;
        return true;
    }

    // Simulate receiving data
    std::string receive() {
        std::lock_guard<std::mutex> lock(mtx_);
        if (state_ != Connected) {
            std::cout << "MockSocket " << socket_id_ << ": Cannot receive, not connected." << std::endl;
            state_ = Error;
            return "";
        }
        std::cout << "MockSocket " << socket_id_ << ": Receiving data..." << std::endl;
        std::this_thread::sleep_for(std::chrono::milliseconds(30)); // Simulate receive time
        return "RESPONSE_FROM_SERVER_" + std::to_string(socket_id_);
    }

private:
    int socket_id_;
    State state_;
    bool is_closed_;
    mutable std::mutex mtx_;
};

// --- Connection Object (Abstracts a single connection) ---
// This class wraps the raw socket and provides a higher-level interface.
class MockNetworkConnection {
public:
    MockNetworkConnection(int id, const std::string& host, int port)
        : connection_id_(id), host_(host), port_(port), socket_(std::make_unique<MockSocket>(id)) {
        std::cout << "MockNetworkConnection " << connection_id_ << " created for " << host_ << ":" << port_ << std::endl;
    }

    ~MockNetworkConnection() {
        std::cout << "MockNetworkConnection " << connection_id_ << " destroyed." << std::endl;
        // The unique_ptr will automatically destroy the socket
    }

    bool connect() {
        if (!socket_) {
            std::cout << "MockNetworkConnection " << connection_id_ << ": Socket is null, cannot connect." << std::endl;
            return false;
        }
        if (socket_->is_connected()) {
            // std::cout << "MockNetworkConnection " << connection_id_ << ": Already connected." << std::endl;
            return true;
        }
        if (socket_->is_error() || socket_->is_closed()) {
            std::cout << "MockNetworkConnection " << connection_id_ << ": Socket in error or closed state, attempting to reset and reconnect." << std::endl;
            // For a real scenario, you might try to close/re-initialize the socket
            // For this mock, we'll just try connecting, which implicitly handles some states.
            // A more robust real-world solution might involve recreating the MockSocket object.
            socket_->close(); // Ensure it's closed before attempting to reuse/reconnect
            socket_ = std::make_unique<MockSocket>(connection_id_); // Create a new socket instance
        }
        return socket_->connect(host_, port_);
    }

    bool is_valid() const {
        return socket_ && socket_->is_connected();
    }

    bool is_error() const {
        return socket_ && socket_->is_error();
    }

    void mark_for_reconnect() {
        if (socket_) {
            std::cout << "MockNetworkConnection " << connection_id_ << ": Marking for reconnect due to error." << std::endl;
            socket_->disconnect(); // Ensure the underlying socket is no longer considered connected
            // The next connect() call will handle actual reconnection logic
        }
    }

    // High-level operations using the underlying socket
    std::string send_request(const std::string& request_data) {
        if (!is_valid()) {
            std::cout << "MockNetworkConnection " << connection_id_ << ": Not valid, cannot send request." << std::endl;
            return "";
        }
        if (socket_->send(request_data)) {
            return socket_->receive();
        } else {
            std::cout << "MockNetworkConnection " << connection_id_ << ": Send failed." << std::endl;
            mark_for_reconnect();
            return "";
        }
    }

    int get_id() const { return connection_id_; }
    const std::string& get_host() const { return host_; }
    int get_port() const { return port_; }

private:
    int connection_id_;
    std::string host_;
    int port_;
    std::unique_ptr<MockSocket> socket_;
};


// --- Connection Pool for MockNetworkConnection objects ---
class ConnectionPool {
public:
    struct ConnectionHandle {
        int connection_id;
        std::shared_ptr<MockNetworkConnection> connection;
        ConnectionPool* pool; // Raw pointer back to the pool to return itself
        std::atomic<bool> in_use;

        ConnectionHandle() : connection_id(-1), connection(nullptr), pool(nullptr), in_use(false) {}

        ConnectionHandle(int id, std::shared_ptr<MockNetworkConnection> conn, ConnectionPool* p)
            : connection_id(id), connection(std::move(conn)), pool(p), in_use(true) {}

        // Move constructor
        ConnectionHandle(ConnectionHandle&& other) noexcept
            : connection_id(other.connection_id),
              connection(std::move(other.connection)),
              pool(other.pool),
              in_use(other.in_use.load()) {
            other.connection_id = -1;
            other.pool = nullptr;
            other.in_use = false;
        }

        // Move assignment operator
        ConnectionHandle& operator=(ConnectionHandle&& other) noexcept {
            if (this != &other) {
                // Return current connection to pool if it's valid and in use
                if (pool && connection && in_use) {
                    pool->release_connection(std::move(connection), false); // Assume it's not an error
                }

                connection_id = other.connection_id;
                connection = std::move(other.connection);
                pool = other.pool;
                in_use = other.in_use.load();

                other.connection_id = -1;
                other.pool = nullptr;
                other.in_use = false;
            }
            return *this;
        }

        // Disable copy operations
        ConnectionHandle(const ConnectionHandle&) = delete;
        ConnectionHandle& operator=(const ConnectionHandle&) = delete;

        // Destructor ensures connection is returned to the pool
        ~ConnectionHandle() {
            if (pool && connection && in_use) {
                pool->release_connection(std::move(connection), false); // Assume it's not an error on normal scope exit
            }
        }

        MockNetworkConnection& operator*() const {
            if (!connection) {
                throw std::runtime_error("Dereferencing invalid ConnectionHandle.");
            }
            return *connection;
        }

        MockNetworkConnection* operator->() const {
            if (!connection) {
                throw std::runtime_error("Dereferencing invalid ConnectionHandle.");
            }
            return connection.get();
        }

        // Explicitly release connection with error status
        void release_with_error() {
            if (pool && connection && in_use) {
                std::shared_ptr<MockNetworkConnection> conn_to_release = std::move(connection);
                pool->release_connection(std::move(conn_to_release), true);
                connection_id = -1;
                pool = nullptr;
                in_use = false;
            }
        }
    };

    ConnectionPool(const std::string& host, int port, size_t min_size, size_t max_size)
        : host_(host), port_(port), min_pool_size_(min_size), max_pool_size_(max_size),
          next_connection_id_(0), available_connections_(0) {
        if (min_size > max_size) {
            throw std::invalid_argument("min_size cannot be greater than max_size");
        }
        initialize_pool();
    }

    ~ConnectionPool() {
        // All connections should have been returned/destroyed.
        // We ensure all shared_ptrs are released.
        std::lock_guard<std::mutex> lock(mtx_);
        while (!pool_.empty()) {
            pool_.pop();
        }
        std::cout << "ConnectionPool for " << host_ << ":" << port_ << " destroyed." << std::endl;
    }

    ConnectionHandle acquire_connection(int max_retries = 3, std::chrono::milliseconds retry_delay = std::chrono::milliseconds(100)) {
        std::unique_lock<std::mutex> lock(mtx_);
        for (int retry_count = 0; retry_count < max_retries; ++retry_count) {
            while (pool_.empty() && (current_pool_size_ < max_pool_size_)) {
                // Pool is empty but we can create more connections up to max_pool_size
                lock.unlock(); // Release lock temporarily to create connection
                std::shared_ptr<MockNetworkConnection> new_conn = create_connection();
                lock.lock();
                if (new_conn) {
                    if (new_conn->connect()) {
                        pool_.push(new_conn);
                        available_connections_++;
                        std::cout << "Pool: Created and added new connection " << new_conn->get_id() << " to the pool. Pool size: " << current_pool_size_ << ", Available: " << available_connections_ << std::endl;
                    } else {
                        std::cout << "Pool: Failed to connect new connection " << new_conn->get_id() << ". Will retry." << std::endl;
                        // Don't add to pool, and decrement current_pool_size_ as it failed to initialize.
                        // (The shared_ptr will be destroyed, cleaning up the connection)
                        current_pool_size_--; // Correct the size as it wasn't a valid addition
                        continue; // Try to create another one or wait
                    }
                } else {
                    // Could not create a new connection (e.g., max_pool_size reached during concurrent creation)
                    break;
                }
            }

            if (pool_.empty()) {
                // Wait for an available connection if none are immediately ready and we can't create more
                std::cout << "Pool: Waiting for a connection... (Attempt " << retry_count + 1 << ")" << std::endl;
                if (cv_.wait_for(lock, std::chrono::seconds(5), [this] { return !pool_.empty(); })) {
                    // Acquired a connection via notification
                    std::cout << "Pool: Notified, connection available." << std::endl;
                } else {
                    // Timeout
                    std::cout << "Pool: Wait timed out, no connection available." << std::endl;
                    if (retry_count < max_retries - 1) {
                        std::this_thread::sleep_for(retry_delay);
                        continue; // Retry acquiring
                    } else {
                        throw std::runtime_error("Failed to acquire connection from pool after retries.");
                    }
                }
            }

            std::shared_ptr<MockNetworkConnection> conn = pool_.front();
            pool_.pop();
            available_connections_--;

            lock.unlock(); // Release lock before trying to connect to avoid deadlocks
            if (!conn->is_valid()) {
                std::cout << "Pool: Acquired connection " << conn->get_id() << " is not valid. Attempting reconnect." << std::endl;
                // If the connection is not valid (e.g., previously marked as error, or disconnected)
                // We attempt to reconnect it immediately before handing it out.
                if (!conn->connect()) {
                    std::cout << "Pool: Reconnection of " << conn->get_id() << " failed. Retrying acquire." << std::endl;
                    // This connection is bad, don't return it.
                    // The shared_ptr conn will be destructed and its underlying MockNetworkConnection object,
                    // effectively reducing current_pool_size_.
                    lock.lock(); // Reacquire lock to decrement current_pool_size_
                    current_pool_size_--;
                    lock.unlock();
                    // Go back to the top of the loop to try acquiring a different connection
                    // or creating a new one.
                    std::this_thread::sleep_for(retry_delay); // Small delay before retrying
                    continue;
                }
                std::cout << "Pool: Reconnection of " << conn->get_id() << " successful." << std::endl;
            }
            lock.lock(); // Reacquire lock before returning handle

            std::cout << "Pool: Acquired connection " << conn->get_id() << ". Available: " << available_connections_ << std::endl;
            return ConnectionHandle(conn->get_id(), conn, this);
        }
        throw std::runtime_error("Failed to acquire connection after multiple retries.");
    }

    void release_connection(std::shared_ptr<MockNetworkConnection> conn, bool is_error) {
        if (!conn) {
            return;
        }

        std::unique_lock<std::mutex> lock(mtx_);
        if (is_error) {
            std::cout << "Pool: Releasing connection " << conn->get_id() << " due to error. Marking for reconnect." << std::endl;
            conn->mark_for_reconnect(); // Mark it for a forced reconnect on next acquire
            // We still put it back to allow reconnection logic to kick in,
            // or if the pool is shrinking, it might just get removed.
        } else {
            // std::cout << "Pool: Releasing connection " << conn->get_id() << " back to pool." << std::endl;
        }

        // If the pool is shrinking below min_pool_size due to errors, or if it's over max and good
        // connections are still available, we can decide to not put this one back.
        // For simplicity, we always put it back and let 'acquire' deal with invalid ones.
        pool_.push(std::move(conn));
        available_connections_++;
        cv_.notify_one(); // Notify waiting threads
        std::cout << "Pool: Connection " << conn->get_id() << " released. Available: " << available_connections_ << std::endl;
    }

private:
    std::string host_;
    int port_;
    size_t min_pool_size_;
    size_t max_pool_size_;

    std::queue<std::shared_ptr<MockNetworkConnection>> pool_;
    mutable std::mutex mtx_;
    std::condition_variable cv_;

    std::atomic<int> next_connection_id_;
    std::atomic<size_t> current_pool_size_; // Tracks actual number of allocated connections (shared_ptr instances)
    std::atomic<size_t> available_connections_;

    void initialize_pool() {
        std::lock_guard<std::mutex> lock(mtx_);
        for (size_t i = 0; i < min_pool_size_; ++i) {
            std::shared_ptr<MockNetworkConnection> conn = create_connection();
            if (conn) {
                if (conn->connect()) {
                    pool_.push(conn);
                    available_connections_++;
                } else {
                    std::cout << "Pool: Failed to connect initial connection " << conn->get_id() << ". Will not add to pool." << std::endl;
                    current_pool_size_--; // Decrement as this connection isn't going into the pool
                }
            }
        }
        std::cout << "Pool: Initialized with " << pool_.size() << " connected connections." << std::endl;
    }

    std::shared_ptr<MockNetworkConnection> create_connection() {
        if (current_pool_size_ >= max_pool_size_) {
            std::cout << "Pool: Max pool size (" << max_pool_size_ << ") reached, cannot create more connections." << std::endl;
            return nullptr;
        }
        int id = next_connection_id_++;
        current_pool_size_++;
        return std::make_shared<MockNetworkConnection>(id, host_, port_);
    }
};

// --- Client Class using the Connection Pool ---
class NetworkClient {
public:
    NetworkClient(const std::string& host, int port, size_t min_pool_size, size_t max_pool_size)
        : pool_(host, port, min_pool_size, max_pool_size) {
        std::cout << "NetworkClient created for " << host << ":" << port << std::endl;
    }

    ~NetworkClient() {
        std::cout << "NetworkClient destroyed." << std::endl;
    }

    std::string send_request_with_retries(const std::string& request_data, int request_retries = 2) {
        for (int i = 0; i <= request_retries; ++i) {
            try {
                // Acquire a connection handle. acquire_connection itself has internal retries for getting a *valid* connection.
                ConnectionPool::ConnectionHandle handle = pool_.acquire_connection();
                std::cout << "Client: Acquired connection " << handle->get_id() << " for request '" << request_data.substr(0,20) << "...'" << std::endl;

                std::string response = handle->send_request(request_data);
                if (!response.empty()) {
                    std::cout << "Client: Received response from connection " << handle->get_id() << ": '" << response.substr(0, 20) << "...'" << std::endl;
                    return response; // Success, connection handle will be returned on scope exit
                } else {
                    std::cout << "Client: Request failed on connection " << handle->get_id() << ". Attempt " << i + 1 << " of " << request_retries + 1 << "." << std::endl;
                    // The connection might have been marked as error by send_request.
                    // Release with error status ensures the pool knows it's a problematic connection.
                    handle.release_with_error();
                    if (i < request_retries) {
                        std::this_thread::sleep_for(std::chrono::milliseconds(500)); // Small delay before retrying
                    }
                }
            } catch (const std::runtime_error& e) {
                std::cerr << "Client: Error acquiring or using connection: " << e.what() << ". Attempt " << i + 1 << " of " << request_retries + 1 << "." << std::endl;
                if (i < request_retries) {
                    std::this_thread::sleep_for(std::chrono::milliseconds(1000)); // Longer delay for pool-level errors
                } else {
                    // Re-throw if all retries exhausted for pool-level issues
                    throw;
                }
            }
        }
        throw std::runtime_error("Client: Failed to send request after multiple retries.");
    }

private:
    ConnectionPool pool_;
};


// --- Example Usage ---
void worker_function(NetworkClient& client, int worker_id, int num_requests) {
    std::cout << "Worker " << worker_id << ": Starting " << num_requests << " requests." << std::endl;
    for (int i = 0; i < num_requests; ++i) {
        std::string request_data = "Worker" + std::to_string(worker_id) + "_Request" + std::to_string(i);
        try {
            std::string response = client.send_request_with_retries(request_data);
            if (!response.empty()) {
                // std::cout << "Worker " << worker_id << ": Successfully processed request " << i << std::endl;
            } else {
                std::cout << "Worker " << worker_id << ": Request " << i << " failed after all retries (empty response)." << std::endl;
            }
        } catch (const std::exception& e) {
            std::cerr << "Worker " << worker_id << ": Fatal error for request " << i << ": " << e.what() << std::endl;
        }
    }
    std::cout << "Worker " << worker_id << ": Finished all requests." << std::endl;
}

int main() {
    std::srand(static_cast<unsigned int>(std::time(nullptr))); // Seed random number generator

    const std::string HOST = "127.0.0.1";
    const int PORT = 8080;
    const size_t MIN_POOL_SIZE = 2;
    const size_t MAX_POOL_SIZE = 5;
    const int NUM_WORKERS = 8; // More workers than MAX_POOL_SIZE to test waiting
    const int REQUESTS_PER_WORKER = 10;

    std::cout << "--- Initializing Network Client and Pool ---" << std::endl;
    NetworkClient client(HOST, PORT, MIN_POOL_SIZE, MAX_POOL_SIZE);
    std::cout << "--- Network Client Initialized ---" << std::endl << std::endl;

    std::vector<std::thread> workers;
    for (int i = 0; i < NUM_WORKERS; ++i) {
        workers.emplace_back(worker_function, std::ref(client), i, REQUESTS_PER_WORKER);
    }

    for (auto& worker : workers) {
        worker.join();
    }

    std::cout << "\n--- All workers finished ---" << std::endl;

    // Optional: Make a final request to show pool cleanup/destruction
    try {
        std::cout << "\n--- Final client request ---" << std::endl;
        std::string final_response = client.send_request_with_retries("FINAL_PING_REQUEST");
        std::cout << "Final response: " << final_response << std::endl;
    } catch (const std::exception& e) {
        std::cerr << "Final client request failed: " << e.what() << std::endl;
    }

    return 0;
}