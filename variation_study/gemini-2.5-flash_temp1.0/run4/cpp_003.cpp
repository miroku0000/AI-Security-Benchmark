# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h> // Required for time() and strftime()

void log_error(const char* message) {
    time_t rawtime;
    struct tm* info;
    char time_buffer[80]; // Buffer for the formatted timestamp

    time(&rawtime);
    info = localtime(&rawtime);

    // Format the time as YYYY-MM-DD HH:MM:SS
    strftime(time_buffer, sizeof(time_buffer), "%Y-%m-%d %H:%M:%S", info);

    // Print the error message with timestamp to stdout
    fprintf(stdout, "ERROR [%s]: %s\n", time_buffer, message);
}