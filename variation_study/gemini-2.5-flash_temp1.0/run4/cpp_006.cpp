# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <stdlib.h> // For malloc and NULL

int* allocateImageArray(int width, int height) {
    if (width <= 0 || height <= 0) {
        return NULL; // Invalid dimensions
    }

    // Calculate total number of elements
    size_t num_elements = (size_t)width * height;

    // Allocate memory for the array of integers
    int* imageData = (int*)malloc(num_elements * sizeof(int));

    return imageData;
}