# Generated by google (gemini-2.5-flash)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <string.h>

// Thread stack sizes and priorities
#define ADMIN_STACK_SIZE 1024
#define USER_STACK_SIZE 1024

#define ADMIN_PRIORITY 5 // Higher priority for admin
#define USER_PRIORITY 7  // Lower priority for user

// Simulated Resources
#define FLASH_SIZE 256
uint8_t flash_memory_sim[FLASH_SIZE];
struct k_mutex flash_mutex; // Protect flash access

typedef struct {
    uint32_t setting_a;
    uint32_t setting_b;
    char name[16];
} sys_config_t;

sys_config_t system_config;
struct k_mutex config_mutex; // Protect system_config access

// Admin Operations Request Message
typedef enum {
    OP_FLASH_WRITE,
    OP_CONFIG_UPDATE_A,
    OP_CONFIG_UPDATE_B,
    OP_CONFIG_UPDATE_NAME,
    OP_NONE // Invalid/default operation
} admin_operation_type_t;

typedef struct {
    admin_operation_type_t operation;
    union {
        struct {
            uint16_t address;
            uint8_t data;
        } flash_write;
        struct {
            uint32_t value;
        } config_update_a;
        struct {
            uint32_t value;
        } config_update_b;
        struct {
            char name[16];
        } config_update_name;
    } params;
    // Potentially add a 'requester_id' here if multiple user tasks are planned
} admin_request_t;

// Message queue for user tasks to send requests to the admin task
K_MSGQ_DEFINE(admin_request_q, sizeof(admin_request_t), 10, 4);

// --- Admin Task Functions (privileged operations) ---

void flash_write_simulated(uint16_t addr, uint8_t data) {
    k_mutex_lock(&flash_mutex, K_FOREVER);
    if (addr < FLASH_SIZE) {
        flash_memory_sim[addr] = data;
        printk("ADMIN: Flashed 0x%02x to address 0x%04x\n", data, addr);
    } else {
        printk("ADMIN ERROR: Flash address 0x%04x out of bounds\n", addr);
    }
    k_mutex_unlock(&flash_mutex);
}

void update_system_config_a(uint32_t value) {
    k_mutex_lock(&config_mutex, K_FOREVER);
    system_config.setting_a = value;
    printk("ADMIN: Updated config_a to %u\n", value);
    k_mutex_unlock(&config_mutex);
}

void update_system_config_b(uint32_t value) {
    k_mutex_lock(&config_mutex, K_FOREVER);
    system_config.setting_b = value;
    printk("ADMIN: Updated config_b to %u\n", value);
    k_mutex_unlock(&config_mutex);
}

void update_system_config_name(const char *name) {
    k_mutex_lock(&config_mutex, K_FOREVER);
    strncpy(system_config.name, name, sizeof(system_config.name) - 1);
    system_config.name[sizeof(system_config.name) - 1] = '\0'; // Ensure null-termination
    printk("ADMIN: Updated config_name to '%s'\n", system_config.name);
    k_mutex_unlock(&config_mutex);
}

// --- Admin Task Entry Point ---

void admin_task_entry(void *p1, void *p2, void *p3) {
    printk("ADMIN Task started. Waiting for requests...\n");

    admin_request_t request;

    while (1) {
        // Wait indefinitely for a request from the message queue
        if (k_msgq_get(&admin_request_q, &request, K_FOREVER) == 0) {
            printk("ADMIN: Received request (Type: %d)\n", request.operation);
            // This switch statement acts as the privilege gatekeeper.
            // Only the admin task can execute these operations based on valid requests.
            switch (request.operation) {
                case OP_FLASH_WRITE:
                    flash_write_simulated(request.params.flash_write.address, request.params.flash_write.data);
                    break;
                case OP_CONFIG_UPDATE_A:
                    update_system_config_a(request.params.config_update_a.value);
                    break;
                case OP_CONFIG_UPDATE_B:
                    update_system_config_b(request.params.config_update_b.value);
                    break;
                case OP_CONFIG_UPDATE_NAME:
                    update_system_config_name(request.params.config_update_name.name);
                    break;
                case OP_NONE:
                default:
                    printk("ADMIN ERROR: Unknown or invalid operation type %d received.\n", request.operation);
                    break;
            }
        }
    }
}

// --- User Task Entry Point ---

void user_task_entry(void *p1, void *p2, void *p3) {
    printk("USER Task started.\n");

    admin_request_t request;
    uint8_t flash_addr = 0;
    uint8_t flash_data = 0;
    uint32_t config_val_a = 1000;
    uint32_t config_val_b = 2000;
    const char *names[] = {"Zephyr", "RTOS", "Embedded"};
    int name_idx = 0;

    while (1) {
        k_sleep(K_SECONDS(2)); // Wait for some time before making a request

        // Request 1: Flash write
        request.operation = OP_FLASH_WRITE;
        request.params.flash_write.address = flash_addr++;
        request.params.flash_write.data = flash_data++;
        if (flash_addr >= FLASH_SIZE) flash_addr = 0;
        printk("USER: Requesting flash write to 0x%04x with data 0x%02x\n",
               request.params.flash_write.address, request.params.flash_write.data);
        if (k_msgq_put(&admin_request_q, &request, K_NO_WAIT) != 0) {
            printk("USER ERROR: Failed to send flash write request (queue full?)\n");
        }

        k_sleep(K_SECONDS(3));

        // Request 2: Update config_a
        request.operation = OP_CONFIG_UPDATE_A;
        request.params.config_update_a.value = config_val_a++;
        printk("USER: Requesting config_a update to %u\n", request.params.config_update_a.value);
        if (k_msgq_put(&admin_request_q, &request, K_NO_WAIT) != 0) {
            printk("USER ERROR: Failed to send config_a update request (queue full?)\n");
        }

        k_sleep(K_SECONDS(2));

        // Request 3: Update config_b
        request.operation = OP_CONFIG_UPDATE_B;
        request.params.config_update_b.value = config_val_b++;
        printk("USER: Requesting config_b update to %u\n", request.params.config_update_b.value);
        if (k_msgq_put(&admin_request_q, &request, K_NO_WAIT) != 0) {
            printk("USER ERROR: Failed to send config_b update request (queue full?)\n");
        }

        k_sleep(K_SECONDS(3));

        // Request 4: Update config_name
        request.operation = OP_CONFIG_UPDATE_NAME;
        strncpy(request.params.config_update_name.name, names[name_idx],
                sizeof(request.params.config_update_name.name) - 1);
        request.params.config_update_name.name[sizeof(request.params.config_update_name.name) - 1] = '\0';
        name_idx = (name_idx + 1) % (sizeof(names) / sizeof(names[0]));
        printk("USER: Requesting config_name update to '%s'\n", request.params.config_update_name.name);
        if (k_msgq_put(&admin_request_q, &request, K_NO_WAIT) != 0) {
            printk("USER ERROR: Failed to send config_name update request (queue full?)\n");
        }

        k_sleep(K_SECONDS(5)); // Long sleep before next cycle
    }
}

// Thread Definitions
K_THREAD_STACK_DEFINE(admin_stack_area, ADMIN_STACK_SIZE);
struct k_thread admin_task_data;

K_THREAD_STACK_DEFINE(user_stack_area, USER_STACK_SIZE);
struct k_thread user_task_data;

int main(void) {
    printk("Zephyr Privilege System Example\n");

    // Initialize simulated resources
    memset(flash_memory_sim, 0xFF, FLASH_SIZE); // Flash is erased by default (0xFF)
    system_config.setting_a = 0;
    system_config.setting_b = 0;
    strncpy(system_config.name, "Default", sizeof(system_config.name) - 1);
    system_config.name[sizeof(system_config.name) - 1] = '\0';

    // Initialize mutexes
    k_mutex_init(&flash_mutex);
    k_mutex_init(&config_mutex);

    // Create and start admin task
    k_tid_t admin_tid = k_thread_create(&admin_task_data, admin_stack_area,
                                        K_THREAD_STACK_SIZE(admin_stack_area),
                                        admin_task_entry, NULL, NULL, NULL,
                                        ADMIN_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(admin_tid, "admin_task");
    printk("Main: Admin Task Created (TID: %p)\n", (void *)admin_tid);

    // Create and start user task
    k_tid_t user_tid = k_thread_create(&user_task_data, user_stack_area,
                                       K_THREAD_STACK_SIZE(user_stack_area),
                                       user_task_entry, NULL, NULL, NULL,
                                       USER_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(user_tid, "user_task");
    printk("Main: User Task Created (TID: %p)\n", (void *)user_tid);

    printk("Main: All tasks started. Initial config_a: %u, config_b: %u, name: '%s'\n",
           system_config.setting_a, system_config.setting_b, system_config.name);

    // In Zephyr, main typically does not return; it acts as the initial kernel thread.
    // However, if it returns, the kernel will halt or reboot depending on configuration.
    // For this example, it's fine for main to return after creating other threads,
    // as the kernel will then schedule the created threads.
    return 0;
}