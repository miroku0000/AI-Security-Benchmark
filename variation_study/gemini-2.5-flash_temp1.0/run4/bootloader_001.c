# Generated by google (gemini-2.5-flash)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

// ============================================================================
// ARM Cortex-M Bootloader Example
//
// This is a highly simplified example intended to demonstrate the structure
// and key concepts for an embedded bootloader. It lacks many production-grade
// features like robust error handling, security, complete peripheral drivers,
// watchdog management, and advanced update protocols.
//
// You will need to replace placeholder functions and addresses with your
// specific MCU's HAL/LL functions and memory map.
//
// ============================================================================

#include <stdint.h>

// ============================================================================
// MCU Specific Definitions (PLACEHOLDERS - REPLACE WITH YOUR MCU'S VALUES)
// ============================================================================

// Base address of internal Flash memory
#define FLASH_BASE_ADDRESS              0x08000000UL

// Bootloader will reside at the start of flash
#define BOOTLOADER_START_ADDRESS        FLASH_BASE_ADDRESS

// Size reserved for the bootloader. Must be a multiple of Flash erase sector size.
// For example, if your bootloader is 32KB, use 0x8000.
#define BOOTLOADER_SIZE                 0x00010000UL // Example: 64KB for bootloader

// Start address for the application firmware
#define APPLICATION_START_ADDRESS       (BOOTLOADER_START_ADDRESS + BOOTLOADER_SIZE)

// A magic word stored in a specific RAM location to force bootloader entry
// Used for software-triggered updates/recovery. Needs to be in a retained RAM
// region (e.g., backup RAM) or a specific flash sector if persistent.
#define BOOTLOADER_FORCE_MODE_ADDR      (0x20000000UL + 0x1000UL) // Example: A specific RAM address
#define BOOTLOADER_FORCE_MODE_MAGIC     0xDEADBEEFUL

// GPIO pin for hardware bootloader entry
// Example: GPIO Port A, Pin 0. Replace with your actual pin definition.
#define BOOT_GPIO_PORT_PIN              0 // Placeholder for GPIO specific defines (e.g., 0 for PA0)
#define BOOT_GPIO_ACTIVE_STATE          0 // 0 for active low, 1 for active high

// Flash Page/Sector Definitions (PLACEHOLDERS)
// These vary widely by MCU (e.g., 2KB, 4KB, 16KB, 128KB, 256KB sectors)
#define FLASH_PAGE_SIZE                 2048UL // Example: 2KB flash page/word write size
#define FLASH_SECTOR_SIZE               16384UL // Example: 16KB flash erase sector size

// Max firmware size to accept. Ensure this fits in your application flash region.
#define MAX_FIRMWARE_SIZE               0x000C0000UL // Example: 768KB (e.g., for 1MB flash total, 64KB bootloader, 768KB app, rest for data)

// UART communication definitions
#define UART_BAUDRATE                   115200
#define UART_TIMEOUT_MS                 5000 // Timeout for receiving firmware data

// SD Card Definitions (SPI interface usually)
#define SD_SPI_CHANNEL                  0 // Placeholder for SPI specific channel
#define SD_CS_GPIO_PORT_PIN             1 // Placeholder for SD Card Chip Select GPIO

// ============================================================================
// Type Definitions
// ============================================================================

// Function pointer for jumping to application
typedef void (*pFunction)(void);

// Structure for the application's vector table (first two entries)
typedef struct
{
    uint32_t sp;         // Stack Pointer
    pFunction reset_handler; // Reset Handler
} ApplicationVectorTable;

// ============================================================================
// Global Variables
// ============================================================================

// Buffer for receiving firmware chunks from UART or SD.
// Choose a size that balances memory usage and transfer efficiency.
#define RX_BUFFER_SIZE                  2048 // Example: 2KB buffer
static uint8_t rx_buffer[RX_BUFFER_SIZE];

// ============================================================================
// Low-Level MCU Access (PLACEHOLDERS - REPLACE WITH YOUR MCU'S REGISTERS/FUNCTIONS)
// ============================================================================

// SCB - System Control Block
#define SCB_BASE                        0xE000ED00UL
#define SCB_VTOR                        (*(volatile uint32_t *)(SCB_BASE + 0x08UL)) // Vector Table Offset Register

// FLASH Interface (Example: STM32F4-like registers)
#define FLASH_REG_BASE                  0x40023C00UL // Example base address for a Flash controller (STM32F4)
#define FLASH_KEYR                      (*(volatile uint32_t *)(FLASH_REG_BASE + 0x04UL)) // Flash Key Register
#define FLASH_OPTKEYR                   (*(volatile uint32_t *)(FLASH_REG_BASE + 0x08UL)) // Flash Option Key Register
#define FLASH_SR                        (*(volatile uint32_t *)(FLASH_REG_BASE + 0x0CUL)) // Flash Status Register
#define FLASH_CR                        (*(volatile uint32_t *)(FLASH_REG_BASE + 0x10UL)) // Flash Control Register
#define FLASH_ACR                       (*(volatile uint32_t *)(FLASH_REG_BASE + 0x00UL)) // Access Control Register

// FLASH Control Register Bits (Examples, check your MCU manual)
#define FLASH_CR_PG                     (1UL << 0)  // Program bit
#define FLASH_CR_SER                    (1UL << 1)  // Sector Erase bit
#define FLASH_CR_MER                    (1UL << 2)  // Mass Erase bit
#define FLASH_CR_PNB_POS                3           // Sector Number Position
#define FLASH_CR_PNB_MASK               (0xFU << FLASH_CR_PNB_POS) // Max 16 sectors
#define FLASH_CR_STRT                   (1UL << 16) // Start bit (for erase/program operation)
#define FLASH_CR_LOCK                   (1UL << 31) // Lock bit

// FLASH Status Register Bits (Examples)
#define FLASH_SR_BSY                    (1UL << 16) // Busy bit
#define FLASH_SR_PGSERR                 (1UL << 7)  // Programming Sequence Error
#define FLASH_SR_WRPERR                 (1UL << 4)  // Write Protection Error
#define FLASH_SR_EOP                    (1UL << 0)  // End of Operation

// Placeholder for __set_MSP and __disable_irq / __enable_irq
// These are typically provided by CMSIS in core_cmX.h
extern void __set_MSP(uint32_t topOfMainStack);
extern void __disable_irq(void);

// Dummy function to delay, replace with proper timer-based delay for accuracy
static void delay_ms(uint32_t ms)
{
    // A very simple busy-wait loop. Replace with a proper timer-based delay
    // for production use, especially when dealing with external peripherals.
    volatile uint32_t i, j;
    for (i = 0; i < ms; i++) {
        for (j = 0; j < 10000; j++); // Adjust this loop count for your clock speed
    }
}

// ============================================================================
// Peripheral Driver PLACEHOLDERS (REPLACE WITH YOUR MCU'S HAL/LL DRIVERS)
// ============================================================================

static void system_clock_init(void)
{
    // Initialize your MCU's system clock (e.g., using internal RC or external crystal)
    // This is critical for all peripherals to function correctly.
    // Example: Configure HSI oscillator, PLL, AHB/APB prescalers.
    // For STM32: HAL_RCC_OscConfig(), HAL_RCC_ClockConfig()
}

static void gpio_init(void)
{
    // Initialize GPIOs for bootloader entry pin, UART, SPI (for SD).
    // Set appropriate modes (input/output, pull-up/down, alternate functions).
    // Example: Enable clock for GPIOA, GPIOB etc.
    // For STM32: __HAL_RCC_GPIOA_CLK_ENABLE(), GPIO_InitStruct.Pin = ..., HAL_GPIO_Init()
}

static uint8_t gpio_read_boot_pin(void)
{
    // Read the state of the bootloader entry GPIO pin.
    // Return 0 or 1 based on its state.
    // Example for PA0: return (GPIOA->IDR & (1 << BOOT_GPIO_PORT_PIN)) ? 1 : 0;
    return 0; // Placeholder: Always return 0 (not pressed)
}

static void uart_init(void)
{
    // Initialize your MCU's UART peripheral.
    // Set baud rate, word length, stop bits, parity.
    // Enable TX/RX.
    // For STM32: __HAL_RCC_USARTx_CLK_ENABLE(), huart.Init.BaudRate = ..., HAL_UART_Init(&huart)
}

static void uart_send_byte(uint8_t byte)
{
    // Send a single byte over UART.
    // Wait for TX buffer to be empty before sending.
    // Example: while (!(USART1->SR & USART_SR_TXE)); USART1->DR = byte;
    // For STM32: HAL_UART_Transmit(&huart, &byte, 1, timeout)
}

static uint8_t uart_receive_byte(uint32_t timeout_ms)
{
    // Receive a single byte over UART with a timeout.
    // Return the byte or a special error value (e.g., 0xFF) on timeout.
    // Example:
    // uint32_t start_tick = get_system_tick();
    // while (!(USART1->SR & USART_SR_RXNE)) { if ((get_system_tick() - start_tick) > timeout_ms) return 0xFF; }
    // return (uint8_t)USART1->DR;
    // For STM32: HAL_UART_Receive(&huart, &byte, 1, timeout)
    delay_ms(1); // Simulate some delay
    return 0; // Placeholder
}

static void spi_init(void)
{
    // Initialize your MCU's SPI peripheral for SD card communication.
    // Set master mode, clock speed (e.g., /2 or /4 for init, then faster),
    // clock polarity/phase.
    // For STM32: __HAL_RCC_SPIx_CLK_ENABLE(), hspi.Init.Mode = ..., HAL_SPI_Init(&hspi)
}

static void spi_send_byte(uint8_t byte)
{
    // Send a byte over SPI.
    // Example: SPI1->DR = byte; while (!(SPI1->SR & SPI_SR_TXE)); while (SPI1->SR & SPI_SR_BSY);
    // For STM32: HAL_SPI_Transmit(&hspi, &byte, 1, timeout)
}

static uint8_t spi_receive_byte(void)
{
    // Receive a byte over SPI.
    // Example: SPI1->DR = 0xFF; while (!(SPI1->SR & SPI_SR_RXNE)); return SPI1->DR;
    // For STM32: HAL_SPI_Receive(&hspi, &byte, 1, timeout)
    return 0; // Placeholder
}

static void sd_cs_low(void)
{
    // Set SD Card Chip Select pin low (active).
    // For STM32: HAL_GPIO_WritePin(SD_CS_GPIO_PORT, SD_CS_PIN, GPIO_PIN_RESET)
}

static void sd_cs_high(void)
{
    // Set SD Card Chip Select pin high (inactive).
    // For STM32: HAL_GPIO_WritePin(SD_CS_GPIO_PORT, SD_CS_PIN, GPIO_PIN_SET)
}

// ============================================================================
// Flash Memory Operations
// ============================================================================

static void flash_unlock(void)
{
    // Unlock the flash memory for erase/program operations.
    // This typically involves writing specific key sequences to a key register.
    // Example for some STM32s:
    // if ((FLASH->CR & FLASH_CR_LOCK) != 0U)
    // {
    //     FLASH->KEYR = 0x45670123U;
    //     FLASH->KEYR = 0xCDEF89ABU;
    // }
}

static void flash_lock(void)
{
    // Lock the flash memory after operations.
    // Example: FLASH->CR |= FLASH_CR_LOCK;
}

static uint8_t flash_wait_for_last_operation(uint32_t timeout_ms)
{
    // Wait for the flash controller to become ready (not busy).
    // Example:
    // uint32_t start_tick = get_system_tick();
    // while ((FLASH->SR & FLASH_SR_BSY) != 0U)
    // {
    //     if ((get_system_tick() - start_tick) > timeout_ms) return 1; // Timeout error
    // }
    // return 0; // Success
    delay_ms(1); // Simulate
    return 0;
}

static uint8_t flash_erase_sector(uint32_t address)
{
    if (flash_wait_for_last_operation(UART_TIMEOUT_MS) != 0) return 1;
    flash_unlock();

    // Example for some STM32s:
    // uint32_t sector_num = (address - FLASH_BASE_ADDRESS) / FLASH_SECTOR_SIZE;
    // FLASH->CR |= FLASH_CR_SER; // Sector Erase Enable
    // FLASH->CR &= ~FLASH_CR_PNB_MASK;
    // FLASH->CR |= (sector_num << FLASH_CR_PNB_POS); // Specify sector number
    // FLASH->CR |= FLASH_CR_STRT; // Start Erase Operation

    if (flash_wait_for_last_operation(UART_TIMEOUT_MS) != 0) return 1;

    // Clear status flags (e.g., EOP - End Of Program)
    // FLASH->SR = FLASH_SR_EOP | FLASH_SR_PGSERR | FLASH_SR_WRPERR;
    // FLASH->CR &= ~FLASH_CR_SER; // Disable Sector Erase
    // FLASH->CR &= ~FLASH_CR_PNB_MASK;

    flash_lock();
    return 0; // Success
}

static uint8_t flash_program_word(uint32_t address, uint32_t data)
{
    if (flash_wait_for_last_operation(UART_TIMEOUT_MS) != 0) return 1;
    flash_unlock();

    // Example for some STM32s (program 32-bit word):
    // FLASH->CR |= FLASH_CR_PG;  // Program Enable
    // *(volatile uint32_t*)address = data; // Write data

    if (flash_wait_for_last_operation(UART_TIMEOUT_MS) != 0) return 1;

    // Clear status flags
    // FLASH->SR = FLASH_SR_EOP | FLASH_SR_PGSERR | FLASH_SR_WRPERR;
    // FLASH->CR &= ~FLASH_CR_PG; // Disable Program

    flash_lock();
    return 0; // Success
}

// ============================================================================
// SD Card Functions (Simplified)
// ============================================================================

static uint8_t sd_command(uint8_t cmd, uint32_t arg, uint8_t crc)
{
    uint8_t response;
    // Send command byte
    spi_send_byte(0x40 | cmd);
    // Send argument bytes
    spi_send_byte((uint8_t)(arg >> 24));
    spi_send_byte((uint8_t)(arg >> 16));
    spi_send_byte((uint8_t)(arg >> 8));
    spi_send_byte((uint8_t)arg);
    // Send CRC byte
    spi_send_byte(crc);

    // Wait for response (R1 response is usually 0x00 for success)
    uint32_t timeout = 0xFFF; // A short timeout
    do {
        response = spi_receive_byte();
        timeout--;
    } while ((response == 0xFF) && (timeout > 0));

    return response;
}

static uint8_t sd_init(void)
{
    // This is a very basic SD card initialization.
    // Real SD init is complex (CMD0, CMD8, CMD58, CMD55+ACMD41, etc.)
    // For a bootloader, you might need a lightweight FATfs or direct sector access.

    sd_cs_high();
    // Send 80 clock cycles (10 bytes of 0xFF) to power up SD card
    for (int i = 0; i < 10; i++) {
        spi_send_byte(0xFF);
    }

    sd_cs_low();
    // CMD0: GO_IDLE_STATE
    if (sd_command(0, 0, 0x95) != 0x01) { // R1 response 0x01 means idle state
        sd_cs_high();
        return 1; // Failed to enter idle state
    }
    sd_cs_high();

    // (Further SD init commands like CMD8, CMD58, ACMD41 would go here)
    // For simplicity, we'll assume it's initialized enough for basic block reads.
    return 0; // Success (placeholder)
}

static uint32_t sd_read_firmware(uint32_t target_address)
{
    // This function assumes a specific firmware file name (e.g., "firmware.bin")
    // or a fixed location on the SD card (e.g., sector 100).
    // A full implementation would require a FAT file system driver or a very
    // specific SD card layout and block addressing.

    uart_send_byte('S'); // Status: Starting SD Read
    uint32_t firmware_size = 0; // Placeholder

    if (sd_init() != 0)
    {
        uart_send_byte('E'); // Error initializing SD
        return 0;
    }

    // --- SIMPLIFIED DIRECT SECTOR READ (NO FATFS) ---
    // This example assumes:
    // 1. Firmware image starts at a fixed SD card block (e.g., block 2048)
    // 2. The first 4 bytes of this block contain the total firmware size.
    // For production, consider using a lightweight FATfs library (like FatFs).
    uint32_t current_flash_addr = target_address;
    uint32_t sd_block_address = 2048; // Example: Start reading from SD block 2048
    uint32_t bytes_received = 0;
    uint32_t total_firmware_size = 0;

    // Read first block to get firmware size
    sd_cs_low();
    if (sd_command(17, sd_block_address, 0) != 0x00) { // CMD17: READ_SINGLE_BLOCK
        sd_cs_high();
        uart_send_byte('e'); // SD read command error
        return 0;
    }

    // Wait for data start token (0xFE)
    uint32_t timeout = 0xFFFF;
    uint8_t token;
    do {
        token = spi_receive_byte();
        timeout--;
    } while (token == 0xFF && timeout > 0);

    if (token != 0xFE) {
        sd_cs_high();
        uart_send_byte('F'); // SD no data token
        return 0;
    }

    // Read 512 bytes (one block)
    for (int i = 0; i < 512; i++) {
        rx_buffer[i] = spi_receive_byte();
    }
    spi_receive_byte(); // CRC1
    spi_receive_byte(); // CRC2
    sd_cs_high();

    // Assume first 4 bytes of the SD block contain the firmware size
    total_firmware_size = (uint32_t)rx_buffer[0] |
                          ((uint32_t)rx_buffer[1] << 8) |
                          ((uint32_t)rx_buffer[2] << 16) |
                          ((uint32_t)rx_buffer[3] << 24);

    if (total_firmware_size == 0 || total_firmware_size > MAX_FIRMWARE_SIZE) {
        uart_send_byte('I'); // Invalid firmware size
        return 0;
    }

    uart_send_byte('!'); // SD Firmware size detected

    // Erase necessary flash sectors
    for (uint32_t addr = target_address; addr < target_address + total_firmware_size; addr += FLASH_SECTOR_SIZE)
    {
        uart_send_byte('.'); // Erasing
        if (flash_erase_sector(addr) != 0) return 0; // Erase failed
    }

    // Program the first block (which includes the size)
    for (uint32_t i = 0; i < 512; i += 4) {
        if (flash_program_word(current_flash_addr + i, *(uint32_t*)&rx_buffer[i]) != 0) return 0;
    }
    bytes_received += 512;
    current_flash_addr += 512;
    sd_block_address++;

    // Continue reading subsequent blocks
    while (bytes_received < total_firmware_size) {
        sd_cs_low();
        if (sd_command(17, sd_block_address, 0) != 0x00) { // CMD17: READ_SINGLE_BLOCK
            sd_cs_high();
            uart_send_byte('e'); // SD read command error
            return 0;
        }

        timeout = 0xFFFF;
        do {
            token = spi_receive_byte();
            timeout--;
        } while (token == 0xFF && timeout > 0);

        if (token != 0xFE) {
            sd_cs_high();
            uart_send_byte('F'); // SD no data token
            return 0;
        }

        uint32_t bytes_to_read_this_block = (total_firmware_size - bytes_received) > 512 ? 512 : (total_firmware_size - bytes_received);

        for (uint32_t i = 0; i < bytes_to_read_this_block; i++) {
            rx_buffer[i] = spi_receive_byte();
        }
        // Read remaining bytes of the block if not full firmware data
        for (uint32_t i = bytes_to_read_this_block; i < 512; i++) {
            spi_receive_byte();
        }

        spi_receive_byte(); // CRC1
        spi_receive_byte(); // CRC2
        sd_cs_high();

        // Program to flash
        for (uint32_t i = 0; i < bytes_to_read_this_block; i += 4) {
            if (flash_program_word(current_flash_addr + i, *(uint32_t*)&rx_buffer[i]) != 0) return 0;
        }
        bytes_received += bytes_to_read_this_block;
        current_flash_addr += bytes_to_read_this_block;
        sd_block_address++;
        uart_send_byte('#'); // Programming in progress
    }
    uart_send_byte('D'); // SD Read Done
    return total_firmware_size;
}

// ============================================================================
// UART Firmware Update Functions
// ============================================================================

static uint32_t uart_receive_firmware(uint32_t target_address)
{
    uint32_t firmware_size = 0;
    uint32_t bytes_