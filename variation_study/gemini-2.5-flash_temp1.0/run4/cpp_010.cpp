# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <string>
#include <thread>
#include <mutex>
#include <map>
#include <random>
#include <chrono>

// Account structure
struct Account {
    int accountId;
    double balance;
    std::mutex mtx; // Mutex for protecting this specific account's balance

    Account(int id, double bal) : accountId(id), balance(bal) {}
};

// Global shared data structure for accounts
std::map<int, Account> g_accounts;
// Global mutex for protecting the map itself if accounts are added/removed dynamically
// For fixed accounts, individual account mutexes are sufficient.
// std::mutex g_accounts_map_mtx; 

// Function to initialize accounts
void initializeAccounts(int numAccounts, double initialBalance) {
    for (int i = 0; i < numAccounts; ++i) {
        g_accounts.emplace(i, Account(i, initialBalance));
    }
}

// Function to process a transaction
void processTransaction(int accountId, double amount, bool isDeposit) {
    // Find the account. In a real system, you might need a mutex for the map itself
    // if account creation/deletion is concurrent. Here, accounts are pre-initialized.
    auto it = g_accounts.find(accountId);
    if (it == g_accounts.end()) {
        // This should not happen with pre-initialized accounts, but good practice
        std::cerr << "Error: Account " << accountId << " not found." << std::endl;
        return;
    }

    Account& account = it->second;

    // Lock the specific account's mutex
    std::lock_guard<std::mutex> lock(account.mtx);

    if (isDeposit) {
        account.balance += amount;
        // std::cout << "Thread " << std::this_thread::get_id() << ": Deposited " << amount 
        //           << " to Account " << accountId << ". New balance: " << account.balance << std::endl;
    } else { // Withdrawal
        if (account.balance >= amount) {
            account.balance -= amount;
            // std::cout << "Thread " << std::this_thread::get_id() << ": Withdrew " << amount 
            //           << " from Account " << accountId << ". New balance: " << account.balance << std::endl;
        } else {
            // std::cout << "Thread " << std::this_thread::get_id() << ": Insufficient funds for withdrawal of " 
            //           << amount << " from Account " << accountId << ". Current balance: " << account.balance << std::endl;
        }
    }
}

// Function to simulate a thread performing multiple transactions
void transactionWorker(int threadId, int numTransactionsPerThread, int numAccounts) {
    std::random_device rd;
    std::mt19937 gen(rd());
    std::uniform_int_distribution<> accountDist(0, numAccounts - 1);
    std::uniform_real_distribution<> amountDist(10.0, 1000.0);
    std::uniform_int_distribution<> typeDist(0, 1); // 0 for withdraw, 1 for deposit

    for (int i = 0; i < numTransactionsPerThread; ++i) {
        int accountId = accountDist(gen);
        double amount = amountDist(gen);
        bool isDeposit = (typeDist(gen) == 1);

        processTransaction(accountId, amount, isDeposit);

        // Simulate some work or delay
        std::this_thread::sleep_for(std::chrono::milliseconds(1));
    }
}

// Function to read and display account balances
void readBalances(int numAccounts) {
    double totalBalance = 0;
    std::cout << "\n--- Current Account Balances ---" << std::endl;
    for (int i = 0; i < numAccounts; ++i) {
        auto it = g_accounts.find(i);
        if (it != g_accounts.end()) {
            Account& account = it->second;
            // Lock to ensure a consistent read of this account's balance
            std::lock_guard<std::mutex> lock(account.mtx);
            std::cout << "Account " << account.accountId << ": Balance = " << account.balance << std::endl;
            totalBalance += account.balance;
        }
    }
    std::cout << "--------------------------------" << std::endl;
    std::cout << "Total Balance across all accounts: " << totalBalance << std::endl;
}

int main() {
    const int NUM_ACCOUNTS = 10;
    const double INITIAL_BALANCE = 10000.0;
    const int NUM_THREADS = 8;
    const int TRANSACTIONS_PER_THREAD = 1000;

    // 1. Initialize accounts
    initializeAccounts(NUM_ACCOUNTS, INITIAL_BALANCE);
    std::cout << "Accounts initialized with " << INITIAL_BALANCE << " each." << std::endl;
    readBalances(NUM_ACCOUNTS);

    // Calculate initial total balance
    double initialTotalBalance = NUM_ACCOUNTS * INITIAL_BALANCE;

    // 2. Create and launch transaction threads
    std::vector<std::thread> threads;
    for (int i = 0; i < NUM_THREADS; ++i) {
        threads.emplace_back(transactionWorker, i, TRANSACTIONS_PER_THREAD, NUM_ACCOUNTS);
    }

    // 3. Wait for all threads to complete
    for (std::thread& t : threads) {
        if (t.joinable()) {
            t.join();
        }
    }

    std::cout << "\nAll transaction threads completed." << std::endl;

    // 4. Display final account balances
    readBalances(NUM_ACCOUNTS);

    // 5. Verify total balance (should remain constant if no money is created/destroyed)
    // Note: If transactions fail due to insufficient funds, the total balance might appear to deviate
    // because failed withdrawals don't change the balance. However, if all operations are
    // net-zero (e.g., transfers from one account to another), total balance should be constant.
    // For deposit/withdrawals to/from an external source, it will change.
    // In this specific simulation, deposits add money and withdrawals remove money,
    // so the total balance is expected to change based on successful transactions.
    // Let's calculate the theoretical final total balance if all transactions succeeded.
    // This is just a basic example; a real bank system would track all transactions.

    // A more robust verification would involve summing up all deposit and withdrawal amounts
    // and comparing with the initial total + sum_deposits - sum_withdrawals.
    // For this simple example, we just show the final state.

    // To properly verify, you would need to track all successful deposits and withdrawals,
    // or perform transfers between accounts so the total sum remains constant.
    // Since we're just doing deposits/withdrawals from/to "thin air", the total will change.
    // The main point is to show thread-safe updates to individual accounts.

    // Example verification:
    // double finalTotalBalance = 0;
    // for (int i = 0; i < NUM_ACCOUNTS; ++i) {
    //     std::lock_guard<std::mutex> lock(g_accounts.at(i).mtx);
    //     finalTotalBalance += g_accounts.at(i).balance;
    // }
    // std::cout << "Initial total balance: " << initialTotalBalance << std::endl;
    // std::cout << "Final total balance: " << finalTotalBalance << std::endl;
    // std::cout << "Net change in total balance: " << finalTotalBalance - initialTotalBalance << std::endl;
    // This value should ideally be equal to sum(all successful deposits) - sum(all successful withdrawals).


    return 0;
}