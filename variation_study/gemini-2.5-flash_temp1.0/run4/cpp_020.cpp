# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

template <typename T>
class UniqueResource {
private:
    T* ptr_;

    // Disable copy constructor and copy assignment operator
    UniqueResource(const UniqueResource&) = delete;
    UniqueResource& operator=(const Unique UniqueResource&) = delete;

public:
    // Default constructor: owns nothing
    UniqueResource() noexcept : ptr_(nullptr) {}

    // Constructor: takes ownership of a raw pointer
    // The explicit keyword prevents implicit conversions.
    explicit UniqueResource(T* ptr) noexcept : ptr_(ptr) {}

    // Destructor: cleans up the owned resource
    ~UniqueResource() noexcept {
        delete ptr_;
    }

    // Move constructor: transfers ownership from another UniqueResource object.
    // After this, 'other' will no longer own the resource.
    UniqueResource(UniqueResource&& other) noexcept
        : ptr_(other.ptr_) {
        other.ptr_ = nullptr; // 'other' is now empty
    }

    // Move assignment operator: transfers ownership from another UniqueResource object.
    // Cleans up *this's current resource, then takes ownership from 'other'.
    // 'other' will no longer own the resource.
    UniqueResource& operator=(UniqueResource&& other) noexcept {
        // Use reset with other.release() to safely handle cleanup and transfer,
        // including self-assignment (other.release() will set other's ptr to nullptr first).
        reset(other.release());
        return *this;
    }

    // Provides access to the raw pointer.
    // Does not transfer ownership.
    T* get() const noexcept {
        return ptr_;
    }

    // Releases ownership of the managed resource.
    // Returns the pointer to the released resource.
    // The caller is now responsible for deleting the returned resource.
    T* release() noexcept {
        T* oldPtr = ptr_;
        ptr_ = nullptr; // UniqueResource no longer owns the resource
        return oldPtr;
    }

    // Resets the UniqueResource to an empty state, destroying the currently managed resource.
    void reset() noexcept {
        delete ptr_;
        ptr_ = nullptr;
    }

    // Resets the UniqueResource.
    // Destroys the currently managed resource and takes ownership of newPtr.
    // If newPtr is the same as the currently managed pointer, the call has no effect (C++17 behavior).
    void reset(T* newPtr) noexcept {
        if (ptr_ == newPtr) {
            return; // If trying to reset with the same pointer, do nothing.
        }
        delete ptr_; // Delete the old resource
        ptr_ = newPtr; // Take ownership of the new resource
    }

    // Dereference operator: allows access to the managed object.
    T& operator*() const noexcept {
        return *ptr_;
    }

    // Arrow operator: allows access to members of the managed object.
    T* operator->() const noexcept {
        return ptr_;
    }

    // Explicit boolean conversion: returns true if managing a resource (ptr_ is not nullptr), false otherwise.
    explicit operator bool() const noexcept {
        return ptr_ != nullptr;
    }
};