# Generated by google (gemini-2.5-flash)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"

#define MAX_PACKET_SIZE 128U // Maximum size for network packets

static size_t prvSimulatedNetworkDriverReceive(uint8_t *pucBuffer, size_t xBufferSize);

void vNetworkPacketProcessorTask(void *pvParameters)
{
    uint8_t ucPacketBuffer[MAX_PACKET_SIZE]; // Buffer for packet data on the stack
    size_t xReceivedLength;

    for (;;)
    {
        // Attempt to receive a packet from the network driver.
        // In a real system, this would interact with your network interface hardware
        // or a network stack, potentially blocking until a packet arrives.
        xReceivedLength = prvSimulatedNetworkDriverReceive(ucPacketBuffer, sizeof(ucPacketBuffer));

        if (xReceivedLength > 0)
        {
            // A packet was received and copied into ucPacketBuffer.
            // Process the packet data from this local stack buffer.
            //
            // Example processing (replace with your actual logic):
            // for (size_t i = 0; i < xReceivedLength; i++)
            // {
            //     // Process ucPacketBuffer[i]
            // }

            // Simulate some processing time before looking for the next packet.
            vTaskDelay(pdMS_TO_TICKS(10));
        }
        else
        {
            // No packet was received in this iteration, or an error occurred.
            // Yield to other tasks and wait before checking again to avoid busy-waiting.
            vTaskDelay(pdMS_TO_TICKS(50));
        }
    }
}

// A simulated network driver receive function.
// In a real embedded system, this function would interface directly with
// the network hardware (e.g., Ethernet controller) to fetch received data.
// It might involve reading from DMA buffers or hardware FIFOs.
// This simulation periodically "generates" a small packet.
static size_t prvSimulatedNetworkDriverReceive(uint8_t *pucBuffer, size_t xBufferSize)
{
    static TickType_t xNextPacketReceiveTime = 0;
    static uint32_t ulPacketCounter = 0;

    // Check if it's time to "receive" a new simulated packet.
    if (xTaskGetTickCount() < xNextPacketReceiveTime)
    {
        return 0; // No packet available yet.
    }

    // Schedule the next simulated packet reception with a variable delay.
    TickType_t xDelayTicks = pdMS_TO_TICKS(100 + (ulPacketCounter % 900)); // Delay between 100ms and 1000ms
    xNextPacketReceiveTime = xTaskGetTickCount() + xDelayTicks;

    // Simulate a packet length, ensuring it fits within the provided buffer.
    size_t xSimulatedLength = (ulPacketCounter % (xBufferSize - 1)) + 1; // Length from 1 to xBufferSize-1

    // Fill the buffer with dummy data.
    for (size_t i = 0; i < xSimulatedLength; i++)
    {
        pucBuffer[i] = (uint8_t)(ulPacketCounter + i);
    }
    ulPacketCounter++;

    return xSimulatedLength; // Return the simulated packet length.
}

// Helper function to create the network packet processing task.
void vStartNetworkPacketProcessorTask(UBaseType_t uxPriority)
{
    xTaskCreate(vNetworkPacketProcessorTask,
                "NetProc",                         // A descriptive name for the task.
                configMINIMAL_STACK_SIZE,          // The stack size allocated for the task.
                NULL,                              // No parameters passed to the task.
                uxPriority,                        // The priority at which the task will run.
                NULL);                             // No task handle needed.
}