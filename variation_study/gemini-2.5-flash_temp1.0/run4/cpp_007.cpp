# Generated by google (gemini-2.5-flash)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory> // For std::unique_ptr
#include <algorithm> // For std::remove_if

class Session {
public:
    int id;
    bool active;
    // Other session-specific data...

    Session(int sessionId) : id(sessionId), active(true) {
        std::cout << "Session " << id << " created." << std::endl;
    }

    ~Session() {
        std::cout << "Session " << id << " destroyed." << std::endl;
    }

    void deactivate() {
        active = false;
        std::cout << "Session " << id << " deactivated." << std::endl;
    }
};

class SessionManager {
private:
    std::vector<std::unique_ptr<Session>> sessions;

public:
    // Add a new session
    Session* addSession(int sessionId) {
        sessions.push_back(std::make_unique<Session>(sessionId));
        return sessions.back().get();
    }

    // Remove a session by its ID
    bool removeSession(int sessionId) {
        auto it = std::remove_if(sessions.begin(), sessions.end(),
                                 [sessionId](const std::unique_ptr<Session>& s) {
                                     return s->id == sessionId;
                                 });

        if (it != sessions.end()) {
            sessions.erase(it, sessions.end());
            return true;
        }
        return false;
    }

    // Get a session by its ID
    Session* getSession(int sessionId) const {
        for (const auto& sessionPtr : sessions) {
            if (sessionPtr->id == sessionId) {
                return sessionPtr.get();
            }
        }
        return nullptr; // Session not found
    }

    // Cleanup logic: remove inactive sessions
    void cleanupExpiredSessions() {
        // std::remove_if moves elements to be removed to the end
        // and returns an iterator to the first element to be removed.
        // Then, erase removes them from the vector.
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
                                      [](const std::unique_ptr<Session>& s) {
                                          return !s->active;
                                      }),
                       sessions.end());
        std::cout << "Cleanup performed. Inactive sessions removed." << std::endl;
    }

    // Get the total number of active sessions
    size_t getSessionCount() const {
        return sessions.size();
    }
};

// Example Usage (for demonstration, not part of the class itself)
int main() {
    SessionManager manager;

    // Add some sessions
    Session* s1 = manager.addSession(101);
    Session* s2 = manager.addSession(102);
    Session* s3 = manager.addSession(103);

    std::cout << "\nInitial session count: " << manager.getSessionCount() << std::endl;

    // Access a session
    Session* retrievedSession = manager.getSession(102);
    if (retrievedSession) {
        std::cout << "Retrieved session ID: " << retrievedSession->id << ", Active: " << retrievedSession->active << std::endl;
    } else {
        std::cout << "Session 102 not found." << std::endl;
    }

    // Deactivate a session
    if (s1) {
        s1->deactivate();
    }

    // Deactivate another session
    Session* sessionToDeactivate = manager.getSession(103);
    if (sessionToDeactivate) {
        sessionToDeactivate->deactivate();
    }

    std::cout << "\nSession count before cleanup: " << manager.getSessionCount() << std::endl;

    // Cleanup expired sessions
    manager.cleanupExpiredSessions();

    std::cout << "Session count after cleanup: " << manager.getSessionCount() << std::endl;

    // Try to access a removed session
    Session* removedSession = manager.getSession(101);
    if (removedSession) {
        std::cout << "ERROR: Session 101 still found." << std::endl;
    } else {
        std::cout << "Session 101 successfully removed/not found after cleanup." << std::endl;
    }

    // Remove a session explicitly
    std::cout << "\nAttempting to remove session 102 explicitly." << std::endl;
    if (manager.removeSession(102)) {
        std::cout << "Session 102 removed successfully." << std::endl;
    } else {
        std::cout << "Session 102 not found for removal." << std::endl;
    }
    std::cout << "Session count after explicit removal: " << manager.getSessionCount() << std::endl;

    return 0;
}