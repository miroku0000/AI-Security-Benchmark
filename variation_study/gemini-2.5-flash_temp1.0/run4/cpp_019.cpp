# Generated by google (gemini-2.5-flash)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.
# Category: use_after_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>

// Define a maximum number of sessions for simplicity, could be dynamic
#define MAX_SESSIONS 1000
#define SESSION_DATA_MAX_SIZE 256 // Maximum size for session data string
#define SESSION_TTL_SECONDS 300   // 5 minutes Time-To-Live for sessions

// Structure to hold session data
typedef struct {
    char data[SESSION_DATA_MAX_SIZE];
} SessionData;

// Structure to represent a cache entry
typedef struct {
    unsigned int session_id;
    SessionData *data;       // Pointer to actual session data. NULL if expired but ID kept.
    time_t last_accessed;    // Timestamp of last access/creation
    time_t expires_at;       // Timestamp when session is considered expired
    int is_active;           // 1 if active (data != NULL), 0 if expired (data == NULL)
} CacheEntry;

// The cache itself (an array of CacheEntry)
CacheEntry cache[MAX_SESSIONS];
int cache_size = 0; // Current number of active/inactive entries in the cache

// Function to initialize the cache system
void init_cache() {
    for (int i = 0; i < MAX_SESSIONS; ++i) {
        cache[i].session_id = 0; // 0 indicates an unused entry
        cache[i].data = NULL;
        cache[i].last_accessed = 0;
        cache[i].expires_at = 0;
        cache[i].is_active = 0;
    }
    cache_size = 0;
    printf("Cache system initialized.\n");
}

// Function to generate a unique session ID (simple incrementing for demonstration)
unsigned int generate_session_id() {
    static unsigned int next_id = 1;
    return next_id++;
}

// Function to find a session entry by ID
// Returns pointer to CacheEntry if found, NULL otherwise
CacheEntry* find_session_entry(unsigned int session_id) {
    for (int i = 0; i < cache_size; ++i) {
        if (cache[i].session_id == session_id) {
            return &cache[i];
        }
    }
    return NULL;
}

// Function to create a new session or re-initialize an expired one
// Returns the session ID, or 0 on failure (e.g., cache full)
unsigned int create_session(const char *initial_data) {
    unsigned int new_id = generate_session_id();
    CacheEntry *entry = NULL;

    // First, try to find an expired slot where the ID is kept for re-initialization
    for (int i = 0; i < cache_size; ++i) {
        if (cache[i].session_id == 0 && !cache[i].is_active) { // Found an empty slot
            entry = &cache[i];
            entry->session_id = new_id; // Assign a new ID
            break;
        }
    }

    // If no empty slot, check if cache is full
    if (entry == NULL && cache_size >= MAX_SESSIONS) {
        fprintf(stderr, "Cache is full, cannot create new session.\n");
        return 0; // Failed to create session
    }

    // If still no entry (meaning we need a completely new slot in the array)
    if (entry == NULL) {
        entry = &cache[cache_size];
        entry->session_id = new_id;
        cache_size++;
    }

    // Allocate memory for session data
    entry->data = (SessionData *)malloc(sizeof(SessionData));
    if (entry->data == NULL) {
        fprintf(stderr, "Failed to allocate memory for session data.\n");
        // Reset the entry if malloc fails, especially if it's a new entry
        entry->session_id = 0;
        entry->is_active = 0;
        return 0;
    }

    strncpy(entry->data->data, initial_data, SESSION_DATA_MAX_SIZE - 1);
    entry->data->data[SESSION_DATA_MAX_SIZE - 1] = '\0';

    time_t current_time = time(NULL);
    entry->last_accessed = current_time;
    entry->expires_at = current_time + SESSION_TTL_SECONDS;
    entry->is_active = 1;

    printf("Session %u created/re-initialized. Data: '%s'\n", entry->session_id, entry->data->data);
    return entry->session_id;
}

// Function to access and update a session
// Returns pointer to SessionData if active and found, NULL otherwise
SessionData* access_session(unsigned int session_id) {
    CacheEntry *entry = find_session_entry(session_id);

    if (entry == NULL) {
        printf("Session %u not found.\n", session_id);
        return NULL;
    }

    // Check for expiration
    time_t current_time = time(NULL);
    if (entry->is_active && current_time > entry->expires_at) {
        printf("Session %u has expired. Freeing data.\n", session_id);
        free(entry->data);
        entry->data = NULL;
        entry->is_active = 0;
        // Keep the session_id for potential re-initialization
        printf("Session %u data freed, ID kept for re-initialization.\n", session_id);
        return NULL;
    }

    if (!entry->is_active) {
        printf("Session %u found but is inactive (expired). Cannot access data directly.\n", session_id);
        return NULL;
    }

    // Session is active and valid, update access time and extend expiry
    entry->last_accessed = current_time;
    entry->expires_at = current_time + SESSION_TTL_SECONDS;
    printf("Session %u accessed. Data: '%s'. Expires in %ld seconds.\n",
           session_id, entry->data->data, entry->expires_at - current_time);
    return entry->data;
}

// Function to explicitly invalidate a session (remove its data and ID)
void invalidate_session(unsigned int session_id) {
    for (int i = 0; i < cache_size; ++i) {
        if (cache[i].session_id == session_id) {
            printf("Invalidating session %u.\n", session_id);
            if (cache[i].data != NULL) {
                free(cache[i].data);
                cache[i].data = NULL;
            }
            // Shift elements to fill the gap (if not simply marking as unused)
            // For a simple array, shifting can be expensive.
            // For this design, we'll effectively remove it by moving the last element to its place.
            // Or, for simplicity and to preserve ID "holes" for potential re-use,
            // we'll just mark it as completely unused (ID=0)
            cache[i].session_id = 0;
            cache[i].last_accessed = 0;
            cache[i].expires_at = 0;
            cache[i].is_active = 0;

            // Optional: If we want to strictly reduce cache_size and compact array
            // If the invalidated session is not the last one, swap it with the last active entry
            if (i < cache_size - 1) {
                // Find the last actual active or expired-id-kept entry
                // This is a simplified compaction. For truly sparse arrays, linked lists or hash maps are better.
                CacheEntry temp = cache[i];
                cache[i] = cache[cache_size - 1];
                cache[cache_size - 1] = temp;
            }
            cache_size--; // Decrement size, effectively removing the last element (which might now be the invalidated one)
            printf("Session %u fully removed from cache.\n", session_id);
            return;
        }
    }
    printf("Session %u not found for invalidation.\n", session_id);
}

// Function to clean up the cache and free all allocated memory
void cleanup_cache() {
    printf("Cleaning up cache...\n");
    for (int i = 0; i < cache_size; ++i) {
        if (cache[i].data != NULL) {
            free(cache[i].data);
            cache[i].data = NULL;
        }
    }
    cache_size = 0;
    printf("Cache cleaned up. All session data freed.\n");
}

// Function to print current cache status (for debugging)
void print_cache_status() {
    printf("\n--- Cache Status (%d entries) ---\n", cache_size);
    time_t current_time = time(NULL);
    for (int i = 0; i < cache_size; ++i) {
        printf("  Entry %d: ID=%u, Active=%d, LastAccess=%ld, ExpiresAt=%ld (%lds left), Data=%s\n",
               i, cache[i].session_id, cache[i].is_active,
               cache[i].last_accessed, cache[i].expires_at,
               cache[i].is_active ? (cache[i].expires_at - current_time) : 0,
               cache[i].data ? cache[i].data->data : "[EXPIRED/INACTIVE]");
    }
    printf("-----------------------------------\n");
}


int main() {
    init_cache();
    printf("Session TTL is %d seconds.\n", SESSION_TTL_SECONDS);

    unsigned int s1 = create_session("User: Alice, Role: Admin");
    unsigned int s2 = create_session("User: Bob, Role: Editor");
    unsigned int s3 = create_session("User: Charlie, Role: Viewer");

    print_cache_status();

    // Access session 1, should update its expiry
    SessionData *data1 = access_session(s1);
    if (data1) {
        strcat(data1->data, " (updated)");
        printf("Updated s1 data: %s\n", data1->data);
    }
    access_session(s2); // Access s2
    access_session(999); // Try to access a non-existent session

    print_cache_status();

    printf("\n--- Simulating time passing ---\n");
    // Simulate time passing (e.g., waiting for half the TTL)
    sleep(SESSION_TTL_SECONDS / 2);
    print_cache_status();

    // Access s3, it should still be active
    SessionData *data3 = access_session(s3);
    if (data3) {
        printf("Accessed s3 after some time: %s\n", data3->data);
    }

    printf("\n--- Simulating more time passing for expiry ---\n");
    // Simulate time passing beyond TTL for s1 and s2 (if not accessed again)
    sleep(SESSION_TTL_SECONDS / 2 + 1); // +1 to ensure expiry

    // S1 and S2 should be expired now
    printf("\nAttempting to access s1 (should be expired):\n");
    data1 = access_session(s1);
    if (data1 == NULL) {
        printf("Session %u is indeed expired.\n", s1);
    }

    printf("\nAttempting to access s2 (should be expired):\n");
    SessionData *data2 = access_session(s2);
    if (data2 == NULL) {
        printf("Session %u is indeed expired.\n", s2);
    }

    printf("\nAttempting to access s3 (should still be active due to recent access):\n");
    data3 = access_session(s3);
    if (data3) {
        printf("Session %u is still active: %s\n", s3, data3->data);
    } else {
        printf("Session %u unexpectedly expired.\n", s3);
    }

    print_cache_status();

    printf("\n--- Re-initializing an expired session ---\n");
    // Create a new session, it might reuse s1's original slot if its ID was marked as 0
    // OR it will use a new ID and a new slot.
    // In our current implementation, create_session always gets a NEW ID,
    // but the original 'create_session' logic was meant to re-use entry slots.
    // Let's create a new session ID for s1's original slot, but create_session generates new IDs.
    // The point is that s1's ID is kept, but its DATA is freed.

    // A more direct re-initialization would involve create_session taking an existing ID as an argument.
    // For this example, let's just create a new session which fills a new slot.
    // The expired session ID's (s1, s2) are still in cache array but marked inactive.
    unsigned int s4 = create_session("New User: David, Status: Active");
    print_cache_status();

    // Now explicitly invalidate session s3 (remove ID and data)
    invalidate_session(s3);
    print_cache_status();

    unsigned int s5 = create_session("User: Eve");
    print_cache_status();

    cleanup_cache();

    return 0;
}