# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept> // For std::runtime_error
#include <string>
#include <utility>   // For std::move

// A simplified representation of a network connection resource
// In a real application, this would be a socket descriptor, a library connection object, etc.
struct ConnectionResource {
    int handle;
    bool is_valid;

    ConnectionResource() : handle(-1), is_valid(false) {}
    ConnectionResource(int h) : handle(h), is_valid(true) {}

    // Simulate release of the resource
    void release() {
        if (is_valid) {
            std::cout << "DEBUG: Releasing connection resource with handle: " << handle << std::endl;
            // In a real scenario, this would involve calling close(), shutdown(), etc.
            handle = -1;
            is_valid = false;
        }
    }
};

class NetworkConnectionManager {
private:
    ConnectionResource connection_resource_;
    bool is_connected_;

    // Static counter to simulate unique connection handles
    static int next_connection_handle_id_;

    // Private helper to simulate establishing a new connection
    // Returns true on success, false on failure (and ensures no partial resource leaks)
    bool establish_connection_internal() {
        std::cout << "DEBUG: Attempting to establish a new connection..." << std::endl;

        // Simulate a connection failure every 3 attempts
        if (next_connection_handle_id_ % 3 == 0 && next_connection_handle_id_ != 0) {
            std::cout << "ERROR: Simulated connection failure during establishment." << std::endl;
            connection_resource_.release(); // Ensure no previous resource is leaked if trying to re-establish
            is_connected_ = false;
            return false;
        }

        // Simulate acquiring a new handle
        int new_handle = ++next_connection_handle_id_;
        std::cout << "DEBUG: Connection established, assigned handle: " << new_handle << std::endl;

        // If there was an old resource, it should have been released by `release_connection_internal`
        connection_resource_ = ConnectionResource(new_handle);
        is_connected_ = true;
        return true;
    }

    // Private helper to simulate releasing an existing connection
    void release_connection_internal() {
        if (is_connected_ && connection_resource_.is_valid) {
            connection_resource_.release();
            is_connected_ = false;
            std::cout << "DEBUG: Connection successfully released." << std::endl;
        } else {
            std::cout << "DEBUG: No active connection to release." << std::endl;
        }
    }

public:
    // Constructor: Allocates initial connection resources
    NetworkConnectionManager() : is_connected_(false) {
        std::cout << "NetworkConnectionManager: Constructor called." << std::endl;
        if (!establish_connection_internal()) {
            // Constructor failed to establish an initial connection.
            // All resources acquired by establish_connection_internal (if any partial) should be cleaned up.
            // Throw an exception to indicate construction failure.
            throw std::runtime_error("Failed to initialize NetworkConnectionManager: initial connection failed.");
        }
        std::cout << "NetworkConnectionManager: Initial connection successful, handle: " << connection_resource_.handle << std::endl;
    }

    // Destructor: Cleans up any active connection resources
    ~NetworkConnectionManager() {
        std::cout << "NetworkConnectionManager: Destructor called." << std::endl;
        release_connection_internal();
        std::cout << "NetworkConnectionManager: Resources cleaned up." << std::endl;
    }

    // Prevents copying of the connection manager
    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    // Allows moving of the connection manager
    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept
        : connection_resource_(std::exchange(other.connection_resource_, ConnectionResource())),
          is_connected_(std::exchange(other.is_connected_, false)) {
        std::cout << "NetworkConnectionManager: Move constructor called." << std::endl;
    }

    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            release_connection_internal(); // Release current resources

            connection_resource_ = std::exchange(other.connection_resource_, ConnectionResource());
            is_connected_ = std::exchange(other.is_connected_, false);
            std::cout << "NetworkConnectionManager: Move assignment operator called." << std::endl;
        }
        return *this;
    }

    // Resets the connection: releases the current one and attempts to establish a new one.
    // Handles failures gracefully without throwing if object was initially constructed.
    void reset_connection() {
        std::cout << "\nNetworkConnectionManager: Resetting connection..." << std::endl;
        release_connection_internal();

        if (establish_connection_internal()) {
            std::cout << "NetworkConnectionManager: Connection reset successful, new handle: " << connection_resource_.handle << std::endl;
        } else {
            std::cout << "ERROR: NetworkConnectionManager: Failed to reset connection. Manager is now disconnected." << std::endl;
            // The manager is now in a disconnected state, but no resources are leaked.
            // It might be possible to try resetting again later.
        }
    }

    // Reinitializes the connection: conceptually similar to reset, but might imply
    // clearing more internal state if this were a more complex object.
    // For this example, it behaves identically to reset_connection().
    void reinitialize_connection() {
        std::cout << "\nNetworkConnectionManager: Reinitializing connection..." << std::endl;
        // In a more complex class, this might involve clearing cached data,
        // resetting internal buffers, or other state unique to the connection instance.
        // For simple resource management, it often mirrors 'reset'.
        reset_connection();
    }

    // Returns true if the manager currently holds an active connection.
    bool is_active() const {
        return is_connected_ && connection_resource_.is_valid;
    }

    // Returns the current connection handle, or -1 if no active connection.
    int get_connection_handle() const {
        return connection_resource_.handle;
    }
};

// Initialize the static member
int NetworkConnectionManager::next_connection_handle_id_ = 0;


// Example Usage
int main() {
    std::cout << "--- Attempting to create manager 1 (should succeed) ---" << std::endl;
    try {
        NetworkConnectionManager manager1;
        std::cout << "Manager 1 created successfully. Active: " << (manager1.is_active() ? "Yes" : "No")
                  << ", Handle: " << manager1.get_connection_handle() << std::endl;

        manager1.reset_connection();
        std::cout << "Manager 1 after reset. Active: " << (manager1.is_active() ? "Yes" : "No")
                  << ", Handle: " << manager1.get_connection_handle() << std::endl;

        manager1.reinitialize_connection();
        std::cout << "Manager 1 after reinitialize. Active: " << (manager1.is_active() ? "Yes" : "No")
                  << ", Handle: " << manager1.get_connection_handle() << std::endl;

        std::cout << "\n--- Attempting to create manager 2 (should fail on initial connection) ---" << std::endl;
        try {
            // This will trigger a simulated failure because next_connection_handle_id_ will be 3
            NetworkConnectionManager manager2;
            std::cout << "Manager 2 created successfully. This should not happen if simulation works." << std::endl;
        } catch (const std::runtime_error& e) {
            std::cerr << "Caught expected error during manager 2 construction: " << e.what() << std::endl;
        }

        std::cout << "\n--- Attempting to create manager 3 (should succeed) ---" << std::endl;
        NetworkConnectionManager manager3;
        std::cout << "Manager 3 created successfully. Active: " << (manager3.is_active() ? "Yes" : "No")
                  << ", Handle: " << manager3.get_connection_handle() << std::endl;

        std::cout << "\n--- Testing move semantics ---" << std::endl;
        NetworkConnectionManager manager4 = std::move(manager3);
        std::cout << "Manager 4 (moved from manager 3) created successfully. Active: " << (manager4.is_active() ? "Yes" : "No")
                  << ", Handle: " << manager4.get_connection_handle() << std::endl;
        std::cout << "Manager 3 after move: Active: " << (manager3.is_active() ? "Yes" : "No")
                  << ", Handle: " << manager3.get_connection_handle() << std::endl;


    } catch (const std::runtime_error& e) {
        std::cerr << "Caught unexpected error in main: " << e.what() << std::endl;
    }

    std::cout << "\n--- End of main function ---" << std::endl;
    // Destructors for manager1 and manager4 will be called automatically here
    return 0;
}