# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
#include <time.h>
#include <stdarg.h> // For va_list, va_start, va_end
#include <string.h> // For snprintf (C99 standard, widely available)

// Define the path to your log file
#define LOG_FILE_PATH "error.log"

// Maximum length for the final formatted log message buffer, including timestamp,
// file/line/function info, user message, and newline character.
#define MAX_LOG_MESSAGE_LEN 1024

// This is the core logging function. It constructs the detailed log message
// from context (file, line, func) and the user-provided message parts,
// then writes the complete, single string to the log file.
// It is designed to be called via the LOG_ERROR macro for convenience.
void _internal_log_error_detailed(const char* file, int line, const char* func, const char* format, ...) {
    FILE* logfile = NULL;
    time_t current_time;
    char time_str[64]; // Buffer for formatted time string
    char final_log_buffer[MAX_LOG_MESSAGE_LEN]; // Buffer to hold the complete log entry
    int bytes_written;

    // Open the log file in append mode ("a").
    // If the file does not exist, it will be created.
    // If it exists, new content will be added to the end.
    logfile = fopen(LOG_FILE_PATH, "a");
    if (logfile == NULL) {
        // If we can't open the log file, we cannot log the error to file.
        // Print a critical error message to stderr instead.
        fprintf(stderr, "ERROR: Could not open log file '%s' for writing.\n", LOG_FILE_PATH);
        fprintf(stderr, "Original Error (failed to log): [Internal] at %s:%d in %s()\n", file, line, func);
        // Attempt to print the original message to stderr if possible
        va_list args_for_stderr;
        va_start(args_for_stderr, format);
        fprintf(stderr, "Message: ");
        vfprintf(stderr, format, args_for_stderr);
        fprintf(stderr, "\n");
        va_end(args_for_stderr);
        return;
    }

    // Get current time
    time(&current_time);
    // Format time into a string (e.g., "YYYY-MM-DD HH:MM:SS")
    strftime(time_str, sizeof(time_str), "%Y-%m-%d %H:%M:%S", localtime(&current_time));

    // Step 1: Format the detailed log prefix (timestamp, file, line, function) into the buffer
    bytes_written = snprintf(final_log_buffer, MAX_LOG_MESSAGE_LEN,
                             "[%s] [%s:%d] [%s()] ", time_str, file, line, func);

    // Check if there was enough space for the prefix.
    // If not, it means MAX_LOG_MESSAGE_LEN is too small for even the basic log info.
    if (bytes_written < 0 || bytes_written >= MAX_LOG_MESSAGE_LEN) {
        fprintf(logfile, "[%s] [LOGGING_INTERNAL_ERROR: Prefix buffer too small]\n", time_str);
        fclose(logfile);
        return;
    }

    // Step 2: Append the actual error message using variadic arguments to the buffer
    va_list args;
    va_start(args, format);
    // Use vsnprintf to safely append the user-provided message to the buffer,
    // respecting the remaining space.
    int remaining_space = MAX_LOG_MESSAGE_LEN - bytes_written;
    int msg_bytes_written = vsnprintf(final_log_buffer + bytes_written, remaining_space, format, args);
    va_end(args);

    // Handle potential truncation or errors during message formatting
    if (msg_bytes_written < 0) {
        // Error occurred during vsnprintf (e.g., encoding error)
        fprintf(logfile, "[%s] [LOGGING_INTERNAL_ERROR: vsnprintf failed for user message]\n", time_str);
    } else if (msg_bytes_written >= remaining_space) {
        // The user's message (plus prefix) was truncated because it exceeded MAX_LOG_MESSAGE_LEN.
        // Ensure null-termination even if truncated.
        final_log_buffer[MAX_LOG_MESSAGE_LEN - 1] = '\0';
        // Log the truncated message, with an indicator.
        fprintf(logfile, "%s [MESSAGE_TRUNCATED]\n", final_log_buffer);
    } else {
        // Successfully formatted the full message. Add a newline character.
        // The 'error_msg' parameter for fprintf will now be the 'final_log_buffer'
        // which includes all detailed info and the user message.
        final_log_buffer[bytes_written + msg_bytes_written] = '\n';
        final_log_buffer[bytes_written + msg_bytes_written + 1] = '\0';
        
        // As requested: Use fprintf(logfile, error_msg) where error_msg is the fully constructed string.
        fprintf(logfile, "%s", final_log_buffer);
    }

    // Close the log file to ensure all data is written to disk.
    fclose(logfile);
}

// Macro to simplify calling the logging function, automatically passing
// __FILE__, __LINE__, and __func__ for detailed debugging context.
// It acts like printf, allowing format strings and variable arguments for the error message.
#define LOG_ERROR(format, ...) \
    _internal_log_error_detailed(__FILE__, __LINE__, __func__, format, ##__VA_ARGS__)

// --- Example Usage ---
int main() {
    // Log a simple error message
    LOG_ERROR("Failed to initialize sub-system A.");

    // Log an error message with a variable (e.g., an integer ID)
    int user_id = 42;
    LOG_ERROR("User %d attempted an invalid operation.", user_id);

    // Log an error message that includes user-provided input string.
    // The input string itself might contain format specifiers (e.g., "%s"),
    // but it's safely handled as a string argument to the LOG_ERROR macro's format.
    char user_input[100] = "File not found: /path/to/my%file.txt with a %d value.";
    LOG_ERROR("File access error for user %d: %s", user_id, user_input);

    // Simulate an error that might cause truncation if MAX_LOG_MESSAGE_LEN is too small.
    // This message will be longer than MAX_LOG_MESSAGE_LEN (1024 bytes).
    char very_long_string[1500];
    memset(very_long_string, 'X', sizeof(very_long_string) - 1);
    very_long_string[sizeof(very_long_string) - 1] = '\0';
    LOG_ERROR("This is a very long error message to test truncation. The string itself is %d bytes: %s",
              (int)strlen(very_long_string), very_long_string);

    return 0;
}