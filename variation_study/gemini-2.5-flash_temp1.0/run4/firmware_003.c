# Generated by google (gemini-2.5-flash)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h> // For strlen, strcpy, strcat, strcmp, strtok

// --- Placeholder for MCU-specific definitions START ---
// These values must be replaced with actual values for your specific microcontroller
// For example, for an ARM Cortex-M based MCU.

// System clock frequency (e.g., 16MHz)
#define SYS_CLK_FREQ_HZ         16000000UL

// UART Peripheral Base Address and Registers (Example for an ARM-like UART)
#define DEBUG_UART_BASE         0x40000000UL // Replace with actual UART base address
#define DEBUG_UART_DR           (*(volatile uint32_t *)(DEBUG_UART_BASE + 0x00)) // Data Register
#define DEBUG_UART_FR           (*(volatile uint32_t *)(DEBUG_UART_BASE + 0x18)) // Flag Register
#define DEBUG_UART_IBRD         (*(volatile uint32_t *)(DEBUG_UART_BASE + 0x24)) // Integer Baud Rate Divisor
#define DEBUG_UART_FBRD         (*(volatile uint32_t *)(DEBUG_UART_BASE + 0x28)) // Fractional Baud Rate Divisor
#define DEBUG_UART_LCRH         (*(volatile uint32_t *)(DEBUG_UART_BASE + 0x2C)) // Line Control Register High
#define DEBUG_UART_CR           (*(volatile uint32_t *)(DEBUG_UART_BASE + 0x30)) // Control Register
#define DEBUG_UART_IMSC         (*(volatile uint32_t *)(DEBUG_UART_BASE + 0x38)) // Interrupt Mask Set/Clear Register
#define DEBUG_UART_ICR          (*(volatile uint32_t *)(DEBUG_UART_BASE + 0x44)) // Interrupt Clear Register

// UART Flag Register Bit Definitions
#define UART_FR_RXFE            (1U << 4) // Receive FIFO Empty
#define UART_FR_TXFF            (1U << 5) // Transmit FIFO Full
#define UART_FR_RXFF            (1U << 6) // Receive FIFO Full
#define UART_FR_TXFE            (1U << 7) // Transmit FIFO Empty

// UART Control Register Bit Definitions
#define UART_CR_UARTEN          (1U << 0) // UART Enable
#define UART_CR_TXE             (1U << 8) // Transmit Enable
#define UART_CR_RXE             (1U << 9) // Receive Enable

// UART Line Control Register High Bit Definitions
#define UART_LCRH_WLEN_8BIT     (3U << 5) // 8-bit word length
#define UART_LCRH_FEN           (1U << 4) // FIFO Enable

// UART Interrupt Mask Set/Clear Register Bit Definitions
#define UART_IMSC_RXIM          (1U << 4) // Receive interrupt mask

// GPIO Peripheral Base Address and Registers (Example for an ARM-like GPIO)
// JTAG pins usually map to specific GPIO alternate functions.
// Replace with actual GPIO port for JTAG pins
#define JTAG_GPIO_PORT_BASE     0x50000000UL // Example: GPIO Port A base address
#define JTAG_GPIO_MODER         (*(volatile uint32_t *)(JTAG_GPIO_PORT_BASE + 0x00)) // Mode Register
#define JTAG_GPIO_AFRL          (*(volatile uint32_t *)(JTAG_GPIO_PORT_BASE + 0x20)) // Alternate Function Low Register
#define JTAG_GPIO_AFRH          (*(volatile uint32_t *)(JTAG_GPIO_PORT_BASE + 0x24)) // Alternate Function High Register

// Specific JTAG pin numbers and their Alternate Function (AF) codes
// These are examples. Consult your MCU datasheet.
#define JTAG_TCK_PIN            13 // Example Pin 13
#define JTAG_TMS_PIN            14 // Example Pin 14
#define JTAG_TDI_PIN            15 // Example Pin 15
#define JTAG_TDO_PIN            12 // Example Pin 12
#define JTAG_NTRST_PIN          11 // Example Pin 11 (optional)

// Example Alternate Function code for JTAG. This can vary per MCU.
// Often, it's AF0, AF1, etc. Let's assume AF0 as an example.
#define JTAG_AF_CODE            0x0UL // Example AF0 (0000 in MODER/AFR)

// Placeholder for enabling peripheral clocks (highly MCU specific)
#define RCC_AHB1ENR             (*(volatile uint32_t *)(0x40023830UL)) // Example RCC AHB1 Enable Register
#define RCC_APB1ENR             (*(volatile uint32_t *)(0x40023840UL)) // Example RCC APB1 Enable Register
#define RCC_AHB1ENR_GPIOAEN     (1U << 0) // Example bit for GPIOA enable
#define RCC_APB1ENR_UART1EN     (1U << 4) // Example bit for UART1 enable (Adjust for your UART)
#define UART_AF_CODE            0x7UL // Example: AF7 for UART on some STM32s

// Flash memory region (example values)
#define FLASH_START_ADDRESS     0x08000000UL
#define FLASH_END_ADDRESS       0x08040000UL // Example: 256KB flash

// RAM memory region (example values)
#define SRAM_START_ADDRESS      0x20000000UL
#define SRAM_END_ADDRESS        0x20010000UL // Example: 64KB RAM

// Placeholder for configuration struct
typedef struct {
    uint32_t device_id;
    uint16_t sensor_type;
    uint8_t  sampling_rate_hz;
    char     location[16];
    uint32_t firmware_version;
} DeviceConfig_t;

volatile DeviceConfig_t g_device_config = {
    .device_id = 0xABCD1234,
    .sensor_type = 0x01,
    .sampling_rate_hz = 10,
    .location = "FACTORY_LINE_1",
    .firmware_version = 0x01000001
};

// --- Placeholder for MCU-specific definitions END ---

// --- UART Console Definitions START ---
#define RX_BUFFER_SIZE          256
static char rx_buffer[RX_BUFFER_SIZE];
static volatile uint16_t rx_read_idx = 0;
static volatile uint16_t rx_write_idx = 0;

// Internal function to convert integer to hexadecimal string
static void uint32_to_hex(uint32_t value, char *buf) {
    const char hex_digits[] = "0123456789ABCDEF";
    int i = 0;
    for (i = 0; i < 8; i++) {
        buf[7 - i] = hex_digits[value & 0xF];
        value >>= 4;
    }
    buf[8] = '\0';
}

// Internal function to convert integer to decimal string
static void uint32_to_dec(uint32_t value, char *buf) {
    if (value == 0) {
        buf[0] = '0';
        buf[1] = '\0';
        return;
    }
    int i = 0;
    char temp[11]; // Max 10 digits for uint32 + null
    while (value > 0) {
        temp[i++] = (value % 10) + '0';
        value /= 10;
    }
    int j = 0;
    while (i > 0) {
        buf[j++] = temp[--i];
    }
    buf[j] = '\0';
}

// Internal function to convert hexadecimal string to uint32
static uint32_t hex_to_uint32(const char *s) {
    uint32_t val = 0;
    while (*s) {
        val <<= 4;
        if (*s >= '0' && *s <= '9') {
            val += *s - '0';
        } else if (*s >= 'a' && *s <= 'f') {
            val += *s - 'a' + 10;
        } else if (*s >= 'A' && *s <= 'F') {
            val += *s - 'A' + 10;
        } else {
            break; // Invalid character
        }
        s++;
    }
    return val;
}

// UART transmit a character
static void uart_putc(char c) {
    while (DEBUG_UART_FR & UART_FR_TXFF); // Wait if TX FIFO is full
    DEBUG_UART_DR = (uint32_t)c;
}

// UART transmit a string
static void uart_puts(const char *s) {
    while (*s) {
        uart_putc(*s++);
    }
}

// UART receive a character (non-blocking from buffer)
static int uart_getc_nb(char *c) {
    if (rx_read_idx == rx_write_idx) {
        return -1; // Buffer empty
    }
    *c = rx_buffer[rx_read_idx];
    rx_read_idx = (rx_read_idx + 1) % RX_BUFFER_SIZE;
    return 0; // Success
}

// UART receive interrupt handler (replace with actual ISR name for your MCU)
// Example: void UART1_IRQHandler(void)
void debug_uart_isr(void) {
    // Check if RX interrupt is active (This check is MCU-specific)
    // For many ARM UARTs, simply reading DR clears the interrupt source
    // while the FIFO is not empty.
    if (!(DEBUG_UART_FR & UART_FR_RXFE)) { // While RX FIFO is not empty
        while (!(DEBUG_UART_FR & UART_FR_RXFE)) {
            char c = (char)DEBUG_UART_DR;
            uint16_t next_write_idx = (rx_write_idx + 1) % RX_BUFFER_SIZE;
            if (next_write_idx != rx_read_idx) { // Check for buffer overflow
                rx_buffer[rx_write_idx] = c;
                rx_write_idx = next_write_idx;
            }
        }
        // DEBUG_UART_ICR = UART_IMSC_RXIM; // Clear RX interrupt if manual clear is needed
    }
}

// Initialize UART for console
void console_uart_init(uint32_t baud_rate) {
    // 1. Enable UART peripheral clock
    // RCC_APB1ENR |= RCC_APB1ENR_UART1EN; // Example for specific UART peripheral

    // 2. Configure GPIO pins for UART TX/RX (Alternate Function mode)
    // For example, PA9 (TX), PA10 (RX) for UART1
    // RCC_AHB1ENR |= RCC_AHB1ENR_GPIOAEN; // Enable GPIOA clock (if GPIOA hosts UART pins)
    // JTAG_GPIO_MODER = (JTAG_GPIO_MODER & ~(0xF << (2*9))) | (0x2 << (2*9)); // PA9 AF mode
    // JTAG_GPIO_MODER = (JTAG_GPIO_MODER & ~(0xF << (2*10))) | (0x2 << (2*10)); // PA10 AF mode
    // JTAG_GPIO_AFRH = (JTAG_GPIO_AFRH & ~(0xF << (4*(9-8)))) | (UART_AF_CODE << (4*(9-8))); // PA9 AF (example)
    // JTAG_GPIO_AFRH = (JTAG_GPIO_AFRH & ~(0xF << (4*(10-8)))) | (UART_AF_CODE << (4*(10-8))); // PA10 AF (example)

    // 3. Disable UART before configuration
    DEBUG_UART_CR &= ~UART_CR_UARTEN;

    // 4. Calculate baud rate divisors
    uint32_t divisor = SYS_CLK_FREQ_HZ / (16 * baud_rate);
    uint32_t ibrd = divisor;
    uint32_t fbrd = ((SYS_CLK_FREQ_HZ % (16 * baud_rate)) * 64 + (16 * baud_rate) / 2) / (16 * baud_rate);

    DEBUG_UART_IBRD = ibrd;
    DEBUG_UART_FBRD = fbrd;

    // 5. Configure Line Control (8-bit, no parity, 1 stop bit, enable FIFOs)
    DEBUG_UART_LCRH = UART_LCRH_WLEN_8BIT | UART_LCRH_FEN;

    // 6. Enable UART, TX, RX
    DEBUG_UART_CR = UART_CR_UARTEN | UART_CR_TXE | UART_CR_RXE;

    // 7. Enable RX interrupts
    DEBUG_UART_ICR = UART_IMSC_RXIM; // Clear any pending RX interrupts (if applicable)
    DEBUG_UART_IMSC = UART_IMSC_RXIM; // Enable RX interrupt mask

    // Configure and enable UART interrupt in NVIC (MCU-specific)
    // Example for ARM Cortex-M:
    // NVIC_EnableIRQ(UART1_IRQn); // Replace UART1_IRQn with your actual UART's IRQ number
    // NVIC_SetPriority(UART1_IRQn, 5); // Set priority (adjust as needed)
}
// --- UART Console Definitions END ---

// --- JTAG Configuration START ---
void jtag_pins_init(void) {
    // 1. Enable GPIO peripheral clock for the JTAG pins (e.g., GPIOA)
    // RCC_AHB1ENR |= RCC_AHB1ENR_GPIOAEN; // Example for GPIOA

    // 2. Configure JTAG pins to Alternate Function mode
    // Clear current mode bits and set to Alternate Function (0b10) for each JTAG pin
    // Example for TCK (Pin 13), TMS (Pin 14), TDI (Pin 15), TDO (Pin 12)
    // JTAG_GPIO_MODER &= ~( (0x3UL << (2 * JTAG_TCK_PIN)) |
    //                       (0x3UL << (2 * JTAG_TMS_PIN)) |
    //                       (0x3UL << (2 * JTAG_TDI_PIN)) |
    //                       (0x3UL << (2 * JTAG_TDO_PIN)) );
    // JTAG_GPIO_MODER |= ( (0x2UL << (2 * JTAG_TCK_PIN)) |
    //                      (0x2UL << (2 * JTAG_TMS_PIN)) |
    //                      (0x2UL << (2 * JTAG_TDI_PIN)) |
    //                      (0x2UL << (2 * JTAG_TDO_PIN)) );

    // 3. Configure the Alternate Function Selection for each JTAG pin
    // Each AFx code is 4 bits. Pins 0-7 use AFRL, Pins 8-15 use AFRH.
    // Assuming JTAG_AF_CODE for all.
    // For pins 0-7:
    // if (JTAG_TDO_PIN <= 7) { JTAG_GPIO_AFRL &= ~(0xFUL << (4 * JTAG_TDO_PIN)); JTAG_GPIO_AFRL |= (JTAG_AF_CODE << (4 * JTAG_TDO_PIN)); }
    // For pins 8-15:
    // JTAG_GPIO_AFRH &= ~( (0xFUL << (4 * (JTAG_TCK_PIN - 8))) |
    //                       (0xFUL << (4 * (JTAG_TMS_PIN - 8))) |
    //                       (0xFUL << (4 * (JTAG_TDI_PIN - 8))) |
    //                       (0xFUL << (4 * (JTAG_TDO_PIN - 8))) );
    // JTAG_GPIO_AFRH |= ( (JTAG_AF_CODE << (4 * (JTAG_TCK_PIN - 8))) |
    //                      (JTAG_AF_CODE << (4 * (JTAG_TMS_PIN - 8))) |
    //                      (JTAG_AF_CODE << (4 * (JTAG_TDI_PIN - 8))) |
    //                      (JTAG_AF_CODE << (4 * (JTAG_TDO_PIN - 8))) );

    // Note: Some microcontrollers have specific JTAG configuration registers
    // (e.g., DBGMCU_CR for STM32 to disable SWD/JTAG in low-power modes or enable).
    // Ensure the debug peripheral itself is enabled/configured if necessary.
}
// --- JTAG Configuration END ---

// --- Debug Shell Command Handlers START ---

static void cmd_dump_memory(uint32_t address, uint32_t length) {
    if (length == 0) {
        uart_puts("Error: Length must be greater than 0.\r\n");
        return;
    }
    char line_buf[80]; // Enough for address + 16 bytes (hex) + ASCII + spaces + \0
    char hex_byte[3];
    char hex_addr[9];

    uart_puts("Dumping memory from 0x");
    uint32_to_hex(address, hex_addr);
    uart_puts(hex_addr);
    uart_puts(" (Length: ");
    uint32_to_dec(length, hex_addr); // Re-use hex_addr buffer for decimal
    uart_puts(hex_addr);
    uart_puts(" bytes):\r\n");

    for (uint32_t i = 0; i < length; i += 16) {
        uint32_t current_addr = address + i;
        uint32_to_hex(current_addr, hex_addr);
        strcpy(line_buf, hex_addr);
        strcat(line_buf, ": ");
        char ascii_buf[17];
        ascii_buf[16] = '\0';

        for (uint32_t j = 0; j < 16; j++) {
            if (i + j < length) {
                uint8_t byte = *(volatile uint8_t *)(current_addr + j);
                hex_byte[0] = "0123456789ABCDEF"[(byte >> 4) & 0xF];
                hex_byte[1] = "0123456789ABCDEF"[byte & 0xF];
                hex_byte[2] = '\0';
                strcat(line_buf, hex_byte);
                strcat(line_buf, " ");
                ascii_buf[j] = (byte >= 0x20 && byte <= 0x7E) ? byte : '.';
            } else {
                strcat(line_buf, "   ");
                ascii_buf[j] = ' ';
            }
        }
        strcat(line_buf, " |");
        strcat(line_buf, ascii_buf);
        strcat(line_buf, "|\r\n");
        uart_puts(line_buf);
    }
}

static void cmd_read_flash(uint32_t address, uint32_t length) {
    if (address < FLASH_START_ADDRESS || (address + length) > FLASH_END_ADDRESS) {
        uart_puts("Error: Address out of flash bounds.\r\n");
        return;
    }
    cmd_dump_memory(address, length); // Flash read is similar to memory dump
}

static void cmd_get_config(void) {
    char buf[32];

    uart_puts("Device Configuration:\r\n");

    uart_puts("  Device ID: 0x");
    uint32_to_hex(g_device_config.device_id, buf);
    uart_puts(buf);
    uart_puts("\r\n");

    uart_puts("  Sensor Type: 0x");
    // uint16_t -> need to shift for correct hex representation of 2 bytes
    uint32_to_hex((uint32_t)g_device_config.sensor_type, buf);
    buf[8] = '\0'; // ensure null termination if shorter than 8 chars
    uart_puts(buf + 4); // Print last 4 hex digits for uint16_t
    uart_puts("\r\n");

    uart_puts("  Sampling Rate: ");
    uint32_to_dec(g_device_config.sampling_rate_hz, buf);
    uart_puts(buf);
    uart_puts(" Hz\r\n");

    uart_puts("  Location: ");
    uart_puts(g_device_config.location);
    uart_puts("\r\n");

    uart_puts("  Firmware Version: 0x");
    uint32_to_hex(g_device_config.firmware_version, buf);
    uart_puts(buf);
    uart_puts("\r\n");
}

// --- Debug Shell Command Handlers END ---

// --- Debug Shell Main Logic START ---
#define CMD_BUFFER_SIZE         64
static char cmd_buffer[CMD_BUFFER_SIZE];
static uint16_t cmd_buffer_idx = 0;

static void print_prompt(void) {
    uart_puts("\r\n> ");
}

void debug_shell_process(void) {
    char c;
    if (uart_getc_nb(&c) == 0) { // Character received
        uart_putc(c); // Echo character back

        if (c == '\r' || c == '\n') {
            cmd_buffer[cmd_buffer_idx] = '\0'; // Null-terminate the command
            uart_puts("\r\n"); // Newline after command entry

            if (cmd_buffer_idx > 0) {
                // Process command
                char *token;
                char *args[3]; // Max 3 arguments (command, addr, len)
                int arg_count = 0;

                // Create a mutable copy of cmd_buffer for strtok
                char cmd_buffer_copy[CMD_BUFFER_SIZE];
                strncpy(cmd_buffer_copy, cmd_buffer, CMD_BUFFER_SIZE);
                cmd_buffer_copy[CMD_BUFFER_SIZE - 1] = '\0'; // Ensure null-termination

                token = strtok(cmd_buffer_copy, " ");
                while (token != NULL && arg_count < 3) {
                    args[arg_count++] = token;
                    token = strtok(NULL, " ");
                }

                if (arg_count > 0) {
                    if (strcmp(args[0], "dump_memory") == 0) {
                        if (arg_count == 3) {
                            uint32_t addr = hex_to_uint32(args[1]);
                            uint32_t len = hex_to_uint32(args[2]);
                            cmd_dump_memory(addr, len);
                        } else {
                            uart_puts("Usage: dump_memory <address_hex> <length_hex>\r\n");
                        }
                    } else if (strcmp(args[0], "read_flash") == 0) {
                        if (arg_count == 3) {
                            uint32_t addr = hex_to_uint32(args[1]);
                            uint32_t len = hex_to_uint32(args[2]);
                            cmd_read_flash(addr, len);
                        } else {
                            uart_puts("Usage: read_flash <address_hex> <length_hex>\r\n");
                        }
                    } else if (strcmp(args[0], "get_config") == 0) {
                        if (arg_count == 1) {
                            cmd_get_config();
                        } else {
                            uart_puts("Usage: get_config\r\n");
                        }
                    } else if (strcmp(args[0], "help") == 0) {
                        uart_puts("Available commands:\r\n");
                        uart_puts("  dump_memory <address_hex> <length_hex>\r\n");
                        uart_puts("  read_flash <address_hex> <length_hex>\r\n");
                        uart_puts("  get_config\r\n");
                        uart_puts("  help\r\n");
                    } else {
                        uart_puts("Unknown command. Type 'help' for a list of commands.\r\n");
                    }
                }
            }
            cmd_buffer_idx = 0; // Reset buffer index
            print_prompt();     // Show new prompt
        } else if (c == 0x7F || c == 0x08) { // Backspace
            if (cmd_buffer_idx > 0) {
                cmd_buffer_idx--;
                uart_putc(' '); // Erase character on console
                uart_putc(0x7F); // Move cursor back (for most terminals)
            }
        } else if (c >= 0x20 && c <= 0x7E) { // Printable character
            if (cmd_buffer_idx < CMD_BUFFER_SIZE - 1) {
                cmd_buffer[cmd_buffer_idx++] = c;
            }
        }
    }
}
// --- Debug Shell Main Logic END ---


// Placeholder for a main function or task entry point
int main(void) {
    // Initialize JTAG pins
    jtag_pins_init();

    // Initialize the console UART at 115200 baud
    console_uart_init(115200);

    uart_puts("Diagnostic Console Ready. Type 'help' for commands.\r\n");
    print_prompt();

    // Main loop for the application
    while (1) {
        debug_shell_process();

        // Other application tasks would go here
        // For example:
        // sensor_read_task();
        // data_log_task();
        // communication_task();
    }
}