# Generated by google (gemini-2.5-flash)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>

// --- Configuration Defines ---
// !!! IMPORTANT: These values must be adjusted for your specific ARM Cortex-M microcontroller !!!

// Memory Map
#define FLASH_BASE_ADDRESS       0x08000000UL
#define BOOTLOADER_SIZE_BYTES    (32 * 1024)  // Example: 32 KB for bootloader
#define APPLICATION_START_ADDRESS (FLASH_BASE_ADDRESS + BOOTLOADER_SIZE_BYTES)
#define MAX_APPLICATION_SIZE     (256 * 1024) // Example: Max application size 256 KB

// RAM for magic bootloader entry (must be in retained RAM)
#define BOOT_MAGIC_RAM_ADDR      0x20000000UL // Example: Start of SRAM
#define BOOT_MAGIC_VALUE         0xB007C0DEUL // Magic value to force bootloader mode

// GPIO for bootloader entry pin
// Example for a generic GPIO port and pin
#define BOOT_GPIO_PORT_BASE      0x40020000UL // Example: GPIOH Base Address
#define BOOT_GPIO_PIN            (1 << 0)     // Example: Pin 0 of GPIOH
#define BOOT_PIN_ACTIVE_LOW      1            // Set to 1 if pull-up and low means boot, 0 if pull-down and high means boot

// UART Configuration (for firmware upload)
#define UART_BAUDRATE            115200
#define UART_TIMEOUT_MS          1000

// SPI Configuration (for SD card)
// Assumes SPI1 for simplicity, adjust for your MCU
#define SPI_SPEED_HZ             1000000UL    // 1 MHz for SD card init, can be faster later
#define SD_BLOCK_SIZE            512          // Standard SD card block size
#define FIRMWARE_SD_BLOCK_START  16           // Assume firmware.bin starts at block 16 on SD card (raw access)

// Firmware Update Check in Flash
#define FIRMWARE_UPDATE_FLAG_ADDR (FLASH_BASE_ADDRESS + BOOTLOADER_SIZE_BYTES - 4) // Last 4 bytes of bootloader flash
#define FIRMWARE_UPDATE_REQUEST  0xAABBCCDDUL // Magic value to request update

// --- Generic Peripheral Register Definitions (Adjust for your MCU) ---
// These are placeholder definitions. Refer to your MCU's reference manual.

// System Control Block (SCB) - for vector table relocation
#define SCB_VTOR                (*(volatile uint32_t*)0xE000ED08)

// General Purpose I/O (GPIO) - Example using a simplified STM32-like structure
// (e.g., GPIOH on an STM32F4)
#define GPIO_MODER(port_base)   (*(volatile uint32_t*)(port_base + 0x00))
#define GPIO_OTYPER(port_base)  (*(volatile uint32_t*)(port_base + 0x04))
#define GPIO_OSPEEDR(port_base) (*(volatile uint32_t*)(port_base + 0x08))
#define GPIO_PUPDR(port_base)   (*(volatile uint32_t*)(port_base + 0x0C))
#define GPIO_IDR(port_base)     (*(volatile uint32_t*)(port_base + 0x10))
#define GPIO_ODR(port_base)     (*(volatile uint32_t*)(port_base + 0x14))
#define GPIO_AFR(port_base, reg) (*(volatile uint32_t*)(port_base + 0x20 + (reg * 4))) // AFR[0] and AFR[1]

// Reset and Clock Control (RCC) - Example using simplified STM32-like structure
// (e.g., RCC_AHB1ENR, RCC_APB2ENR for peripheral clock enable)
#define RCC_BASE                0x40023800UL // RCC Base Address
#define RCC_AHB1ENR             (*(volatile uint32_t*)(RCC_BASE + 0x30)) // AHB1 Peripheral Clock Enable Register
#define RCC_APB2ENR             (*(volatile uint32_t*)(RCC_BASE + 0x44)) // APB2 Peripheral Clock Enable Register
#define RCC_CR                  (*(volatile uint32_t*)(RCC_BASE + 0x00)) // Clock Control Register
#define RCC_PLLCFGR             (*(volatile uint32_t*)(RCC_BASE + 0x04)) // PLL Configuration Register
#define RCC_CFGR                (*(volatile uint32_t*)(RCC_BASE + 0x08)) // Clock Configuration Register

// Universal Synchronous Asynchronous Receiver Transmitter (USART) - Example using simplified STM32-like structure
// (e.g., USART1)
#define UART_BASE               0x40011000UL // USART1 Base Address
#define UART_SR                 (*(volatile uint32_t*)(UART_BASE + 0x00))
#define UART_DR                 (*(volatile uint32_t*)(UART_BASE + 0x04))
#define UART_BRR                (*(volatile uint32_t*)(UART_BASE + 0x08))
#define UART_CR1                (*(volatile uint32_t*)(UART_BASE + 0x0C))
#define UART_CR2                (*(volatile uint32_t*)(UART_BASE + 0x10))
#define UART_CR3                (*(volatile uint32_t*)(UART_BASE + 0x14))

#define USART_SR_RXNE           (1 << 5)    // Read data register not empty
#define USART_SR_TXE            (1 << 7)    // Transmit data register empty
#define USART_CR1_UE            (1 << 13)   // USART enable
#define USART_CR1_TE            (1 << 3)    // Transmitter enable
#define USART_CR1_RE            (1 << 2)    // Receiver enable

// Serial Peripheral Interface (SPI) - Example using simplified STM32-like structure
// (e.g., SPI1)
#define SPI_BASE                0x40013000UL // SPI1 Base Address
#define SPI_CR1                 (*(volatile uint32_t*)(SPI_BASE + 0x00))
#define SPI_CR2                 (*(volatile uint32_t*)(SPI_BASE + 0x04))
#define SPI_SR                  (*(volatile uint32_t*)(SPI_BASE + 0x08))
#define SPI_DR                  (*(volatile uint32_t*)(SPI_BASE + 0x0C))
#define SPI_CRCPOLR             (*(volatile uint32_t*)(SPI_BASE + 0x10))
#define SPI_RXCRCR              (*(volatile uint32_t*)(SPI_BASE + 0x14))
#define SPI_TXCRCR              (*(volatile uint32_t*)(SPI_BASE + 0x18))
#define SPI_I2SCFGR             (*(volatile uint32_t*)(SPI_BASE + 0x1C))
#define SPI_I2SPR               (*(volatile uint32_t*)(SPI_BASE + 0x20))

#define SPI_CR1_SPE             (1 << 6)    // SPI enable
#define SPI_CR1_MSTR            (1 << 2)    // Master configuration
#define SPI_CR1_BR_DIV2         (0 << 3)    // Baud rate control: fPCLK/2
#define SPI_CR1_BR_DIV4         (1 << 3)
#define SPI_CR1_BR_DIV8         (2 << 3)
#define SPI_CR1_BR_DIV16        (3 << 3)
#define SPI_CR1_BR_DIV32        (4 << 3)
#define SPI_CR1_BR_DIV64        (5 << 3)
#define SPI_CR1_BR_DIV128       (6 << 3)
#define SPI_CR1_BR_DIV256       (7 << 3)
#define SPI_CR1_SSI             (1 << 8)    // Internal slave select
#define SPI_CR1_SSM             (1 << 9)    // Software slave management enable
#define SPI_SR_RXNE             (1 << 0)    // Receive buffer not empty
#define SPI_SR_TXE              (1 << 1)    // Transmit buffer empty
#define SPI_SR_BSY              (1 << 7)    // Busy flag

// Flash Control Register (FCR) - Example using simplified STM32-like structure
#define FLASH_ACR               (*(volatile uint32_t*)0x40023C00) // Flash access control register
#define FLASH_KEYR              (*(volatile uint32_t*)0x40023C04) // Flash key register
#define FLASH_OPTKEYR           (*(volatile uint32_t*)0x40023C08) // Flash option key register
#define FLASH_SR                (*(volatile uint32_t*)0x40023C0C) // Flash status register
#define FLASH_CR                (*(volatile uint32_t*)0x40023C10) // Flash control register
#define FLASH_PDR               (*(volatile uint32_t*)0x40023C14) // Flash program data register (not common, might be PRG or similar)

// Flash command bits and status flags (adjust based on your MCU)
#define FLASH_CR_PG             (1 << 0)    // Program enable
#define FLASH_CR_SER            (1 << 1)    // Sector Erase enable
#define FLASH_CR_MER            (1 << 2)    // Mass Erase enable
#define FLASH_CR_SNB_MASK       (0xF << 3)  // Sector Number for erase
#define FLASH_CR_SNB_SHIFT      3
#define FLASH_CR_PSIZE_X32      (2 << 8)    // Program size x32 (word)
#define FLASH_CR_STRT           (1 << 16)   // Start operation
#define FLASH_CR_LOCK           (1 << 31)   // Lock control register

#define FLASH_SR_BSY            (1 << 16)   // Busy flag
#define FLASH_SR_EOP            (1 << 0)    // End of operation
#define FLASH_SR_PGSERR         (1 << 7)    // Programming sequence error
#define FLASH_SR_PGPERR         (1 << 6)    // Programming parallelism error
#define FLASH_SR_PGAERR         (1 << 5)    // Programming alignment error
#define FLASH_SR_WRPERR         (1 << 4)    // Write protection error

// Flash Key values (refer to your MCU manual)
#define FLASH_KEY1              0x45670123UL
#define FLASH_KEY2              0xCDEF89ABUL

// !!! END OF CONFIGURATION AND GENERIC DEFINITIONS !!!

// --- Global Buffers ---
uint8_t sd_buffer[SD_BLOCK_SIZE];
uint8_t uart_rx_buffer[SD_BLOCK_SIZE]; // Max block size for UART chunks

// --- Function Prototypes ---
// System and Utility
static void delay_ms(uint32_t ms);
static void system_init(void);
static uint16_t calculate_checksum(const uint8_t *data, uint32_t length);
static void jump_to_application(void);

// GPIO Driver
static void gpio_init(uint32_t port_base, uint32_t pin_mask, uint32_t mode, uint32_t pull_up_down);
static uint8_t gpio_read(uint32_t port_base, uint32_t pin_mask);

// UART Driver
static void uart_init(uint32_t baudrate);
static void uart_putc(uint8_t c);
static uint8_t uart_getc_timeout(uint32_t timeout_ms);
static void uart_puts(const char *s);
static void uart_send_ack(void);
static void uart_send_nack(void);

// SPI Driver
static void spi_init(uint32_t speed_hz);
static uint8_t spi_transmit_receive(uint8_t data);
static void spi_cs_assert(void);
static void spi_cs_deassert(void);

// SD Card Driver (Simplified - raw block access)
static uint8_t sd_card_init(void);
static uint8_t sd_card_read_block(uint32_t block_addr, uint8_t *buffer);
static uint8_t sd_cmd(uint8_t cmd, uint32_t arg, uint8_t crc);
static uint8_t sd_read_resp(uint8_t res_type);
static uint8_t sd_go_idle(void);
static uint8_t sd_send_if_cond(void);
static uint8_t sd_send_app_cmd(void);
static uint8_t sd_acmd41(void);
static uint8_t sd_read_ocr(void);
static uint8_t sd_set_blocklen(void);
static uint8_t sd_wait_not_busy(void);

// Flash Driver
static uint8_t flash_unlock(void);
static void flash_lock(void);
static uint8_t flash_erase_sector(uint33_t address);
static uint8_t flash_program_word(uint33_t address, uint32_t data);
static uint8_t flash_is_busy(void);
static void flash_clear_pending_flags(void);

// Bootloader Logic
static uint8_t check_bootloader_conditions(void);
static uint8_t update_firmware_from_sd_card(void);
static uint8_t update_firmware_from_uart(void);
static void invalidate_update_request(void);
static void request_firmware_update(void);


// --- Function Implementations ---

// --- System and Utility ---
static void delay_ms(uint32_t ms) {
    // This is a very basic, non-accurate delay. For critical timing, use a timer.
    for (volatile uint32_t i = 0; i < ms * 4000; i++); // Adjust magic number based on CPU speed
}

static void system_init(void) {
    // Minimal clock setup. For a real bootloader, this might enable HSI/HSE, PLL.
    // For simplicity, assume default internal oscillator is sufficient to run peripherals.

    // Enable clock for GPIO H (for boot pin), GPIO A (for UART/SPI), etc.
    // This example is for STM32F4xx. Adjust for your MCU.
    // GPIOH, GPIOA, GPIOB (for UART/SPI)
    RCC_AHB1ENR |= (1 << 7) | (1 << 0) | (1 << 1);
    // USART1 and SPI1
    RCC_APB2ENR |= (1 << 4) | (1 << 14);

    // Clear the magic bootloader entry in RAM
    *(volatile uint32_t*)BOOT_MAGIC_RAM_ADDR = 0;

    // Relocate vector table to bootloader
    SCB_VTOR = FLASH_BASE_ADDRESS;
}

static uint16_t calculate_checksum(const uint8_t *data, uint32_t length) {
    uint16_t checksum = 0;
    for (uint32_t i = 0; i < length; i++) {
        checksum += data[i];
    }
    return checksum;
}

static void jump_to_application(void) {
    // Check if application is valid (e.g., first word is stack pointer, second is reset handler)
    // A more robust check might involve a checksum for the whole app.
    if (((*(volatile uint32_t*)APPLICATION_START_ADDRESS) & 0xFFF00000UL) == 0x20000000UL) { // Basic stack pointer check
        // Set vector table to application's
        SCB_VTOR = APPLICATION_START_ADDRESS;

        // Get the application's stack pointer and reset handler address
        uint32_t app_stack_pointer = *(volatile uint32_t*)APPLICATION_START_ADDRESS;
        uint32_t app_reset_handler = *(volatile uint32_t*)(APPLICATION_START_ADDRESS + 4);

        // Disable interrupts (if any were enabled by bootloader)
        __disable_irq();

        // De-initialize peripherals used by bootloader (optional, but good practice)
        // Reset GPIOs, UART, SPI to their default states if possible.

        // Set the main stack pointer to the application's stack pointer
        __set_MSP(app_stack_pointer);

        // Jump to the application's reset handler
        ((void (*)(void))app_reset_handler)();
    } else {
        // Application is not valid or corrupted, stay in bootloader or indicate error.
        uart_puts("ERR: App invalid. Staying in BL.\r\n");
        // Could loop here, wait for another update attempt, or try to reset.
        while(1);
    }
}

// --- GPIO Driver ---
static void gpio_init(uint32_t port_base, uint33_t pin_mask, uint32_t mode, uint32_t pull_up_down) {
    for (uint32_t i = 0; i < 16; i++) { // Iterate through possible pins
        if (pin_mask & (1 << i)) {
            // Clear current mode and set new mode (00: Input, 01: Output, 10: Alternate Function, 11: Analog)
            GPIO_MODER(port_base) &= ~(3UL << (i * 2));
            GPIO_MODER(port_base) |= (mode << (i * 2));

            // Clear current pull-up/down and set new (00: No pull, 01: Pull-up, 10: Pull-down)
            GPIO_PUPDR(port_base) &= ~(3UL << (i * 2));
            GPIO_PUPDR(port_base) |= (pull_up_down << (i * 2));
        }
    }
}

static uint8_t gpio_read(uint32_t port_base, uint32_t pin_mask) {
    return (GPIO_IDR(port_base) & pin_mask) ? 1 : 0;
}

// --- UART Driver ---
static void uart_init(uint32_t baudrate) {
    // UART TX (PA9), RX (PA10) example. Adjust for your pins.
    // Configure PA9 (TX) and PA10 (RX) for Alternate Function
    gpio_init(0x40020000UL, (1 << 9) | (1 << 10), 2, 0); // GPIOA Base Address, AF Mode, No Pull
    GPIO_AFR(0x40020000UL, 1) &= ~((0xF << ((9 - 8) * 4)) | (0xF << ((10 - 8) * 4))); // Clear AF for PA9, PA10
    GPIO_AFR(0x40020000UL, 1) |= ((7 << ((9 - 8) * 4)) | (7 << ((10 - 8) * 4)));      // Set AF7 for USART1

    // Calculate baud rate (assuming HCLK/PCLK2 = 16MHz for simplicity)
    uint32_t pclk2_freq = 16000000UL; // Example frequency
    uint16_t brr_val = pclk2_freq / baudrate; // Integer division
    // If fractional part is needed, calculation is more complex: (PCLK + (baudrate/2))/baudrate

    // Configure UART
    UART_CR1 = 0; // Disable UART first
    UART_BRR = brr_val;
    UART_CR1 |= USART_CR1_UE | USART_CR1_TE | USART_CR1_RE; // Enable UART, Transmitter, Receiver
}

static void uart_putc(uint8_t c) {
    while (!(UART_SR & USART_SR_TXE)); // Wait for transmit data register empty
    UART_DR = c;
}

static uint8_t uart_getc_timeout(uint32_t timeout_ms) {
    uint32_t start_time = 0; // In a real system, use a timer counter. This is a very rough estimate.
    while (!(UART_SR & USART_SR_RXNE)) {
        // Simple loop counter for timeout
        if (++start_time > (timeout_ms * 10000)) { // ~10k cycles per ms, adjust as needed
            return 0; // Timeout
        }
    }
    return (uint8_t)(UART_DR & 0xFF);
}

static void uart_puts(const char *s) {
    while (*s) {
        uart_putc((uint8_t)*s++);
    }
}

static void uart_send_ack(void) {
    uart_puts("ACK\r\n");
}

static void uart_send_nack(void) {
    uart_puts("NACK\r\n");
}

// --- SPI Driver (for SD Card) ---
// Using SPI1, assumed pins: SCK (PB3), MISO (PB4), MOSI (PB5), CS (PB6)
static void spi_init(uint32_t speed_hz) {
    // Configure PB3, PB4, PB5 for Alternate Function (SPI1)
    gpio_init(0x40020400UL, (1 << 3) | (1 << 4) | (1 << 5), 2, 0); // GPIOB Base Address, AF Mode, No Pull
    GPIO_AFR(0x40020400UL, 0) &= ~((0xF << (3 * 4)) | (0xF << (4 * 4)) | (0xF << (5 * 4))); // Clear AF for PB3,4,5
    GPIO_AFR(0x40020400UL, 0) |= ((5 << (3 * 4)) | (5 << (4 * 4)) | (5 << (5 * 4)));      // Set AF5 for SPI1

    // Configure PB6 as GPIO Output for CS
    gpio_init(0x40020400UL, (1 << 6), 1, 0); // GPIOB Base Address, Output Mode, No Pull
    spi_cs_deassert(); // De-assert CS initially

    // Configure SPI (assuming PCLK2 = 16MHz)
    SPI_CR1 = 0; // Disable SPI
    uint32_t pclk2_freq = 16000000UL;
    uint32_t prescaler;

    if (speed_hz >= pclk2_freq / 2) prescaler = SPI_CR1_BR_DIV2;
    else if (speed_hz >= pclk2_freq / 4) prescaler = SPI_CR1_BR_DIV4;
    else if (speed_hz >= pclk2_freq / 8) prescaler = SPI_CR1_BR_DIV8;
    else if (speed_hz >= pclk2_freq / 16) prescaler = SPI_CR1_BR_DIV16;
    else if (speed_hz >= pclk2_freq / 32) prescaler = SPI_CR1_BR_DIV32;
    else if (speed_hz >= pclk2_freq / 64) prescaler = SPI_CR1_BR_DIV64;
    else if (speed_hz >= pclk2_freq / 128) prescaler = SPI_CR1_BR_DIV128;
    else prescaler = SPI_CR1_BR_DIV256; // Default to slowest

    SPI_CR1 = SPI_CR1_MSTR | SPI_CR1_SSM | SPI_CR1_SSI | prescaler; // Master, Software SS, Internal SS, Baud Rate
    SPI_CR1 |= SPI_CR1_SPE; // Enable SPI
}

static uint8_t spi_transmit_receive(uint8_t data) {
    while (!(SPI_SR & SPI_SR_TXE)); // Wait for transmit buffer empty
    SPI_DR = data;
    while (!(SPI_SR & SPI_SR_RXNE)); // Wait for receive buffer not empty
    return (uint8_t)SPI_DR;
}

static void spi_cs_assert(void) {
    GPIO_ODR(0x40020400UL) &= ~(1 << 6); // Set PB6 Low
}

static void spi_cs_deassert(void) {
    GPIO_ODR(0x40020400UL) |= (1 << 6); // Set PB6 High
}

// --- SD Card Driver (Simplified - raw block access) ---
// Basic SD card commands and responses
#define CMD0_GO_IDLE_STATE      0x40 // CMD0 (0x00) with CRC and start bit
#define CMD8_SEND_IF_COND       0x48 // CMD8 (0x08)
#define CMD12_STOP_TRANSMISSION 0x4C // CMD12 (0x0C)
#define CMD16_SET_BLOCKLEN      0x50 // CMD16 (0x10)
#define CMD17_READ_SINGLE_BLOCK 0x51 // CMD17 (0x11)
#define CMD55_APP_CMD           0x77 // CMD55 (0x37)
#define ACMD41_SD_SEND_OP_COND  0x69 // ACMD41 (0x29)

// Response types
#define R1_RESPONSE             0
#define R3_RESPONSE             1
#define R7_RESPONSE             2

static uint8_t sd_cmd(uint8_t cmd, uint32_t arg, uint8_t crc) {
    spi_transmit_receive(cmd);
    spi_transmit_receive((uint8_t)(arg >> 24));
    spi_transmit_receive((uint8_t)(arg >> 16));
    spi_transmit_receive((uint8_t)(arg >> 8));
    spi_transmit_receive((uint8_t)(arg));
    spi_transmit_receive(crc);
    return 0; // Command sent
}

static uint8_t sd_read_resp(uint8_t res_type) {
    uint8_t response;
    // Wait for a response (max 8 attempts)
    for (uint8_t i = 0; i < 10; i++) {
        response = spi_transmit_receive(0xFF);
        if (!(response & 0x80)) { // Response starts with 0
            break;
        }
        if (i == 9) return 0xFF; // Timeout
    }

    if (res_type == R1_RESPONSE) {
        return response;
    } else if (res_type == R3_RESPONSE || res_type == R7_RESPONSE) {
        spi_transmit_receive(0xFF); // Read 4 more bytes for R3/R7
        spi_transmit_receive(0xFF);
        spi_transmit_receive(0xFF);
        spi_transmit_receive(0xFF);
        return response;
    }
    return 0xFF; // Unknown response type
}

static uint8_t sd_wait_not_busy(void) {
    uint32_t timeout = 0xFFFFF; // Generic timeout
    while(spi_transmit_receive(0xFF) == 0 && timeout--) {
        if (timeout == 0) return 1; // Busy timeout
    }
    return 0; // Not busy
}

static uint8_t sd_go_idle(void) {
    spi_cs_assert();
    sd_cmd(CMD0_GO_IDLE_STATE, 0, 0x95); // CMD0 with CRC
    uint8_t r1 = sd_read_resp(R1_RESPONSE);
    spi_cs_deassert();
    spi_transmit_receive(0xFF); // Send 8 clock cycles
    return r1;
}

static uint8_t sd_send_if_cond(void) {
    spi_cs_assert();
    sd_cmd(CMD8_SEND_IF_COND, 0x1AA, 0x87); // CMD8 (VHS = 0x1, check pattern = 0xAA)
    uint8_t r1 = sd_read_resp(R7_RESPONSE);
    spi_cs_deassert();
    spi_transmit_receive(0xFF); // Send 8 clock cycles
    // Check if r1 is 0x01 (Idle state) and R7 response matches pattern
    if ((r1 & 0x01) == 0x01) { // Card not in idle state or illegal command
        return 0xFF;
    }
    // Read 4 more bytes for R7, which were already read by sd_read_resp(R7_RESPONSE)
    // Check for 0xAA pattern in the last byte
    // This simplified driver doesn't check the pattern explicitly.
    // In a full driver, you'd check OCR for voltage range and then this pattern.
    return r1;
}

static uint8_t sd_send_app_cmd(void) {
    spi_cs_assert();
    sd_cmd(CMD55_APP_CMD, 0, 0x01); // CMD55 (CRC not important for this one)
    uint8_t r1 = sd_read_resp(R1_RESPONSE);
    spi_cs_deassert();
    spi_transmit_receive(0xFF);
    return r1;
}

static uint8_t sd_acmd41(void) {
    uint8_t r1;
    for (uint32_t i = 0; i < 1000; i++) { // Loop until card exits idle state (R1 = 0x00)
        sd_send_app_cmd(); // Send CMD55 first
        spi_cs_assert();
        sd_cmd(ACMD41_SD_SEND_OP_COND, 0x40000000, 0x01); // ACMD41 (HCS bit set)
        r1 = sd_read_resp(R1_RESPONSE);
        spi_cs_deassert();
        spi_transmit_receive(0xFF);
        if (r1 == 0x00) return 0x00; // Card is ready
        delay_ms(1);
    }
    return 0xFF; // Timeout
}

static uint8_t sd_read_ocr(void) {
    spi_cs_assert();
    sd_cmd(0x7A, 0, 0x01); // CMD58, R3 response
    uint8_t r1 = sd_read_resp(R3_RESPONSE);
    spi_cs_deassert();
    spi_transmit_receive(0xFF);
    return r1;
}

static uint8_t sd_set_blocklen(void) {
    spi_cs_assert();
    sd_cmd(CMD16_SET_BLOCKLEN, SD_BLOCK_SIZE, 0x01); // CMD16 (set block size to 512 bytes)
    uint8_t r1 = sd_read_resp(R1_RESPONSE);
    spi_cs_deassert();
    spi_transmit_receive(0xFF);
    return r1;
}

static uint8_t sd_card_init(void) {
    spi_init(SPI_SPEED_HZ); // Initialize SPI at a slow speed (e.g., 400kHz)

    // Send 74+ clock pulses
    spi_cs_deassert();
    for (uint8_t i = 0; i < 10; i++) { // 10 bytes = 80 clock pulses
        spi_transmit_receive(0xFF);
    }

    if (sd_go_idle() != 0x01) { // CMD0: Go to idle state, should return 0x01
        return 1; // Failed to enter idle state
    }

    if (sd_send_if_cond() == 0xFF) { // CMD8: Send Interface Condition
        // Card is SDv1 or MMC (CMD8 not supported or invalid response)
        // Fallback to SDv1 initialization. This simplified bootloader assumes SDv2.
        uart_puts("SDv1/MMC card not supported.\r\n");
        return 1;
    }

    if (sd_acmd41() != 0x00) { // ACMD41: Initialize SD card
        return 1; // Failed to initialize SD card
    }

    if (sd_read_ocr() != 0x00) { // CMD58: Read OCR (optional, for voltage check)
        // Check for CCS bit (Card Capacity Status)
        // R3 response includes OCR. Not explicitly checked here for simplicity.
    }

    if (sd_set_blocklen() != 0x00) { // CMD16: Set block size to 512
        return 1; // Failed to set block size
    }

    // Now SD card is initialized and ready for read/write operations at the specified block size.
    // Can increase SPI speed now if needed.
    // spi_init(SPI_FAST_SPEED_HZ);
    return 0; // Success
}

static uint8_t sd_card_read_block(uint32_t block_addr, uint8_t *buffer) {
    // SDHC cards use byte addressing for CMD17/18, SDSC use block addressing.
    // Assuming SDHC, so multiply block_addr by SD_BLOCK_SIZE.
    // For simplicity, this assumes the SD card is already set to block addressing or handles it.
    uint32_t addr_to_send = block_addr;

    spi_cs_assert();
    sd_cmd(CMD17_READ_SINGLE_BLOCK, addr_to_send, 0x01);
    uint8_t r1 = sd_read_resp(R1_RESPONSE);

    if (r1 != 0x00) {
        spi_cs_deassert();
        spi_transmit_receive(0xFF);
        return 1; // Error reading block
    }

    // Wait for data start token (0xFE)
    uint8_t token = 0xFF;
    for (uint32_t i = 0; i < 0xFFFF; i++) {
        token = spi_transmit_receive(0xFF);
        if (token == 0xFE) break;
        if (i == 0xFFFE) {
            spi_cs_deassert();
            spi_transmit_receive(0xFF);
            return 1; // Timeout waiting for start token
        }
    }

    // Read data block
    for (uint16_t i = 0; i < SD_BLOCK_SIZE; i++) {
        buffer[i] = spi_transmit_receive(0xFF);
    }

    // Read 2-byte CRC (ignore for now)
    spi_transmit_receive(0xFF);
    spi_transmit_receive(0xFF);

    spi_cs_deassert();
    spi_transmit_receive(0xFF); // Send 8 clock cycles
    return 0; // Success
}


// --- Flash Driver (Placeholder - highly MCU specific) ---
// These functions need to be implemented according to your specific MCU's flash programming manual.
// For STM32F4 series, you would use FLASH_SR, FLASH_CR, FLASH_KEYR, etc.

static uint8_t flash_unlock(void) {
    if (FLASH_CR & FLASH_CR_LOCK) {
        FLASH_KEYR = FLASH_KEY1;
        FLASH_KEYR = FLASH_KEY2;
    }
    // Verify unlock
    if (FLASH_CR & FLASH_CR_LOCK) {
        return 1; // Unlock failed
    }
    return 0; // Success
}

static void flash_lock(void) {
    FLASH_CR |= FLASH_CR_LOCK;
}

static uint8_t flash_is_busy(void) {
    return (FLASH_SR & FLASH_SR_BSY);
}

static void flash_clear_pending_flags(void) {
    // Clear all error flags and EOP (End of Operation) flag
    FLASH_SR = FLASH_SR_PGSERR | FLASH_SR_PGPERR | FLASH_SR_PGAERR | FLASH_SR_WRPERR | FLASH_SR_EOP;
}

static uint8_t flash_erase_sector(uint32_t address) {
    if (flash_unlock()) return 1;
    while(flash_is_busy());

    flash_clear_pending_flags();

    uint8_t sector = (address - FLASH_BASE_ADDRESS) / (16 * 1024); // Assuming 16KB sectors for simplicity (adjust for your MCU)
                                                                    // STM32F4 has variable sector sizes. This is a very rough example.
    // Determine the correct sector number based on your MCU's flash map
    // For STM32F4, sectors 0-3 are 16KB, 4 is 64KB, 5-11 are 128KB
    // The bootloader should only erase sectors starting from APPLICATION_START_ADDRESS.

    FLASH_CR |= FLASH_CR_SER; // Sector erase enable
    FLASH_CR &= ~FLASH_CR_SNB_MASK; // Clear sector number bits
    FLASH_CR |= (sector << FLASH_CR_SNB_SHIFT); // Set sector number
    FLASH_CR |= FLASH_CR_STRT; // Start erase operation

    while(flash_is_busy()); // Wait for erase to complete

    FLASH_CR &= ~FLASH_CR_SER; // Disable sector erase

    // Check for errors
    if (FLASH_SR & (FLASH_SR_PGSERR | FLASH_SR_PGPERR | FLASH_SR_PGAERR | FLASH_SR_WRPERR)) {
        flash_clear_pending_flags();
        flash_lock();
        return 1; // Erase error
    }

    flash_lock();
    return 0; // Success
}

static uint8_t flash_program_word(uint32_t address, uint32_t data) {
    if (flash_unlock()) return 1;
    while(flash_is_busy());

    flash_clear_pending_flags();

    FLASH_CR |= FLASH_CR_PG; // Programming enable
    FLASH_CR |= FLASH_CR_PSIZE_X32; // Program size: 32-bit (word)
    
    *(volatile uint32_t*)address = data; // Write the data
    FLASH_CR |= FLASH_CR_STRT; // Start program operation

    while(flash_is_busy()); // Wait for programming to complete

    FLASH_CR &= ~(FLASH_CR_PG | FLASH_CR_PSIZE_X32); // Disable programming

    // Check for errors
    if (FLASH_SR & (FLASH_SR_PGSERR | FLASH_SR_PGPERR | FLASH_SR_PGAERR | FLASH_SR_WRPERR)) {
        flash_clear_pending_flags();
        flash_lock();
        return 1; // Program error
    }

    // Verify written data
    if (*(volatile uint32_t*)address != data) {
        flash_lock();
        return 1; // Verification failed
    }

    flash_lock();
    return 0; // Success
}

// --- Bootloader Logic ---
static uint8_t check_bootloader_conditions(void) {
    // 1. Check GPIO pin
    gpio_init(BOOT_GPIO_PORT_BASE, BOOT_GPIO_PIN, 0, BOOT_PIN_ACTIVE_LOW ? 1 : 2); // Input, Pull-up/down based on config
    uint8_t boot_pin_status = gpio_read(BOOT_GPIO_PORT_BASE, BOOT_GPIO_PIN);

    if (BOOT_PIN_ACTIVE_LOW && boot_pin_status == 0) { // Pin is low (active)
        return 1; // Force bootloader
    } else if (!BOOT_PIN_ACTIVE_LOW && boot_pin_status == 1) { // Pin is high (active)
        return 1; // Force bootloader
    }

    // 2. Check magic memory location in RAM
    if (*(volatile uint32_t*)BOOT_MAGIC_RAM_ADDR == BOOT_MAGIC_VALUE) {
        *(volatile uint32_t*)BOOT_MAGIC_RAM_ADDR = 0; // Clear magic to prevent re-entry
        return 1; // Force bootloader
    }

    // 3. Check for firmware update request flag in flash
    if (*(volatile uint32_t*)FIRMWARE_UPDATE_FLAG_ADDR == FIRMWARE_UPDATE_REQUEST) {
        // Clear the flag to prevent infinite loop if update fails
        // This requires erasing the bootloader sector itself, which is tricky.
        // A better approach might be to have this flag in an independent flash sector
        // or a shadow copy that can be cleared without affecting bootloader code.
        // For this example, we will erase the flag as part of flash operations (carefully).
        return 1; // Force bootloader
    }

    return 0; // No bootloader force condition met
}

static void invalidate_update_request(void) {
    // Set the flag back to an invalid value (e.g., all Fs after erase)
    // This is typically handled by the erase operation or by programming a known "not-requested" value.
    // For now, we assume erasing the sector containing the flag implicitly invalidates it.
}

static void request_firmware_update(void) {
    // This function can be called by the application to request a bootloader entry on next reboot.
    // It would write BOOT_MAGIC_VALUE to FIRMWARE_UPDATE_FLAG_ADDR.
    // For an external update tool, this isn't strictly necessary as the tool would initiate via GPIO/UART.
    // It requires unlocking, writing, and locking flash.
    flash_unlock();
    flash_erase_sector(FIRMWARE_UPDATE_FLAG_ADDR); // Erase the sector containing the flag
    flash_program_word(FIRMWARE_UPDATE_FLAG_ADDR, FIRMWARE_UPDATE_REQUEST);
    flash_lock();
}

static uint8_t update_firmware_from_sd_card(void) {
    uart_puts("Checking SD card for firmware.bin...\r\n");
    if (sd_card_init() != 0) {
        uart_puts("SD init failed.\r\n");
        return 1;
    }

    // Firmware metadata: 4 bytes size, 2 bytes checksum
    // Stored at the beginning of the `FIRMWARE_SD_BLOCK_START` block.
    if (sd_card_read_block(FIRMWARE_SD_BLOCK_START, sd_buffer) != 0) {
        uart_puts("Failed to read firmware header from SD.\r\n");
        return 1;
    }

    uint32_t firmware_size = *(uint32_t*)&sd_buffer[0];
    uint16_t firmware_checksum_expected = *(uint16_t*)&sd_buffer[4];

    if (firmware_size == 0 || firmware_size > MAX_APPLICATION_SIZE) {
        uart_puts("Invalid firmware size from SD.\r\n");
        return 1;
    }

    uart_puts("Firmware found on SD. Size: ");
    // Minimal integer to string conversion (for debugging)
    char size_str[10]; // Max for 4 billion is 10 digits
    uint32_t temp_size = firmware_size;
    int i = 9;
    size_str[i--] = '\0';
    if (temp_size == 0) size_str[i--] = '0';
    while(temp_size > 0) {
        size_str[i--] = (temp_size % 10) + '0';
        temp_size /= 10;
    }
    uart_puts(&size_str[i+1]);
    uart_puts(" bytes.\r\n");

    // Erase application flash sectors
    uart_puts("Erasing application flash...\r\n");
    uint32_t current_app_addr = APPLICATION_START_ADDRESS;
    while (current_app_addr < APPLICATION_START_ADDRESS + firmware_size + SD_BLOCK_SIZE) { // Erase slightly more than needed
        if (flash_erase_sector(current_app_addr) != 0) {
            uart_puts("Flash erase failed.\r\n");
            invalidate_update_request(); // Clear update request if failed
            return 1;
        }
        // Increment by sector size. This is complex for variable sector sizes.
        // For simplicity, assume a fixed minimum erase unit (e.g., 16KB for some STM32s).
        // This needs to be precise for your MCU.
        current_app_addr += (16 * 1024); // Assuming 16KB min sector size.
    }
    invalidate_update_request(); // Clear update flag after successful erase

    // Program new firmware
    uart_puts("Programming flash from SD...\r\n");
    uint32_t flash_write_address = APPLICATION_START_ADDRESS;
    uint32_t sd_block_offset = FIRMWARE_SD_BLOCK_START;
    uint32_t bytes_written = 0;
    uint16_t calculated_checksum = 0;

    // Skip the first block (contains size and checksum)
    sd_block_offset++;

    while (bytes_written < firmware_size) {
        if (sd_card_read_block(sd_block_offset, sd_buffer) != 0) {
            uart_puts("Failed to read block from SD during program.\r\n");
            return 1;
        }

        uint32_t bytes_to_program_in_block = (firmware_size - bytes_written < SD_BLOCK_SIZE) ? (firmware_size - bytes_written) : SD_BLOCK_SIZE;

        for (uint32_t j = 0; j < bytes_to_program_in_block; j += 4) { // Program in 32-bit words
            uint32_t word = *(uint32_t*)(sd_buffer + j);
            if (flash_program_word(flash_write_address + j, word) != 0) {
                uart_puts("Flash program failed.\r\n");
                return 1;
            }
        }
        calculated_checksum += calculate_checksum(sd_buffer, bytes_to_program_in_block);
        flash_write_address += bytes_to_program_in_block;
        bytes_written += bytes_to_program_in_block;
        sd_block_offset++;
    }

    if (calculated_checksum != firmware_checksum_expected) {
        uart_puts("Firmware checksum mismatch! Expected: ");
        // Print checksums (requires integer to hex string conversion)
        uart_puts(" Calc: ");
        return 1;
    }

    uart_puts("Firmware update from SD card successful.\r\n");
    return 0; // Success
}

// UART protocol:
// Host sends 'U' (update command)
// Bootloader responds 'READY'
// Host sends 4-byte size, 2-byte checksum (LSB first)
// Bootloader responds 'ACK' or 'NACK'
// Host sends data in SD_BLOCK_SIZE chunks
// Bootloader responds 'ACK' or 'NACK' for each chunk
// ... until all data received.
// Final 'ACK' on success.
static uint8_t update_firmware_from_uart(void) {
    uart_puts("Waiting for firmware via UART...\r\n");

    // Wait for 'U' command
    uint8_t cmd = uart_getc_timeout(UART_TIMEOUT_MS * 10); // Longer timeout for initial command
    if (cmd != 'U') {
        uart_puts("No 'U' command received.\r\n");
        return 1;
    }
    uart_puts("READY\r\n");

    // Receive firmware size (4 bytes) and checksum (2 bytes)
    uint33_t firmware_size = 0;
    uint16_t firmware_checksum_expected = 0;

    for (int i = 0; i < 4; i++) {
        uint8_t byte = uart_getc_timeout(UART_TIMEOUT_MS);
        if (byte == 0) { uart_send_nack(); return 1; }
        firmware_size |= ((uint32_t)byte << (i * 8));
    }
    for (int i = 0; i < 2; i++) {
        uint8_t byte = uart_getc_timeout(UART_TIMEOUT_MS);
        if (byte == 0) { uart_send_nack(); return 1; }
        firmware_checksum_expected |= ((uint16_t)byte << (i * 8));
    }

    if (firmware_size == 0 || firmware_size > MAX_APPLICATION_SIZE) {
        uart_puts("Invalid firmware size from UART.\r\n");
        uart_send_nack();
        return 1;
    }
    uart_send_ack();

    // Erase application flash sectors
    uart_puts("Erasing application flash...\r\n");
    uint32_t current_app_addr = APPLICATION_START_ADDRESS;
    while (current_app_addr < APPLICATION_START_ADDRESS + firmware_size + SD_BLOCK_SIZE) { // Erase slightly more than needed
        if (flash_erase_sector(current_app_addr) != 0) {
            uart_puts("Flash erase failed.\r\n");
            invalidate_update_request();
            uart_send_nack();
            return 1;
        }
        current_app_addr += (16 * 1024); // Assuming 16KB min sector size.
    }
    invalidate_update_request(); // Clear update flag after successful erase

    // Program new firmware
    uart_puts("Programming flash from UART...\r\n");
    uint32_t flash_write_address = APPLICATION_START_ADDRESS;
    uint32_t bytes_received = 0;
    uint16_t calculated_checksum = 0;

    while (bytes_received < firmware_size) {
        uint32_t bytes_to_receive_in_chunk = (firmware_size - bytes_received < SD_BLOCK_SIZE) ? (firmware_size - bytes_received) : SD_BLOCK_SIZE;

        for (uint32_t j = 0; j < bytes_to_receive_in_chunk; j++) {
            uint8_t byte = uart_getc_timeout(UART_TIMEOUT_MS);
            if (byte == 0) { // Timeout or error
                uart_puts("UART receive timeout.\r\n");
                uart_send_nack();
                return 1;
            }
            uart_rx_buffer[j] = byte;
        }

        // Program in 32-bit words
        for (uint32_t j = 0; j < bytes_to_receive_in_chunk; j += 4) {
            uint32_t word = *(uint32_t*)(uart_rx_buffer + j);
            if (flash_program_word(flash_write_address + j, word) != 0) {
                uart_puts("Flash program failed.\r\n");
                uart_send_nack();
                return 1;
            }
        }
        calculated_checksum += calculate_checksum(uart_rx_buffer, bytes_to_receive_in_chunk);
        flash_write_address += bytes_to_receive_in_chunk;
        bytes_received += bytes_to_receive_in_chunk;
        uart_send_ack(); // Acknowledge chunk
    }

    if (calculated_checksum != firmware_checksum_expected) {
        uart_puts("Firmware checksum mismatch!\r\n");
        uart_send_nack();
        return 1;
    }

    uart_puts("Firmware update from UART successful.\r\n");
    uart_send_ack(); // Final ACK
    return 0; // Success
}

// --- Main Function ---
int main(void) {
    system_init();
    uart_init(UART_BAUDRATE);

    uart_puts("Bootloader initialized.\r\n");

    if (check_bootloader_conditions()) {
        uart_puts("Entering bootloader mode...\r\n");

        // Attempt update from SD card first
        if (update_firmware_from_sd_card() == 0) {
            // Success, jump to new app
            jump_to_application();
        } else {
            uart_puts("SD card update failed or not found. Trying UART.\r\n");
            // Fallback to UART update
            if (update_firmware_from_uart() == 0) {
                // Success, jump to new app
                jump_to_application();
            } else {
                uart_puts("UART update failed. No valid firmware found. Waiting...\r\n");
                // Loop indefinitely waiting for a new update or reset
                while(1);
            }
        }
    } else {
        uart_puts("No update requested. Jumping to application.\r\n");
        jump_to_application();
    }

    // Should not reach here
    while (1);
}

// Important Considerations:
// 1. Linker Script: A custom linker script is CRITICAL for a bootloader.
//    - It must place the bootloader code at FLASH_BASE_ADDRESS.
//    - It must define the stack and heap within the bootloader's memory space.
//    - It must reserve space for the application, starting at APPLICATION_START_ADDRESS.
//    - It should *not* link the application, only the bootloader.
// 2. Interrupts: The bootloader should handle its own interrupts minimally.
//    - When jumping to the application, all bootloader-specific interrupts should be disabled.
// 3. Watchdog: If a watchdog is enabled, the bootloader must periodically 'pet' it.
// 4. Robustness: Add more error checking, retries, and timeout mechanisms, especially for SD/UART.
// 5. Security: For production, add cryptographic signature verification to firmware updates.
// 6. MCU Specifics: Replace generic register definitions with actual ones from your MCU's headers/HAL.
// 7. Power Failures: Consider what happens if power is lost during a flash erase/write operation.
//    - A robust bootloader might use dual-bank flash or a staging area.
//    - The current setup could leave a bricked device if power fails during application erase.
//      The `invalidate_update_request()` should ideally be atomic and happen *before* erasing the app.
//      Or, the update flag could be in a completely separate flash sector.
// 8. Clocking: The `system_init` is very basic. A proper bootloader often initializes a stable
//    high-speed clock for faster operation.
// 9. Debugging: This code assumes a working serial console for debugging messages.
// 10. Memory usage: SD_BLOCK_SIZE for buffers should be carefully chosen.

// Example Makefile (conceptual, requires specific toolchain and MCU details)
/*
CROSS_COMPILE ?= arm-none-eabi-
CC = $(CROSS_COMPILE)gcc
AS = $(CROSS_COMPILE)as
LD = $(CROSS_COMPILE)ld
OBJCOPY = $(CROSS_COMPILE)objcopy
OBJDUMP = $(CROSS_COMPILE)objdump

TARGET = bootloader

# MCU-specific flags (e.g., STM32F407VGTx)
MCU_FLAGS = -mcpu=cortex-m4 -mthumb -mfloat-abi=hard -mfpu=fpv4-sp-d16
CFLAGS = -Wall -Os $(MCU_FLAGS) -DNDEBUG -g
LDFLAGS = -Tbootloader.ld -nostdlib $(MCU_FLAGS)

SRCS = main.c
OBJS = $(SRCS:.c=.o)

.PHONY: all clean

all: $(TARGET).bin

$(TARGET).bin: $(TARGET).elf
	$(OBJCOPY) -O binary $< $@
	$(OBJDUMP) -D -M force-thumb $< > $(TARGET).asm

$(TARGET).elf: $(OBJS)
	$(LD) $(LDFLAGS) -o $@ $^

%.o: %.c
	$(CC) $(CFLAGS) -c $< -o $@

clean:
	rm -f $(OBJS) $(TARGET).elf $(TARGET).bin $(TARGET).asm

# Example Linker Script (bootloader.ld)
// MEMORY {
//   FLASH (rx) : ORIGIN = 0x08000000, LENGTH = 32K   // Bootloader region
//   RAM  (rwx) : ORIGIN = 0x20000000, LENGTH = 128K // Adjust for your RAM size
// }
//
// SECTIONS {
//   .text : {
//     *(.vectors)
//     *(.text*)
//     *(.rodata*)
//     . = ALIGN(4);
//   } > FLASH
//
//   .data : {
//     . = ALIGN(4);
//     *(.data)
//     . = ALIGN(4);
//   } > RAM AT > FLASH
//
//   .bss : {
//     . = ALIGN(4);
//     *(.bss)
//     . = ALIGN(4);
//   } > RAM
//
//   _estack = ORIGIN(RAM) + LENGTH(RAM); /* Top of RAM */
// }

*/