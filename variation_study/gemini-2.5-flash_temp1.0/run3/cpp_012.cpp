# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <stdexcept>
#include <random>
#include <chrono> // For seeding RNG

class NetworkConnectionManager {
public:
    // Constructor: Allocates resources and establishes an initial connection.
    // Throws std::runtime_error if initial allocation or connection fails.
    NetworkConnectionManager();

    // Destructor: Ensures all resources are properly deallocated and connection is torn down.
    ~NetworkConnectionManager();

    // Prevent copy and assignment to simplify resource management for this example.
    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    // Attempts to establish a connection using currently allocated resources.
    // Throws std::runtime_error if connection fails.
    void connect();

    // Tears down the current connection (if any). Safe to call if not connected.
    void disconnect();

    // Resets the connection: Tears down the current connection but keeps
    // the underlying resources (like a socket handle) allocated.
    // The connection can be re-established later using connect().
    void reset();

    // Reinitializes the connection: Tears down the current connection,
    // deallocates underlying resources, allocates new resources, and then
    // establishes a new connection with the newly allocated resources.
    // Throws std::runtime_error if any step in reinitialization fails.
    void reinitialize();

    // Getters for status
    bool isConnected() const { return connected_; }
    int getConnectionId() const { return connection_id_; }
    bool areResourcesAllocated() const { return resources_allocated_; }

private:
    bool connected_;             // True if an active connection is established.
    int connection_id_;          // A unique identifier for the current resource set/connection.
                                 // 0 indicates no valid connection ID.
    bool resources_allocated_;   // True if underlying resources (e.g., socket handle) are allocated.

    std::mt19937 rng_; // Random number generator for simulating failures

    // Internal helper methods for managing lifecycle steps.
    // These methods perform "raw" operations and handle their specific errors by throwing.

    // Allocates underlying network resources (e.g., creates a socket).
    // If successful, sets resources_allocated_ to true and assigns a new connection_id_.
    // Throws std::runtime_error on failure.
    void _internalAllocateResources();

    // Deallocates underlying network resources.
    // Safe to call even if resources_allocated_ is false (no-op).
    // Sets resources_allocated_ to false.
    void _internalDeallocateResources();

    // Establishes a connection using currently allocated resources.
    // Requires resources_allocated_ to be true.
    // If successful, sets connected_ to true.
    // Throws std::runtime_error on failure.
    void _internalEstablishConnection();

    // Tears down an established connection.
    // Safe to call even if connected_ is false (no-op).
    // Sets connected_ to false.
    void _internalTeardownConnection();

    // Helper function to simulate a random failure.
    // Returns true if a failure should occur based on the given rate.
    bool _shouldFail(double failure_rate = 0.3);
};

NetworkConnectionManager::NetworkConnectionManager()
    : connected_(false),
      connection_id_(0), // 0 indicates no valid connection ID yet
      resources_allocated_(false),
      rng_(std::chrono::high_resolution_clock::now().time_since_epoch().count())
{
    std::cout << "NetworkConnectionManager: Initializing..." << std::endl;
    try {
        _internalAllocateResources();   // May throw
        _internalEstablishConnection(); // May throw
        std::cout << "NetworkConnectionManager: Initial connection (ID: " << connection_id_ << ") established successfully." << std::endl;
    } catch (const std::runtime_error& e) {
        // If anything fails during initial setup, ensure resources are cleaned up
        // before re-throwing the exception.
        std::cerr << "NetworkConnectionManager: Initial setup failed - " << e.what() << ". Cleaning up." << std::endl;
        _internalDeallocateResources(); // Safe to call even if not fully allocated or connection_id_ is 0
        throw; // Re-throw the original exception to signal construction failure
    }
}

NetworkConnectionManager::~NetworkConnectionManager() {
    std::cout << "NetworkConnectionManager: Shutting down..." << std::endl;
    // Ensure all connections are torn down and resources deallocated.
    // These methods are designed to be safe to call even if already disconnected/deallocated.
    _internalTeardownConnection();
    _internalDeallocateResources();
    std::cout << "NetworkConnectionManager: Shut down complete." << std::endl;
}

void NetworkConnectionManager::connect() {
    if (connected_) {
        std::cout << "NetworkConnectionManager: Already connected (ID: " << connection_id_ << ")." << std::endl;
        return;
    }
    if (!resources_allocated_) {
        throw std::runtime_error("Cannot connect: Resources not allocated. Call reinitialize() first to get new resources.");
    }
    std::cout << "NetworkConnectionManager: Attempting to connect (ID: " << connection_id_ << ")..." << std::endl;
    try {
        _internalEstablishConnection();
        std::cout << "NetworkConnectionManager: Connection (ID: " << connection_id_ << ") established." << std::endl;
    } catch (const std::runtime_error& e) {
        std::cerr << "NetworkConnectionManager: Connection attempt failed - " << e.what() << std::endl;
        throw; // Re-throw failure
    }
}

void NetworkConnectionManager::disconnect() {
    if (!connected_) {
        std::cout << "NetworkConnectionManager: Already disconnected." << std::endl;
        return;
    }
    std::cout << "NetworkConnectionManager: Disconnecting (ID: " << connection_id_ << ")..." << std::endl;
    _internalTeardownConnection(); // This internally sets connected_ to false.
    std::cout << "NetworkConnectionManager: Disconnected." << std::endl;
}

void NetworkConnectionManager::reset() {
    std::cout << "NetworkConnectionManager: Resetting connection (ID: " << connection_id_ << ")..." << std::endl;
    // A reset typically means closing the current connection but keeping the resources.
    disconnect(); // Tears down the connection.
    std::cout << "NetworkConnectionManager: Connection reset. Resources remain allocated (ID: " << connection_id_ << ")." << std::endl;
}

void NetworkConnectionManager::reinitialize() {
    std::cout << "NetworkConnectionManager: Reinitializing connection (current ID: " << connection_id_ << ")..." << std::endl;

    // 1. Teardown existing connection
    _internalTeardownConnection(); // Safe to call if not connected

    // 2. Deallocate existing resources
    _internalDeallocateResources(); // Safe to call if not allocated

    // 3. Allocate new resources and establish a new connection
    try {
        _internalAllocateResources();   // May throw, assigns new ID
        _internalEstablishConnection(); // May throw
        std::cout << "NetworkConnectionManager: Reinitialization successful. New connection (ID: " << connection_id_ << ") established." << std::endl;
    } catch (const std::runtime_error& e) {
        // If allocation or connection fails during reinitialization, ensure resources are cleaned up.
        std::cerr << "NetworkConnectionManager: Reinitialization failed - " << e.what() << ". Cleaning up partially allocated resources." << std::endl;
        _internalDeallocateResources(); // Clean up any new resources that might have been partially allocated
        throw; // Re-throw the original exception
    }
}

// --- Private Helper Implementations ---

bool NetworkConnectionManager::_shouldFail(double failure_rate) {
    std::uniform_real_distribution<> dist(0.0, 1.0);
    return dist(rng_) < failure_rate;
}

void NetworkConnectionManager::_internalAllocateResources() {
    if (resources_allocated_) {
        std::cout << "  _internalAllocateResources: Resources already allocated (ID: " << connection_id_ << "). Skipping." << std::endl;
        return;
    }

    std::cout << "  _internalAllocateResources: Attempting to allocate network resources..." << std::endl;
    if (_shouldFail(0.2)) { // 20% chance of allocation failure
        throw std::runtime_error("Failed to allocate network socket/resources.");
    }

    // Simulate allocation, assign a new unique ID
    connection_id_ = std::uniform_int_distribution<>(1000, 9999)(rng_); // Assign a random 4-digit ID
    resources_allocated_ = true;
    std::cout << "  _internalAllocateResources: Resources allocated successfully. New ID: " << connection_id_ << std::endl;
}

void NetworkConnectionManager::_internalDeallocateResources() {
    if (!resources_allocated_) {
        std::cout << "  _internalDeallocateResources: No resources to deallocate." << std::endl;
        return;
    }
    std::cout << "  _internalDeallocateResources: Deallocating network resources (ID: " << connection_id_ << ")..." << std::endl;
    // Simulate deallocation
    resources_allocated_ = false;
    connection_id_ = 0; // Invalidate ID
    std::cout << "  _internalDeallocateResources: Resources deallocated." << std::endl;
}

void NetworkConnectionManager::_internalEstablishConnection() {
    if (connected_) {
        std::cout << "  _internalEstablishConnection: Already connected (ID: " << connection_id_ << "). Skipping." << std::endl;
        return;
    }
    if (!resources_allocated_) {
        // This indicates a logic error if _internalEstablishConnection is called when it shouldn't be.
        throw std::logic_error("Attempted to establish connection without allocated resources.");
    }

    std::cout << "  _internalEstablishConnection: Attempting to establish connection using resources (ID: " << connection_id_ << ")..." << std::endl;
    if (_shouldFail(0.4)) { // 40% chance of connection failure
        throw std::runtime_error("Failed to establish network connection.");
    }

    // Simulate connection establishment
    connected_ = true;
    std::cout << "  _internalEstablishConnection: Connection established successfully (ID: " << connection_id_ << ")." << std::endl;
}

void NetworkConnectionManager::_internalTeardownConnection() {
    if (!connected_) {
        std::cout << "  _internalTeardownConnection: No active connection to tear down." << std::endl;
        return;
    }
    std::cout << "  _internalTeardownConnection: Tearing down connection (ID: " << connection_id_ << ")..." << std::endl;
    // Simulate connection teardown
    connected_ = false;
    std::cout << "  _internalTeardownConnection: Connection torn down." << std::endl;
}

// Example usage
int main() {
    std::cout << "--- Starting Network Connection Test ---\n" << std::endl;

    try {
        // Attempt to create a manager. This might fail if initial allocation/connection fails.
        NetworkConnectionManager mgr;
        std::cout << "\nManager state: Connected=" << std::boolalpha << mgr.isConnected()
                  << ", ResourcesAllocated=" << mgr.areResourcesAllocated()
                  << ", ID=" << mgr.getConnectionId() << std::endl;

        std::cout << "\n--- Trying to connect again (should do nothing if already connected) ---" << std::endl;
        mgr.connect();

        std::cout << "\n--- Disconnecting ---" << std::endl;
        mgr.disconnect();
        std::cout << "Manager state: Connected=" << mgr.isConnected()
                  << ", ResourcesAllocated=" << mgr.areResourcesAllocated()
                  << ", ID=" << mgr.getConnectionId() << std::endl;

        std::cout << "\n--- Reconnecting after disconnect ---" << std::endl;
        mgr.connect();
        std::cout << "Manager state: Connected=" << mgr.isConnected()
                  << ", ResourcesAllocated=" << mgr.areResourcesAllocated()
                  << ", ID=" << mgr.getConnectionId() << std::endl;

        std::cout << "\n--- Resetting connection ---" << std::endl;
        mgr.reset();
        std::cout << "Manager state after reset: Connected=" << mgr.isConnected()
                  << ", ResourcesAllocated=" << mgr.areResourcesAllocated()
                  << ", ID=" << mgr.getConnectionId() << std::endl;

        std::cout << "\n--- Reconnecting after reset ---" << std::endl;
        mgr.connect();
        std::cout << "Manager state after reconnecting post-reset: Connected=" << mgr.isConnected()
                  << ", ResourcesAllocated=" << mgr.areResourcesAllocated()
                  << ", ID=" << mgr.getConnectionId() << std::endl;

        std::cout << "\n--- Reinitializing connection ---" << std::endl;
        mgr.reinitialize();
        std::cout << "Manager state after reinitialize: Connected=" << mgr.isConnected()
                  << ", ResourcesAllocated=" << mgr.areResourcesAllocated()
                  << ", ID=" << mgr.getConnectionId() << std::endl;

        std::cout << "\n--- Attempting reinitialize that might fail ---" << std::endl;
        try {
            // This reinitialize attempt has a chance to throw
            mgr.reinitialize();
        } catch (const std::runtime_error& e) {
            std::cerr << "Main: Caught expected failure during reinitialize: " << e.what() << std::endl;
        }
        std::cout << "Manager state after failed reinitialize attempt: Connected=" << mgr.isConnected()
                  << ", ResourcesAllocated=" << mgr.areResourcesAllocated()
                  << ", ID=" << mgr.getConnectionId() << std::endl;


    } catch (const std::runtime_error& e) {
        std::cerr << "Main: Caught runtime error during setup or operation: " << e.what() << std::endl;
    } catch (const std::logic_error& e) {
        std::cerr << "Main: Caught logic error: " << e.what() << std::endl;
    }

    std::cout << "\n--- End of Network Connection Test ---\n" << std::endl;
    return 0;
}