# Generated by google (gemini-2.5-flash)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>
#include <string.h> // For memcpy

// --- Configuration Defines ---

// The priority of the network packet processing task.
// This should be chosen carefully based on your system's overall priority scheme.
#define NETWORK_PROCESSOR_TASK_PRIORITY (tskIDLE_PRIORITY + 1)

// Maximum size of a network packet we expect to copy into the local stack buffer.
//
// !!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!
// WARNING: This value DIRECTLY impacts the required stack size.
// If you intend to process standard Ethernet frames (e.g., 1500 bytes MTU),
// configMINIMAL_STACK_SIZE will be INSUFFICIENT for the local packet_buffer.
//
// For this example, we assume very small packets (e.g., control packets, not
// full Ethernet frames) to fit the configMINIMAL_STACK_SIZE constraint.
// If your network packets are larger, you MUST increase the task's stack depth.
// For example, for 1500-byte packets, a stack depth like
// (configMINIMAL_STACK_SIZE + (1500 / sizeof(StackType_t)) + some_overhead)
// would be necessary.
// !!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!
#define MAX_PACKET_SIZE_BYTES       64 // Example: Suitable for small control packets.

// --- Simulated Network Interface Functions ---
// In a real system, these would interact with your actual network driver
// (e.g., polling a hardware buffer, reading from a queue filled by an ISR).

// Structure to hold packet data and its length.
typedef struct {
    uint8_t *data;
    uint16_t length;
} Packet_t;

// Simulated function to receive a network packet.
// In a real application, this might block, poll, or read from a FreeRTOS queue.
// It returns a Packet_t with a pointer to the received data and its length.
// Returns {.data = NULL, .length = 0} if no packet is available.
// The returned `data` pointer might point to a driver-internal buffer that
// eventually needs to be freed by `free_received_packet_buffer`.
static Packet_t receive_network_packet(void)
{
    // Simulate packet reception. For demonstration, we use a static buffer
    // and provide a packet intermittently.
    static uint8_t simulated_packet_data[MAX_PACKET_SIZE_BYTES];
    static uint16_t packet_counter = 0;

    // Simulate receiving a packet every 5 calls to this function.
    if ((packet_counter % 5) == 0) {
        // Vary packet length to simulate different packet sizes.
        uint16_t current_packet_len = (packet_counter % (MAX_PACKET_SIZE_BYTES - 10)) + 10;
        // Fill simulated data.
        for (uint16_t i = 0; i < current_packet_len; i++) {
            simulated_packet_data[i] = (uint8_t)(packet_counter + i);
        }
        packet_counter++;
        return (Packet_t){.data = simulated_packet_data, .length = current_packet_len};
    } else {
        packet_counter++;
        return (Packet_t){.data = NULL, .length = 0}; // No packet available.
    }
}

// Simulated function to free a network packet buffer.
// In a real system, this would return the buffer to a network driver's pool
// or free dynamically allocated memory.
// For this simulation (using a static buffer), no action is needed.
static void free_received_packet_buffer(uint8_t *data_ptr)
{
    (void)data_ptr; // Suppress unused parameter warning.
    // In a real implementation:
    // e.g., network_driver_buffer_free(data_ptr);
}

// Simulated function to process the packet data.
// Replace this with your actual packet parsing, validation, and processing logic.
static void process_packet_data(const uint8_t *data, uint16_t length)
{
    // Example: Perform some computation or logging based on the packet.
    if (length > 0) {
        // Simulate some CPU-bound work. Avoid printf in a small stack task
        // due to its own stack usage.
        volatile uint32_t work_cycles = 1000 * length;
        while(work_cycles--);

        // In a real system, you might extract headers, check checksums,
        // route the packet, or pass it to a higher-layer protocol stack.
        // For example:
        // if (data[0] == SOME_PROTOCOL_ID) {
        //     handle_protocol_packet(data, length);
        // }
    }
}

// --- FreeRTOS Task Function ---

void network_packet_processor_task(void *pvParameters)
{
    (void)pvParameters; // Suppress unused parameter warning.

    // Buffer allocated on the task's stack for copying received packet data.
    // The size of this array (MAX_PACKET_SIZE_BYTES) directly dictates
    // a significant portion of the task's required stack depth.
    uint8_t local_packet_buffer[MAX_PACKET_SIZE_BYTES];
    Packet_t received_packet;

    for (;;) {
        // 1. Attempt to receive a packet from the network interface.
        received_packet = receive_network_packet();

        if (received_packet.data != NULL && received_packet.length > 0) {
            // Check if the received packet's length fits within our local buffer.
            if (received_packet.length <= MAX_PACKET_SIZE_BYTES) {
                // 2. Copy the received packet data into the local stack buffer.
                // This is crucial for small stack tasks as it immediately releases
                // any driver-managed buffers and processes data from its own context.
                memcpy(local_packet_buffer, received_packet.data, received_packet.length);

                // 3. Free the network driver's buffer (if applicable) AS SOON AS POSSIBLE.
                // This releases the network interface's resources quickly.
                free_received_packet_buffer(received_packet.data);

                // 4. Process the packet data using the local stack buffer.
                process_packet_data(local_packet_buffer, received_packet.length);

            } else {
                // Packet received is too large for the local stack buffer.
                // This scenario indicates a mismatch between MAX_PACKET_SIZE_BYTES
                // and the expected packet sizes, or a malformed packet.
                // In a real system, you would log this error and free the buffer.
                free_received_packet_buffer(received_packet.data);
                // Consider increasing MAX_PACKET_SIZE_BYTES and the task's stack size.
            }
        } else {
            // No packet received or an error occurred during reception.
            // Introduce a delay to prevent busy-waiting and allow other tasks to run.
            vTaskDelay(pdMS_TO_TICKS(10)); // Adjust delay based on expected packet arrival rate.
        }

        // If packets are expected very frequently, you might still add a small
        // vTaskDelay here to ensure other tasks get a chance to run, even
        // after processing a packet.
        // e.g., vTaskDelay(pdMS_TO_TICKS(1));
    }
}


// --- Task Creation Example (usually in main.c) ---
// This snippet demonstrates how to create the network processing task.
/*
void create_network_processor_task(void)
{
    BaseType_t xReturned;

    // IMPORTANT: The stack size (configMINIMAL_STACK_SIZE) *must* be sufficient
    // for all local variables (especially local_packet_buffer), function calls,
    // and the FreeRTOS task context overhead.
    // As noted above, if MAX_PACKET_SIZE_BYTES is large, configMINIMAL_STACK_SIZE
    // will be insufficient and cause a stack overflow. Adjust the stack depth
    // if larger packets are expected.

    xReturned = xTaskCreate(
                    network_packet_processor_task,      // Function that implements the task.
                    "NetProcessor",                     // Text name for the task.
                    configMINIMAL_STACK_SIZE,           // Stack depth in words, as requested.
                    NULL,                               // Parameter passed into the task (not used here).
                    NETWORK_PROCESSOR_TASK_PRIORITY,    // Priority at which the task is created.
                    NULL);                              // Used to pass out the created task's handle (not used here).

    if (xReturned != pdPASS) {
        // Task creation failed. This indicates a critical error, likely
        // insufficient heap memory or invalid parameters.
        // Implement appropriate error handling, e.g., turn on an error LED,
        // log the error, or assert.
        for (;;); // Stop if task cannot be created.
    }
}

// Example main function snippet to start the FreeRTOS scheduler:
int main(void)
{
    // Initialize your hardware (clocks, peripherals, etc.).

    // Create the network processing task.
    create_network_processor_task();

    // Start the FreeRTOS scheduler. This function never returns.
    vTaskStartScheduler();

    // Should never reach here.
    for (;;);
}
*/