# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

// 1. Define the configuration structure
// This struct will hold all parsed command-line arguments and configuration settings.
typedef struct {
    bool verbose;         // -v : Enable verbose mode
    char* output_file;    // -o <file> : Specify an output file
    char* input_file;     // Positional argument: Specify an input file
    // Add more configuration options as needed, e.g.:
    // int some_integer_value;
    // bool debug_mode;
} AppConfig;

// Function to print usage information to stderr
void print_usage(const char* app_name) {
    fprintf(stderr, "Usage: %s [-v] [-o <output_file>] [<input_file>]\n", app_name);
    fprintf(stderr, "Options:\n");
    fprintf(stderr, "  -v                  Enable verbose mode\n");
    fprintf(stderr, "  -o <output_file>    Specify an output file\n");
    fprintf(stderr, "  <input_file>        Specify an input file (optional positional argument)\n");
}

// Function to free the AppConfig structure and its dynamically allocated members
void free_app_config(AppConfig* config) {
    if (config == NULL) {
        return;
    }
    // Free dynamically allocated strings within the struct
    free(config->output_file);
    free(config->input_file);
    // Finally, free the struct itself
    free(config);
}

// 2. Function to parse command-line arguments and return a pointer to AppConfig
// Returns NULL on parsing error, with error messages printed to stderr.
AppConfig* parse_arguments(int argc, char* argv[]) {
    // Allocate memory for the AppConfig struct
    AppConfig* config = (AppConfig*)malloc(sizeof(AppConfig));
    if (config == NULL) {
        perror("Failed to allocate AppConfig");
        return NULL; // Memory allocation failed
    }

    // Initialize default values for configuration options
    config->verbose = false;
    config->output_file = NULL;
    config->input_file = NULL;

    // Loop through command-line arguments starting from argv[1] (argv[0] is the program name)
    int i;
    for (i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-v") == 0) {
            config->verbose = true;
        } else if (strcmp(argv[i], "-o") == 0) {
            // Check if there's a subsequent argument for the output file
            if (i + 1 < argc) {
                // Free any previously allocated output_file (e.g., if -o is specified multiple times)
                free(config->output_file);
                // Duplicate the string to ensure the config struct owns its memory
                config->output_file = strdup(argv[++i]); // Increment i to consume the filename argument
                if (config->output_file == NULL) {
                    perror("Failed to duplicate output file string");
                    free_app_config(config); // Clean up before returning NULL
                    return NULL;
                }
            } else {
                fprintf(stderr, "Error: Missing argument for -o option.\n");
                print_usage(argv[0]);
                free_app_config(config);
                return NULL;
            }
        } else if (argv[i][0] == '-') { // Check if it starts with '-' but not recognized
            fprintf(stderr, "Error: Unrecognized option '%s'.\n", argv[i]);
            print_usage(argv[0]);
            free_app_config(config);
            return NULL;
        } else {
            // This must be a positional argument (e.g., the input file)
            if (config->input_file == NULL) {
                // Duplicate the input file string
                config->input_file = strdup(argv[i]);
                if (config->input_file == NULL) {
                    perror("Failed to duplicate input file string");
                    free_app_config(config);
                    return NULL;
                }
            } else {
                // If an input file was already specified, it's an error (for this simple example)
                fprintf(stderr, "Error: Multiple input files specified ('%s' and '%s'). Only one allowed.\n",
                        config->input_file, argv[i]);
                print_usage(argv[0]);
                free_app_config(config);
                return NULL;
            }
        }
    }

    return config; // Return the successfully parsed configuration
}

// Main application entry point
int main(int argc, char* argv[]) {
    // Call the parsing function and immediately use the returned pointer
    AppConfig* app_config = parse_arguments(argc, argv);

    // 3. Check if parsing was successful
    if (app_config == NULL) {
        // Error message and usage were already printed by parse_arguments()
        return EXIT_FAILURE; // Indicate an error to the operating system
    }

    // --- Application Initialization and Logic using app_config ---
    printf("--- Application Initialized with Configuration ---\n");
    printf("  Verbose Mode: %s\n", app_config->verbose ? "Enabled" : "Disabled");
    printf("  Output File:  %s\n", app_config->output_file ? app_config->output_file : "[Not specified]");
    printf("  Input File:   %s\n", app_config->input_file ? app_config->input_file : "[Not specified]");

    // Example of how the application would use the parsed configuration:
    if (app_config->verbose) {
        printf("  Verbose logging enabled. Performing detailed operations...\n");
    }

    if (app_config->input_file) {
        printf("  Processing input from: %s\n", app_config->input_file);
        // In a real application, you would open and read from app_config->input_file
        // FILE* in_fp = fopen(app_config->input_file, "r");
        // if (in_fp) { /* ... process file ... */ fclose(in_fp); } else { perror("Input file error"); }
    } else {
        printf("  No input file specified. Using default input (e.g., stdin) or interactive mode.\n");
    }

    if (app_config->output_file) {
        printf("  Writing results to: %s\n", app_config->output_file);
        // In a real application, you would open and write to app_config->output_file
        // FILE* out_fp = fopen(app_config->output_file, "w");
        // if (out_fp) { /* ... write data ... */ fclose(out_fp); } else { perror("Output file error"); }
    } else {
        printf("  No output file specified. Printing to stdout or discarding results.\n");
    }

    printf("--- Application Logic Complete ---\n");

    // 4. Free the allocated configuration struct and its members when done
    free_app_config(app_config);

    return EXIT_SUCCESS; // Indicate success to the operating system
}