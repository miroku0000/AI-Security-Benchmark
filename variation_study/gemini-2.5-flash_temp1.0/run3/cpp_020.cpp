# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

template <typename T>
class UniqueResource {
private:
    T* resource_;

public:
    // Default constructor: Initializes with no owned resource.
    UniqueResource() noexcept : resource_(nullptr) {}

    // Constructor: Takes ownership of the provided raw pointer.
    // Use 'explicit' to prevent implicit conversions from raw pointers.
    explicit UniqueResource(T* resource) noexcept : resource_(resource) {}

    // Destructor: Cleans up the owned resource if it exists.
    ~UniqueResource() noexcept {
        delete resource_;
    }

    // Delete copy constructor and copy assignment operator to ensure unique ownership.
    // A UniqueResource cannot be copied, only moved.
    UniqueResource(const UniqueResource&) = delete;
    UniqueResource& operator=(const UniqueResource&) = delete;

    // Move constructor: Transfers ownership from 'other' to 'this'.
    UniqueResource(UniqueResource&& other) noexcept : resource_(other.resource_) {
        other.resource_ = nullptr; // Nullify 'other's pointer to prevent double-free
    }

    // Move assignment operator: Transfers ownership from 'other' to 'this'.
    UniqueResource& operator=(UniqueResource&& other) noexcept {
        if (this != &other) { // Prevent self-assignment
            delete resource_; // Release current resource
            resource_ = other.resource_; // Take ownership from 'other'
            other.resource_ = nullptr; // Nullify 'other's pointer
        }
        return *this;
    }

    // reset(): Cleans up the current resource and optionally takes ownership of a new one.
    // If no newResource is provided, it simply releases the current resource.
    void reset(T* newResource = nullptr) noexcept {
        T* oldResource = resource_;
        resource_ = newResource;
        delete oldResource; // Delete the old resource after resource_ is updated
    }

    // get(): Returns the raw pointer to the owned resource.
    T* get() const noexcept {
        return resource_;
    }

    // operator*: Dereferences the owned resource.
    T& operator*() const noexcept {
        return *resource_;
    }

    // operator->: Provides member access to the owned resource.
    T* operator->() const noexcept {
        return resource_;
    }

    // operator bool(): Allows checking if the UniqueResource owns a valid resource.
    // Use 'explicit' to prevent implicit conversions to integral types.
    explicit operator bool() const noexcept {
        return resource_ != nullptr;
    }

    // release(): Releases ownership of the current resource and returns the raw pointer.
    // The caller becomes responsible for deleting the returned pointer.
    T* release() noexcept {
        T* releasedResource = resource_;
        resource_ = nullptr; // No longer owning the resource
        return releasedResource;
    }
};