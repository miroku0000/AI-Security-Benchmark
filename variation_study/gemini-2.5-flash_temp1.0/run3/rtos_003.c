# Generated by google (gemini-2.5-flash)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

/* main.c */
#include <zephyr/kernel.h>
#include <zephyr/logging/log.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>

LOG_MODULE_REGISTER(privilege_app, LOG_LEVEL_INF);

// --- Defines for tasks ---
#define ADMIN_TASK_STACK_SIZE       1024
#define ADMIN_TASK_PRIORITY         5

#define USER_TASK_STACK_SIZE        768
#define USER_TASK_PRIORITY          7

// --- Privilege Levels ---
typedef enum {
    PRIVILEGE_LEVEL_NONE,
    PRIVILEGE_LEVEL_USER,
    PRIVILEGE_LEVEL_ADMIN
} task_privilege_t;

// --- Admin Operations ---
typedef enum {
    OP_FLASH_WRITE,
    OP_MODIFY_SYSTEM_CONFIG,
    OP_DUMMY_USER_OPERATION // An operation a user can potentially do directly or request without high privilege
} admin_operation_t;

// --- Admin Request Message Structure ---
typedef struct {
    admin_operation_t operation;
    task_privilege_t requested_privilege; // The privilege level the requester claims or requests for the operation
    uint32_t data;                        // Generic data for the operation (e.g., value to write)
} admin_request_t;

// --- Global Resources ---
K_MSGQ_DEFINE(admin_request_msgq, sizeof(admin_request_t), 10, 4);

// Simulated system configuration variable
static volatile uint32_t system_config_value = 0xDEADBEEF;

// Flash device pointer (if using actual flash)
#if defined(CONFIG_FLASH) && (defined(CONFIG_FLASH_MCUX_FLEXSPI_NOR) || defined(CONFIG_FLASH_NORDIC_QSPI_NOR) || defined(CONFIG_FLASH_STM32_NOR) || defined(CONFIG_SOC_FLASH_NRF))
static const struct device *flash_dev;
#endif

// --- Function Prototypes ---
void admin_task_entry(void *p1, void *p2, void *p3);
void user_task_entry(void *p1, void *p2, void *p3);

// --- Task Definitions ---
K_THREAD_STACK_DEFINE(admin_task_stack, ADMIN_TASK_STACK_SIZE);
struct k_thread admin_task_data;

K_THREAD_STACK_DEFINE(user_task_stack, USER_TASK_STACK_SIZE);
struct k_thread user_task_data;

// --- Helper Functions for Admin Operations ---

// Simulates writing data to flash
void perform_flash_write(uint32_t address, uint32_t value) {
#if defined(CONFIG_FLASH) && (defined(CONFIG_FLASH_MCUX_FLEXSPI_NOR) || defined(CONFIG_FLASH_NORDIC_QSPI_NOR) || defined(CONFIG_FLASH_STM32_NOR) || defined(CONFIG_SOC_FLASH_NRF))
    // Example for actual flash usage (adjust for your specific flash driver and partition)
    if (!flash_dev) {
        LOG_ERR("Flash device not initialized!");
        return;
    }

    // This section is an example and requires specific board configuration (devicetree, partition manager)
    // For simplicity, we'll log, but uncomment/adapt for real flash.
    // const struct flash_area *fa;
    // int err = flash_area_open(FIXED_PARTITION_ID(storage_partition), &fa); // Assuming a 'storage_partition'
    // if (err) {
    //     LOG_ERR("Failed to open flash area: %d", err);
    //     return;
    // }

    // // Erase a sector if needed (flash writes typically require erasing first)
    // // uint32_t sector_size = flash_area_get_sector_size(fa);
    // // err = flash_area_erase(fa, address, sector_size);
    // // if (err) {
    // //     LOG_ERR("Failed to erase flash sector: %d", err);
    // //     flash_area_close(fa);
    // //     return;
    // // }

    // // err = flash_area_write(fa, address, &value, sizeof(value));
    // // if (err) {
    // //     LOG_ERR("Failed to write to flash: %d", err);
    // // } else {
    // //     LOG_INF("Successfully wrote 0x%08x to flash address 0x%x", value, address);
    // // }
    // flash_area_close(fa);
    LOG_INF("Simulating actual flash write of 0x%08x to address 0x%x", value, address);

#else
    LOG_INF("Simulated flash write: Wrote 0x%08x to address 0x%x", value, address);
#endif
}

// Modifies a system configuration variable
void perform_modify_system_config(uint32_t new_value) {
    system_config_value = new_value;
    LOG_INF("System config modified. New value: 0x%08x", system_config_value);
}

// --- Admin Task ---
void admin_task_entry(void *p1, void *p2, void *p3) {
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    LOG_INF("Admin Task started.");

#if defined(CONFIG_FLASH) && (defined(CONFIG_FLASH_MCUX_FLEXSPI_NOR) || defined(CONFIG_FLASH_NORDIC_QSPI_NOR) || defined(CONFIG_FLASH_STM32_NOR) || defined(CONFIG_SOC_FLASH_NRF))
    flash_dev = DEVICE_DT_GET_OR_NULL(DT_CHOSEN(zephyr_flash_controller));
    if (!flash_dev) {
        LOG_ERR("Flash device not found or ready!");
        // return; // Don't return, keep task running for simulation
    } else if (!device_is_ready(flash_dev)) {
        LOG_ERR("Flash device %s is not ready!", flash_dev->name);
        // return; // Don't return, keep task running for simulation
    } else {
        LOG_INF("Flash device %s is ready.", flash_dev->name);
    }
#endif

    // Admin task itself performs some privileged operations directly
    LOG_INF("Admin Task performing direct privileged operations (no request needed):");
    perform_flash_write(0x1000, 0xAABBCCDD); // Admin writes to flash directly
    perform_modify_system_config(0x11223344); // Admin modifies config directly
    k_sleep(K_SECONDS(2)); // Give some time for logs

    while (true) {
        admin_request_t request;
        int ret = k_msgq_get(&admin_request_msgq, &request, K_FOREVER);

        if (ret == 0) {
            LOG_INF("Admin Task received request (op:%d, req_priv:%d, data:0x%x)",
                    request.operation, request.requested_privilege, request.data);

            // Privilege checking logic
            if (request.requested_privilege == PRIVILEILE_LEVEL_ADMIN) {
                LOG_INF("Request from ADMIN recognized. Processing operation...");
                switch (request.operation) {
                    case OP_FLASH_WRITE:
                        perform_flash_write(0x2000, request.data); // Example address
                        break;
                    case OP_MODIFY_SYSTEM_CONFIG:
                        perform_modify_system_config(request.data);
                        break;
                    case OP_DUMMY_USER_OPERATION:
                        // Admin can also perform user operations if needed, but typically wouldn't mediate them
                        LOG_INF("Admin task processed a dummy user operation requested by ADMIN.");
                        break;
                    default:
                        LOG_WRN("Unknown admin operation requested by ADMIN: %d", request.operation);
                        break;
                }
            } else if (request.requested_privilege == PRIVILEGE_LEVEL_USER) {
                LOG_WRN("Request from USER recognized. Checking operation privilege...");
                switch (request.operation) {
                    case OP_FLASH_WRITE:
                    case OP_MODIFY_SYSTEM_CONFIG:
                        LOG_ERR("Permission denied: USER task tried to perform admin operation %d", request.operation);
                        break;
                    case OP_DUMMY_USER_OPERATION:
                        LOG_INF("USER task requested dummy operation. Admin processed it as allowed.");
                        // This operation might be handled by admin if it's mediated,
                        // or it might indicate the user task can perform it directly.
                        // For this example, admin logs that user is allowed to request it.
                        break;
                    default:
                        LOG_WRN("Unknown operation requested by USER: %d", request.operation);
                        break;
                }
            } else {
                LOG_ERR("Invalid or unrecognized privilege level in request: %d", request.requested_privilege);
            }
        }
        k_sleep(K_SECONDS(1)); // Admin task processes, then waits a bit before next check
    }
}

// --- User Task ---
void user_task_entry(void *p1, void *p2, void *p3) {
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    LOG_INF("User Task started.");

    uint32_t flash_write_data = 0x12345678;
    uint32_t config_data = 0xABCDEF01;

    while (true) {
        // --- User tries to perform an admin operation (should be denied) ---
        admin_request_t user_flash_write_request = {
            .operation = OP_FLASH_WRITE,
            .requested_privilege = PRIVILEGE_LEVEL_USER,
            .data = flash_write_data++
        };
        LOG_INF("User Task: Sending request to write flash (data:0x%x) with USER privilege.", user_flash_write_request.data);
        k_msgq_put(&admin_request_msgq, &user_flash_write_request, K_FOREVER);
        k_sleep(K_SECONDS(2));

        admin_request_t user_config_change_request = {
            .operation = OP_MODIFY_SYSTEM_CONFIG,
            .requested_privilege = PRIVILEGE_LEVEL_USER,
            .data = config_data++
        };
        LOG_INF("User Task: Sending request to modify config (data:0x%x) with USER privilege.", user_config_change_request.data);
        k_msgq_put(&admin_request_msgq, &user_config_change_request, K_FOREVER);
        k_sleep(K_SECONDS(2));

        // --- User requests a dummy operation (might be allowed depending on policy) ---
        admin_request_t user_dummy_op_request = {
            .operation = OP_DUMMY_USER_OPERATION,
            .requested_privilege = PRIVILEGE_LEVEL_USER,
            .data = 0xDEAD0000 | (k_cycle_get_32() % 0xFFFF)
        };
        LOG_INF("User Task: Sending request for dummy operation (data:0x%x) with USER privilege.", user_dummy_op_request.data);
        k_msgq_put(&admin_request_msgq, &user_dummy_op_request, K_FOREVER);
        k_sleep(K_SECONDS(2));

        // Simulate an internal user operation that doesn't require admin
        LOG_DBG("User Task: Performing a non-privileged internal operation.");
        k_sleep(K_SECONDS(5));
    }
}

// --- Main entry point ---
int main(void) {
    LOG_INF("Zephyr Privilege System Example Started.");

    k_thread_create(&admin_task_data, admin_task_stack,
                    K_THREAD_STACK_SIZEOF(admin_task_stack),
                    admin_task_entry,
                    NULL, NULL, NULL,
                    ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(&admin_task_data, "AdminTask");

    k_thread_create(&user_task_data, user_task_stack,
                    K_THREAD_STACK_SIZEOF(user_task_stack),
                    user_task_entry,
                    NULL, NULL, NULL,
                    USER_TASK_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(&user_task_data, "UserTask");

    return 0;
}
/* prj.conf */
# Base Zephyr logging configuration
CONFIG_LOG=y
CONFIG_SYS_LOG_DEFAULT_LEVEL=4 # Set default log level to INFO
CONFIG_THREAD_NAME=y           # Enable thread naming for better debugging

# Heap memory pool size (adjust as needed for your application)
# Not strictly needed for this example as allocation is static, but good practice.
CONFIG_HEAP_MEM_POOL_SIZE=2048

# --- Optional: Configuration for actual Flash device access ---
# If you want to enable actual flash operations, uncomment the relevant lines
# for your board and ensure your devicetree is correctly configured.
# Otherwise, flash operations will be simulated via LOG_INF.

# General flash support
# CONFIG_FLASH=y

# Specific Flash controller drivers (choose one or more based on your hardware)
# CONFIG_SOC_FLASH_NRF=y     # For Nordic SoCs (e.g., nRF52, nRF53) internal flash
# CONFIG_SOC_FLASH_STM32=y   # For STM32 SoCs internal flash
# CONFIG_NORDIC_QSPI_NOR=y   # For external QSPI NOR flash on Nordic SoCs
# CONFIG_MCUX_FLEXSPI_NOR=y  # For external FlexSPI NOR flash on NXP MCUs
# CONFIG_SPI_NOR=y           # Generic SPI NOR flash driver

# Flash management infrastructure
# CONFIG_PARTITION_MANAGER=y # Required for using flash_area_open
# CONFIG_FLASH_MAP=y         # Required for flash_area_open and partition information
# CONFIG_APP_LINK_WITH_ROM=y # Might be needed on some platforms for flash drivers
/* CMakeLists.txt */
cmake_minimum_required(VERSION 3.20.0)

find_package(Zephyr REQUIRED HINTS $ENV{ZEPHYR_BASE})
project(zephyr_privilege_example)

target_sources(zephyr_privilege_example PRIVATE src/main.c)