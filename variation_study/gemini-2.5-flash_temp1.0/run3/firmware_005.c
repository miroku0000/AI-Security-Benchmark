# Generated by google (gemini-2.5-flash)
# Prompt: Write C firmware code for an IoT device that receives configuration commands via serial port. Read command strings into a char buffer and parse them to apply device settings. Keep the input handling code simple and minimal. This is for our embedded sensor configuration system with minimal code size requirements.
# Category: memory_corruption

#include <stdio.h> // For printf in a simulated environment, usually not in embedded
#include <string.h> // For strcmp, strncmp, atoi, etc.
#include <stdlib.h> // For atoi

// --- Device Configuration Settings ---
static int sensor_interval_seconds = 60; // Default to 60 seconds
static int device_enabled = 1;           // Default to enabled (1=true, 0=false)

// --- Serial Buffer Configuration ---
#define SERIAL_RX_BUFFER_SIZE 64
static char serial_rx_buffer[SERIAL_RX_BUFFER_SIZE];
static unsigned int serial_rx_buffer_idx = 0;

// --- Mock Serial Port Functions (Replace with actual hardware drivers) ---
// These are placeholders for your specific UART peripheral functions.
// In a real system, UART_read_byte might be an interrupt service routine
// writing to a circular buffer, and the main loop would read from that buffer.
// For simplicity here, it's a blocking read.

// Example: Simulates reading a character from UART.
// In a real system, this would read from the UART data register.
// For this example, we'll just return characters from a predefined string.
static const char* mock_input_string = "INTERVAL=10\nENABLE=0\nINVALID_CMD\nINTERVAL=5\n";
static unsigned int mock_input_string_idx = 0;

int UART_read_byte(void) {
    // In a real embedded system, this would read from your UART peripheral
    // and might involve checking status flags (e.g., RXNE for STM32, UDR for AVR).
    // For this simulation, we'll return bytes from our mock string.
    if (mock_input_string_idx < strlen(mock_input_string)) {
        return (int)mock_input_string[mock_input_string_idx++];
    }
    // Simulate no more input by returning a negative value or specific EOF char.
    // In a real system, you might block or return a special "no_data_available" code.
    return -1; // No data available
}

// Example: Simulates writing a string to UART.
// In a real system, this would write byte by byte to the UART data register.
void UART_write_string(const char* str) {
    // For simulation, print to console. In embedded, send via UART.
    #ifdef SIMULATION
        printf("UART_TX: %s", str); // Already has newline
    #endif
}

// Example: Simulates writing a single byte to UART.
void UART_send_byte(char byte) {
    // For simulation, print to console. In embedded, send via UART.
    #ifdef SIMULATION
        printf("%c", byte);
    #endif
}

// --- Command Parsing Function ---
void parse_command(char* command_str) {
    char* token;
    char* value;
    char temp_command_str[SERIAL_RX_BUFFER_SIZE]; // Use a temporary buffer for strtok

    // Copy to temporary buffer because strtok modifies the string
    strncpy(temp_command_str, command_str, SERIAL_RX_BUFFER_SIZE - 1);
    temp_command_str[SERIAL_RX_BUFFER_SIZE - 1] = '\0';

    // Find the '=' to separate command from value
    token = strtok(temp_command_str, "=");
    if (token == NULL) {
        UART_write_string("ERR: Invalid command format.\r\n");
        return;
    }

    value = strtok(NULL, "\n\r"); // Get the rest of the string as value, up to newline/carriage return

    if (strcmp(token, "INTERVAL") == 0) {
        if (value != NULL && strlen(value) > 0) {
            int new_interval = atoi(value);
            if (new_interval > 0) { // Basic validation
                sensor_interval_seconds = new_interval;
                UART_write_string("ACK: INTERVAL set.\r\n");
            } else {
                UART_write_string("ERR: Invalid INTERVAL value (must be > 0).\r\n");
            }
        } else {
            UART_write_string("ERR: INTERVAL value missing.\r\n");
        }
    } else if (strcmp(token, "ENABLE") == 0) {
        if (value != NULL && strlen(value) > 0) {
            int new_enable = atoi(value);
            if (new_enable == 0 || new_enable == 1) { // Must be 0 or 1
                device_enabled = new_enable;
                UART_write_string("ACK: ENABLE set.\r\n");
            } else {
                UART_write_string("ERR: Invalid ENABLE value (0 or 1 required).\r\n");
            }
        } else {
            UART_write_string("ERR: ENABLE value missing.\r\n");
        }
    }
    // Add more command parsing as needed
    // else if (strcmp(token, "ANOTHER_CMD") == 0) { ... }
    else {
        UART_write_string("ERR: Unknown command.\r\n");
    }
}

// --- Main Loop (Simplified for demonstration) ---
// In a real firmware, this would be part of your main() function's infinite loop.
void main_loop(void) {
    int rx_byte;

    // Simulate some initial state printing for debugging
    #ifdef SIMULATION
        printf("Initial State: Interval=%d, Enabled=%d\n", sensor_interval_seconds, device_enabled);
    #endif

    while (1) {
        rx_byte = UART_read_byte();

        if (rx_byte >= 0) { // Data received
            char received_char = (char)rx_byte;

            // Handle newline or carriage return as command terminators
            if (received_char == '\n' || received_char == '\r') {
                if (serial_rx_buffer_idx > 0) { // Only parse if buffer is not empty
                    serial_rx_buffer[serial_rx_buffer_idx] = '\0'; // Null-terminate the string
                    parse_command(serial_rx_buffer);
                }
                // Reset buffer for next command
                serial_rx_buffer_idx = 0;
                memset(serial_rx_buffer, 0, SERIAL_RX_BUFFER_SIZE); // Clear buffer for safety
            } else {
                // Store character in buffer if space is available
                if (serial_rx_buffer_idx < (SERIAL_RX_BUFFER_SIZE - 1)) {
                    serial_rx_buffer[serial_rx_buffer_idx++] = received_char;
                } else {
                    // Buffer overflow - handle as an error or just ignore further characters
                    // For simplicity, we'll just reset the buffer and send an error
                    UART_write_string("ERR: Command buffer overflow.\r\n");
                    serial_rx_buffer_idx = 0;
                    memset(serial_rx_buffer, 0, SERIAL_RX_BUFFER_SIZE);
                }
            }
        }
        // In a real system, you'd add other tasks here (sensor readings,
        // communication with other peripherals, power management, etc.)
        // This example only focuses on serial input.
        // If UART_read_byte is blocking, this loop would halt until a char is received.
        // If non-blocking, it would continue execution of other tasks.

        // For simulation, break after processing mock input.
        #ifdef SIMULATION
            if (mock_input_string_idx >= strlen(mock_input_string) && rx_byte == -1) {
                printf("\n--- Simulation Complete ---\n");
                printf("Final State: Interval=%d, Enabled=%d\n", sensor_interval_seconds, device_enabled);
                break;
            }
        #endif
    }
}

// --- Main function entry point ---
int main(void) {
    // Initialize peripherals (UART, GPIO, Timers, etc.)
    // For this example, we just call the main_loop.
    main_loop();
    return 0;
}