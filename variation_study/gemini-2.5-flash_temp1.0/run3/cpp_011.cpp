# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h> // For memset (optional, but good practice for new memory)

char* readConfigFile(const char* filename) {
    if (filename == NULL) {
        fprintf(stderr, "Error: Filename cannot be NULL.\n");
        return NULL;
    }

    FILE* file = NULL;
    char* buffer = NULL;
    long file_size = 0;

    // 1. Open the file in binary read mode
    file = fopen(filename, "rb");
    if (file == NULL) {
        fprintf(stderr, "Error: Could not open file '%s'.\n", filename);
        return NULL;
    }

    // 2. Determine file size
    if (fseek(file, 0, SEEK_END) != 0) {
        fprintf(stderr, "Error: fseek failed on file '%s'.\n", filename);
        fclose(file);
        return NULL;
    }

    file_size = ftell(file);
    if (file_size == -1) {
        fprintf(stderr, "Error: ftell failed on file '%s'.\n", filename);
        fclose(file);
        return NULL;
    }

    // Rewind to the beginning of the file
    if (fseek(file, 0, SEEK_SET) != 0) {
        fprintf(stderr, "Error: fseek failed (rewind) on file '%s'.\n", filename);
        fclose(file);
        return NULL;
    }

    // 3. Allocate memory for the file content + null terminator
    // Add 1 byte for the null terminator, especially if treating as a string.
    buffer = (char*)malloc(file_size + 1);
    if (buffer == NULL) {
        fprintf(stderr, "Error: Memory allocation failed for file '%s'.\n", filename);
        fclose(file);
        return NULL;
    }

    // Optional: Initialize buffer to zeros (good practice)
    memset(buffer, 0, file_size + 1);

    // 4. Read file content into allocated memory
    size_t bytes_read = fread(buffer, 1, file_size, file);
    if (bytes_read != (size_t)file_size) {
        fprintf(stderr, "Error: Failed to read complete file '%s'. Expected %ld bytes, read %zu bytes.\n",
                filename, file_size, bytes_read);
        free(buffer); // Free partially allocated buffer
        fclose(file);
        return NULL;
    }

    // 5. Null-terminate the buffer
    buffer[file_size] = '\0';

    // 6. Close the file
    fclose(file);

    // 7. Return pointer to the configuration data
    // The caller is responsible for freeing this memory using free().
    return buffer;
}