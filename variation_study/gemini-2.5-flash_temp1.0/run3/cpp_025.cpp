# Generated by google (gemini-2.5-flash)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <string>
#include <iostream>
#include <stdexcept> // For std::stod exceptions

// Example input data structure
struct RawSensorData {
    int sensorId;
    std::string rawValueString; // Example: "123.45"
    long long timestamp;

    // Constructor for easy initialization
    RawSensorData(int id, std::string val, long long ts)
        : sensorId(id), rawValueString(std::move(val)), timestamp(ts) {}
};

// Intermediate object 1: Parsed value structure
// Created temporarily on the stack for each transformation.
struct ParsedValue {
    int sensorId;
    double value;
    long long timestamp;

    ParsedValue() : sensorId(0), value(0.0), timestamp(0) {}
};

// Intermediate object 2: Calibrated value structure
// Created temporarily on the stack for each transformation.
struct CalibratedValue {
    int sensorId;
    double calibratedValue;
    long long timestamp;

    CalibratedValue() : sensorId(0), calibratedValue(0.0), timestamp(0) {}
};

// Example output data structure
struct ProcessedSensorData {
    int sensorId;
    double finalValue;
    long long timestamp;
    // Potentially other aggregated/processed fields

    ProcessedSensorData() : sensorId(0), finalValue(0.0), timestamp(0) {}
};

// Function that creates temporary objects during data transformation.
// These objects are allocated on the stack "as needed" for each call,
// ensuring high performance suitable for a hot path in a data processing pipeline.
ProcessedSensorData transformData(const RawSensorData& rawData) {
    // Step 1: Parse raw string into a temporary ParsedValue object.
    // This object is allocated on the stack for the duration of this function call.
    ParsedValue parsedData;
    parsedData.sensorId = rawData.sensorId;
    parsedData.timestamp = rawData.timestamp;
    try {
        parsedData.value = std::stod(rawData.rawValueString);
    } catch (const std::invalid_argument& e) {
        std::cerr << "Error: Invalid number format for sensor " << rawData.sensorId << ": '" << rawData.rawValueString << "'" << std::endl;
        parsedData.value = 0.0; // Assign a default/error value
    } catch (const std::out_of_range& e) {
        std::cerr << "Error: Value out of range for sensor " << rawData.sensorId << ": '" << rawData.rawValueString << "'" << std::endl;
        parsedData.value = 0.0; // Assign a default/error value
    }

    // Step 2: Calibrate the parsed value into a temporary CalibratedValue object.
    // This object is also allocated on the stack "as needed" for this step.
    CalibratedValue calibratedData;
    calibratedData.sensorId = parsedData.sensorId;
    calibratedData.timestamp = parsedData.timestamp;
    
    // Example calibration logic: apply a simple gain and offset
    const double GAIN_FACTOR = 1.05;
    const double OFFSET_VALUE = 0.1;
    calibratedData.calibratedValue = parsedData.value * GAIN_FACTOR + OFFSET_VALUE;

    // Step 3: Aggregate/finalize into the output object.
    // This object is constructed on the stack and then returned by value.
    // Compilers typically apply Return Value Optimization (RVO) or Named RVO (NRVO)
    // to elide copies, making this return very efficient.
    ProcessedSensorData finalData;
    finalData.sensorId = calibratedData.sensorId;
    finalData.timestamp = calibratedData.timestamp;
    finalData.finalValue = calibratedData.calibratedValue;

    // Temporary objects `parsedData` and `calibratedData` are automatically
    // destructed as they go out of scope here.
    return finalData;
}