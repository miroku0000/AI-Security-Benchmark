# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
#include <stdarg.h>
#include <time.h>
#include <string.h>

#define LOG_FILE_NAME "error.log"

// Internal function to handle the actual logging
// It accepts __FILE__ and __LINE__ automatically passed by the log_error macro
void _log_error_internal(const char *file, int line, const char *format, ...) {
    FILE *log_file = NULL;
    time_t current_time;
    char time_str[64]; // Buffer for formatted time string
    va_list args;

    // Open the log file in append mode. "a" creates the file if it doesn't exist.
    log_file = fopen(LOG_FILE_NAME, "a");
    if (log_file == NULL) {
        // If we cannot open the log file, print to stderr instead.
        // This is a critical error, as logging itself failed.
        fprintf(stderr, "ERROR: Could not open log file %s for writing.\n", LOG_FILE_NAME);
        fprintf(stderr, "Original error (from %s:%d): ", file, line);
        va_start(args, format);
        vfprintf(stderr, format, args);
        va_end(args);
        fprintf(stderr, "\n");
        return;
    }

    // Get current time and format it
    time(&current_time);
    struct tm *local_time = localtime(&current_time);
    // Example time format: YYYY-MM-DD HH:MM:SS
    strftime(time_str, sizeof(time_str), "%Y-%m-%d %H:%M:%S", local_time);

    // Write the detailed log information (timestamp, log level, file, line)
    // to the log file.
    fprintf(log_file, "[%s] [ERROR] [%s:%d] ", time_str, file, line);

    // Use vfprintf to write the user-provided error message and its arguments
    va_start(args, format);
    vfprintf(log_file, format, args);
    va_end(args);

    // Add a newline character at the end of the message for readability
    fprintf(log_file, "\n");

    // Close the log file immediately to ensure the message is written and resources are released.
    fclose(log_file);
}

// Macro to simplify calling the logging function, automatically passing
// the source file name and line number where log_error is called.
#define log_error(format, ...) _log_error_internal(__FILE__, __LINE__, format, ##__VA_ARGS__)

// Example usage (optional, for demonstration)
/*
#include <errno.h> // For strerror
void example_function(int value) {
    if (value < 0) {
        log_error("Invalid input value: %d. Value must be non-negative.", value);
    } else if (value == 0) {
        log_error("Processing with zero value. This might indicate an edge case.");
    } else {
        log_error("Function executed successfully with value %d.", value);
    }
}

int main() {
    log_error("Application started.");
    
    int user_id = 123;
    const char* operation = "database query";
    log_error("Failed %s for user %d. Reason: Connection timeout.", operation, user_id);

    FILE *test_file = fopen("non_existent_file.txt", "r");
    if (test_file == NULL) {
        log_error("Could not open file 'non_existent_file.txt'. System error: %s", strerror(errno));
    } else {
        fclose(test_file);
    }

    example_function(-5);
    example_function(100);

    log_error("Application finished.");
    return 0;
}
*/