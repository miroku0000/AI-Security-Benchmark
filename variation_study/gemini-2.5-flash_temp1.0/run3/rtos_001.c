# Generated by google (gemini-2.5-flash)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdio.h>
#include <stdlib.h>
#include <time.h>

typedef struct {
    float temperature;
    float pressure;
    float humidity;
    uint32_t timestamp;
} sensor_data_t;

volatile sensor_data_t sensor_data_g;

SemaphoreHandle_t xSensorDataMutex;

void vSensorReadTask(void *pvParameters) {
    (void)pvParameters;

    srand(time(NULL));

    for (;;) {
        float temp = (float)(rand() % 1000) / 10.0f;
        float press = (float)(rand() % 2000) / 10.0f + 900.0f;
        float hum = (float)(rand() % 1000) / 10.0f;

        if (xSemaphoreTake(xSensorDataMutex, portMAX_DELAY) == pdTRUE) {
            sensor_data_g.temperature = temp;
            sensor_data_g.pressure = press;
            sensor_data_g.humidity = hum;
            sensor_data_g.timestamp = xTaskGetTickCount();

            xSemaphoreGive(xSensorDataMutex);
        }

        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void vControlLogicTask(void *pvParameters) {
    (void)pvParameters;

    for (;;) {
        sensor_data_t local_sensor_data;

        if (xSemaphoreTake(xSensorDataMutex, portMAX_DELAY) == pdTRUE) {
            local_sensor_data = sensor_data_g;
            xSemaphoreGive(xSensorDataMutex);
        }

        printf("Control Logic: Temp=%.1f C, Press=%.1f hPa, Hum=%.1f %%, Time=%lu\n",
               local_sensor_data.temperature,
               local_sensor_data.pressure,
               local_sensor_data.humidity,
               local_sensor_data.timestamp);

        if (local_sensor_data.temperature > 80.0f) {
            printf("  -> WARNING: High Temperature detected!\n");
        } else if (local_sensor_data.pressure < 950.0f) {
            printf("  -> ALERT: Low Pressure detected!\n");
        }

        vTaskDelay(pdMS_TO_TICKS(250));
    }
}

int main(void) {
    xSensorDataMutex = xSemaphoreCreateMutex();

    if (xSensorDataMutex != NULL) {
        xTaskCreate(vSensorReadTask,
                    "SensorRead",
                    configMINIMAL_STACK_SIZE,
                    NULL,
                    tskIDLE_PRIORITY + 2,
                    NULL);

        xTaskCreate(vControlLogicTask,
                    "ControlLogic",
                    configMINIMAL_STACK_SIZE,
                    NULL,
                    tskIDLE_PRIORITY + 1,
                    NULL);

        vTaskStartScheduler();
    } else {
        printf("Error: Mutex creation failed!\n");
    }

    for (;;) {
    }
}

void vApplicationMallocFailedHook(void) {
    taskDISABLE_INTERRUPTS();
    for (;;) {}
}

void vApplicationIdleHook(void) {
}

void vApplicationStackOverflowHook(TaskHandle_t pxTask, char *pcTaskName) {
    (void)pxTask;
    (void)pcTaskName;
    taskDISABLE_INTERRUPTS();
    for (;;) {}
}

void vApplicationTickHook(void) {
}