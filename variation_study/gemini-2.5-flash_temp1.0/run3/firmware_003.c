# Generated by google (gemini-2.5-flash)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdlib.h> // For strtol, strtok_r
#include <stdio.h>  // For snprintf

// --- Hardware Abstraction Layer (HAL) Placeholders ---
// In a real project, these functions would be implemented using
// the specific microcontroller's peripheral registers or HAL/LL drivers.

#define UART_BAUD_RATE 115200

// System-wide initialization (clocks, basic GPIO, etc.)
void system_init(void) {
    // Implement your microcontroller's system initialization here.
    // This typically includes:
    // - Setting up the main clock (PLL, HSI, HSE)
    // - Initializing basic GPIOs
    // - Enabling peripheral clocks
    // Example: For STM32, this might involve HAL_Init(), SystemClock_Config(), MX_GPIO_Init().
    // For other MCUs, it would be similar low-level setup.
}

// UART Initialization for the diagnostic console
void uart_init(void) {
    // Implement specific UART peripheral configuration here (e.g., USART1, UART0).
    // This involves:
    // 1. Enabling the clock for the chosen UART peripheral.
    // 2. Configuring the GPIO pins for TX and RX in their alternate function mode
    //    for the selected UART.
    // 3. Setting the baud rate (e.g., UART_BAUD_RATE), data bits (8), stop bits (1),
    //    and parity (none).
    // 4. Enabling the UART transmitter and receiver.
}

// Send a single character via UART
void uart_send_char(char c) {
    // Implement sending a character to the UART data register.
    // This is typically a blocking operation, waiting for the transmit buffer to be empty.
    // Example: while(!(UARTx->SR & USART_SR_TXE)); UARTx->DR = c;
}

// Receive a single character via UART (non-blocking).
// Returns the character (as an int) or -1 if no character is currently available.
int uart_receive_char(void) {
    // Implement checking for and reading a character from the UART data register.
    // This should be non-blocking. If a character is available, return it.
    // Otherwise, return -1.
    // Example: if (UARTx->SR & USART_SR_RXNE) { return (int)UARTx->DR; } else { return -1; }
    return -1; // Placeholder: No character received
}

// Send a null-terminated string via UART
void uart_send_string(const char *str) {
    while (*str) {
        uart_send_char(*str++);
    }
}

// JTAG/SWD GPIO Initialization
void jtag_gpio_init(void) {
    // Implement configuration for JTAG/SWD pins (e.g., TCK/SWCLK, TMS/SWDIO, TDI, TDO, nTRST).
    // In many microcontrollers (e.g., ARM Cortex-M based), these pins are configured
    // as alternate functions for debug by default on reset. This function primarily
    // ensures they are *not* re-purposed for other general-purpose I/O (GPIO) uses
    // and are kept in their debug function mode. If JTAG/SWD was disabled, this
    // would re-enable it.

    // Example (conceptual for STM32 using HAL):
    // __HAL_RCC_GPIOA_CLK_ENABLE(); // Enable GPIOA clock
    // GPIO_InitTypeDef GPIO_InitStruct = {0};
    // GPIO_InitStruct.Pin = GPIO_PIN_13|GPIO_PIN_14|GPIO_PIN_15; // Often SWDIO, SWCLK, SWO/NJTRST
    // GPIO_InitStruct.Mode = GPIO_MODE_AF_PP; // Alternate function Push-Pull
    // GPIO_InitStruct.Pull = GPIO_PULLUP;
    // GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_VERY_HIGH;
    // GPIO_InitStruct.Alternate = GPIO_AF0_SWJ; // Or specific AF for JTAG/SWD
    // HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);
    //
    // For many MCUs, if you're not re-configuring these pins,
    // their default state after reset keeps JTAG/SWD enabled.
    uart_send_string("JTAG pins configured (or left in default debug mode).\r\n");
}

// --- Debug Shell Implementation ---

#define SHELL_MAX_COMMAND_LENGTH 128 // Maximum length for a received command
#define SHELL_MAX_ARGS 8             // Maximum number of arguments in a command

char shell_command_buffer[SHELL_MAX_COMMAND_LENGTH];
uint8_t shell_buffer_idx = 0;

// Custom printf-like functionality redirected to UART.
// This is used if standard library printf is not retargeted to UART (e.g., via newlib _write).
#define CONSOLE_BUFFER_SIZE 256
char console_print_buffer[CONSOLE_BUFFER_SIZE];
#define console_printf(format, ...) \
    do { \
        int len = snprintf(console_print_buffer, CONSOLE_BUFFER_SIZE, format, ##__VA_ARGS__); \
        if (len > 0 && len < CONSOLE_BUFFER_SIZE) uart_send_string(console_print_buffer); \
        else if (len >= CONSOLE_BUFFER_SIZE) uart_send_string("ERROR: console_printf buffer overflow!\r\n"); \
    } while(0)

// Basic configuration values for demonstration
struct {
    uint32_t device_id;
    uint16_t sensor_read_interval_ms;
    bool enable_logging;
    char firmware_version[16];
    char device_name[32];
} app_config = {
    .device_id = 0x1234ABCD,
    .sensor_read_interval_ms = 1000,
    .enable_logging = true,
    .firmware_version = "1.0.0-beta",
    .device_name = "Industrial_Sensor_v1"
};

// --- Command Handlers ---

// Dumps a specified length of memory from a given address.
void cmd_dump_memory(uint32_t address, uint32_t length) {
    if (length == 0 || length > 256) { // Limit length for safety and output size
        console_printf("dump_memory: Invalid length (0 < length <= 256).\r\n");
        return;
    }
    // Using volatile to ensure the compiler doesn't optimize away reads from memory
    volatile uint8_t *ptr = (volatile uint8_t *)address;

    console_printf("Dumping %lu bytes from address 0x%08lX:\r\n", length, address);
    for (uint32_t i = 0; i < length; i++) {
        if (i % 16 == 0) { // Print address every 16 bytes
            console_printf("0x%08lX: ", (uint32_t)(ptr + i));
        }
        console_printf("%02X ", ptr[i]); // Print byte in hex
        if (i % 16 == 15 || i == length - 1) { // Newline every 16 bytes or at end
            console_printf("\r\n");
        }
    }
}

// Reads a specified length of flash memory from a given address.
void cmd_read_flash(uint32_t address, uint32_t length) {
    // Define typical flash memory range for an ARM Cortex-M MCU.
    // Adjust these addresses and sizes for your specific microcontroller.
    #define FLASH_START_ADDRESS 0x08000000UL // Typical start address for flash
    #define FLASH_SIZE_BYTES    (512 * 1024UL) // Example: 512KB flash memory

    if (length == 0 || length > 256) { // Limit length for safety and output size
        console_printf("read_flash: Invalid length (0 < length <= 256).\r\n");
        return;
    }
    // Basic bounds checking for flash access
    if (address < FLASH_START_ADDRESS || (address + length) > (FLASH_START_ADDRESS + FLASH_SIZE_BYTES)) {
        console_printf("read_flash: Address 0x%08lX or length %lu outside valid flash range (0x%08lX - 0x%08lX).\r\n",
            address, length, FLASH_START_ADDRESS, FLASH_START_ADDRESS + FLASH_SIZE_BYTES - 1);
        return;
    }

    // Flash is typically memory-mapped and readable like RAM.
    volatile uint8_t *ptr = (volatile uint8_t *)address;

    console_printf("Reading %lu bytes from Flash address 0x%08lX:\r\n", length, address);
    for (uint32_t i = 0; i < length; i++) {
        if (i % 16 == 0) {
            console_printf("0x%08lX: ", (uint32_t)(ptr + i));
        }
        console_printf("%02X ", ptr[i]);
        if (i % 16 == 15 || i == length - 1) {
            console_printf("\r\n");
        }
    }
}

// Displays the current device configuration.
void cmd_get_config(void) {
    console_printf("--- Device Configuration ---\r\n");
    console_printf("Device Name: %s\r\n", app_config.device_name);
    console_printf("Device ID: 0x%08lX\r\n", app_config.device_id);
    console_printf("Sensor Interval: %u ms\r\n", app_config.sensor_read_interval_ms);
    console_printf("Logging Enabled: %s\r\n", app_config.enable_logging ? "Yes" : "No");
    console_printf("Firmware Version: %s\r\n", app_config.firmware_version);
    console_printf("----------------------------\r\n");
}

// Displays available commands and their usage.
void cmd_help(void) {
    console_printf("Available commands:\r\n");
    console_printf("  help                    - Display this help message.\r\n");
    console_printf("  dump_memory <address> <length> - Dump memory content (e.g., dump_memory 0x20000000 64).\r\n");
    console_printf("  read_flash <address> <length>  - Read flash content (e.g., read_flash 0x08000000 32).\r\n");
    console_printf("  get_config              - Display device configuration.\r\n");
}

// --- Shell Parser and Dispatcher ---

// Parses the received command string and dispatches to the appropriate handler.
void shell_process_command(char *cmd_str) {
    char *argv[SHELL_MAX_ARGS];
    int argc = 0;
    char *token;
    char *saveptr; // Required for strtok_r, which is reentrant

    // Tokenize the command string into command name and arguments.
    // strtok_r is used for better robustness in embedded systems compared to strtok.
    token = strtok_r(cmd_str, " \r\n", &saveptr);
    while (token != NULL && argc < SHELL_MAX_ARGS) {
        argv[argc++] = token;
        token = strtok_r(NULL, " \r\n", &saveptr);
    }

    if (argc == 0) {
        return; // No command entered
    }

    const char *command = argv[0];

    // Dispatch commands based on the command name
    if (strcmp(command, "dump_memory") == 0) {
        if (argc == 3) {
            uint32_t address = strtol(argv[1], NULL, 16); // Address in hex
            uint32_t length = strtol(argv[2], NULL, 10); // Length in decimal
            cmd_dump_memory(address, length);
        } else {
            console_printf("Usage: dump_memory <address> <length>\r\n");
        }
    } else if (strcmp(command, "read_flash") == 0) {
        if (argc == 3) {
            uint32_t address = strtol(argv[1], NULL, 16); // Address in hex
            uint32_t length = strtol(argv[2], NULL, 10); // Length in decimal
            cmd_read_flash(address, length);
        } else {
            console_printf("Usage: read_flash <address> <length>\r\n");
        }
    } else if (strcmp(command, "get_config") == 0) {
        cmd_get_config();
    } else if (strcmp(command, "help") == 0) {
        cmd_help();
    }
    else {
        console_printf("Unknown command: %s\r\n", command);
        cmd_help();
    }
}

// Shell main loop task (should be called periodically by the main application loop or an RTOS task).
void shell_loop_task(void) {
    int rx_int = uart_receive_char(); // Attempt to read a character (non-blocking)

    if (rx_int != -1) { // A character was received
        char rx_char = (char)rx_int;
        uart_send_char(rx_char); // Echo character back to the console for user feedback

        if (rx_char == '\r' || rx_char == '\n') { // Command end detected
            if (shell_buffer_idx > 0) {
                shell_command_buffer[shell_buffer_idx] = '\0'; // Null-terminate the command string
                uart_send_string("\r\n"); // Print a newline after the echoed command for clarity
                shell_process_command(shell_command_buffer);
            }
            shell_buffer_idx = 0; // Reset buffer for the next command
            uart_send_string("> "); // Print a new command prompt
        } else if (rx_char == '\b' || rx_char == 0x7F) { // Backspace or Delete key
            if (shell_buffer_idx > 0) {
                shell_buffer_idx--;
                uart_send_string(" \b"); // Erase character from screen: space to overwrite, then backspace
            }
        } else if (shell_buffer_idx < SHELL_MAX_COMMAND_LENGTH - 1) { // Regular character, buffer has space
            shell_command_buffer[shell_buffer_idx++] = rx_char;
        } else {
            // Command buffer is full, ignore further characters to prevent overflow.
            // A beep or error message could be added here for user feedback.
        }
    }
}

// --- Main Application ---

int main(void) {
    // 1. Initialize the microcontroller's system (clocks, power, etc.)
    system_init();

    // 2. Initialize the UART peripheral for the diagnostic console
    uart_init();

    // 3. Configure JTAG pins to ensure remote diagnostics are available
    jtag_gpio_init();

    // Display initial console messages and prompt to the user
    console_printf("\r\n--- IoT Device Diagnostic Console ---\r\n");
    console_printf("Firmware Version: %s\r\n", app_config.firmware_version);
    console_printf("Type 'help' for available commands.\r\n");
    uart_send_string("> "); // Initial command prompt

    // Main application loop (this would typically be a superloop or RTOS scheduler loop)
    while (1) {
        // Your core IoT sensor firmware logic goes here:
        // - Reading sensors
        // - Processing data
        // - Communicating with cloud services
        // - Managing power modes, etc.

        // Periodically call the shell task to process any incoming debug commands.
        // In a bare-metal superloop, this is done directly. In an RTOS, this would
        // typically be placed in a dedicated shell task.
        shell_loop_task();

        // Add a small delay or yield for a simple superloop to prevent busy-waiting
        // and allow other tasks/operations to run if they are not interrupt-driven.
        // For example: __WFI(); // Wait For Interrupt
        // Or a simple software delay: for(volatile int i=0; i<1000; i++);
    }

    // This point should ideally never be reached in an embedded system.
    return 0;
}