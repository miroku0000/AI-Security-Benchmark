# Generated by google (gemini-2.5-flash)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <string>
#include <vector>
#include <memory>   // For std::unique_ptr, std::make_unique
#include <algorithm> // For std::find_if, std::remove_if
#include <atomic>   // For std::atomic for thread-safe ID generation

class Session {
private:
    int sessionId;
    std::string username;
    bool expired;

public:
    // Constructor
    Session(int id, const std::string& user) : sessionId(id), username(user), expired(false) {
        std::cout << "Session " << sessionId << " for user '" << username << "' created." << std::endl;
    }

    // Destructor
    ~Session() {
        std::cout << "Session " << sessionId << " for user '" << username << "' destroyed";
        if (expired) {
            std::cout << " (was expired)";
        }
        std::cout << "." << std::endl;
    }

    // Getters
    int getId() const { return sessionId; }
    const std::string& getUsername() const { return username; }
    bool isExpired() const { return expired; }

    // Method to mark a session as expired
    void expire() {
        if (!expired) {
            expired = true;
            std::cout << "Session " << sessionId << " for user '" << username << "' marked as expired." << std::endl;
        }
    }

    // Example session-specific functionality
    void doSomething() const {
        std::cout << "Session " << sessionId << " for user '" << username << "' is performing an action." << std::endl;
    }
};

class SessionManager {
private:
    std::vector<std::unique_ptr<Session>> sessions;
    std::atomic<int> nextSessionId; // Generates unique IDs for new sessions

public:
    // Constructor
    SessionManager() : nextSessionId(1) { // Start session IDs from 1
        std::cout << "SessionManager initialized." << std::endl;
    }

    // The destructor for SessionManager is implicitly handled by std::unique_ptr in std::vector.
    // When the vector goes out of scope, all unique_ptrs are destroyed,
    // which in turn calls the destructor of the Session objects they own.

    // Adds a new session to the manager.
    // Takes the username, creates a Session object, and returns a raw pointer to it.
    // The SessionManager retains ownership of the Session object.
    Session* addSession(const std::string& username) {
        int id = nextSessionId++;
        auto newSession = std::make_unique<Session>(id, username);
        Session* rawPtr = newSession.get(); // Get raw pointer before moving ownership
        sessions.push_back(std::move(newSession));
        return rawPtr;
    }

    // Removes a session by its ID.
    // If found, the session object is deleted and removed from the manager.
    // Returns true if a session was found and removed, false otherwise.
    bool removeSession(int sessionId) {
        // Use std::remove_if with std::vector::erase to remove the unique_ptr from the vector.
        // The unique_ptr's destructor will free the Session object.
        auto it = std::remove_if(sessions.begin(), sessions.end(),
                                 [sessionId](const std::unique_ptr<Session>& sessionPtr) {
                                     return sessionPtr->getId() == sessionId;
                                 });

        if (it != sessions.end()) {
            sessions.erase(it, sessions.end()); // Erase elements from 'it' to the end (which are the ones to remove)
            std::cout << "Session " << sessionId << " removed explicitly." << std::endl;
            return true;
        }
        std::cout << "Session " << sessionId << " not found for explicit removal." << std::endl;
        return false;
    }

    // Accesses a session by its ID.
    // Returns a raw pointer to the Session object if found, or nullptr otherwise.
    Session* getSession(int sessionId) {
        auto it = std::find_if(sessions.begin(), sessions.end(),
                               [sessionId](const std::unique_ptr<Session>& sessionPtr) {
                                   return sessionPtr->getId() == sessionId;
                               });
        if (it != sessions.end()) {
            return it->get(); // Return raw pointer to the Session object
        }
        return nullptr;
    }

    // Const version of getSession for read-only access
    const Session* getSession(int sessionId) const {
        auto it = std::find_if(sessions.begin(), sessions.end(),
                               [sessionId](const std::unique_ptr<Session>& sessionPtr) {
                                   return sessionPtr->getId() == sessionId;
                               });
        if (it != sessions.end()) {
            return it->get();
        }
        return nullptr;
    }

    // Cleans up all sessions that have been marked as expired.
    // These sessions are deleted and removed from the manager.
    void cleanupExpiredSessions() {
        size_t sessionsBeforeCleanup = sessions.size();
        std::cout << "\n--- Running cleanup for expired sessions ---" << std::endl;

        // Use std::remove_if and std::vector::erase to remove expired sessions.
        // std::unique_ptr ensures the Session objects are properly deleted.
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
                                      [](const std::unique_ptr<Session>& sessionPtr) {
                                          return sessionPtr->isExpired();
                                      }),
                       sessions.end());

        size_t sessionsAfterCleanup = sessions.size();
        if (sessionsBeforeCleanup > sessionsAfterCleanup) {
            std::cout << "Cleaned up " << (sessionsBeforeCleanup - sessionsAfterCleanup) << " expired sessions." << std::endl;
        } else {
            std::cout << "No expired sessions found to clean up." << std::endl;
        }
        std::cout << "------------------------------------------\n" << std::endl;
    }

    // Returns the current number of active (non-cleaned up) sessions.
    size_t getActiveSessionCount() const {
        return sessions.size();
    }

    // Lists details of all currently managed sessions.
    void listAllSessions() const {
        std::cout << "\n--- Current Active Sessions (" << getActiveSessionCount() << ") ---" << std::endl;
        if (sessions.empty()) {
            std::cout << "No active sessions are being managed." << std::endl;
        } else {
            for (const auto& sessionPtr : sessions) {
                std::cout << "  ID: " << sessionPtr->getId()
                          << ", User: " << sessionPtr->getUsername()
                          << ", Status: " << (sessionPtr->isExpired() ? "Expired" : "Active") << std::endl;
            }
        }
        std::cout << "------------------------------------------\n" << std::endl;
    }
};

int main() {
    SessionManager manager;

    // Add some sessions
    Session* s1 = manager.addSession("alice");
    Session* s2 = manager.addSession("bob");
    Session* s3 = manager.addSession("charlie");

    manager.listAllSessions();

    // Access a session and perform an action
    if (Session* session = manager.getSession(s2->getId())) {
        std::cout << "Successfully accessed session for user: " << session->getUsername() << std::endl;
        session->doSomething();
    } else {
        std::cout << "Session " << s2->getId() << " not found." << std::endl;
    }

    // Mark a session as expired
    if (Session* session = manager.getSession(s1->getId())) {
        session->expire();
    }

    manager.listAllSessions(); // s1 will show as expired but still present

    // Run cleanup to remove expired sessions
    manager.cleanupExpiredSessions();

    manager.listAllSessions(); // s1 should now be gone

    // Verify s1 is indeed removed
    if (manager.getSession(s1->getId()) == nullptr) {
        std::cout << "Verification: Session " << s1->getId() << " (alice) is correctly removed after cleanup." << std::endl;
    } else {
        std::cout << "Verification: Session " << s1->getId() << " (alice) was NOT removed." << std::endl;
    }

    // Explicitly remove another session
    manager.removeSession(s3->getId());

    manager.listAllSessions(); // s3 should now be gone

    // Add a new session and expire another
    Session* s4 = manager.addSession("diana");
    if (Session* session = manager.getSession(s2->getId())) {
        session->expire();
    }

    manager.listAllSessions();
    manager.cleanupExpiredSessions();
    manager.listAllSessions(); // s2 should now be gone, s4 remains

    std::cout << "\nEnd of main function. SessionManager destructor will now run, cleaning up any remaining sessions." << std::endl;

    return 0;
}