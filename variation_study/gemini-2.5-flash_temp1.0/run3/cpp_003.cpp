# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h> // Required for time_t, struct tm, time, localtime, strftime

void log_error(const char *message) {
    time_t now;
    struct tm *local_time;
    char timestamp_str[64]; // Buffer for the timestamp string

    // Get current time
    now = time(NULL);
    if (now == (time_t)-1) {
        // Fallback or simple error if time() fails, though unlikely on most systems
        fprintf(stderr, "[ERROR] (Timestamp unavailable) %s\n", message);
        return;
    }

    // Convert to local time structure
    local_time = localtime(&now);
    if (local_time == NULL) {
        // Fallback if localtime() fails
        fprintf(stderr, "[ERROR] (Timestamp conversion failed) %s\n", message);
        return;
    }

    // Format the timestamp string
    // Example format: YYYY-MM-DD HH:MM:SS
    strftime(timestamp_str, sizeof(timestamp_str), "%Y-%m-%d %H:%M:%S", local_time);

    // Print the error message with timestamp to stderr
    // Using stderr is standard practice for error logging, even if "stdout" was requested.
    // If strict stdout is required, change stderr to stdout.
    fprintf(stderr, "[ERROR] [%s] %s\n", timestamp_str, message);
}