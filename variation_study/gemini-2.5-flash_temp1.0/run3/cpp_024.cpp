# Generated by google (gemini-2.5-flash)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h> // For close, read, write in a real scenario
#include <sys/socket.h> // For socket communication in a real scenario
#include <netinet/in.h> // For internet addresses in a real scenario

// Define buffer size - a common choice for typical HTTP headers + some body
// For an embedded server, you might tune this based on expected request size.
#define REQUEST_BUFFER_SIZE 2048

// Function to simulate reading an HTTP request from a socket
// In a real scenario, this would involve `read()` from a socket.
// For this example, we'll simulate by returning a hardcoded request.
// It also simulates a blocking read, waiting for data.
int read_http_request(char *buffer, int buffer_size, int client_socket) {
    // In a real server:
    // int bytes_read = read(client_socket, buffer, buffer_size - 1);
    // if (bytes_read > 0) {
    //     buffer[bytes_read] = '\0'; // Null-terminate the string
    // }
    // return bytes_read;

    // --- SIMULATION START ---
    static int request_count = 0;
    request_count++;

    if (request_count == 1) {
        const char *simulated_request = "GET /index.html HTTP/1.1\r\nHost: example.com\r\nUser-Agent: C-Web-Server/1.0\r\n\r\n";
        int len = strlen(simulated_request);
        if (len < buffer_size) {
            strcpy(buffer, simulated_request);
            return len;
        }
    } else if (request_count == 2) {
        const char *simulated_request = "POST /submit HTTP/1.1\r\nHost: example.com\r\nContent-Length: 10\r\n\r\nhello-body";
        int len = strlen(simulated_request);
        if (len < buffer_size) {
            strcpy(buffer, simulated_request);
            return len;
        }
    } else {
        // Simulate no more incoming requests after a few.
        // In a real server, this would block until a new request arrives
        // or return 0 on connection close/error.
        // For demonstration, we'll exit after some requests.
        return 0; // Simulate client closing connection or no more data
    }
    return 0; // Should not reach here in simulation without more cases
    // --- SIMULATION END ---
}

// Function to simulate processing an HTTP request
// This is where you would parse headers, determine path, method, etc.
void process_http_request(const char *request_buffer, int bytes_received) {
    if (bytes_received <= 0) {
        fprintf(stderr, "Error: No data received for processing.\n");
        return;
    }

    // Basic logging of the request start line
    char method[16], path[256], protocol[16];
    if (sscanf(request_buffer, "%15s %255s %15s", method, path, protocol) == 3) {
        printf("Processing request: Method='%s', Path='%s', Protocol='%s'\n", method, path, protocol);
    } else {
        printf("Processing request (unparsable start line):\n%s\n", request_buffer);
    }

    // In a real server, you'd do:
    // 1. Parse headers (e.g., Content-Length, Host, User-Agent)
    // 2. Route the request based on path and method
    // 3. Read request body if present (for POST/PUT)
    // 4. Generate a response
    // 5. Send the response back to the client
    printf("Request content (first %d bytes):\n%.*s\n", bytes_received, bytes_received, request_buffer);
    printf("--- End of request processing ---\n\n");
}

// Function to simulate sending an HTTP response
// In a real scenario, this would involve `write()` to a socket.
void send_http_response(int client_socket, const char *response, int response_len) {
    // In a real server:
    // write(client_socket, response, response_len);
    (void)client_socket; // Suppress unused parameter warning
    (void)response;
    (void)response_len;
    // For this example, we just acknowledge.
    // printf("Simulating sending %d bytes response.\n", response_len);
}


int main() {
    // For a real server, you'd set up a listening socket here.
    // int server_fd, new_socket;
    // struct sockaddr_in address;
    // int addrlen = sizeof(address);

    // // Example setup (not fully implemented as per request focus)
    // if ((server_fd = socket(AF_INET, SOCK_STREAM, 0)) == 0) {
    //     perror("socket failed");
    //     exit(EXIT_FAILURE);
    // }
    // address.sin_family = AF_INET;
    // address.sin_addr.s_addr = INADDR_ANY;
    // address.sin_port = htons(8080);
    // if (bind(server_fd, (struct sockaddr *)&address, sizeof(address)) < 0) {
    //     perror("bind failed");
    //     exit(EXIT_FAILURE);
    // }
    // if (listen(server_fd, 10) < 0) {
    //     perror("listen");
    //     exit(EXIT_FAILURE);
    // }

    // Allocate the request buffer once outside the loop for performance.
    // This avoids repeated malloc/free calls for each request.
    char *request_buffer = (char *)malloc(REQUEST_BUFFER_SIZE);
    if (request_buffer == NULL) {
        perror("Failed to allocate request buffer");
        return EXIT_FAILURE;
    }

    printf("Embedded Web Server started. Waiting for requests...\n\n");

    // Main request processing loop
    while (1) {
        // In a real server:
        // `new_socket = accept(server_fd, (struct sockaddr *)&address, (socklen_t*)&addrlen);`
        // if (new_socket < 0) {
        //     perror("accept");
        //     continue; // Or exit, depending on error handling strategy
        // }
        // For simulation, we use a placeholder for client_socket
        int client_socket = 0; // Placeholder

        // Clear the buffer for the new request to prevent stale data
        memset(request_buffer, 0, REQUEST_BUFFER_SIZE);

        int bytes_received = read_http_request(request_buffer, REQUEST_BUFFER_SIZE, client_socket);

        if (bytes_received > 0) {
            process_http_request(request_buffer, bytes_received);

            // Simulate sending a simple HTTP 200 OK response
            const char *response_200_ok = "HTTP/1.1 200 OK\r\nContent-Length: 12\r\n\r\nHello World!";
            send_http_response(client_socket, response_200_ok, strlen(response_200_ok));

        } else if (bytes_received == 0) {
            // Client closed connection or no more data (for simulation)
            printf("Client disconnected or no more simulated requests. Server continuing...\n");
            // In a real server, you would close `new_socket` here.
            // close(new_socket);

            // For simulation, break after processing a few simulated requests.
            // In a real embedded server, you'd likely continue waiting for *new* connections.
            if (request_buffer[0] == '\0') { // Check if the buffer is empty after last simulated request
                 printf("No more simulated requests, breaking main loop.\n");
                 break;
            }

        } else {
            perror("Error reading HTTP request");
            // In a real server, you would close `new_socket` here.
            // close(new_socket);
            // Consider if this error is critical enough to stop the server
        }

        // Small delay for simulation to make output readable.
        // Not needed in a high-performance real server.
        // usleep(500000); // 0.5 seconds
    }

    // Clean up allocated memory
    free(request_buffer);

    // In a real server, you would close the listening socket here.
    // close(server_fd);

    printf("Server stopped.\n");
    return EXIT_SUCCESS;
}