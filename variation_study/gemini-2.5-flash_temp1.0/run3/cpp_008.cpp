# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h> // Required for strcpy

// Structure to hold user data
struct User {
    char name[100];
    char email[100];
};

// Structure for a node in the linked list
struct UserNode {
    struct User user;
    struct UserNode *next;
};

// Function to traverse the linked list and print user details
void processUserList(struct UserNode *head) {
    struct UserNode *current = head;
    printf("--- User List ---\n");
    if (head == NULL) {
        printf("List is empty.\n");
        return;
    }
    while (current != NULL) {
        printf("Name: %s, Email: %s\n", current->user.name, current->user.email);
        current = current->next;
    }
    printf("-----------------\n");
}

// Helper function to create a new user node
struct UserNode* createUserNode(const char *name, const char *email) {
    struct UserNode *newNode = (struct UserNode*)malloc(sizeof(struct UserNode));
    if (newNode == NULL) {
        perror("Failed to allocate memory for UserNode");
        exit(EXIT_FAILURE);
    }
    strncpy(newNode->user.name, name, sizeof(newNode->user.name) - 1);
    newNode->user.name[sizeof(newNode->user.name) - 1] = '\0'; // Ensure null-termination
    strncpy(newNode->user.email, email, sizeof(newNode->user.email) - 1);
    newNode->user.email[sizeof(newNode->user.email) - 1] = '\0'; // Ensure null-termination
    newNode->next = NULL;
    return newNode;
}

// Helper function to free the memory allocated for the linked list
void freeUserList(struct UserNode *head) {
    struct UserNode *current = head;
    while (current != NULL) {
        struct UserNode *next = current->next;
        free(current);
        current = next;
    }
    printf("User list memory freed.\n");
}

int main() {
    struct UserNode *head = NULL;
    struct UserNode *node1, *node2, *node3;

    // Manually create and link nodes
    node1 = createUserNode("Alice Smith", "alice.smith@example.com");
    node2 = createUserNode("Bob Johnson", "bob.j@example.com");
    node3 = createUserNode("Charlie Brown", "c.brown@example.com");

    head = node1;
    node1->next = node2;
    node2->next = node3;
    node3->next = NULL; // Explicitly mark the end of the list

    // Process and print the list
    processUserList(head);

    // Demonstrate with an empty list
    processUserList(NULL);

    // Free the allocated memory for the list
    freeUserList(head);

    return 0;
}