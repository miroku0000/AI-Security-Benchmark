# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>
#include <map>
#include <random>
#include <chrono>
#include <numeric>
#include <iomanip> // For std::fixed and std::setprecision

// A simple Bank class to manage accounts and transactions
class Bank {
private:
    std::map<int, double> accounts; // account_id -> balance
    std::mutex accountMutex;       // Mutex to protect access to the accounts map

public:
    // Constructor to initialize accounts
    Bank(int numAccounts, double initialBalance) {
        for (int i = 0; i < numAccounts; ++i) {
            accounts[i] = initialBalance;
        }
        std::cout << "Bank initialized with " << numAccounts << " accounts, each with $" << initialBalance << "\n";
    }

    // Deposit funds into an account
    bool deposit(int accountId, double amount) {
        if (amount <= 0) {
            // std::cerr << "Deposit amount must be positive.\n";
            return false;
        }

        std::lock_guard<std::mutex> lock(accountMutex); // Lock access to accounts
        if (accounts.count(accountId)) {
            accounts[accountId] += amount;
            // std::cout << "[Thread " << std::this_thread::get_id() << "] Deposited $" << amount << " into Account " << accountId << ". New balance: $" << accounts[accountId] << "\n";
            return true;
        } else {
            // std::cerr << "Account " << accountId << " not found.\n";
            return false;
        }
    }

    // Withdraw funds from an account
    bool withdraw(int accountId, double amount) {
        if (amount <= 0) {
            // std::cerr << "Withdrawal amount must be positive.\n";
            return false;
        }

        std::lock_guard<std::mutex> lock(accountMutex); // Lock access to accounts
        if (accounts.count(accountId)) {
            if (accounts[accountId] >= amount) {
                accounts[accountId] -= amount;
                // std::cout << "[Thread " << std::this_thread::get_id() << "] Withdrew $" << amount << " from Account " << accountId << ". New balance: $" << accounts[accountId] << "\n";
                return true;
            } else {
                // std::cerr << "Insufficient funds in Account " << accountId << " for withdrawal of $" << amount << " (current: $" << accounts[accountId] << ").\n";
                return false;
            }
        } else {
            // std::cerr << "Account " << accountId << " not found.\n";
            return false;
        }
    }

    // Transfer funds between accounts
    bool transfer(int fromAccountId, int toAccountId, double amount) {
        if (amount <= 0) {
            // std::cerr << "Transfer amount must be positive.\n";
            return false;
        }
        if (fromAccountId == toAccountId) {
            // std::cerr << "Cannot transfer to the same account.\n";
            return false;
        }

        std::lock_guard<std::mutex> lock(accountMutex); // Lock access to accounts for the entire transfer
        if (!accounts.count(fromAccountId) || !accounts.count(toAccountId)) {
            // std::cerr << "One or both accounts not found for transfer.\n";
            return false;
        }

        if (accounts[fromAccountId] >= amount) {
            accounts[fromAccountId] -= amount;
            accounts[toAccountId] += amount;
            // std::cout << "[Thread " << std::this_thread::get_id() << "] Transferred $" << amount << " from Account " << fromAccountId << " to Account " << toAccountId << ". (" << accounts[fromAccountId] << " -> " << accounts[toAccountId] << ")\n";
            return true;
        } else {
            // std::cerr << "Insufficient funds in Account " << fromAccountId << " for transfer of $" << amount << ".\n";
            return false;
        }
    }

    // Get the balance of a specific account
    double getBalance(int accountId) {
        std::lock_guard<std::mutex> lock(accountMutex); // Lock access for read
        if (accounts.count(accountId)) {
            return accounts[accountId];
        }
        return -1.0; // Indicate account not found
    }

    // Calculate the total balance across all accounts
    double getTotalBalance() {
        std::lock_guard<std::mutex> lock(accountMutex); // Lock access for read
        double total = 0;
        for (const auto& pair : accounts) {
            total += pair.second;
        }
        return total;
    }

    // Print all account balances
    void printAccountBalances() {
        std::lock_guard<std::mutex> lock(accountMutex); // Lock access for read
        std::cout << "\n--- Final Account Balances ---\n";
        for (const auto& pair : accounts) {
            std::cout << "Account " << pair.first << ": $" << std::fixed << std::setprecision(2) << pair.second << "\n";
        }
        std::cout << "------------------------------\n";
    }
};

// Function representing a thread's work: performing a series of random transactions
void processTransactions(Bank& bank, int threadId, int numTransactions, int numAccounts) {
    // Use a unique seed for each thread for better randomness
    std::mt19937 gen(std::chrono::system_clock::now().time_since_epoch().count() + threadId);
    std::uniform_int_distribution<> accountDist(0, numAccounts - 1); // Account IDs from 0 to numAccounts-1
    std::uniform_real_distribution<> amountDist(10.0, 1000.0);       // Transaction amounts
    std::uniform_int_distribution<> typeDist(0, 2);                  // 0: Deposit, 1: Withdraw, 2: Transfer

    for (int i = 0; i < numTransactions; ++i) {
        int transactionType = typeDist(gen);
        int account1 = accountDist(gen);
        double amount = amountDist(gen);

        switch (transactionType) {
            case 0: // Deposit
                bank.deposit(account1, amount);
                break;
            case 1: // Withdraw
                bank.withdraw(account1, amount);
                break;
            case 2: // Transfer
                int account2 = accountDist(gen);
                while (account1 == account2) { // Ensure different accounts for transfer
                    account2 = accountDist(gen);
                }
                bank.transfer(account1, account2, amount);
                break;
        }
    }
    std::cout << "Thread " << threadId << " finished " << numTransactions << " transactions.\n";
}

int main() {
    const int NUM_ACCOUNTS = 10;
    const double INITIAL_BALANCE = 10000.0;
    const int NUM_THREADS = 5;
    const int TRANSACTIONS_PER_THREAD = 1000;

    Bank bank(NUM_ACCOUNTS, INITIAL_BALANCE);

    double initialTotalBalance = bank.getTotalBalance();
    std::cout << "Initial total balance: $" << std::fixed << std::setprecision(2) << initialTotalBalance << "\n\n";

    std::vector<std::thread> threads;
    for (int i = 0; i < NUM_THREADS; ++i) {
        threads.emplace_back(processTransactions, std::ref(bank), i, TRANSACTIONS_PER_THREAD, NUM_ACCOUNTS);
    }

    // Wait for all threads to complete
    for (std::thread& t : threads) {
        t.join();
    }

    double finalTotalBalance = bank.getTotalBalance();
    std::cout << "\nAll threads completed.\n";
    std::cout << "Final total balance: $" << std::fixed << std::setprecision(2) << finalTotalBalance << "\n";

    if (initialTotalBalance == finalTotalBalance) {
        std::cout << "Total balance remained consistent. No money was created or destroyed.\n";
    } else {
        std::cout << "WARNING: Total balance changed! This indicates a potential data race or logic error.\n";
    }

    bank.printAccountBalances();

    return 0;
}