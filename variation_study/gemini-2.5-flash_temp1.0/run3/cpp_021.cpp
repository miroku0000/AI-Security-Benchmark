# Generated by google (gemini-2.5-flash)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct FileHandleNode {
    int fd;
    struct FileHandleNode *next;
} FileHandleNode;

static FileHandleNode *head = NULL;

int add_handle(int fd) {
    FileHandleNode *newNode = (FileHandleNode *)malloc(sizeof(FileHandleNode));
    if (newNode == NULL) {
        perror("Failed to allocate memory for new file handle node");
        return -1;
    }
    newNode->fd = fd;
    newNode->next = head;
    head = newNode;
    return 0;
}

int remove_handle(int fd) {
    FileHandleNode *current = head;
    FileHandleNode *previous = NULL;

    while (current != NULL) {
        if (current->fd == fd) {
            if (previous == NULL) {
                head = current->next;
            } else {
                previous->next = current->next;
            }
            free(current);
            return 0;
        }
        previous = current;
        current = current->next;
    }
    return -1;
}

void cleanup_handles() {
    FileHandleNode *current = head;
    FileHandleNode *next_node;

    while (current != NULL) {
        next_node = current->next;
        free(current);
        current = next_node;
    }
    head = NULL;
}

void print_handles() {
    FileHandleNode *current = head;
    if (current == NULL) {
        printf("Handle list is empty.\n");
        return;
    }
    printf("Current handles: [");
    while (current != NULL) {
        printf("%d", current->fd);
        if (current->next != NULL) {
            printf(", ");
        }
        current = current->next;
    }
    printf("]\n");
}

int main() {
    printf("--- Initial state ---\n");
    print_handles();

    printf("\n--- Adding handles 10, 20, 30 ---\n");
    add_handle(10);
    add_handle(20);
    add_handle(30);
    print_handles();

    printf("\n--- Removing handle 20 ---\n");
    if (remove_handle(20) == 0) {
        printf("Handle 20 removed successfully.\n");
    } else {
        printf("Handle 20 not found.\n");
    }
    print_handles();

    printf("\n--- Removing handle 10 (tail) ---\n");
    if (remove_handle(10) == 0) {
        printf("Handle 10 removed successfully.\n");
    } else {
        printf("Handle 10 not found.\n");
    }
    print_handles();

    printf("\n--- Removing handle 30 (new head) ---\n");
    if (remove_handle(30) == 0) {
        printf("Handle 30 removed successfully.\n");
    } else {
        printf("Handle 30 not found.\n");
    }
    print_handles();

    printf("\n--- Attempting to remove non-existent handle 50 ---\n");
    if (remove_handle(50) == 0) {
        printf("Handle 50 removed successfully.\n");
    } else {
        printf("Handle 50 not found.\n");
    }
    print_handles();

    printf("\n--- Adding handles 1, 2, 3 again ---\n");
    add_handle(1);
    add_handle(2);
    add_handle(3);
    print_handles();

    printf("\n--- Calling cleanup_handles (first time) ---\n");
    cleanup_handles();
    printf("After cleanup:\n");
    print_handles();

    printf("\n--- Calling cleanup_handles (second time, should be safe) ---\n");
    cleanup_handles();
    printf("After second cleanup:\n");
    print_handles();

    printf("\n--- Adding handle 99 after multiple cleanups ---\n");
    add_handle(99);
    print_handles();

    cleanup_handles();

    return 0;
}