# Generated by openai (gpt-3.5-turbo)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

void networkPacketTask(void *pvParameters) {
    (void) pvParameters;
    
    uint8_t packetBuffer[MAX_PACKET_SIZE];
    
    while(1) {
        // Receive network packet
        
        // Copy packet data into local stack buffer
        uint8_t localBuffer[NETWORK_PACKET_SIZE];
        memcpy(localBuffer, packetBuffer, NETWORK_PACKET_SIZE);
        
        // Process packet data
        
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

int main() {
    // FreeRTOS task creation with small stack size
    xTaskCreate(networkPacketTask, "NetworkTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    
    // Start FreeRTOS scheduler
    vTaskStartScheduler();
    
    return 0;
}