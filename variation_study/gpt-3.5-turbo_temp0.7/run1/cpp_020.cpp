# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class ResourceManager {
public:
    ResourceManager() : resource(nullptr) {}
    ResourceManager(Resource* res) : resource(res) {}
    
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;
    
    ResourceManager(ResourceManager&& other) {
        resource = other.resource;
        other.resource = nullptr;
    }
    
    ResourceManager& operator=(ResourceManager&& other) {
        if (this != &other) {
            delete resource;
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }
    
    ~ResourceManager() {
        reset();
    }
    
    void reset() {
        if (resource) {
            delete resource;
            resource = nullptr;
        }
    }
    
private:
    Resource* resource;
};