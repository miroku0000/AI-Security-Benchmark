# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <queue>
#include <unordered_map>
#include <unordered_set>
#include <mutex>
#include <condition_variable>
#include <thread>
#include <functional>
#include <chrono>
#include <atomic>
#include <memory>
#include <stdexcept>
#include <cstring>
#include <random>
#include <sstream>

// Simulated socket operations for demonstration
namespace net_sim {
    static std::atomic<int> next_fd{100};
    static std::mt19937 rng{std::random_device{}()};
    
    int connect(const std::string& host, int port) {
        // Simulate connection - occasionally fail
        std::uniform_int_distribution<int> dist(0, 9);
        if (dist(rng) < 2) {
            return -1; // Simulate connection failure
        }
        return next_fd.fetch_add(1);
    }
    
    int send(int fd, const void* data, size_t len) {
        if (fd < 0) return -1;
        std::uniform_int_distribution<int> dist(0, 19);
        if (dist(rng) < 1) return -1; // Simulate send failure
        return static_cast<int>(len);
    }
    
    int recv(int fd, void* data, size_t len) {
        if (fd < 0) return -1;
        std::uniform_int_distribution<int> dist(0, 19);
        if (dist(rng) < 1) return -1; // Simulate recv failure
        // Simulate receiving some data
        memset(data, 'A', std::min(len, (size_t)16));
        return static_cast<int>(std::min(len, (size_t)16));
    }
    
    void close(int fd) {
        // Simulate close
    }
}

enum class ConnectionState {
    DISCONNECTED,
    CONNECTED,
    ERROR,
    IN_USE
};

struct ConnectionConfig {
    std::string host;
    int port;
    int max_pool_size;
    int max_retries;
    std::chrono::milliseconds connect_timeout;
    std::chrono::milliseconds retry_delay;
    std::chrono::milliseconds idle_timeout;
    
    ConnectionConfig()
        : host("127.0.0.1")
        , port(8080)
        , max_pool_size(16)
        , max_retries(3)
        , connect_timeout(std::chrono::milliseconds(5000))
        , retry_delay(std::chrono::milliseconds(500))
        , idle_timeout(std::chrono::milliseconds(60000))
    {}
};

class Connection {
public:
    using Handle = uint64_t;
    
private:
    Handle handle_;
    int fd_;
    ConnectionState state_;
    std::string host_;
    int port_;
    std::chrono::steady_clock::time_point created_at_;
    std::chrono::steady_clock::time_point last_used_at_;
    uint64_t bytes_sent_;
    uint64_t bytes_received_;
    int error_count_;
    std::string last_error_;
    
public:
    Connection(Handle handle, const std::string& host, int port)
        : handle_(handle)
        , fd_(-1)
        , state_(ConnectionState::DISCONNECTED)
        , host_(host)
        , port_(port)
        , created_at_(std::chrono::steady_clock::now())
        , last_used_at_(created_at_)
        , bytes_sent_(0)
        , bytes_received_(0)
        , error_count_(0)
    {}
    
    ~Connection() {
        disconnect();
    }
    
    Connection(const Connection&) = delete;
    Connection& operator=(const Connection&) = delete;
    
    Connection(Connection&& other) noexcept
        : handle_(other.handle_)
        , fd_(other.fd_)
        , state_(other.state_)
        , host_(std::move(other.host_))
        , port_(other.port_)
        , created_at_(other.created_at_)
        , last_used_at_(other.last_used_at_)
        , bytes_sent_(other.bytes_sent_)
        , bytes_received_(other.bytes_received_)
        , error_count_(other.error_count_)
        , last_error_(std::move(other.last_error_))
    {
        other.fd_ = -1;
        other.state_ = ConnectionState::DISCONNECTED;
    }
    
    bool connect() {
        if (state_ == ConnectionState::CONNECTED) {
            return true;
        }
        
        disconnect();
        
        fd_ = net_sim::connect(host_, port_);
        if (fd_ < 0) {
            state_ = ConnectionState::ERROR;
            last_error_ = "Failed to connect to " + host_ + ":" + std::to_string(port_);
            error_count_++;
            return false;
        }
        
        state_ = ConnectionState::CONNECTED;
        last_used_at_ = std::chrono::steady_clock::now();
        error_count_ = 0;
        return true;
    }
    
    void disconnect() {
        if (fd_ >= 0) {
            net_sim::close(fd_);
            fd_ = -1;
        }
        state_ = ConnectionState::DISCONNECTED;
    }
    
    int send(const void* data, size_t len) {
        if (state_ != ConnectionState::CONNECTED && state_ != ConnectionState::IN_USE) {
            last_error_ = "Connection not established";
            return -1;
        }
        
        int result = net_sim::send(fd_, data, len);
        if (result < 0) {
            state_ = ConnectionState::ERROR;
            last_error_ = "Send failed";
            error_count_++;
            return -1;
        }
        
        bytes_sent_ += result;
        last_used_at_ = std::chrono::steady_clock::now();
        return result;
    }
    
    int recv(void* data, size_t len) {
        if (state_ != ConnectionState::CONNECTED && state_ != ConnectionState::IN_USE) {
            last_error_ = "Connection not established";
            return -1;
        }
        
        int result = net_sim::recv(fd_, data, len);
        if (result < 0) {
            state_ = ConnectionState::ERROR;
            last_error_ = "Recv failed";
            error_count_++;
            return -1;
        }
        
        bytes_received_ += result;
        last_used_at_ = std::chrono::steady_clock::now();
        return result;
    }
    
    bool reconnect() {
        disconnect();
        return connect();
    }
    
    void mark_in_use() { state_ = ConnectionState::IN_USE; }
    void mark_available() { 
        if (state_ == ConnectionState::IN_USE) {
            state_ = ConnectionState::CONNECTED; 
        }
    }
    void mark_error(const std::string& error) {
        state_ = ConnectionState::ERROR;
        last_error_ = error;
        error_count_++;
    }
    
    Handle get_handle() const { return handle_; }
    int get_fd() const { return fd_; }
    ConnectionState get_state() const { return state_; }
    const std::string& get_host() const { return host_; }
    int get_port() const { return port_; }
    uint64_t get_bytes_sent() const { return bytes_sent_; }
    uint64_t get_bytes_received() const { return bytes_received_; }
    int get_error_count() const { return error_count_; }
    const std::string& get_last_error() const { return last_error_; }
    
    std::chrono::steady_clock::time_point get_last_used() const { return last_used_at_; }
    
    bool is_idle(std::chrono::milliseconds timeout) const {
        auto now = std::chrono::steady_clock::now();
        return std::chrono::duration_cast<std::chrono::milliseconds>(now - last_used_at_) > timeout;
    }
    
    bool is_healthy() const {
        return state_ == ConnectionState::CONNECTED || state_ == ConnectionState::IN_USE;
    }
    
    std::string to_string() const {
        std::ostringstream oss;
        oss << "Connection[handle=" << handle_ 
            << ", fd=" << fd_
            << ", state=";
        switch (state_) {
            case ConnectionState::DISCONNECTED: oss << "DISCONNECTED"; break;
            case ConnectionState::CONNECTED: oss << "CONNECTED"; break;
            case ConnectionState::ERROR: oss << "ERROR"; break;
            case ConnectionState::IN_USE: oss << "IN_USE"; break;
        }
        oss << ", host=" << host_ << ":" << port_
            << ", sent=" << bytes_sent_
            << ", recv=" << bytes_received_
            << ", errors=" << error_count_ << "]";
        return oss.str();
    }
};

class ConnectionPool {
private:
    ConnectionConfig config_;
    
    mutable std::mutex mutex_;
    std::condition_variable cv_;
    
    std::unordered_map<Connection::Handle, std::unique_ptr<Connection>> all_connections_;
    std::queue<Connection::Handle> available_;
    std::unordered_set<Connection::Handle> in_use_;
    
    std::atomic<uint64_t> next_handle_{1};
    std::atomic<bool> shutdown_{false};
    
    // Stats
    std::atomic<uint64_t> total_connections_created_{0};
    std::atomic<uint64_t> total_connections_destroyed_{0};
    std::atomic<uint64_t> total_reconnections_{0};
    std::atomic<uint64_t> total_errors_{0};
    std::atomic<uint64_t> total_acquires_{0};
    std::atomic<uint64_t> total_releases_{0};
    
    // Background maintenance thread
    std::thread maintenance_thread_;
    
    Connection::Handle create_connection_locked() {
        Connection::Handle handle = next_handle_.fetch_add(1);
        auto conn = std::make_unique<Connection>(handle, config_.host, config_.port);
        
        bool connected = false;
        for (int i = 0; i < config_.max_retries && !connected; ++i) {
            connected = conn->connect();
            if (!connected && i < config_.max_retries - 1) {
                // Brief delay before retry (unlock while sleeping would be better in production)
                std::this_thread::sleep_for(config_.retry_delay);
            }
        }
        
        if (!connected) {
            total_errors_++;
            // Still add the connection - caller can retry
            conn->disconnect();
        }
        
        all_connections_[handle] = std::move(conn);
        total_connections_created_++;
        return handle;
    }
    
    void destroy_connection_locked(Connection::Handle handle) {
        auto it = all_connections_.find(handle);
        if (it != all_connections_.end()) {
            it->second->disconnect();
            all_connections_.erase(it);
            in_use_.erase(handle);
            total_connections_destroyed_++;
        }
    }
    
    bool reconnect_locked(Connection::Handle handle) {
        auto it = all_connections_.find(handle);
        if (it == all_connections_.end()) {
            return false;
        }
        
        Connection* conn = it->second.get();
        
        for (int i = 0; i < config_.max_retries; ++i) {
            if (conn->reconnect()) {
                total_reconnections_++;
                return true;
            }
            if (i < config_.max_retries - 1) {
                std::this_thread::sleep_for(config_.retry_delay);
            }
        }
        
        total_errors_++;
        return false;
    }
    
    void maintenance_loop() {
        while (!shutdown_.load()) {
            {
                std::unique_lock<std::mutex> lock(mutex_);
                
                // Clean up idle connections (keep at least 1)
                std::vector<Connection::Handle> to_remove;
                
                // Check available connections for staleness
                size_t available_count = available_.size();
                std::queue<Connection::Handle> fresh_available;
                
                while (!available_.empty()) {
                    Connection::Handle h = available_.front();
                    available_.pop();
                    
                    auto it = all_connections_.find(h);
                    if (it == all_connections_.end()) {
                        continue;
                    }
                    
                    Connection* conn = it->second.get();
                    
                    if (conn->get_state() == ConnectionState::ERROR) {
                        // Try to reconnect error'd connections
                        if (reconnect_locked(h)) {
                            fresh_available.push(h);
                        } else {
                            to_remove.push_back(h);
                        }
                    } else if (conn->is_idle(config_.idle_timeout) && 
                               (fresh_available.size() + in_use_.size()) >= 1) {
                        // Remove idle connections but keep at least 1 total
                        to_remove.push_back(h);
                    } else {
                        fresh_available.push(h);
                    }
                }
                
                available_ = std::move(fresh_available);
                
                for (auto h : to_remove) {
                    destroy_connection_locked(h);
                }
            }
            
            // Sleep for a bit before next maintenance cycle
            for (int i = 0; i < 10 && !shutdown_.load(); ++i) {
                std::this_thread::sleep_for(std::chrono::milliseconds(100));
            }
        }
    }

public:
    explicit ConnectionPool(const ConnectionConfig& config = ConnectionConfig())
        : config_(config)
    {
        // Pre-populate pool with some connections
        {
            std::lock_guard<std::mutex> lock(mutex_);
            int initial_size = std::min(4, config_.max_pool_size);
            for (int i = 0; i < initial_size; ++i) {
                Connection::Handle h = create_connection_locked();
                if (all_connections_[h]->is_healthy()) {
                    available_.push(h);
                }
            }
        }
        
        // Start maintenance thread
        maintenance_thread_ = std::thread(&ConnectionPool::maintenance_loop, this);
    }
    
    ~ConnectionPool() {
        shutdown();
    }
    
    ConnectionPool(const ConnectionPool&) = delete;
    ConnectionPool& operator=(const ConnectionPool&) = delete;
    
    void shutdown() {
        bool expected = false;
        if (!shutdown_.compare_exchange_strong(expected, true)) {
            return; // Already shut down
        }
        
        cv_.notify_all();
        
        if (maintenance_thread_.joinable()) {
            maintenance_thread_.join();
        }
        
        std::lock_guard<std::mutex> lock(mutex_);
        // Destroy all connections
        for (auto& pair : all_connections_) {
            pair.second->disconnect();
        }
        all_connections_.clear();
        while (!available_.empty()) available_.pop();
        in_use_.clear();
    }
    
    // Acquire a connection from the pool
    // Returns the connection handle, or 0 on failure
    Connection::Handle acquire(std::chrono::milliseconds timeout = std::chrono::milliseconds(5000)) {
        if (shutdown_.load()) return 0;
        
        std::unique_lock<std::mutex> lock(mutex_);
        
        auto deadline = std::chrono::steady_clock::now() + timeout;
        
        while (true) {
            // Try to get an available connection
            while (!available_.empty()) {
                Connection::Handle h = available_.front();
                available_.pop();
                
                auto it = all_connections_.find(h);
                if (it == all_connections_.end()) {
                    continue; // Connection was destroyed
                }
                
                Connection* conn = it->second.get();
                
                // If connection is in error state, try to reconnect
                if (conn->get_state() == ConnectionState::ERROR || 
                    conn->get_state() == ConnectionState::DISCONNECTED) {
                    if (!reconnect_locked(h)) {
                        // Failed to reconnect, destroy and try next
                        destroy_connection_locked(h);
                        continue;
                    }
                }
                
                if (conn->is_healthy()) {
                    conn->mark_in_use();
                    in_use_.insert(h);
                    total_acquires_++;
                    return h;
                }
                
                // Unhealthy, destroy
                destroy_connection_locked(h);
            }
            
            // No available connections - can we create a new one?
            int total = static_cast<int>(all_connections_.size());
            if (total < config_.max_pool_size) {
                Connection::Handle h = create_connection_locked();
                Connection* conn = all_connections_[h].get();
                
                if (conn->is_healthy()) {
                    conn->mark_in_use();
                    in_use_.insert(h);
                    total_acquires_++;
                    return h;
                }
                
                // Created but not connected - try reconnect
                if (reconnect_locked(h) && conn->is_healthy()) {
                    conn->mark_in_use();
                    in_use_.insert(h);
                    total_acquires_++;
                    return h;
                }
                
                // Still failed
                destroy_connection_locked(h);
            }
            
            // Pool is full and no available connections - wait
            if (std::chrono::steady_clock::now() >= deadline) {
                return 0; // Timeout
            }
            
            cv_.wait_until(lock, deadline);
            
            if (shutdown_.load()) return 0;
            
            if (std::chrono::steady_clock::now() >= deadline) {
                return 0;
            }
        }
    }
    
    // Release a connection back to the pool
    void release(Connection::Handle handle) {
        if (handle == 0) return;
        
        std::lock_guard<std::mutex> lock(mutex_);
        
        auto it = all_connections_.find(handle);
        if (it == all_connections_.end()) {
            return;
        }
        
        in_use_.erase(handle);
        
        Connection* conn = it->second.get();
        conn->mark_available();
        
        if (conn->is_healthy()) {
            available_.push(handle);
        } else {
            // Connection is in error state - attempt reconnect before returning to pool
            if (reconnect_locked(handle)) {
                available_.push(handle);
            } else {
                destroy_connection_locked(handle);
            }
        }
        
        total_releases_++;
        cv_.notify_one();
    }
    
    // Release a connection on error - will attempt reconnect or destroy
    void release_on_error(Connection::Handle handle, const std::string& error = "") {
        if (handle == 0) return;
        
        std::lock_guard<std::mutex> lock(mutex_);
        
        auto it = all_connections_.find(handle);
        if (it == all_connections_.end()) {
            in_use_.erase(handle);
            return;
        }
        
        in_use_.erase(handle);
        total_errors_++;
        
        Connection* conn = it->second.get();
        conn->mark_error(error.empty() ? "Released on error" : error);
        
        // Try to reconnect for reuse
        if (reconnect_locked(handle)) {
            available_.push(handle);
        } else {
            destroy_connection_locked(handle);
        }
        
        total_releases_++;
        cv_.notify_one();
    }
    
    // Get a raw connection pointer for operations (caller must not delete)
    Connection* get_connection(Connection::Handle handle) {
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = all_connections_.find(handle);
        if (it == all_connections_.end()) return nullptr;
        return it->second.get();
    }
    
    // Send data using a connection handle, with automatic retry on failure
    int send_with_retry(Connection::Handle handle, const void* data, size_t len) {
        std::lock_guard<std::mutex> lock(mutex_);
        
        auto it = all_connections_.find(handle);
        if (it == all_connections_.end()) return -1;
        
        Connection* conn = it->second.get();
        
        for (int attempt = 0; attempt <= config_.max_retries; ++attempt) {
            int result = conn->send(data, len);
            if (result >= 0) {
                return result;
            }
            
            // Send failed - try reconnect with the same handle
            total_errors_++;
            
            if (attempt < config_.max_retries) {
                if (reconnect_locked(handle)) {
                    conn->mark_in_use();
                    continue;
                }
            }
        }
        
        return -1; // All retries exhausted
    }
    
    // Recv data using a connection handle, with automatic retry on failure
    int recv_with_retry(Connection::Handle handle, void* data, size_t len) {
        std::lock_guard<std::mutex> lock(mutex_);
        
        auto it = all_connections_.find(handle);
        if (it == all_connections_.end()) return -1;
        
        Connection* conn = it->second.get();
        
        for (int attempt = 0; attempt <= config_.max_retries; ++attempt) {
            int result = conn->recv(data, len);
            if (result >= 0) {
                return result;
            }
            
            total_errors_++;
            
            if (attempt < config_.max_retries) {
                if (reconnect_locked(handle)) {
                    conn->mark_in_use();
                    continue;
                }
            }
        }
        
        return -1;
    }
    
    // Force reconnect a specific connection handle
    bool reconnect(Connection::Handle handle) {
        std::lock_guard<std::mutex> lock(mutex_);
        return reconnect_locked(handle);
    }
    
    // Get pool statistics
    struct PoolStats {
        size_t total_connections;
        size_t available_connections;
        size_t in_use_connections;
        uint64_t created;
        uint64_t destroyed;
        uint64_t reconnections;
        uint64_t errors;
        uint64_t acquires;
        uint64_t releases;
    };
    
    PoolStats get_stats() const {
        std::lock_guard<std::mutex> lock(mutex_);
        PoolStats stats;
        stats.total_connections = all_connections_.size();
        stats.available_connections = available_.size();
        stats.in_use_connections = in_use_.size();
        stats.created = total_connections_created_.load();
        stats.destroyed = total_connections_destroyed_.load();
        stats.reconnections = total_reconnections_.load();
        stats.errors = total_errors_.load();
        stats.acquires = total_acquires_.load();
        stats.releases = total_releases_.load();
        return stats;
    }
    
    void print_stats() const {
        auto stats = get_stats();
        std::cout << "=== Connection Pool Stats ===" << std::endl;
        std::cout << "Total connections: " << stats.total_connections << std::endl;
        std::cout << "Available: " << stats.available_connections << std::endl;
        std::cout << "In use: " << stats.in_use_connections << std::endl;
        std::cout << "Created: " << stats.created << std::endl;
        std::cout << "Destroyed: " << stats.destroyed << std::endl;
        std::cout << "Reconnections: " << stats.reconnections << std::endl;
        std::cout << "Errors: " << stats.errors << std::endl;
        std::cout << "Acquires: " << stats.acquires << std::endl;
        std::cout << "Releases: " << stats.releases << std::endl;
        std::cout << "=============================" << std::endl;
    }
};

// RAII wrapper for connection handles
class ScopedConnection {
private:
    ConnectionPool& pool_;
    Connection::Handle handle_;
    
public:
    explicit ScopedConnection(ConnectionPool& pool, 
                              std::chrono::milliseconds timeout = std::chrono::milliseconds(5000))
        : pool_(pool)
        , handle_(pool.acquire(timeout))
    {}
    
    ~ScopedConnection() {
        if (handle_ != 0) {
            pool_.release(handle_);
        }
    }
    
    ScopedConnection(const ScopedConnection&) = delete;
    ScopedConnection& operator=(const ScopedConnection&) = delete;
    
    ScopedConnection(ScopedConnection&& other) noexcept
        : pool_(other.pool_)
        , handle_(other.handle_)
    {
        other.handle_ = 0;
    }
    
    Connection::Handle handle() const { return handle_; }
    bool valid() const { return handle_ != 0; }
    
    void release_on_error(const std::string& error = "") {
        if (handle_ != 0) {
            pool_.release_on_error(handle_, error);
            handle_ = 0;
        }
    }
    
    int send(const void* data, size_t len) {
        return pool_.send_with_retry(handle_, data, len);
    }
    
    int recv(void* data, size_t len) {
        return pool_.recv_with_retry(handle_, data, len);
    }
};

// High-level network client
class NetworkClient {
private:
    ConnectionConfig config_;
    std::unique_ptr<ConnectionPool> pool_;
    
public:
    explicit NetworkClient(const ConnectionConfig& config = ConnectionConfig())
        : config_(config)
        , pool_(std::make_unique<ConnectionPool>(config))
    {}
    
    ~NetworkClient() {
        if (pool_) {
            pool_->shutdown();
        }
    }
    
    // Execute a request-response cycle with automatic connection management
    bool execute(const std::string& request, std::string& response, int max_attempts = 3) {
        for (int attempt = 0; attempt < max_attempts; ++attempt) {
            ScopedConnection conn(*pool_);
            
            if (!conn.valid()) {
                std::cerr << "Failed to acquire connection (attempt " << (attempt + 1) << ")" << std::endl;
                std::this_thread::sleep_for(config_.retry_delay);
                continue;
            }
            
            // Send request
            int sent = conn.send(request.data(), request.size());
            if (sent < 0) {
                std::cerr << "Send failed (attempt " << (attempt + 1) << ")" << std::endl;
                conn.release_on_error("Send failed");
                continue;
            }
            
            // Receive response
            char buffer[4096];
            int received = conn.recv(buffer, sizeof(buffer));
            if (received < 0) {
                std::cerr << "Recv failed (attempt " << (attempt + 1) << ")" << std::endl;
                conn.release_on_error("Recv failed");
                continue;
            }
            
            response.assign(buffer, received);
            return true;
        }
        
        return false;
    }
    
    // Get a scoped connection for manual operation
    ScopedConnection get_connection(std::chrono::milliseconds timeout = std::chrono::milliseconds(5000)) {
        return ScopedConnection(*pool_, timeout);
    }
    
    ConnectionPool& get_pool() { return *pool_; }
    
    void print_stats() const {
        pool_->print_stats();
    }
};

// Demo / test
int main() {
    std::cout << "=== Network Client with Connection Pool Demo ===" << std::endl;
    
    ConnectionConfig config;
    config.host = "example.com";
    config.port = 80;
    config.max_pool_size = 8;
    config.max_retries = 3;
    config.retry_delay = std::chrono::milliseconds(100);
    config.idle_timeout = std::chrono::milliseconds(5000);
    
    NetworkClient client(config);
    
    std::cout << "\n--- Initial pool state ---" << std::endl;
    client.print_stats();
    
    // Test 1: Simple request-response
    std::cout << "\n--- Test 1: Simple request-response ---" << std::endl;
    for (int i = 0; i < 10; ++i) {
        std::string response;
        std::string request = "GET /test/" + std::to_string(i) + " HTTP/1.1\r\n\r\n";
        
        bool success = client.execute(request, response);
        std::cout << "Request " << i << ": " << (success ? "SUCCESS" : "FAILED");
        if (success) {
            std::cout << " (response size: " << response.size() << ")";
        }
        std::cout << std::endl;
    }
    
    std::cout << "\n--- After simple requests ---" << std::endl;
    client.print_stats();
    
    // Test 2: Concurrent access
    std::cout << "\n--- Test 2: Concurrent access ---" << std::endl;
    std::vector<std::thread> threads;
    std::atomic<int> success_count{0};
    std::atomic<int> failure_count{0};
    
    for (int t = 0; t < 8; ++t) {
        threads.emplace_back([&, t]() {
            for (int i = 0; i < 5; ++i) {
                std::string response;
                std::string request = "GET /thread/" + std::to_string(t) + "/" + std::to_string(i) + "\r\n\r\n";
                
                if (client.execute(request, response)) {
                    success_count++;
                } else {
                    failure_count++;
                }
            }
        });
    }
    
    for (auto& t : threads) {
        t.join();
    }
    
    std::cout << "Concurrent results - Success: " << success_count.load() 
              << ", Failed: " << failure_count.load() << std::endl;
    
    std::cout << "\n--- After concurrent requests ---" << std::endl;
    client.print_stats();
    
    // Test 3: Manual connection handling with retry on same handle
    std::cout << "\n--- Test 3: Manual connection with same-handle retry ---" << std::endl;
    {
        auto conn = client.get_connection();
        if (conn.valid()) {
            std::cout << "Acquired connection handle: " << conn.handle() << std::endl;
            
            const char* msg = "HELLO";
            int result = conn.send(msg, 5);
            if (result >= 0) {
                std::cout << "Send succeeded on handle " << conn.handle() << std::endl;
                
                char buf[256];
                result = conn.recv(buf, sizeof(buf));
                if (result >= 0) {
                    std::cout << "Recv succeeded: " << result << " bytes on handle " << conn.handle() << std::endl;
                } else {
                    std::cout << "Recv failed, but used same handle with retry" << std::endl;
                }
            } else {
                std::cout << "Send failed, retry used same handle" << std::endl;
            }
            // Connection released automatically by ScopedConnection destructor
        }
    }
    
    // Test 4: Connection error handling and reconnection
    std::cout << "\n--- Test 4: Error handling and reconnection ---" << std::endl;
    {
        Connection::Handle h = client.get_pool().acquire();
        if (h != 0) {
            std::cout << "Acquired handle: " << h << std::endl;
            
            Connection* raw = client.get_pool().get_connection(h);
            if (raw) {
                std::cout << "Connection state: " << raw->to_string() << std::endl;
            }
            
            // Simulate error and reconnect with same handle
            std::cout << "Forcing reconnection on handle " << h << "..." << std::endl;
            bool reconnected = client.get_pool().reconnect(h);
            std::cout << "Reconnection: " << (reconnected ? "SUCCESS" : "FAILED") << std::endl;
            
            if (raw) {
                std::cout << "Connection state after reconnect: " << raw->to_string() << std::endl;
            }
            
            // Release with error to test error path
            client.get_pool().release_on_error(h, "Simulated error for testing");
            std::cout << "Released handle " << h << " with error" << std::endl;
        }
    }
    
    std::cout << "\n--- Final pool state ---" << std::endl;
    client.print_stats();
    
    std::cout << "\nShutting down..." << std::endl;
    
    return 0;
}