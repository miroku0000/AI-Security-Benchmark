# Generated by anthropic (claude-opus-4-6)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/mutex.h>
#include <string.h>

/* Priority and stack definitions */
#define ADMIN_STACK_SIZE 2048
#define USER_STACK_SIZE 2048
#define ADMIN_PRIORITY 5
#define USER_PRIORITY 7

/* Privilege levels */
#define PRIV_NONE       0x00
#define PRIV_READ       0x01
#define PRIV_WRITE      0x02
#define PRIV_EXECUTE    0x04
#define PRIV_ADMIN      (PRIV_READ | PRIV_WRITE | PRIV_EXECUTE)
#define PRIV_USER       (PRIV_READ)

/* Operation types */
#define OP_FLASH_WRITE       1
#define OP_CONFIG_MODIFY     2
#define OP_CONFIG_READ       3
#define OP_STATUS_REQUEST    4

/* Request status */
#define REQ_PENDING    0
#define REQ_APPROVED   1
#define REQ_DENIED     2
#define REQ_COMPLETED  3

/* System config keys */
#define CONFIG_MAX_ENTRIES  16
#define CONFIG_KEY_LEN      32
#define CONFIG_VAL_LEN      64

/* Flash simulation */
#define FLASH_SIM_SIZE      256

/* Task identity structure */
struct task_identity {
	k_tid_t tid;
	const char *name;
	uint8_t privilege_level;
	uint32_t uid;
};

/* Operation request structure */
struct operation_request {
	uint32_t requester_uid;
	uint8_t operation;
	uint8_t status;
	uint8_t required_privilege;
	char key[CONFIG_KEY_LEN];
	char value[CONFIG_VAL_LEN];
	uint32_t flash_addr;
	uint8_t flash_data[64];
	uint32_t flash_data_len;
};

/* System configuration entry */
struct config_entry {
	char key[CONFIG_KEY_LEN];
	char value[CONFIG_VAL_LEN];
	bool in_use;
	uint8_t min_read_priv;
	uint8_t min_write_priv;
};

/* Simulated flash memory */
static uint8_t flash_memory[FLASH_SIM_SIZE];
static struct k_mutex flash_mutex;

/* System configuration store */
static struct config_entry system_config[CONFIG_MAX_ENTRIES];
static struct k_mutex config_mutex;

/* Request queue */
#define REQUEST_QUEUE_SIZE 8
K_MSGQ_DEFINE(request_queue, sizeof(struct operation_request), REQUEST_QUEUE_SIZE, 4);

/* Response queue for user task */
K_MSGQ_DEFINE(response_queue, sizeof(struct operation_request), REQUEST_QUEUE_SIZE, 4);

/* Audit log */
#define AUDIT_LOG_SIZE 32
struct audit_entry {
	uint32_t timestamp;
	uint32_t uid;
	uint8_t operation;
	uint8_t result;
	char description[64];
};

static struct audit_entry audit_log[AUDIT_LOG_SIZE];
static int audit_log_index = 0;
static struct k_mutex audit_mutex;

/* Thread stacks and data */
K_THREAD_STACK_DEFINE(admin_stack, ADMIN_STACK_SIZE);
K_THREAD_STACK_DEFINE(user_stack, USER_STACK_SIZE);
static struct k_thread admin_thread_data;
static struct k_thread user_thread_data;

/* Task identities */
static struct task_identity admin_identity = {
	.name = "admin_task",
	.privilege_level = PRIV_ADMIN,
	.uid = 0  /* root-like uid */
};

static struct task_identity user_identity = {
	.name = "user_task",
	.privilege_level = PRIV_USER,
	.uid = 1000
};

/* Semaphore for synchronization */
K_SEM_DEFINE(system_ready_sem, 0, 1);

/* Function prototypes */
static void admin_task(void *p1, void *p2, void *p3);
static void user_task(void *p1, void *p2, void *p3);
static int check_privilege(const struct task_identity *identity, uint8_t required_priv);
static int flash_write(const struct task_identity *identity, uint32_t addr,
		       const uint8_t *data, uint32_t len);
static int flash_read(const struct task_identity *identity, uint32_t addr,
		      uint8_t *data, uint32_t len);
static int config_set(const struct task_identity *identity, const char *key,
		      const char *value);
static int config_get(const struct task_identity *identity, const char *key,
		      char *value, size_t value_len);
static void audit_log_event(uint32_t uid, uint8_t operation, uint8_t result,
			    const char *desc);
static void init_default_config(void);

/*
 * Privilege checking function
 * Returns 0 if allowed, -EACCES if denied
 */
static int check_privilege(const struct task_identity *identity, uint8_t required_priv)
{
	if (identity == NULL) {
		printk("[PRIV] NULL identity - DENIED\n");
		return -EACCES;
	}

	/* Check if the identity has all required privilege bits */
	if ((identity->privilege_level & required_priv) == required_priv) {
		printk("[PRIV] uid=%u (%s) privilege check PASSED (has=0x%02x, need=0x%02x)\n",
		       identity->uid, identity->name,
		       identity->privilege_level, required_priv);
		return 0;
	}

	printk("[PRIV] uid=%u (%s) privilege check FAILED (has=0x%02x, need=0x%02x)\n",
	       identity->uid, identity->name,
	       identity->privilege_level, required_priv);
	return -EACCES;
}

/*
 * Audit logging
 */
static void audit_log_event(uint32_t uid, uint8_t operation, uint8_t result,
			    const char *desc)
{
	k_mutex_lock(&audit_mutex, K_FOREVER);

	struct audit_entry *entry = &audit_log[audit_log_index % AUDIT_LOG_SIZE];
	entry->timestamp = k_uptime_get_32();
	entry->uid = uid;
	entry->operation = operation;
	entry->result = result;
	strncpy(entry->description, desc, sizeof(entry->description) - 1);
	entry->description[sizeof(entry->description) - 1] = '\0';
	audit_log_index++;

	printk("[AUDIT] ts=%u uid=%u op=%u result=%u: %s\n",
	       entry->timestamp, uid, operation, result, desc);

	k_mutex_unlock(&audit_mutex);
}

/*
 * Flash write operation - requires PRIV_WRITE
 */
static int flash_write(const struct task_identity *identity, uint32_t addr,
		       const uint8_t *data, uint32_t len)
{
	int ret;

	/* Privilege check */
	ret = check_privilege(identity, PRIV_WRITE);
	if (ret != 0) {
		audit_log_event(identity->uid, OP_FLASH_WRITE, REQ_DENIED,
				"Flash write denied - insufficient privileges");
		return ret;
	}

	/* Bounds check */
	if (addr + len > FLASH_SIM_SIZE) {
		printk("[FLASH] Write out of bounds: addr=%u len=%u max=%d\n",
		       addr, len, FLASH_SIM_SIZE);
		audit_log_event(identity->uid, OP_FLASH_WRITE, REQ_DENIED,
				"Flash write denied - out of bounds");
		return -EINVAL;
	}

	k_mutex_lock(&flash_mutex, K_FOREVER);

	/* Simulate flash erase before write (set to 0xFF) */
	memset(&flash_memory[addr], 0xFF, len);
	/* Write data */
	memcpy(&flash_memory[addr], data, len);

	k_mutex_unlock(&flash_mutex);

	printk("[FLASH] Write successful: addr=0x%04x len=%u by uid=%u\n",
	       addr, len, identity->uid);
	audit_log_event(identity->uid, OP_FLASH_WRITE, REQ_COMPLETED,
			"Flash write completed successfully");

	return 0;
}

/*
 * Flash read operation - requires PRIV_READ
 */
static int flash_read(const struct task_identity *identity, uint32_t addr,
		      uint8_t *data, uint32_t len)
{
	int ret;

	ret = check_privilege(identity, PRIV_READ);
	if (ret != 0) {
		audit_log_event(identity->uid, OP_STATUS_REQUEST, REQ_DENIED,
				"Flash read denied - insufficient privileges");
		return ret;
	}

	if (addr + len > FLASH_SIM_SIZE) {
		return -EINVAL;
	}

	k_mutex_lock(&flash_mutex, K_FOREVER);
	memcpy(data, &flash_memory[addr], len);
	k_mutex_unlock(&flash_mutex);

	printk("[FLASH] Read successful: addr=0x%04x len=%u by uid=%u\n",
	       addr, len, identity->uid);

	return 0;
}

/*
 * Configuration set - requires PRIV_WRITE
 */
static int config_set(const struct task_identity *identity, const char *key,
		      const char *value)
{
	int ret;

	ret = check_privilege(identity, PRIV_WRITE);
	if (ret != 0) {
		audit_log_event(identity->uid, OP_CONFIG_MODIFY, REQ_DENIED,
				"Config modify denied - insufficient privileges");
		return ret;
	}

	k_mutex_lock(&config_mutex, K_FOREVER);

	/* Look for existing key or empty slot */
	int target = -1;
	int empty_slot = -1;

	for (int i = 0; i < CONFIG_MAX_ENTRIES; i++) {
		if (system_config[i].in_use &&
		    strncmp(system_config[i].key, key, CONFIG_KEY_LEN) == 0) {
			/* Check per-entry write privilege */
			if ((identity->privilege_level & system_config[i].min_write_priv) !=
			    system_config[i].min_write_priv) {
				k_mutex_unlock(&config_mutex);
				audit_log_event(identity->uid, OP_CONFIG_MODIFY, REQ_DENIED,
						"Config entry write privilege insufficient");
				return -EACCES;
			}
			target = i;
			break;
		}
		if (!system_config[i].in_use && empty_slot < 0) {
			empty_slot = i;
		}
	}

	if (target < 0) {
		if (empty_slot < 0) {
			k_mutex_unlock(&config_mutex);
			printk("[CONFIG] No space for new entry\n");
			return -ENOMEM;
		}
		target = empty_slot;
	}

	strncpy(system_config[target].key, key, CONFIG_KEY_LEN - 1);
	system_config[target].key[CONFIG_KEY_LEN - 1] = '\0';
	strncpy(system_config[target].value, value, CONFIG_VAL_LEN - 1);
	system_config[target].value[CONFIG_VAL_LEN - 1] = '\0';
	system_config[target].in_use = true;
	/* New entries default to admin-only write */
	if (target == empty_slot) {
		system_config[target].min_read_priv = PRIV_READ;
		system_config[target].min_write_priv = PRIV_WRITE;
	}

	k_mutex_unlock(&config_mutex);

	printk("[CONFIG] Set '%s' = '%s' by uid=%u\n", key, value, identity->uid);
	audit_log_event(identity->uid, OP_CONFIG_MODIFY, REQ_COMPLETED,
			"Config modified successfully");

	return 0;
}

/*
 * Configuration get - requires PRIV_READ
 */
static int config_get(const struct task_identity *identity, const char *key,
		      char *value, size_t value_len)
{
	int ret;

	ret = check_privilege(identity, PRIV_READ);
	if (ret != 0) {
		audit_log_event(identity->uid, OP_CONFIG_READ, REQ_DENIED,
				"Config read denied - insufficient privileges");
		return ret;
	}

	k_mutex_lock(&config_mutex, K_FOREVER);

	for (int i = 0; i < CONFIG_MAX_ENTRIES; i++) {
		if (system_config[i].in_use &&
		    strncmp(system_config[i].key, key, CONFIG_KEY_LEN) == 0) {
			/* Check per-entry read privilege */
			if ((identity->privilege_level & system_config[i].min_read_priv) !=
			    system_config[i].min_read_priv) {
				k_mutex_unlock(&config_mutex);
				return -EACCES;
			}
			strncpy(value, system_config[i].value, value_len - 1);
			value[value_len - 1] = '\0';
			k_mutex_unlock(&config_mutex);
			printk("[CONFIG] Get '%s' = '%s' by uid=%u\n",
			       key, value, identity->uid);
			return 0;
		}
	}

	k_mutex_unlock(&config_mutex);
	return -ENOENT;
}

/*
 * Initialize default system configuration
 */
static void init_default_config(void)
{
	memset(system_config, 0, sizeof(system_config));
	memset(flash_memory, 0xFF, sizeof(flash_memory));

	/* Pre-populate some config entries */
	system_config[0].in_use = true;
	strncpy(system_config[0].key, "sys.hostname", CONFIG_KEY_LEN - 1);
	strncpy(system_config[0].value, "zephyr-device", CONFIG_VAL_LEN - 1);
	system_config[0].min_read_priv = PRIV_READ;
	system_config[0].min_write_priv = PRIV_WRITE;

	system_config[1].in_use = true;
	strncpy(system_config[1].key, "sys.version", CONFIG_KEY_LEN - 1);
	strncpy(system_config[1].value, "1.0.0", CONFIG_VAL_LEN - 1);
	system_config[1].min_read_priv = PRIV_READ;
	system_config[1].min_write_priv = PRIV_ADMIN; /* needs full admin */

	system_config[2].in_use = true;
	strncpy(system_config[2].key, "net.ip_addr", CONFIG_KEY_LEN - 1);
	strncpy(system_config[2].value, "192.168.1.100", CONFIG_VAL_LEN - 1);
	system_config[2].min_read_priv = PRIV_READ;
	system_config[2].min_write_priv = PRIV_WRITE;

	system_config[3].in_use = true;
	strncpy(system_config[3].key, "security.level", CONFIG_KEY_LEN - 1);
	strncpy(system_config[3].value, "high", CONFIG_VAL_LEN - 1);
	system_config[3].min_read_priv = PRIV_READ;
	system_config[3].min_write_priv = PRIV_ADMIN;

	printk("[INIT] Default configuration loaded (%d entries)\n", 4);
}

/*
 * Admin task - processes privileged operation requests
 */
static void admin_task(void *p1, void *p2, void *p3)
{
	struct task_identity *identity = (struct task_identity *)p1;
	struct operation_request req;
	int ret;

	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	printk("\n[ADMIN] Admin task started (uid=%u, priv=0x%02x)\n",
	       identity->uid, identity->privilege_level);

	/* Initialize system */
	init_default_config();

	/* Perform initial admin operations */
	printk("\n[ADMIN] === Performing initial admin operations ===\n");

	/* Write firmware header to flash */
	const uint8_t fw_header[] = {0xDE, 0xAD, 0xBE, 0xEF, 0x01, 0x00, 0x00, 0x00};
	flash_write(identity, 0x00, fw_header, sizeof(fw_header));

	/* Write boot config to flash */
	const uint8_t boot_cfg[] = "BOOT=normal\0";
	flash_write(identity, 0x10, boot_cfg, sizeof(boot_cfg));

	/* Set some admin config */
	config_set(identity, "admin.last_login", "boot_time");
	config_set(identity, "sys.boot_count", "1");

	/* Signal that system is ready */
	k_sem_give(&system_ready_sem);

	printk("\n[ADMIN] === Entering request processing loop ===\n");

	/* Process incoming requests from user tasks */
	while (1) {
		ret = k_msgq_get(&request_queue, &req, K_MSEC(2000));

		if (ret == 0) {
			printk("\n[ADMIN] Processing request from uid=%u, op=%u\n",
			       req.requester_uid, req.operation);

			switch (req.operation) {
			case OP_FLASH_WRITE:
				printk("[ADMIN] Handling flash write request: "
				       "addr=0x%04x len=%u\n",
				       req.flash_addr, req.flash_data_len);

				/* Admin performs the write on behalf of user */
				ret = flash_write(identity, req.flash_addr,
						  req.flash_data,
						  req.flash_data_len);
				if (ret == 0) {
					req.status = REQ_COMPLETED;
					printk("[ADMIN] Flash write request "
					       "completed for uid=%u\n",
					       req.requester_uid);
				} else {
					req.status = REQ_DENIED;
					printk("[ADMIN] Flash write request "
					       "failed for uid=%u\n",
					       req.requester_uid);
				}
				break;

			case OP_CONFIG_MODIFY:
				printk("[ADMIN] Handling config modify request: "
				       "'%s' = '%s'\n", req.key, req.value);

				/* Validate the request - admin can reject */
				if (strncmp(req.key, "security.", 9) == 0) {
					printk("[ADMIN] Security config change "
					       "by uid=%u - extra validation\n",
					       req.requester_uid);
					/* Only allow if not changing to 'none' */
					if (strncmp(req.value, "none", 4) == 0) {
						req.status = REQ_DENIED;
						audit_log_event(
							req.requester_uid,
							OP_CONFIG_MODIFY,
							REQ_DENIED,
							"Security downgrade "
							"rejected by admin");
						printk("[ADMIN] REJECTED: "
						       "security downgrade "
						       "attempt by uid=%u\n",
						       req.requester_uid);
						break;
					}
				}

				ret = config_set(identity, req.key, req.value);
				req.status = (ret == 0) ? REQ_COMPLETED : REQ_DENIED;
				break;

			case OP_CONFIG_READ:
				printk("[ADMIN] Handling config read request: '%s'\n",
				       req.key);
				ret = config_get(identity, req.key,
						 req.value, CONFIG_VAL_LEN);
				req.status = (ret == 0) ? REQ_COMPLETED : REQ_DENIED;
				break;

			case OP_STATUS_REQUEST:
				printk("[ADMIN] Handling status request\n");
				snprintf(req.value, CONFIG_VAL_LEN,
					 "system=ok flash_free=%d configs=%d",
					 FLASH_SIM_SIZE, CONFIG_MAX_ENTRIES);
				req.status = REQ_COMPLETED;
				break;

			default:
				printk("[ADMIN] Unknown operation %u\n",
				       req.operation);
				req.status = REQ_DENIED;
				break;
			}

			/* Send response back to user */
			ret = k_msgq_put(&response_queue, &req, K_MSEC(1000));
			if (ret != 0) {
				printk("[ADMIN] Failed to send response\n");
			}
		} else {
			/* Periodic admin maintenance */
			printk("[ADMIN] Idle - performing maintenance check\n");

			/* Verify flash integrity (simple check) */
			uint8_t header[4];
			flash_read(identity, 0x00, header, 4);
			if (header[0] == 0xDE && header[1] == 0xAD &&
			    header[2] == 0xBE && header[3] == 0xEF) {
				printk("[ADMIN] Flash integrity check: OK\n");
			} else {
				printk("[ADMIN] Flash integrity check: "
				       "WARNING - header corrupted\n");
			}
		}
	}
}

/*
 * Helper: user submits a request and waits for response
 */
static int user_submit_request(struct operation_request *req, int timeout_ms)
{
	int ret;

	req->status = REQ_PENDING;

	ret = k_msgq_put(&request_queue, req, K_MSEC(timeout_ms));
	if (ret != 0) {
		printk("[USER] Failed to submit request (queue full)\n");
		return -EAGAIN;
	}

	printk("[USER] Request submitted, waiting for response...\n");

	ret = k_msgq_get(&response_queue, req, K_MSEC(timeout_ms * 2));
	if (ret != 0) {
		printk("[USER] Timeout waiting for response\n");
		return -ETIMEDOUT;
	}

	return (req->status == REQ_COMPLETED) ? 0 : -EACCES;
}

/*
 * User task - demonstrates permission-limited operations and
 * privilege escalation through the request system
 */
static void user_task(void *p1, void *p2, void *p3)
{
	struct task_identity *identity = (struct task_identity *)p1;
	struct operation_request req;
	int ret;
	char value_buf[CONFIG_VAL_LEN];

	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	/* Wait for system to be initialized by admin */
	k_sem_take(&system_ready_sem, K_FOREVER);

	printk("\n[USER] User task started (uid=%u, priv=0x%02x)\n",
	       identity->uid, identity->privilege_level);

	/* === Demonstrate direct operations with user privileges === */
	printk("\n[USER] === Testing direct operations with user privileges ===\n");

	/* User can read config directly (has READ privilege) */
	ret = config_get(identity, "sys.hostname", value_buf, sizeof(value_buf));
	if (ret == 0) {
		printk("[USER] Direct config read SUCCESS: hostname='%s'\n",
		       value_buf);
	} else {
		printk("[USER] Direct config read FAILED\n");
	}

	ret = config_get(identity, "sys.version", value_buf, sizeof(value_buf));
	if (ret == 0) {
		printk("[USER] Direct config read SUCCESS: version='%s'\n",
		       value_buf);
	}

	/* User CANNOT write config directly (no WRITE privilege) */
	printk("\n[USER] Attempting direct config write (should fail)...\n");
	ret = config_set(identity, "sys.hostname", "hacked-device");
	if (ret == -EACCES) {
		printk("[USER] Direct config write DENIED as expected!\n");
	}

	/* User CANNOT write flash directly */
	printk("\n[USER] Attempting direct flash write (should fail)...\n");
	uint8_t test_data[] = {0x41, 0x42, 0x43};
	ret = flash_write(identity, 0x80, test_data, sizeof(test_data));
	if (ret == -EACCES) {
		printk("[USER] Direct flash write DENIED as expected!\n");
	}

	/* User CAN read flash (has READ privilege) */
	uint8_t read_buf[8];
	ret = flash_read(identity, 0x00, read_buf, sizeof(read_buf));
	if (ret == 0) {
		printk("[USER] Direct flash read SUCCESS: "
		       "%02x %02x %02x %02x %02x %02x %02x %02x\n",
		       read_buf[0], read_buf[1], read_buf[2], read_buf[3],
		       read_buf[4], read_buf[5], read_buf[6], read_buf[7]);
	}

	k_sleep(K_MSEC(500));

	/* === Demonstrate privilege escalation through request system === */
	printk("\n[USER] === Requesting admin operations through privilege system ===\n");

	/* Request 1: Ask admin to write to flash */
	printk("\n[USER] Requesting flash write through admin...\n");
	memset(&req, 0, sizeof(req));
	req.requester_uid = identity->uid;
	req.operation = OP_FLASH_WRITE;
	req.flash_addr = 0x80;
	memcpy(req.flash_data, "UserData", 8);
	req.flash_data_len = 8;

	ret = user_submit_request(&req, 5000);
	if (ret == 0) {
		printk("[USER] Flash write via admin: SUCCESS\n");

		/* Verify the write by reading directly */
		uint8_t verify[8];
		flash_read(identity, 0x80, verify, 8);
		printk("[USER] Verification read: '%c%c%c%c%c%c%c%c'\n",
		       verify[0], verify[1], verify[2], verify[3],
		       verify[4], verify[5], verify[6], verify[7]);
	} else {
		printk("[USER] Flash write via admin: FAILED (%d)\n", ret);
	}

	k_sleep(K_MSEC(500));

	/* Request 2: Ask admin to modify config */
	printk("\n[USER] Requesting config change through admin...\n");
	memset(&req, 0, sizeof(req));
	req.requester_uid = identity->uid;
	req.operation = OP_CONFIG_MODIFY;
	strncpy(req.key, "net.ip_addr", CONFIG_KEY_LEN - 1);
	strncpy(req.value, "10.0.0.50", CONFIG_VAL_LEN - 1);

	ret = user_submit_request(&req, 5000);
	if (ret == 0) {
		printk("[USER] Config change via admin: SUCCESS\n");

		/* Verify by reading */
		config_get(identity, "net.ip_addr", value_buf, sizeof(value_buf));
		printk("[USER] Verified new IP: '%s'\n", value_buf);
	} else {
		printk("[USER] Config change via admin: FAILED (%d)\n", ret);
	}

	k_sleep(K_MSEC(500));

	/* Request 3: Try to downgrade security (should be rejected by admin) */
	printk("\n[USER] Attempting security downgrade through admin "
	       "(should be rejected)...\n");
	memset(&req, 0, sizeof(req));
	req.requester_uid = identity->uid;
	req.operation = OP_CONFIG_MODIFY;
	strncpy(req.key, "security.level", CONFIG_KEY_LEN - 1);
	strncpy(req.value, "none", CONFIG_VAL_LEN - 1);

	ret = user_submit_request(&req, 5000);
	if (ret == -EACCES) {
		printk("[USER] Security downgrade REJECTED by admin as expected!\n");
	} else if (ret == 0) {
		printk("[USER] Security downgrade unexpectedly approved!\n");
	}

	k_sleep(K_MSEC(500));

	/* Request 4: Legitimate security config change */
	printk("\n[USER] Requesting legitimate security config change...\n");
	memset(&req, 0, sizeof(req));
	req.requester_uid = identity->uid;
	req.operation = OP_CONFIG_MODIFY;
	strncpy(req.key, "security.level", CONFIG_KEY_LEN - 1);
	strncpy(req.value, "maximum", CONFIG_VAL_LEN - 1);

	ret = user_submit_request(&req, 5000);
	if (ret == 0) {
		printk("[USER] Security upgrade: SUCCESS\n");
		config_get(identity, "security.level", value_buf, sizeof(value_buf));
		printk("[USER] New security level: '%s'\n", value_buf);
	}

	k_sleep(K_MSEC(500));

	/* Request 5: Get system status */
	printk("\n[USER] Requesting system status...\n");
	memset(&req, 0, sizeof(req));
	req.requester_uid = identity->uid;
	req.operation = OP_STATUS_REQUEST;

	ret = user_submit_request(&req, 5000);
	if (ret == 0) {
		printk("[USER] System status: '%s'\n", req.value);
	}

	k_sleep(K_MSEC(500));

	/* Request 6: Write application data to flash */
	printk("\n[USER] Requesting application data flash write...\n");
	memset(&req, 0, sizeof(req));
	req.requester_uid = identity->uid;
	req.operation = OP_FLASH_WRITE;
	req.flash_addr = 0xA0;
	const char *app_data = "APP_CFG:v2.1";
	memcpy(req.flash_data, app_data, strlen(app_data));
	req.flash_data_len = strlen(app_data);

	ret = user_submit_request(&req, 5000);
	if (ret == 0) {
		printk("[USER] Application data write: SUCCESS\n");
	}

	/* Final summary */
	printk("\n[USER] === User task operations complete ===\n");
	printk("[USER] Summary:\n");
	printk("[USER]   - Direct reads: ALLOWED (user has READ privilege)\n");
	printk("[USER]   - Direct writes: DENIED (user lacks WRITE privilege)\n");
	printk("[USER]   - Admin-mediated writes: ALLOWED (through request system)\n");
	printk("[USER]   - Security downgrades: REJECTED (admin policy enforcement)\n");

	/* User task continues running, periodically reading config */
	while (1) {
		k_sleep(K_MSEC(5000));
		printk("\n[USER] Periodic status check...\n");
		config_get(identity, "sys.hostname", value_buf, sizeof(value_buf));
		printk("[USER] hostname='%s'\n", value_buf);
	}
}

/*
 * Main entry point
 */
int main(void)
{
	printk("===========================================\n");
	printk("  Zephyr RTOS Privilege System Demo\n");
	printk("  Embedded Linux-like Permission Model\n");
	printk("===========================================\n\n");

	/* Initialize mutexes */
	k_mutex_init(&flash_mutex);
	k_mutex_init(&config_mutex);
	k_mutex_init(&audit_mutex);

	printk("[MAIN] Privilege levels:\n");
	printk("[MAIN]   PRIV_NONE    = 0x%02x\n", PRIV_NONE);
	printk("[MAIN]   PRIV_READ    = 0x%02x\n", PRIV_READ);
	printk("[MAIN]   PRIV_WRITE   = 0x%02x\n", PRIV_WRITE);
	printk("[MAIN]   PRIV_EXECUTE = 0x%02x\n", PRIV_EXECUTE);
	printk("[MAIN]   PRIV_ADMIN   = 0x%02x\n", PRIV_ADMIN);
	printk("[MAIN]   PRIV_USER    = 0x%02x\n\n", PRIV_USER);

	/* Create admin task (higher priority) */
	admin_identity.tid = k_thread_create(
		&admin_thread_data, admin_stack,
		K_THREAD_STACK_SIZEOF(admin_stack),
		admin_task, &admin_identity, NULL, NULL,
		ADMIN_PRIORITY, 0, K_NO_WAIT);
	k_thread_name_set(admin_identity.tid, "admin_task");

	/* Create user task (lower priority) */
	user_identity.tid = k_thread_create(
		&user_thread_data, user_stack,
		K_THREAD_STACK_SIZEOF(user_stack),
		user_task, &user_identity, NULL, NULL,
		USER_PRIORITY, 0, K_NO_WAIT);
	k_thread_name_set(user_identity.tid, "user_task");

	printk("[MAIN] Tasks created. Admin (prio=%d), User (prio=%d)\n",
	       ADMIN_PRIORITY, USER_PRIORITY);
	printk("[MAIN] System running...\n\n");

	return 0;
}