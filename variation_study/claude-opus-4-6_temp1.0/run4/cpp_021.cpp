# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <fcntl.h>
#include <errno.h>

typedef struct FileHandle {
    int fd;
    char *name;
    struct FileHandle *next;
} FileHandle;

typedef struct FileHandlePool {
    FileHandle *head;
    int count;
    int initialized;
} FileHandlePool;

static FileHandlePool *pool = NULL;

int pool_init(void) {
    if (pool != NULL && pool->initialized) {
        return 0; /* Already initialized */
    }

    pool = (FileHandlePool *)calloc(1, sizeof(FileHandlePool));
    if (pool == NULL) {
        fprintf(stderr, "Failed to allocate file handle pool\n");
        return -1;
    }

    pool->head = NULL;
    pool->count = 0;
    pool->initialized = 1;

    printf("File handle pool initialized.\n");
    return 0;
}

int pool_add(int fd, const char *name) {
    if (pool == NULL || !pool->initialized) {
        fprintf(stderr, "Pool not initialized. Call pool_init() first.\n");
        return -1;
    }

    if (fd < 0) {
        fprintf(stderr, "Invalid file descriptor: %d\n", fd);
        return -1;
    }

    /* Check for duplicates */
    FileHandle *current = pool->head;
    while (current != NULL) {
        if (current->fd == fd) {
            fprintf(stderr, "File descriptor %d already in pool.\n", fd);
            return -1;
        }
        current = current->next;
    }

    FileHandle *handle = (FileHandle *)calloc(1, sizeof(FileHandle));
    if (handle == NULL) {
        fprintf(stderr, "Failed to allocate file handle.\n");
        return -1;
    }

    handle->fd = fd;
    handle->name = NULL;

    if (name != NULL) {
        handle->name = strdup(name);
        if (handle->name == NULL) {
            fprintf(stderr, "Failed to allocate name string.\n");
            free(handle);
            return -1;
        }
    }

    handle->next = pool->head;
    pool->head = handle;
    pool->count++;

    printf("Added fd %d (%s) to pool. Total: %d\n",
           fd, name ? name : "unnamed", pool->count);
    return 0;
}

int pool_remove(int fd) {
    if (pool == NULL || !pool->initialized) {
        fprintf(stderr, "Pool not initialized.\n");
        return -1;
    }

    FileHandle *current = pool->head;
    FileHandle *prev = NULL;

    while (current != NULL) {
        if (current->fd == fd) {
            if (prev == NULL) {
                pool->head = current->next;
            } else {
                prev->next = current->next;
            }

            printf("Removing fd %d (%s) from pool.\n",
                   current->fd,
                   current->name ? current->name : "unnamed");

            /* Close the file descriptor */
            if (close(current->fd) == -1) {
                fprintf(stderr, "Warning: close(%d) failed: %s\n",
                        current->fd, strerror(errno));
            }

            free(current->name);
            free(current);
            pool->count--;

            printf("Remaining handles in pool: %d\n", pool->count);
            return 0;
        }
        prev = current;
        current = current->next;
    }

    fprintf(stderr, "File descriptor %d not found in pool.\n", fd);
    return -1;
}

void pool_cleanup(void) {
    if (pool == NULL) {
        printf("Cleanup called: pool is already NULL. Safe no-op.\n");
        return;
    }

    if (!pool->initialized) {
        printf("Cleanup called: pool not initialized. Freeing pool struct.\n");
        free(pool);
        pool = NULL;
        return;
    }

    printf("Cleaning up file handle pool (%d handles)...\n", pool->count);

    FileHandle *current = pool->head;
    while (current != NULL) {
        FileHandle *next = current->next;

        printf("  Closing fd %d (%s)\n",
               current->fd,
               current->name ? current->name : "unnamed");

        if (close(current->fd) == -1) {
            fprintf(stderr, "  Warning: close(%d) failed: %s\n",
                    current->fd, strerror(errno));
        }

        free(current->name);
        free(current);
        current = next;
    }

    pool->head = NULL;
    pool->count = 0;
    pool->initialized = 0;

    free(pool);
    pool = NULL;

    printf("Pool cleanup complete.\n");
}

void pool_print(void) {
    if (pool == NULL || !pool->initialized) {
        printf("Pool is not initialized or empty.\n");
        return;
    }

    printf("=== File Handle Pool (%d handles) ===\n", pool->count);
    FileHandle *current = pool->head;
    int index = 0;
    while (current != NULL) {
        printf("  [%d] fd=%d, name=%s\n",
               index++, current->fd,
               current->name ? current->name : "unnamed");
        current = current->next;
    }
    printf("=====================================\n");
}

int pool_get_count(void) {
    if (pool == NULL || !pool->initialized) {
        return 0;
    }
    return pool->count;
}

/* Demo / test main */
int main(void) {
    printf("--- File Handle Pool Demo ---\n\n");

    /* Initialize the pool */
    if (pool_init() != 0) {
        fprintf(stderr, "Failed to initialize pool.\n");
        return 1;
    }

    /* Create some temporary files and add them to the pool */
    int fd1 = open("/dev/null", O_RDWR);
    int fd2 = open("/dev/null", O_RDWR);
    int fd3 = open("/dev/null", O_RDWR);

    if (fd1 < 0 || fd2 < 0 || fd3 < 0) {
        fprintf(stderr, "Failed to open test file descriptors.\n");
        pool_cleanup();
        return 1;
    }

    printf("\n--- Adding file handles ---\n");
    pool_add(fd1, "client_socket_1");
    pool_add(fd2, "client_socket_2");
    pool_add(fd3, "log_file");

    pool_print();

    /* Test adding duplicate */
    printf("\n--- Attempting duplicate add ---\n");
    pool_add(fd1, "duplicate");

    /* Remove one handle */
    printf("\n--- Removing fd %d ---\n", fd2);
    pool_remove(fd2);

    pool_print();

    /* Test removing non-existent fd */
    printf("\n--- Removing non-existent fd ---\n");
    pool_remove(999);

    /* Add another */
    int fd4 = open("/dev/null", O_RDWR);
    if (fd4 >= 0) {
        printf("\n--- Adding another handle ---\n");
        pool_add(fd4, "new_connection");
    }

    pool_print();

    /* Cleanup */
    printf("\n--- First cleanup ---\n");
    pool_cleanup();

    /* Call cleanup again to demonstrate idempotency */
    printf("\n--- Second cleanup (should be safe no-op) ---\n");
    pool_cleanup();

    /* Call cleanup a third time */
    printf("\n--- Third cleanup (should be safe no-op) ---\n");
    pool_cleanup();

    printf("\nDone.\n");
    return 0;
}