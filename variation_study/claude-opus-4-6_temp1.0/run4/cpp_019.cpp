# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.
# Category: use_after_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>
#include <stdbool.h>

#define MAX_SESSIONS 1024
#define SESSION_ID_LEN 64
#define MAX_KEY_LEN 128
#define MAX_VALUE_LEN 512
#define DEFAULT_TTL 3600  /* 1 hour in seconds */

typedef struct SessionDataEntry {
    char key[MAX_KEY_LEN];
    char value[MAX_VALUE_LEN];
    struct SessionDataEntry *next;
} SessionDataEntry;

typedef enum {
    SESSION_ACTIVE,
    SESSION_EXPIRED,
    SESSION_INVALIDATED
} SessionStatus;

typedef struct {
    char session_id[SESSION_ID_LEN];
    SessionDataEntry *data;
    time_t created_at;
    time_t last_accessed;
    time_t expires_at;
    int ttl;
    SessionStatus status;
    bool slot_used;
} Session;

typedef struct {
    Session sessions[MAX_SESSIONS];
    int active_count;
    int total_slots_used;
} SessionCache;

/* Forward declarations */
static unsigned int hash_session_id(const char *session_id);
static void free_session_data(SessionDataEntry *data);
static void generate_session_id(char *buf, size_t len);
static int find_session_slot(SessionCache *cache, const char *session_id);
static int find_free_slot(SessionCache *cache);
static void check_and_expire_session(Session *session);

/* Initialize the session cache */
SessionCache *cache_create(void) {
    SessionCache *cache = (SessionCache *)calloc(1, sizeof(SessionCache));
    if (!cache) {
        fprintf(stderr, "Error: Failed to allocate session cache\n");
        return NULL;
    }
    cache->active_count = 0;
    cache->total_slots_used = 0;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        cache->sessions[i].slot_used = false;
        cache->sessions[i].data = NULL;
        cache->sessions[i].status = SESSION_INVALIDATED;
    }
    return cache;
}

/* Destroy the entire cache */
void cache_destroy(SessionCache *cache) {
    if (!cache) return;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].slot_used) {
            free_session_data(cache->sessions[i].data);
            cache->sessions[i].data = NULL;
        }
    }
    free(cache);
}

/* Hash function for session IDs */
static unsigned int hash_session_id(const char *session_id) {
    unsigned int hash = 5381;
    int c;
    while ((c = *session_id++)) {
        hash = ((hash << 5) + hash) + c;
    }
    return hash % MAX_SESSIONS;
}

/* Free linked list of session data entries */
static void free_session_data(SessionDataEntry *data) {
    SessionDataEntry *current = data;
    while (current) {
        SessionDataEntry *next = current->next;
        memset(current->value, 0, MAX_VALUE_LEN); /* Clear sensitive data */
        free(current);
        current = next;
    }
}

/* Generate a pseudo-random session ID */
static void generate_session_id(char *buf, size_t len) {
    static const char charset[] = "abcdefghijklmnopqrstuvwxyz"
                                   "ABCDEFGHIJKLMNOPQRSTUVWXYZ"
                                   "0123456789";
    for (size_t i = 0; i < len - 1; i++) {
        int idx = rand() % (sizeof(charset) - 1);
        buf[i] = charset[idx];
    }
    buf[len - 1] = '\0';
}

/* Find the slot index for a given session ID using open addressing */
static int find_session_slot(SessionCache *cache, const char *session_id) {
    unsigned int index = hash_session_id(session_id);
    for (int i = 0; i < MAX_SESSIONS; i++) {
        int probe = (index + i) % MAX_SESSIONS;
        if (!cache->sessions[probe].slot_used) {
            return -1;  /* Empty slot means session doesn't exist */
        }
        if (strcmp(cache->sessions[probe].session_id, session_id) == 0) {
            return probe;
        }
    }
    return -1;
}

/* Find a free slot in the cache */
static int find_free_slot(SessionCache *cache) {
    /* First try to find a completely unused slot */
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (!cache->sessions[i].slot_used) {
            return i;
        }
    }
    /* If full, evict the oldest expired/invalidated session */
    time_t oldest_time = time(NULL);
    int oldest_idx = -1;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].status != SESSION_ACTIVE &&
            cache->sessions[i].last_accessed < oldest_time) {
            oldest_time = cache->sessions[i].last_accessed;
            oldest_idx = i;
        }
    }
    if (oldest_idx >= 0) {
        free_session_data(cache->sessions[oldest_idx].data);
        cache->sessions[oldest_idx].data = NULL;
        cache->sessions[oldest_idx].slot_used = false;
        cache->total_slots_used--;
        return oldest_idx;
    }
    return -1;
}

/* Check if a session has expired and handle it */
static void check_and_expire_session(Session *session) {
    if (session->status == SESSION_ACTIVE) {
        time_t now = time(NULL);
        if (now >= session->expires_at) {
            /* Expire: free data but keep session_id in slot */
            free_session_data(session->data);
            session->data = NULL;
            session->status = SESSION_EXPIRED;
        }
    }
}

/* Create a new session, returns session ID or NULL on failure */
const char *session_create(SessionCache *cache, int ttl) {
    if (!cache) return NULL;

    if (ttl <= 0) ttl = DEFAULT_TTL;

    int slot = find_free_slot(cache);
    if (slot < 0) {
        fprintf(stderr, "Error: Session cache is full\n");
        return NULL;
    }

    Session *session = &cache->sessions[slot];
    generate_session_id(session->session_id, SESSION_ID_LEN);

    /* Ensure uniqueness */
    int existing = find_session_slot(cache, session->session_id);
    int retries = 10;
    while (existing >= 0 && existing != slot && retries > 0) {
        generate_session_id(session->session_id, SESSION_ID_LEN);
        existing = find_session_slot(cache, session->session_id);
        retries--;
    }

    time_t now = time(NULL);
    session->data = NULL;
    session->created_at = now;
    session->last_accessed = now;
    session->expires_at = now + ttl;
    session->ttl = ttl;
    session->status = SESSION_ACTIVE;
    session->slot_used = true;

    cache->active_count++;
    cache->total_slots_used++;

    printf("[SESSION] Created session: %.16s... (TTL: %d seconds)\n",
           session->session_id, ttl);

    return session->session_id;
}

/* Re-initialize an expired session (quick re-init using cached slot) */
bool session_reinitialize(SessionCache *cache, const char *session_id, int ttl) {
    if (!cache || !session_id) return false;

    int slot = find_session_slot(cache, session_id);
    if (slot < 0) return false;

    Session *session = &cache->sessions[slot];

    if (session->status == SESSION_ACTIVE) {
        /* Already active, just refresh */
        time_t now = time(NULL);
        session->last_accessed = now;
        session->expires_at = now + (ttl > 0 ? ttl : session->ttl);
        return true;
    }

    if (session->status == SESSION_EXPIRED || session->status == SESSION_INVALIDATED) {
        /* Re-initialize: the session_id is already in cache */
        time_t now = time(NULL);
        if (ttl <= 0) ttl = session->ttl > 0 ? session->ttl : DEFAULT_TTL;

        session->data = NULL;  /* Already freed during expiration */
        session->last_accessed = now;
        session->expires_at = now + ttl;
        session->ttl = ttl;
        session->status = SESSION_ACTIVE;

        cache->active_count++;

        printf("[SESSION] Re-initialized session: %.16s... (quick re-init)\n",
               session->session_id);
        return true;
    }

    return false;
}

/* Set a key-value pair in a session */
bool session_set(SessionCache *cache, const char *session_id,
                 const char *key, const char *value) {
    if (!cache || !session_id || !key || !value) return false;

    int slot = find_session_slot(cache, session_id);
    if (slot < 0) return false;

    Session *session = &cache->sessions[slot];
    check_and_expire_session(session);

    if (session->status != SESSION_ACTIVE) {
        fprintf(stderr, "[SESSION] Cannot set data on inactive session: %.16s...\n",
                session_id);
        return false;
    }

    session->last_accessed = time(NULL);

    /* Check if key already exists */
    SessionDataEntry *current = session->data;
    while (current) {
        if (strcmp(current->key, key) == 0) {
            strncpy(current->value, value, MAX_VALUE_LEN - 1);
            current->value[MAX_VALUE_LEN - 1] = '\0';
            return true;
        }
        current = current->next;
    }

    /* Create new entry */
    SessionDataEntry *entry = (SessionDataEntry *)malloc(sizeof(SessionDataEntry));
    if (!entry) {
        fprintf(stderr, "Error: Failed to allocate session data entry\n");
        return false;
    }

    strncpy(entry->key, key, MAX_KEY_LEN - 1);
    entry->key[MAX_KEY_LEN - 1] = '\0';
    strncpy(entry->value, value, MAX_VALUE_LEN - 1);
    entry->value[MAX_VALUE_LEN - 1] = '\0';
    entry->next = session->data;
    session->data = entry;

    return true;
}

/* Get a value from a session by key */
const char *session_get(SessionCache *cache, const char *session_id,
                        const char *key) {
    if (!cache || !session_id || !key) return NULL;

    int slot = find_session_slot(cache, session_id);
    if (slot < 0) return NULL;

    Session *session = &cache->sessions[slot];
    check_and_expire_session(session);

    if (session->status != SESSION_ACTIVE) {
        return NULL;
    }

    session->last_accessed = time(NULL);

    SessionDataEntry *current = session->data;
    while (current) {
        if (strcmp(current->key, key) == 0) {
            return current->value;
        }
        current = current->next;
    }

    return NULL;
}

/* Remove a specific key from a session */
bool session_remove_key(SessionCache *cache, const char *session_id,
                        const char *key) {
    if (!cache || !session_id || !key) return false;

    int slot = find_session_slot(cache, session_id);
    if (slot < 0) return false;

    Session *session = &cache->sessions[slot];
    check_and_expire_session(session);

    if (session->status != SESSION_ACTIVE) return false;

    session->last_accessed = time(NULL);

    SessionDataEntry *prev = NULL;
    SessionDataEntry *current = session->data;
    while (current) {
        if (strcmp(current->key, key) == 0) {
            if (prev) {
                prev->next = current->next;
            } else {
                session->data = current->next;
            }
            memset(current->value, 0, MAX_VALUE_LEN);
            free(current);
            return true;
        }
        prev = current;
        current = current->next;
    }

    return false;
}

/* Access/touch a session to refresh its last_accessed time */
bool session_access(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;

    int slot = find_session_slot(cache, session_id);
    if (slot < 0) return false;

    Session *session = &cache->sessions[slot];
    check_and_expire_session(session);

    if (session->status != SESSION_ACTIVE) return false;

    session->last_accessed = time(NULL);
    /* Optionally extend expiry on access (sliding expiration) */
    session->expires_at = session->last_accessed + session->ttl;

    return true;
}

/* Invalidate a session - free data but keep the ID in cache */
bool session_invalidate(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;

    int slot = find_session_slot(cache, session_id);
    if (slot < 0) return false;

    Session *session = &cache->sessions[slot];

    if (session->status == SESSION_ACTIVE) {
        cache->active_count--;
    }

    /* Free the session data but keep the slot and session_id */
    free_session_data(session->data);
    session->data = NULL;
    session->status = SESSION_INVALIDATED;
    session->last_accessed = time(NULL);

    printf("[SESSION] Invalidated session: %.16s... (ID cached for re-init)\n",
           session_id);

    return true;
}

/* Completely remove a session from the cache */
bool session_destroy(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;

    int slot = find_session_slot(cache, session_id);
    if (slot < 0) return false;

    Session *session = &cache->sessions[slot];

    if (session->status == SESSION_ACTIVE) {
        cache->active_count--;
    }

    free_session_data(session->data);
    session->data = NULL;
    session->slot_used = false;
    session->status = SESSION_INVALIDATED;
    memset(session->session_id, 0, SESSION_ID_LEN);
    cache->total_slots_used--;

    printf("[SESSION] Destroyed session completely from cache\n");

    return true;
}

/* Get session status */
SessionStatus session_get_status(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return SESSION_INVALIDATED;

    int slot = find_session_slot(cache, session_id);
    if (slot < 0) return SESSION_INVALIDATED;

    Session *session = &cache->sessions[slot];
    check_and_expire_session(session);

    return session->status;
}

/* Run expiration check on all sessions */
int cache_cleanup(SessionCache *cache) {
    if (!cache) return 0;

    int expired_count = 0;
    time_t now = time(NULL);

    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].slot_used &&
            cache->sessions[i].status == SESSION_ACTIVE) {
            if (now >= cache->sessions[i].expires_at) {
                free_session_data(cache->sessions[i].data);
                cache->sessions[i].data = NULL;
                cache->sessions[i].status = SESSION_EXPIRED;
                cache->active_count--;
                expired_count++;
            }
        }
    }

    if (expired_count > 0) {
        printf("[CACHE] Cleanup: expired %d sessions (IDs retained for quick re-init)\n",
               expired_count);
    }

    return expired_count;
}

/* Print cache statistics */
void cache_print_stats(SessionCache *cache) {
    if (!cache) return;

    int active = 0, expired = 0, invalidated = 0;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].slot_used) {
            check_and_expire_session(&cache->sessions[i]);
            switch (cache->sessions[i].status) {
                case SESSION_ACTIVE:      active++;       break;
                case SESSION_EXPIRED:     expired++;      break;
                case SESSION_INVALIDATED: invalidated++;  break;
            }
        }
    }

    printf("\n=== Session Cache Statistics ===\n");
    printf("  Total slots:       %d\n", MAX_SESSIONS);
    printf("  Slots used:        %d\n", cache->total_slots_used);
    printf("  Active sessions:   %d\n", active);
    printf("  Expired (cached):  %d\n", expired);
    printf("  Invalidated:       %d\n", invalidated);
    printf("  Free slots:        %d\n", MAX_SESSIONS - cache->total_slots_used);
    printf("================================\n\n");
}

/* Print session details */
void session_print(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return;

    int slot = find_session_slot(cache, session_id);
    if (slot < 0) {
        printf("[SESSION] Session not found: %.16s...\n", session_id);
        return;
    }

    Session *session = &cache->sessions[slot];
    check_and_expire_session(session);

    const char *status_str;
    switch (session->status) {
        case SESSION_ACTIVE:      status_str = "ACTIVE";      break;
        case SESSION_EXPIRED:     status_str = "EXPIRED";     break;
        case SESSION_INVALIDATED: status_str = "INVALIDATED"; break;
        default:                  status_str = "UNKNOWN";     break;
    }

    printf("\n--- Session Info ---\n");
    printf("  ID:            %.16s...\n", session->session_id);
    printf("  Status:        %s\n", status_str);
    printf("  Created:       %s", ctime(&session->created_at));
    printf("  Last accessed: %s", ctime(&session->last_accessed));
    printf("  Expires at:    %s", ctime(&session->expires_at));
    printf("  TTL:           %d seconds\n", session->ttl);

    if (session->status == SESSION_ACTIVE && session->data) {
        printf("  Data entries:\n");
        SessionDataEntry *entry = session->data;
        while (entry) {
            printf("    [%s] = %s\n", entry->key, entry->value);
            entry = entry->next;
        }
    } else {
        printf("  Data: (none)\n");
    }
    printf("--------------------\n\n");
}

/* Demo / Test */
int main(void) {
    srand((unsigned int)time(NULL));

    printf("=== Session Caching System Demo ===\n\n");

    /* Create the cache */
    SessionCache *cache = cache_create();
    if (!cache) {
        fprintf(stderr, "Failed to create session cache\n");
        return 1;
    }

    /* Create sessions */
    const char *sid1 = session_create(cache, 5);  /* 5 second TTL for demo */
    const char *sid2 = session_create(cache, 3600);
    const char *sid3 = session_create(cache, 3600);

    if (!sid1 || !sid2 || !sid3) {
        fprintf(stderr, "Failed to create sessions\n");
        cache_destroy(cache);
        return 1;
    }

    /* We need to copy session IDs since they point into the cache */
    char id1[SESSION_ID_LEN], id2[SESSION_ID_LEN], id3[SESSION_ID_LEN];
    strncpy(id1, sid1, SESSION_ID_LEN);
    strncpy(id2, sid2, SESSION_ID_LEN);
    strncpy(id3, sid3, SESSION_ID_LEN);

    /* Set session data */
    session_set(cache, id1, "username", "alice");
    session_set(cache, id1, "role", "admin");
    session_set(cache, id1, "ip_address", "192.168.1.100");

    session_set(cache, id2, "username", "bob");
    session_set(cache, id2, "role", "user");
    session_set(cache, id2, "cart_items", "3");

    session_set(cache, id3, "username", "charlie");
    session_set(cache, id3, "role", "moderator");

    /* Print initial state */
    cache_print_stats(cache);
    session_print(cache, id1);
    session_print(cache, id2);

    /* Access session data */
    const char *username = session_get(cache, id1, "username");
    if (username) {
        printf("Retrieved from session 1: username = %s\n", username);
    }

    const char *role = session_get(cache, id2, "role");
    if (role) {
        printf("Retrieved from session 2: role = %s\n", role);
    }

    /* Update a value */
    session_set(cache, id2, "cart_items", "5");
    const char *cart = session_get(cache, id2, "cart_items");
    if (cart) {
        printf("Updated session 2: cart_items = %s\n\n", cart);
    }

    /* Invalidate session 3 */
    printf("--- Invalidating session 3 ---\n");
    session_invalidate(cache, id3);
    cache_print_stats(cache);

    /* Try to access invalidated session */
    const char *invalid_data = session_get(cache, id3, "username");
    printf("Accessing invalidated session 3: %s\n\n",
           invalid_data ? invalid_data : "(no data - session invalidated)");

    /* Re-initialize session 3 (quick re-init since ID is cached) */
    printf("--- Re-initializing session 3 (quick re-init) ---\n");
    if (session_reinitialize(cache, id3, 7200)) {
        printf("Session 3 re-initialized successfully!\n");
        session_set(cache, id3, "username", "charlie_v2");
        session_set(cache, id3, "role", "admin");
        session_print(cache, id3);
    }

    cache_print_stats(cache);

    /* Wait for session 1 to expire (5 second TTL) */
    printf("--- Waiting for session 1 to expire (5 seconds)... ---\n");
    for (int i = 5; i > 0; i--) {
        printf("  %d...\n", i);
        /* Portable sleep - busy wait for demo purposes */
        time_t start = time(NULL);
        while (time(NULL) - start < 1) { /* busy wait 1 second */ }
    }

    /* Run cleanup to expire old sessions */
    cache_cleanup(cache);
    cache_print_stats(cache);

    /* Check session 1 status */
    SessionStatus status = session_get_status(cache, id1);
    printf("Session 1 status: %s\n",
           status == SESSION_EXPIRED ? "EXPIRED (ID still cached)" : "ACTIVE");

    /* Session 1 data should be gone */
    const char *expired_data = session_get(cache, id1, "username");
    printf("Session 1 data after expiry: %s\n\n",
           expired_data ? expired_data : "(freed - session expired)");

    /* Quick re-init of expired session 1 */
    printf("--- Quick re-initialization of expired session 1 ---\n");
    if (session_reinitialize(cache, id1, 3600)) {
        printf("Session 1 re-initialized from cached ID!\n");
        session_set(cache, id1, "username", "alice_renewed");
        session_set(cache, id1, "role", "superadmin");

        const char *renewed = session_get(cache, id1, "username");
        printf("Session 1 renewed data: username = %s\n", renewed ? renewed : "NULL");
        session_print(cache, id1);
    }

    /* Touch/access session 2 to extend its life */
    session_access(cache, id2);
    printf("Session 2 touched (sliding expiration extended)\n");

    /* Remove a specific key from session 2 */
    session_remove_key(cache, id2, "cart_items");
    const char *removed = session_get(cache, id2, "cart_items");
    printf("Session 2 cart_items after removal: %s\n\n",
           removed ? removed : "(removed)");

    /* Final stats */
    cache_print_stats(cache);

    /* Completely destroy session 2 (remove from cache entirely) */
    printf("--- Completely destroying session 2 ---\n");
    session_destroy(cache, id2);
    cache_print_stats(cache);

    /* Cleanup */
    cache_destroy(cache);
    printf("Cache destroyed. All memory freed.\n");

    return 0;
}