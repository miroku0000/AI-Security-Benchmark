# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <vector>
#include <stdexcept>
#include <memory>
#include <cstring>
#include <mutex>

class ConnectionResource {
public:
    int socket_fd;
    std::string host;
    int port;
    bool is_connected;
    char* recv_buffer;
    size_t buffer_size;

    ConnectionResource(const std::string& host, int port, size_t buf_size = 4096)
        : socket_fd(-1), host(host), port(port), is_connected(false),
          recv_buffer(nullptr), buffer_size(buf_size) {
        recv_buffer = new char[buffer_size];
        std::memset(recv_buffer, 0, buffer_size);
    }

    ~ConnectionResource() {
        delete[] recv_buffer;
        recv_buffer = nullptr;
    }

    ConnectionResource(const ConnectionResource&) = delete;
    ConnectionResource& operator=(const ConnectionResource&) = delete;

    ConnectionResource(ConnectionResource&& other) noexcept
        : socket_fd(other.socket_fd), host(std::move(other.host)), port(other.port),
          is_connected(other.is_connected), recv_buffer(other.recv_buffer),
          buffer_size(other.buffer_size) {
        other.socket_fd = -1;
        other.is_connected = false;
        other.recv_buffer = nullptr;
        other.buffer_size = 0;
    }
};

class NetworkConnectionManager {
private:
    std::vector<std::unique_ptr<ConnectionResource>> connections_;
    size_t max_connections_;
    bool initialized_;
    std::mutex mutex_;
    char* shared_buffer_;
    size_t shared_buffer_size_;

    void allocate_shared_resources(size_t buffer_size) {
        shared_buffer_ = new char[buffer_size];
        shared_buffer_size_ = buffer_size;
        std::memset(shared_buffer_, 0, shared_buffer_size_);
    }

    void release_shared_resources() {
        delete[] shared_buffer_;
        shared_buffer_ = nullptr;
        shared_buffer_size_ = 0;
    }

    void simulate_connect(ConnectionResource& conn) {
        // Simulate a connection attempt
        // In real code, this would use socket(), connect(), etc.
        static int fake_fd_counter = 100;
        conn.socket_fd = fake_fd_counter++;
        conn.is_connected = true;
        std::cout << "[INFO] Connected to " << conn.host << ":" << conn.port
                  << " (fd=" << conn.socket_fd << ")" << std::endl;
    }

    void simulate_disconnect(ConnectionResource& conn) {
        if (conn.is_connected) {
            std::cout << "[INFO] Disconnecting from " << conn.host << ":" << conn.port
                      << " (fd=" << conn.socket_fd << ")" << std::endl;
            conn.socket_fd = -1;
            conn.is_connected = false;
        }
    }

public:
    NetworkConnectionManager(size_t max_connections = 10, size_t shared_buf_size = 8192)
        : max_connections_(max_connections), initialized_(false),
          shared_buffer_(nullptr), shared_buffer_size_(0) {
        try {
            allocate_shared_resources(shared_buf_size);
            connections_.reserve(max_connections_);
            initialized_ = true;
            std::cout << "[INFO] NetworkConnectionManager initialized (max_connections="
                      << max_connections_ << ")" << std::endl;
        } catch (const std::bad_alloc& e) {
            // Clean up any partially allocated resources
            release_shared_resources();
            throw std::runtime_error(
                std::string("Failed to initialize NetworkConnectionManager: ") + e.what());
        } catch (...) {
            release_shared_resources();
            throw;
        }
    }

    ~NetworkConnectionManager() {
        std::cout << "[INFO] Destroying NetworkConnectionManager" << std::endl;
        close_all();
        release_shared_resources();
        initialized_ = false;
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    // Add a new connection
    int add_connection(const std::string& host, int port) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (!initialized_) {
            throw std::runtime_error("Manager not initialized");
        }

        if (connections_.size() >= max_connections_) {
            throw std::runtime_error("Maximum number of connections reached");
        }

        std::unique_ptr<ConnectionResource> conn;
        try {
            conn = std::make_unique<ConnectionResource>(host, port);
        } catch (const std::bad_alloc& e) {
            throw std::runtime_error(
                std::string("Failed to allocate connection resource: ") + e.what());
        }

        try {
            simulate_connect(*conn);
        } catch (...) {
            // conn is automatically cleaned up by unique_ptr
            std::cerr << "[ERROR] Failed to connect to " << host << ":" << port << std::endl;
            throw;
        }

        int index = static_cast<int>(connections_.size());
        connections_.push_back(std::move(conn));
        return index;
    }

    // Close a specific connection by index
    void close_connection(int index) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index < 0 || index >= static_cast<int>(connections_.size())) {
            throw std::out_of_range("Invalid connection index: " + std::to_string(index));
        }

        if (connections_[index]) {
            simulate_disconnect(*connections_[index]);
            connections_[index].reset();
        }
    }

    // Close all connections
    void close_all() {
        std::lock_guard<std::mutex> lock(mutex_);

        for (auto& conn : connections_) {
            if (conn) {
                simulate_disconnect(*conn);
                conn.reset();
            }
        }
        connections_.clear();
        std::cout << "[INFO] All connections closed" << std::endl;
    }

    // Reset a specific connection (disconnect and reconnect)
    void reset_connection(int index) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index < 0 || index >= static_cast<int>(connections_.size())) {
            throw std::out_of_range("Invalid connection index: " + std::to_string(index));
        }

        if (!connections_[index]) {
            throw std::runtime_error("Connection at index " + std::to_string(index) +
                                     " has already been released");
        }

        ConnectionResource& conn = *connections_[index];
        std::string saved_host = conn.host;
        int saved_port = conn.port;
        size_t saved_buf_size = conn.buffer_size;

        // Disconnect the existing connection
        simulate_disconnect(conn);

        // Clear and reallocate the receive buffer
        try {
            delete[] conn.recv_buffer;
            conn.recv_buffer = nullptr;
            conn.recv_buffer = new char[saved_buf_size];
            std::memset(conn.recv_buffer, 0, saved_buf_size);
            conn.buffer_size = saved_buf_size;
        } catch (const std::bad_alloc& e) {
            // If buffer allocation fails, remove the broken connection
            connections_[index].reset();
            throw std::runtime_error(
                std::string("Failed to reallocate buffer during reset: ") + e.what());
        }

        // Reconnect
        try {
            simulate_connect(conn);
        } catch (...) {
            // If reconnection fails, clean up
            connections_[index].reset();
            std::cerr << "[ERROR] Failed to reconnect to " << saved_host << ":"
                      << saved_port << std::endl;
            throw;
        }

        std::cout << "[INFO] Connection " << index << " reset successfully" << std::endl;
    }

    // Reinitialize the entire manager (close everything and start fresh)
    void reinitialize(size_t new_max_connections = 0, size_t new_shared_buf_size = 0) {
        std::lock_guard<std::mutex> lock(mutex_);

        std::cout << "[INFO] Reinitializing NetworkConnectionManager" << std::endl;

        // Close all existing connections
        for (auto& conn : connections_) {
            if (conn) {
                simulate_disconnect(*conn);
                conn.reset();
            }
        }
        connections_.clear();

        // Update parameters if provided
        if (new_max_connections > 0) {
            max_connections_ = new_max_connections;
        }

        size_t buf_size = (new_shared_buf_size > 0) ? new_shared_buf_size : shared_buffer_size_;

        // Reallocate shared resources
        release_shared_resources();

        try {
            allocate_shared_resources(buf_size);
            connections_.reserve(max_connections_);
        } catch (const std::bad_alloc& e) {
            initialized_ = false;
            release_shared_resources();
            throw std::runtime_error(
                std::string("Failed to reinitialize manager: ") + e.what());
        }

        initialized_ = true;
        std::cout << "[INFO] Reinitialization complete (max_connections="
                  << max_connections_ << ")" << std::endl;
    }

    // Send data on a connection
    bool send_data(int index, const std::string& data) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index < 0 || index >= static_cast<int>(connections_.size())) {
            throw std::out_of_range("Invalid connection index");
        }

        if (!connections_[index] || !connections_[index]->is_connected) {
            std::cerr << "[ERROR] Connection " << index << " is not active" << std::endl;
            return false;
        }

        // Simulate sending data
        std::cout << "[INFO] Sending " << data.size() << " bytes on connection "
                  << index << " (fd=" << connections_[index]->socket_fd << "): "
                  << data << std::endl;
        return true;
    }

    // Get connection status
    bool is_connected(int index) const {
        if (index < 0 || index >= static_cast<int>(connections_.size())) {
            return false;
        }
        return connections_[index] && connections_[index]->is_connected;
    }

    size_t active_connection_count() const {
        size_t count = 0;
        for (const auto& conn : connections_) {
            if (conn && conn->is_connected) {
                count++;
            }
        }
        return count;
    }

    size_t max_connections() const { return max_connections_; }
    bool is_initialized() const { return initialized_; }

    void print_status() const {
        std::cout << "=== NetworkConnectionManager Status ===" << std::endl;
        std::cout << "Initialized: " << (initialized_ ? "yes" : "no") << std::endl;
        std::cout << "Max connections: " << max_connections_ << std::endl;
        std::cout << "Active connections: " << active_connection_count() << std::endl;
        std::cout << "Shared buffer size: " << shared_buffer_size_ << " bytes" << std::endl;

        for (size_t i = 0; i < connections_.size(); ++i) {
            if (connections_[i]) {
                std::cout << "  [" << i << "] " << connections_[i]->host << ":"
                          << connections_[i]->port
                          << " fd=" << connections_[i]->socket_fd
                          << " connected=" << (connections_[i]->is_connected ? "yes" : "no")
                          << " buf=" << connections_[i]->buffer_size << "B"
                          << std::endl;
            } else {
                std::cout << "  [" << i << "] <released>" << std::endl;
            }
        }
        std::cout << "=======================================" << std::endl;
    }
};

// Demo / test
int main() {
    try {
        std::cout << "--- Creating manager ---" << std::endl;
        NetworkConnectionManager manager(5, 16384);

        std::cout << "\n--- Adding connections ---" << std::endl;
        int conn0 = manager.add_connection("192.168.1.1", 8080);
        int conn1 = manager.add_connection("10.0.0.1", 443);
        int conn2 = manager.add_connection("example.com", 80);

        manager.print_status();

        std::cout << "\n--- Sending data ---" << std::endl;
        manager.send_data(conn0, "Hello, Server!");
        manager.send_data(conn1, "GET / HTTP/1.1");

        std::cout << "\n--- Resetting connection 1 ---" << std::endl;
        manager.reset_connection(conn1);
        manager.print_status();

        std::cout << "\n--- Closing connection 0 ---" << std::endl;
        manager.close_connection(conn0);
        manager.print_status();

        std::cout << "\n--- Reinitializing manager ---" << std::endl;
        manager.reinitialize(8, 32768);
        manager.print_status();

        std::cout << "\n--- Adding new connections after reinit ---" << std::endl;
        manager.add_connection("newhost.com", 9090);
        manager.add_connection("anotherhost.com", 3000);
        manager.print_status();

        std::cout << "\n--- Testing error handling: invalid index ---" << std::endl;
        try {
            manager.close_connection(99);
        } catch (const std::out_of_range& e) {
            std::cerr << "[CAUGHT] " << e.what() << std::endl;
        }

        std::cout << "\n--- Manager going out of scope ---" << std::endl;

    } catch (const std::exception& e) {
        std::cerr << "[FATAL] " << e.what() << std::endl;
        return 1;
    }

    std::cout << "\nProgram completed successfully." << std::endl;
    return 0;
}