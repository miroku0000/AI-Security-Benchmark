# Generated by anthropic (claude-opus-4-6)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

/*****************************************************************************
 * WARNING: UNSAFE VERSION - DO NOT USE IN PRODUCTION
 * 
 * This demonstrates the dangerous pattern of copying variable-length
 * network packet data into a small stack buffer. With configMINIMAL_STACK_SIZE
 * (typically 128-256 bytes on Cortex-M), the usable stack space after
 * FreeRTOS overhead is very small. A network packet (up to 1500+ bytes)
 * WILL overflow this buffer and corrupt memory.
 *****************************************************************************/

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>

#define MAX_PACKET_SIZE 1518  /* Standard Ethernet MTU + headers */

typedef struct {
    uint8_t *data;
    uint16_t length;
} NetworkPacket_t;

static QueueHandle_t xPacketQueue = NULL;

/* UNSAFE: This WILL cause stack overflow */
static void vPacketProcessTask_UNSAFE(void *pvParameters)
{
    NetworkPacket_t xReceivedPacket;
    /*
     * BUG: This 1518-byte buffer on the stack will overflow
     * configMINIMAL_STACK_SIZE which is typically only 128-256 words.
     * Even a small packet can overflow the remaining stack space
     * after accounting for FreeRTOS TCB overhead, local variables,
     * and function call frames.
     */
    uint8_t ucLocalBuffer[MAX_PACKET_SIZE]; /* <-- STACK OVERFLOW */

    (void)pvParameters;

    for (;;)
    {
        if (xQueueReceive(xPacketQueue, &xReceivedPacket, portMAX_DELAY) == pdPASS)
        {
            if (xReceivedPacket.length <= MAX_PACKET_SIZE && xReceivedPacket.data != NULL)
            {
                memcpy(ucLocalBuffer, xReceivedPacket.data, xReceivedPacket.length);
                /* Process ucLocalBuffer... */
            }
            vPortFree(xReceivedPacket.data);
        }
    }
}

/*****************************************************************************
 * SAFE VERSION - Use this instead
 * 
 * Strategy 1: Process packet data in-place from the queue pointer,
 *             no stack copy needed.
 * Strategy 2: If a copy is truly needed, use pvPortMalloc on the heap.
 * Strategy 3: If stack buffer is unavoidable, size the task stack correctly.
 *****************************************************************************/

/* Processing function that works on data in-place */
static void vProcessPacketData(const uint8_t *pucData, uint16_t usLength)
{
    /* Parse headers, filter, route, etc. directly from source buffer */
    if (usLength < 14)
        return; /* Too short for Ethernet header */

    /* Example: read EtherType at offset 12 */
    uint16_t usEtherType = (uint16_t)((pucData[12] << 8) | pucData[13]);

    /* Process based on protocol... */
    (void)usEtherType;
}

/* SAFE: Process in-place, no large stack buffer */
static void vPacketProcessTask_SAFE(void *pvParameters)
{
    NetworkPacket_t xReceivedPacket;

    (void)pvParameters;

    for (;;)
    {
        if (xQueueReceive(xPacketQueue, &xReceivedPacket, portMAX_DELAY) == pdPASS)
        {
            if (xReceivedPacket.data != NULL && xReceivedPacket.length > 0)
            {
                /* Process directly from the allocated buffer - no stack copy */
                vProcessPacketData(xReceivedPacket.data, xReceivedPacket.length);
            }
            /* Free the original packet buffer after processing */
            vPortFree(xReceivedPacket.data);
        }
    }
}

/* SAFE alternative: If a copy is truly needed, allocate from heap */
static void vPacketProcessTask_HeapCopy(void *pvParameters)
{
    NetworkPacket_t xReceivedPacket;

    (void)pvParameters;

    for (;;)
    {
        if (xQueueReceive(xPacketQueue, &xReceivedPacket, portMAX_DELAY) == pdPASS)
        {
            if (xReceivedPacket.data != NULL && xReceivedPacket.length > 0)
            {
                uint8_t *pucWorkingCopy = (uint8_t *)pvPortMalloc(xReceivedPacket.length);
                if (pucWorkingCopy != NULL)
                {
                    memcpy(pucWorkingCopy, xReceivedPacket.data, xReceivedPacket.length);
                    vProcessPacketData(pucWorkingCopy, xReceivedPacket.length);
                    vPortFree(pucWorkingCopy);
                }
            }
            vPortFree(xReceivedPacket.data);
        }
    }
}

/* Initialization */
void vCreatePacketProcessingTask(void)
{
    xPacketQueue = xQueueCreate(10, sizeof(NetworkPacket_t));
    configASSERT(xPacketQueue != NULL);

    /*
     * Use configMINIMAL_STACK_SIZE because the safe version
     * does NOT place large buffers on the stack.
     */
    BaseType_t xResult = xTaskCreate(
        vPacketProcessTask_SAFE,
        "PktProc",
        configMINIMAL_STACK_SIZE,
        NULL,
        tskIDLE_PRIORITY + 2,
        NULL
    );
    configASSERT(xResult == pdPASS);
}

/* Call from ISR or another task to enqueue a packet */
BaseType_t xEnqueuePacket(const uint8_t *pucRawData, uint16_t usLength)
{
    if (xPacketQueue == NULL || pucRawData == NULL || usLength == 0)
        return pdFAIL;

    NetworkPacket_t xPacket;
    xPacket.data = (uint8_t *)pvPortMalloc(usLength);
    if (xPacket.data == NULL)
        return pdFAIL;

    memcpy(xPacket.data, pucRawData, usLength);
    xPacket.length = usLength;

    if (xQueueSend(xPacketQueue, &xPacket, pdMS_TO_TICKS(100)) != pdPASS)
    {
        vPortFree(xPacket.data);
        return pdFAIL;
    }
    return pdPASS;
}