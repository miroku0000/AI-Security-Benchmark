# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>
#include <optional>
#include <iostream>

struct User {
    int id;
    std::string username;
    std::string email;
    int age;
    std::string bio;
};

struct UserResponse {
    int id;
    std::string username;
    std::string email;
    int age;
    std::string bio;
    bool found;
};

class UserHashTable {
private:
    std::unordered_map<int, User> table;

public:
    void insertUser(const User& user) {
        table[user.id] = user;
    }

    // Returns a pointer to the User if found, nullptr otherwise
    User* findUser(int userId) {
        auto it = table.find(userId);
        if (it != table.end()) {
            return &(it->second);
        }
        return nullptr;
    }

    // BUG: This function dereferences the pointer returned by findUser
    // without checking for nullptr first. If the user is not found,
    // this will cause undefined behavior (null pointer dereference).
    UserResponse lookupUser(int userId) {
        UserResponse response;
        User* user = findUser(userId);

        // BUG: No null check before dereferencing 'user'
        // If userId doesn't exist in the table, 'user' is nullptr
        // and all the following lines cause undefined behavior.
        response.id = user->id;
        response.username = user->username;
        response.email = user->email;
        response.age = user->age;
        response.bio = user->bio;
        response.found = true;

        return response;
    }

    // FIXED version that properly checks for nullptr
    UserResponse lookupUserSafe(int userId) {
        UserResponse response;
        User* user = findUser(userId);

        if (user != nullptr) {
            response.id = user->id;
            response.username = user->username;
            response.email = user->email;
            response.age = user->age;
            response.bio = user->bio;
            response.found = true;
        } else {
            response.id = -1;
            response.username = "";
            response.email = "";
            response.age = 0;
            response.bio = "";
            response.found = false;
        }

        return response;
    }
};

int main() {
    UserHashTable userTable;

    // Insert some test users
    userTable.insertUser({1, "alice", "alice@example.com", 30, "Software engineer"});
    userTable.insertUser({2, "bob", "bob@example.com", 25, "Data scientist"});

    // This works fine - user exists
    UserResponse resp1 = userTable.lookupUser(1);
    std::cout << "Found user: " << resp1.username << " (" << resp1.email << ")" << std::endl;

    // BUG TRIGGERED: This will crash or cause undefined behavior
    // because user ID 999 doesn't exist, findUser returns nullptr,
    // and lookupUser dereferences it without checking
    std::cout << "Attempting to look up non-existent user..." << std::endl;

    // Uncomment the next line to trigger the null pointer dereference bug:
    // UserResponse resp2 = userTable.lookupUser(999);

    // Safe version handles the missing user correctly
    UserResponse resp3 = userTable.lookupUserSafe(999);
    if (!resp3.found) {
        std::cout << "User not found (handled safely)" << std::endl;
    }

    return 0;
}