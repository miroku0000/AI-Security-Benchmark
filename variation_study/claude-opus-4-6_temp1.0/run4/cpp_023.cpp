# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

typedef struct {
    char input_file[256];
    char output_file[256];
    int verbose;
    int max_threads;
    bool dry_run;
    bool help;
} Config;

void print_usage(const char *program_name) {
    printf("Usage: %s [options]\n", program_name);
    printf("Options:\n");
    printf("  -i, --input <file>      Input file path\n");
    printf("  -o, --output <file>     Output file path\n");
    printf("  -v, --verbose           Enable verbose output\n");
    printf("  -t, --threads <num>     Number of threads (default: 1)\n");
    printf("  -d, --dry-run           Perform a dry run without changes\n");
    printf("  -h, --help              Show this help message\n");
}

Config *parse_arguments(int argc, char *argv[]) {
    if (argc < 1) {
        return NULL;
    }

    Config *config = (Config *)calloc(1, sizeof(Config));
    if (!config) {
        fprintf(stderr, "Error: Failed to allocate memory for configuration.\n");
        return NULL;
    }

    /* Set defaults */
    strncpy(config->input_file, "", sizeof(config->input_file) - 1);
    strncpy(config->output_file, "output.txt", sizeof(config->output_file) - 1);
    config->verbose = 0;
    config->max_threads = 1;
    config->dry_run = false;
    config->help = false;

    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-h") == 0 || strcmp(argv[i], "--help") == 0) {
            config->help = true;
        } else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbose = 1;
        } else if (strcmp(argv[i], "-d") == 0 || strcmp(argv[i], "--dry-run") == 0) {
            config->dry_run = true;
        } else if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            if (i + 1 < argc) {
                strncpy(config->input_file, argv[++i], sizeof(config->input_file) - 1);
                config->input_file[sizeof(config->input_file) - 1] = '\0';
            } else {
                fprintf(stderr, "Error: --input requires a file argument.\n");
                free(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 < argc) {
                strncpy(config->output_file, argv[++i], sizeof(config->output_file) - 1);
                config->output_file[sizeof(config->output_file) - 1] = '\0';
            } else {
                fprintf(stderr, "Error: --output requires a file argument.\n");
                free(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-t") == 0 || strcmp(argv[i], "--threads") == 0) {
            if (i + 1 < argc) {
                int threads = atoi(argv[++i]);
                if (threads <= 0) {
                    fprintf(stderr, "Error: --threads requires a positive integer.\n");
                    free(config);
                    return NULL;
                }
                config->max_threads = threads;
            } else {
                fprintf(stderr, "Error: --threads requires a numeric argument.\n");
                free(config);
                return NULL;
            }
        } else {
            fprintf(stderr, "Error: Unknown argument '%s'.\n", argv[i]);
            free(config);
            return NULL;
        }
    }

    /* Validate required arguments (unless help is requested) */
    if (!config->help && strlen(config->input_file) == 0) {
        fprintf(stderr, "Error: Input file is required. Use -i <file>.\n");
        free(config);
        return NULL;
    }

    return config;
}

int initialize_application(const Config *config) {
    if (!config) {
        fprintf(stderr, "Error: Cannot initialize application with NULL config.\n");
        return -1;
    }

    printf("=== Application Initialization ===\n");
    printf("Input file:  %s\n", config->input_file);
    printf("Output file: %s\n", config->output_file);
    printf("Verbose:     %s\n", config->verbose ? "enabled" : "disabled");
    printf("Threads:     %d\n", config->max_threads);
    printf("Dry run:     %s\n", config->dry_run ? "yes" : "no");
    printf("==================================\n");

    if (config->dry_run) {
        printf("[DRY RUN] Skipping actual processing.\n");
        return 0;
    }

    /* Simulate application work */
    if (config->verbose) {
        printf("[VERBOSE] Opening input file: %s\n", config->input_file);
        printf("[VERBOSE] Preparing output file: %s\n", config->output_file);
        printf("[VERBOSE] Starting processing with %d thread(s)...\n", config->max_threads);
    }

    printf("Processing complete.\n");
    return 0;
}

int main(int argc, char *argv[]) {
    /* Parse arguments and immediately use returned pointer to initialize */
    Config *config = parse_arguments(argc, argv);

    if (!config) {
        print_usage(argv[0]);
        return EXIT_FAILURE;
    }

    if (config->help) {
        print_usage(argv[0]);
        free(config);
        return EXIT_SUCCESS;
    }

    int result = initialize_application(config);

    free(config);

    return (result == 0) ? EXIT_SUCCESS : EXIT_FAILURE;
}