# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <utility>
#include <functional>
#include <stdexcept>

template <typename T>
class ResourceManager {
public:
    using DeleterType = std::function<void(T*)>;

    // Default constructor - no resource
    ResourceManager() noexcept
        : m_resource(nullptr), m_deleter(DefaultDeleter) {}

    // Constructor with raw pointer and optional custom deleter
    explicit ResourceManager(T* resource, DeleterType deleter = DefaultDeleter)
        : m_resource(resource), m_deleter(std::move(deleter)) {}

    // Destructor - RAII cleanup
    ~ResourceManager() {
        cleanup();
    }

    // Delete copy constructor and copy assignment (unique ownership)
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource), m_deleter(std::move(other.m_deleter)) {
        other.m_resource = nullptr;
    }

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            m_resource = other.m_resource;
            m_deleter = std::move(other.m_deleter);
            other.m_resource = nullptr;
        }
        return *this;
    }

    // Reset with a new resource (and optional new deleter)
    void reset(T* resource = nullptr, DeleterType deleter = DefaultDeleter) {
        cleanup();
        m_resource = resource;
        m_deleter = std::move(deleter);
    }

    // Release ownership without deleting
    T* release() noexcept {
        T* temp = m_resource;
        m_resource = nullptr;
        return temp;
    }

    // Access the managed resource
    T* get() const noexcept {
        return m_resource;
    }

    // Dereference operators
    T& operator*() const {
        if (!m_resource) {
            throw std::runtime_error("Dereferencing a null ResourceManager");
        }
        return *m_resource;
    }

    T* operator->() const {
        if (!m_resource) {
            throw std::runtime_error("Accessing member through a null ResourceManager");
        }
        return m_resource;
    }

    // Boolean conversion - check if resource is held
    explicit operator bool() const noexcept {
        return m_resource != nullptr;
    }

    // Swap
    void swap(ResourceManager& other) noexcept {
        std::swap(m_resource, other.m_resource);
        std::swap(m_deleter, other.m_deleter);
    }

private:
    T* m_resource;
    DeleterType m_deleter;

    static void DefaultDeleter(T* ptr) {
        delete ptr;
    }

    void cleanup() {
        if (m_resource) {
            if (m_deleter) {
                m_deleter(m_resource);
            }
            m_resource = nullptr;
        }
    }
};

// Non-member swap
template <typename T>
void swap(ResourceManager<T>& lhs, ResourceManager<T>& rhs) noexcept {
    lhs.swap(rhs);
}

// Factory function similar to std::make_unique
template <typename T, typename... Args>
ResourceManager<T> makeResource(Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...));
}

// Specialization for array types
template <typename T>
class ResourceManager<T[]> {
public:
    using DeleterType = std::function<void(T*)>;

    ResourceManager() noexcept
        : m_resource(nullptr), m_size(0), m_deleter(DefaultArrayDeleter) {}

    explicit ResourceManager(T* resource, std::size_t size, DeleterType deleter = DefaultArrayDeleter)
        : m_resource(resource), m_size(size), m_deleter(std::move(deleter)) {}

    ~ResourceManager() {
        cleanup();
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource), m_size(other.m_size), m_deleter(std::move(other.m_deleter)) {
        other.m_resource = nullptr;
        other.m_size = 0;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            m_resource = other.m_resource;
            m_size = other.m_size;
            m_deleter = std::move(other.m_deleter);
            other.m_resource = nullptr;
            other.m_size = 0;
        }
        return *this;
    }

    void reset(T* resource = nullptr, std::size_t size = 0, DeleterType deleter = DefaultArrayDeleter) {
        cleanup();
        m_resource = resource;
        m_size = size;
        m_deleter = std::move(deleter);
    }

    T* release() noexcept {
        T* temp = m_resource;
        m_resource = nullptr;
        m_size = 0;
        return temp;
    }

    T* get() const noexcept {
        return m_resource;
    }

    std::size_t size() const noexcept {
        return m_size;
    }

    T& operator[](std::size_t index) const {
        if (!m_resource || index >= m_size) {
            throw std::out_of_range("ResourceManager array index out of range");
        }
        return m_resource[index];
    }

    explicit operator bool() const noexcept {
        return m_resource != nullptr;
    }

    void swap(ResourceManager& other) noexcept {
        std::swap(m_resource, other.m_resource);
        std::swap(m_size, other.m_size);
        std::swap(m_deleter, other.m_deleter);
    }

private:
    T* m_resource;
    std::size_t m_size;
    DeleterType m_deleter;

    static void DefaultArrayDeleter(T* ptr) {
        delete[] ptr;
    }

    void cleanup() {
        if (m_resource) {
            if (m_deleter) {
                m_deleter(m_resource);
            }
            m_resource = nullptr;
            m_size = 0;
        }
    }
};

// --- Demo / Test ---

struct DatabaseConnection {
    int id;
    DatabaseConnection(int connId) : id(connId) {
        std::cout << "  [DB] Connection " << id << " opened.\n";
    }
    ~DatabaseConnection() {
        std::cout << "  [DB] Connection " << id << " closed.\n";
    }
    void query(const std::string& sql) const {
        std::cout << "  [DB] Connection " << id << " executing: " << sql << "\n";
    }
};

struct FileHandle {
    std::string filename;
    FileHandle(const std::string& name) : filename(name) {
        std::cout << "  [File] Opened: " << filename << "\n";
    }
    ~FileHandle() {
        std::cout << "  [File] Closed: " << filename << "\n";
    }
};

int main() {
    std::cout << "=== Test 1: Basic RAII lifecycle ===\n";
    {
        ResourceManager<DatabaseConnection> dbConn(new DatabaseConnection(1));
        dbConn->query("SELECT * FROM users");
        std::cout << "  Connection id: " << (*dbConn).id << "\n";
    }
    std::cout << "  (Scope ended, resource should be cleaned up)\n\n";

    std::cout << "=== Test 2: Early cleanup with reset() ===\n";
    {
        ResourceManager<DatabaseConnection> dbConn(new DatabaseConnection(2));
        dbConn->query("INSERT INTO logs VALUES(...)");
        std::cout << "  Calling reset()...\n";
        dbConn.reset();
        std::cout << "  Resource is now " << (dbConn ? "valid" : "null") << "\n";
        std::cout << "  Resetting with new resource...\n";
        dbConn.reset(new DatabaseConnection(3));
        dbConn->query("UPDATE config SET value='new'");
    }
    std::cout << "\n";

    std::cout << "=== Test 3: Move semantics ===\n";
    {
        ResourceManager<FileHandle> file1(new FileHandle("data.txt"));
        std::cout << "  file1 is " << (file1 ? "valid" : "null") << "\n";

        ResourceManager<FileHandle> file2(std::move(file1));
        std::cout << "  After move construction:\n";
        std::cout << "  file1 is " << (file1 ? "valid" : "null") << "\n";
        std::cout << "  file2 is " << (file2 ? "valid" : "null")
                  << " (" << file2->filename << ")\n";

        ResourceManager<FileHandle> file3;
        file3 = std::move(file2);
        std::cout << "  After move assignment:\n";
        std::cout << "  file2 is " << (file2 ? "valid" : "null") << "\n";
        std::cout << "  file3 is " << (file3 ? "valid" : "null")
                  << " (" << file3->filename << ")\n";
    }
    std::cout << "\n";

    std::cout << "=== Test 4: Custom deleter ===\n";
    {
        auto customDeleter = [](DatabaseConnection* ptr) {
            std::cout << "  [Custom] Cleaning up connection " << ptr->id << " with custom logic.\n";
            delete ptr;
        };
        ResourceManager<DatabaseConnection> dbConn(new DatabaseConnection(42), customDeleter);
        dbConn->query("CUSTOM QUERY");
    }
    std::cout << "\n";

    std::cout << "=== Test 5: release() - transfer ownership out ===\n";
    {
        ResourceManager<FileHandle> file(new FileHandle("important.log"));
        FileHandle* rawPtr = file.release();
        std::cout << "  After release, manager is " << (file ? "valid" : "null") << "\n";
        std::cout << "  Raw pointer file: " << rawPtr->filename << "\n";
        delete rawPtr; // Manual cleanup since we released ownership
    }
    std::cout << "\n";

    std::cout << "=== Test 6: Factory function ===\n";
    {
        auto conn = makeResource<DatabaseConnection>(99);
        conn->query("SELECT COUNT(*) FROM orders");
    }
    std::cout << "\n";

    std::cout << "=== Test 7: Array specialization ===\n";
    {
        ResourceManager<int[]> arr(new int[5], 5);
        for (std::size_t i = 0; i < arr.size(); ++i) {
            arr[i] = static_cast<int>(i * 10);
        }
        std::cout << "  Array contents: ";
        for (std::size_t i = 0; i < arr.size(); ++i) {
            std::cout << arr[i] << " ";
        }
        std::cout << "\n";

        // Test bounds checking
        try {
            arr[10] = 42;
        } catch (const std::out_of_range& e) {
            std::cout << "  Caught expected exception: " << e.what() << "\n";
        }
    }
    std::cout << "\n";

    std::cout << "=== Test 8: Swap ===\n";
    {
        ResourceManager<FileHandle> f1(new FileHandle("alpha.txt"));
        ResourceManager<FileHandle> f2(new FileHandle("beta.txt"));
        std::cout << "  Before swap: f1=" << f1->filename << ", f2=" << f2->filename << "\n";
        swap(f1, f2);
        std::cout << "  After swap:  f1=" << f1->filename << ", f2=" << f2->filename << "\n";
    }
    std::cout << "\n";

    std::cout << "All tests complete.\n";
    return 0;
}