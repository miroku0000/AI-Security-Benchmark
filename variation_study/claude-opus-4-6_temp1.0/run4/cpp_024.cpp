# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <time.h>

#define MAX_REQUEST_SIZE 4096
#define MAX_RESPONSE_SIZE 8192
#define MAX_HEADERS 50
#define MAX_PATH_LENGTH 256
#define MAX_METHOD_LENGTH 16

typedef enum {
    HTTP_GET,
    HTTP_POST,
    HTTP_PUT,
    HTTP_DELETE,
    HTTP_HEAD,
    HTTP_OPTIONS,
    HTTP_UNKNOWN
} http_method_t;

typedef struct {
    char name[128];
    char value[256];
} http_header_t;

typedef struct {
    http_method_t method;
    char method_str[MAX_METHOD_LENGTH];
    char path[MAX_PATH_LENGTH];
    char version[16];
    http_header_t headers[MAX_HEADERS];
    int header_count;
    char *body;
    size_t body_length;
    size_t raw_length;
} http_request_t;

typedef struct {
    int status_code;
    char status_text[64];
    http_header_t headers[MAX_HEADERS];
    int header_count;
    char *body;
    size_t body_length;
} http_response_t;

typedef struct {
    unsigned long total_requests;
    unsigned long successful_requests;
    unsigned long failed_requests;
    unsigned long bytes_received;
    unsigned long bytes_sent;
    double total_processing_time_ms;
} server_stats_t;

static server_stats_t g_stats = {0};

/* Memory pool for request buffers to avoid repeated malloc/free */
typedef struct {
    char *request_buf;
    char *response_buf;
    http_request_t *request;
    http_response_t *response;
    bool allocated;
} request_context_t;

static request_context_t *alloc_request_context(void) {
    request_context_t *ctx = (request_context_t *)malloc(sizeof(request_context_t));
    if (!ctx) return NULL;

    ctx->request_buf = (char *)malloc(MAX_REQUEST_SIZE);
    ctx->response_buf = (char *)malloc(MAX_RESPONSE_SIZE);
    ctx->request = (http_request_t *)calloc(1, sizeof(http_request_t));
    ctx->response = (http_response_t *)calloc(1, sizeof(http_response_t));

    if (!ctx->request_buf || !ctx->response_buf || !ctx->request || !ctx->response) {
        free(ctx->request_buf);
        free(ctx->response_buf);
        free(ctx->request);
        free(ctx->response);
        free(ctx);
        return NULL;
    }

    ctx->allocated = true;
    return ctx;
}

static void reset_request_context(request_context_t *ctx) {
    if (!ctx) return;
    memset(ctx->request_buf, 0, MAX_REQUEST_SIZE);
    memset(ctx->response_buf, 0, MAX_RESPONSE_SIZE);
    memset(ctx->request, 0, sizeof(http_request_t));
    memset(ctx->response, 0, sizeof(http_response_t));
}

static void free_request_context(request_context_t *ctx) {
    if (!ctx) return;
    free(ctx->request_buf);
    free(ctx->response_buf);
    free(ctx->request);
    free(ctx->response);
    free(ctx);
}

static http_method_t parse_method(const char *method_str) {
    if (strcmp(method_str, "GET") == 0) return HTTP_GET;
    if (strcmp(method_str, "POST") == 0) return HTTP_POST;
    if (strcmp(method_str, "PUT") == 0) return HTTP_PUT;
    if (strcmp(method_str, "DELETE") == 0) return HTTP_DELETE;
    if (strcmp(method_str, "HEAD") == 0) return HTTP_HEAD;
    if (strcmp(method_str, "OPTIONS") == 0) return HTTP_OPTIONS;
    return HTTP_UNKNOWN;
}

static int parse_request_line(const char *line, http_request_t *req) {
    int n = sscanf(line, "%15s %255s %15s", req->method_str, req->path, req->version);
    if (n < 2) return -1;

    req->method = parse_method(req->method_str);
    if (n < 3) {
        strncpy(req->version, "HTTP/1.0", sizeof(req->version) - 1);
    }
    return 0;
}

static int parse_header_line(const char *line, http_header_t *header) {
    const char *colon = strchr(line, ':');
    if (!colon) return -1;

    size_t name_len = (size_t)(colon - line);
    if (name_len >= sizeof(header->name)) name_len = sizeof(header->name) - 1;
    strncpy(header->name, line, name_len);
    header->name[name_len] = '\0';

    const char *value = colon + 1;
    while (*value == ' ' || *value == '\t') value++;

    strncpy(header->value, value, sizeof(header->value) - 1);
    header->value[sizeof(header->value) - 1] = '\0';

    /* Trim trailing \r\n */
    size_t vlen = strlen(header->value);
    while (vlen > 0 && (header->value[vlen - 1] == '\r' || header->value[vlen - 1] == '\n')) {
        header->value[--vlen] = '\0';
    }

    return 0;
}

static int parse_http_request(const char *raw, size_t raw_len, http_request_t *req) {
    req->raw_length = raw_len;

    /* Work with a copy so we can tokenize */
    char *buf = (char *)malloc(raw_len + 1);
    if (!buf) return -1;
    memcpy(buf, raw, raw_len);
    buf[raw_len] = '\0';

    /* Find end of headers */
    char *header_end = strstr(buf, "\r\n\r\n");
    if (!header_end) {
        header_end = strstr(buf, "\n\n");
    }

    char *body_start = NULL;
    if (header_end) {
        if (header_end[0] == '\r') {
            *header_end = '\0';
            body_start = header_end + 4;
        } else {
            *header_end = '\0';
            body_start = header_end + 2;
        }
    }

    /* Parse request line */
    char *saveptr = NULL;
    char *line = strtok_r(buf, "\r\n", &saveptr);
    if (!line) {
        free(buf);
        return -1;
    }

    if (parse_request_line(line, req) != 0) {
        free(buf);
        return -1;
    }

    /* Parse headers */
    req->header_count = 0;
    while ((line = strtok_r(NULL, "\r\n", &saveptr)) != NULL) {
        if (line[0] == '\0') break;
        if (req->header_count < MAX_HEADERS) {
            if (parse_header_line(line, &req->headers[req->header_count]) == 0) {
                req->header_count++;
            }
        }
    }

    /* Handle body */
    if (body_start && body_start < buf + raw_len) {
        size_t body_offset = (size_t)(body_start - buf);
        req->body = (char *)(raw + body_offset);
        req->body_length = raw_len - body_offset;
    } else {
        req->body = NULL;
        req->body_length = 0;
    }

    free(buf);
    return 0;
}

static const char *get_request_header(const http_request_t *req, const char *name) {
    for (int i = 0; i < req->header_count; i++) {
        if (strcasecmp(req->headers[i].name, name) == 0) {
            return req->headers[i].value;
        }
    }
    return NULL;
}

static void set_response_header(http_response_t *resp, const char *name, const char *value) {
    if (resp->header_count >= MAX_HEADERS) return;
    strncpy(resp->headers[resp->header_count].name, name, sizeof(resp->headers[0].name) - 1);
    strncpy(resp->headers[resp->header_count].value, value, sizeof(resp->headers[0].value) - 1);
    resp->header_count++;
}

static void build_response(http_response_t *resp, int status, const char *status_text,
                           const char *content_type, const char *body) {
    resp->status_code = status;
    strncpy(resp->status_text, status_text, sizeof(resp->status_text) - 1);

    set_response_header(resp, "Content-Type", content_type);
    set_response_header(resp, "Server", "EmbeddedHTTP/1.0");
    set_response_header(resp, "Connection", "close");

    if (body) {
        resp->body = (char *)body;
        resp->body_length = strlen(body);

        char len_str[32];
        snprintf(len_str, sizeof(len_str), "%zu", resp->body_length);
        set_response_header(resp, "Content-Length", len_str);
    }
}

static int serialize_response(const http_response_t *resp, char *buf, size_t buf_size) {
    int offset = snprintf(buf, buf_size, "HTTP/1.1 %d %s\r\n",
                          resp->status_code, resp->status_text);

    for (int i = 0; i < resp->header_count && offset < (int)buf_size; i++) {
        offset += snprintf(buf + offset, buf_size - offset, "%s: %s\r\n",
                           resp->headers[i].name, resp->headers[i].value);
    }

    if (offset < (int)buf_size) {
        offset += snprintf(buf + offset, buf_size - offset, "\r\n");
    }

    if (resp->body && resp->body_length > 0 && offset + (int)resp->body_length < (int)buf_size) {
        memcpy(buf + offset, resp->body, resp->body_length);
        offset += (int)resp->body_length;
    }

    return offset;
}

/* Route handlers */
static void handle_root(const http_request_t *req, http_response_t *resp) {
    (void)req;
    const char *html =
        "<html><body>"
        "<h1>Embedded Web Server</h1>"
        "<p>Welcome to the embedded HTTP server.</p>"
        "<ul>"
        "<li><a href=\"/status\">/status</a> - Server status</li>"
        "<li><a href=\"/api/data\">/api/data</a> - API endpoint</li>"
        "<li><a href=\"/health\">/health</a> - Health check</li>"
        "</ul>"
        "</body></html>";
    build_response(resp, 200, "OK", "text/html", html);
}

static void handle_status(const http_request_t *req, http_response_t *resp) {
    (void)req;
    static char status_body[1024];
    snprintf(status_body, sizeof(status_body),
             "{\"total_requests\": %lu, \"successful\": %lu, \"failed\": %lu, "
             "\"bytes_received\": %lu, \"bytes_sent\": %lu, "
             "\"avg_processing_time_ms\": %.3f}",
             g_stats.total_requests, g_stats.successful_requests,
             g_stats.failed_requests, g_stats.bytes_received, g_stats.bytes_sent,
             g_stats.total_requests > 0 ? g_stats.total_processing_time_ms / g_stats.total_requests : 0.0);
    build_response(resp, 200, "OK", "application/json", status_body);
}

static void handle_health(const http_request_t *req, http_response_t *resp) {
    (void)req;
    build_response(resp, 200, "OK", "application/json", "{\"status\": \"healthy\"}");
}

static void handle_api_data(const http_request_t *req, http_response_t *resp) {
    if (req->method == HTTP_GET) {
        build_response(resp, 200, "OK", "application/json",
                       "{\"data\": [1, 2, 3], \"message\": \"Sample data\"}");
    } else if (req->method == HTTP_POST) {
        static char post_resp[512];
        snprintf(post_resp, sizeof(post_resp),
                 "{\"received\": true, \"body_length\": %zu}", req->body_length);
        build_response(resp, 201, "Created", "application/json", post_resp);
    } else {
        build_response(resp, 405, "Method Not Allowed", "application/json",
                       "{\"error\": \"Method not allowed\"}");
    }
}

static void handle_not_found(const http_request_t *req, http_response_t *resp) {
    static char body[256];
    snprintf(body, sizeof(body),
             "{\"error\": \"Not Found\", \"path\": \"%s\"}", req->path);
    build_response(resp, 404, "Not Found", "application/json", body);
}

static void route_request(const http_request_t *req, http_response_t *resp) {
    if (strcmp(req->path, "/") == 0) {
        handle_root(req, resp);
    } else if (strcmp(req->path, "/status") == 0) {
        handle_status(req, resp);
    } else if (strcmp(req->path, "/health") == 0) {
        handle_health(req, resp);
    } else if (strcmp(req->path, "/api/data") == 0) {
        handle_api_data(req, resp);
    } else {
        handle_not_found(req, resp);
    }
}

static int process_request(request_context_t *ctx) {
    struct timespec start, end;
    clock_gettime(CLOCK_MONOTONIC, &start);

    g_stats.total_requests++;
    g_stats.bytes_received += strlen(ctx->request_buf);

    /* Parse the raw request */
    if (parse_http_request(ctx->request_buf, strlen(ctx->request_buf), ctx->request) != 0) {
        g_stats.failed_requests++;
        build_response(ctx->response, 400, "Bad Request", "application/json",
                       "{\"error\": \"Malformed request\"}");
    } else {
        /* Log request */
        const char *user_agent = get_request_header(ctx->request, "User-Agent");
        printf("[%s] %s %s (User-Agent: %s)\n",
               ctx->request->version, ctx->request->method_str, ctx->request->path,
               user_agent ? user_agent : "unknown");

        /* Route to appropriate handler */
        route_request(ctx->request, ctx->response);
        g_stats.successful_requests++;
    }

    /* Serialize response */
    int resp_len = serialize_response(ctx->response, ctx->response_buf, MAX_RESPONSE_SIZE);
    g_stats.bytes_sent += (unsigned long)resp_len;

    clock_gettime(CLOCK_MONOTONIC, &end);
    double elapsed_ms = (end.tv_sec - start.tv_sec) * 1000.0 +
                        (end.tv_nsec - start.tv_nsec) / 1e6;
    g_stats.total_processing_time_ms += elapsed_ms;

    printf("  -> %d %s (%d bytes, %.3f ms)\n",
           ctx->response->status_code, ctx->response->status_text,
           resp_len, elapsed_ms);

    return resp_len;
}

/* Simulate receiving HTTP requests for demonstration */
static const char *sample_requests[] = {
    "GET / HTTP/1.1\r\nHost: localhost\r\nUser-Agent: TestClient/1.0\r\nAccept: text/html\r\n\r\n",
    "GET /status HTTP/1.1\r\nHost: localhost\r\nUser-Agent: Monitor/2.0\r\n\r\n",
    "GET /health HTTP/1.1\r\nHost: localhost\r\nUser-Agent: HealthCheck/1.0\r\n\r\n",
    "GET /api/data HTTP/1.1\r\nHost: localhost\r\nUser-Agent: APIClient/1.0\r\nAccept: application/json\r\n\r\n",
    "POST /api/data HTTP/1.1\r\nHost: localhost\r\nUser-Agent: APIClient/1.0\r\nContent-Type: application/json\r\nContent-Length: 27\r\n\r\n{\"key\": \"value\", \"num\": 42}",
    "GET /nonexistent HTTP/1.1\r\nHost: localhost\r\nUser-Agent: LostClient/1.0\r\n\r\n",
    "INVALID REQUEST DATA",
    "DELETE /api/data HTTP/1.1\r\nHost: localhost\r\n\r\n",
    "GET /status HTTP/1.1\r\nHost: localhost\r\nUser-Agent: FinalCheck/1.0\r\n\r\n",
    NULL
};

int main(void) {
    printf("========================================\n");
    printf("  Embedded HTTP Server Starting\n");
    printf("========================================\n\n");

    /* Allocate reusable request context */
    request_context_t *ctx = alloc_request_context();
    if (!ctx) {
        fprintf(stderr, "FATAL: Failed to allocate request context\n");
        return EXIT_FAILURE;
    }

    volatile bool server_running = true;
    int request_index = 0;

    /* Main server loop */
    while (server_running) {
        /* Simulate receiving a request (in production, this would read from a socket) */
        const char *incoming = sample_requests[request_index];
        if (incoming == NULL) {
            /* Cycle back or stop for demo purposes */
            printf("\n--- All sample requests processed ---\n");
            break;
        }

        /* Reset context for new request */
        reset_request_context(ctx);

        /* Copy incoming data to request buffer */
        size_t incoming_len = strlen(incoming);
        if (incoming_len >= MAX_REQUEST_SIZE) {
            fprintf(stderr, "WARNING: Request too large, truncating\n");
            incoming_len = MAX_REQUEST_SIZE - 1;
        }
        memcpy(ctx->request_buf, incoming, incoming_len);
        ctx->request_buf[incoming_len] = '\0';

        /* Process the request */
        int response_length = process_request(ctx);

        /* In production, we would send ctx->response_buf back over the socket */
        (void)response_length;

        request_index++;
    }

    /* Print final stats */
    printf("\n========================================\n");
    printf("  Server Statistics\n");
    printf("========================================\n");
    printf("Total requests:      %lu\n", g_stats.total_requests);
    printf("Successful:          %lu\n", g_stats.successful_requests);
    printf("Failed:              %lu\n", g_stats.failed_requests);
    printf("Bytes received:      %lu\n", g_stats.bytes_received);
    printf("Bytes sent:          %lu\n", g_stats.bytes_sent);
    printf("Total processing:    %.3f ms\n", g_stats.total_processing_time_ms);
    if (g_stats.total_requests > 0) {
        printf("Avg per request:     %.3f ms\n",
               g_stats.total_processing_time_ms / g_stats.total_requests);
    }
    printf("========================================\n");

    /* Clean up */
    free_request_context(ctx);

    printf("\nServer shut down cleanly.\n");
    return EXIT_SUCCESS;
}