# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <string>
#include <algorithm>
#include <chrono>
#include <ctime>
#include <stdexcept>

class Session {
public:
    std::string sessionId;
    std::string username;
    std::chrono::steady_clock::time_point createdAt;
    std::chrono::steady_clock::time_point lastAccessedAt;
    int timeoutSeconds;

    Session(const std::string& id, const std::string& user, int timeout = 3600)
        : sessionId(id), username(user), timeoutSeconds(timeout) {
        createdAt = std::chrono::steady_clock::now();
        lastAccessedAt = createdAt;
    }

    bool isExpired() const {
        auto now = std::chrono::steady_clock::now();
        auto elapsed = std::chrono::duration_cast<std::chrono::seconds>(now - lastAccessedAt).count();
        return elapsed >= timeoutSeconds;
    }

    void touch() {
        lastAccessedAt = std::chrono::steady_clock::now();
    }
};

class SessionManager {
private:
    std::vector<Session*> sessions;

    int findIndexById(const std::string& sessionId) const {
        for (size_t i = 0; i < sessions.size(); ++i) {
            if (sessions[i]->sessionId == sessionId) {
                return static_cast<int>(i);
            }
        }
        return -1;
    }

public:
    SessionManager() = default;

    ~SessionManager() {
        removeAllSessions();
    }

    // Prevent copying to avoid double-free issues
    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    // Allow move semantics
    SessionManager(SessionManager&& other) noexcept : sessions(std::move(other.sessions)) {
        other.sessions.clear();
    }

    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this != &other) {
            removeAllSessions();
            sessions = std::move(other.sessions);
            other.sessions.clear();
        }
        return *this;
    }

    Session* addSession(const std::string& sessionId, const std::string& username, int timeoutSeconds = 3600) {
        // Check if session with same ID already exists
        int idx = findIndexById(sessionId);
        if (idx != -1) {
            throw std::runtime_error("Session with ID '" + sessionId + "' already exists.");
        }

        Session* session = new Session(sessionId, username, timeoutSeconds);
        sessions.push_back(session);
        return session;
    }

    bool removeSession(const std::string& sessionId) {
        int idx = findIndexById(sessionId);
        if (idx == -1) {
            return false;
        }

        delete sessions[idx];
        sessions.erase(sessions.begin() + idx);
        return true;
    }

    Session* getSession(const std::string& sessionId) {
        int idx = findIndexById(sessionId);
        if (idx == -1) {
            return nullptr;
        }

        Session* session = sessions[idx];
        if (session->isExpired()) {
            // Session has expired, clean it up
            delete session;
            sessions.erase(sessions.begin() + idx);
            return nullptr;
        }

        session->touch();
        return session;
    }

    const Session* getSession(const std::string& sessionId) const {
        int idx = findIndexById(sessionId);
        if (idx == -1) {
            return nullptr;
        }
        return sessions[idx];
    }

    Session* getSessionByIndex(size_t index) {
        if (index >= sessions.size()) {
            throw std::out_of_range("Session index out of range.");
        }
        return sessions[index];
    }

    size_t getSessionCount() const {
        return sessions.size();
    }

    int cleanupExpiredSessions() {
        int removedCount = 0;
        auto it = sessions.begin();
        while (it != sessions.end()) {
            if ((*it)->isExpired()) {
                delete *it;
                it = sessions.erase(it);
                ++removedCount;
            } else {
                ++it;
            }
        }
        return removedCount;
    }

    void removeAllSessions() {
        for (Session* session : sessions) {
            delete session;
        }
        sessions.clear();
    }

    bool hasSession(const std::string& sessionId) const {
        return findIndexById(sessionId) != -1;
    }

    std::vector<std::string> getActiveSessionIds() const {
        std::vector<std::string> ids;
        for (const Session* session : sessions) {
            if (!session->isExpired()) {
                ids.push_back(session->sessionId);
            }
        }
        return ids;
    }

    void printSessions() const {
        std::cout << "=== Session Manager (" << sessions.size() << " sessions) ===" << std::endl;
        for (const Session* session : sessions) {
            auto elapsed = std::chrono::duration_cast<std::chrono::seconds>(
                std::chrono::steady_clock::now() - session->lastAccessedAt).count();
            std::cout << "  ID: " << session->sessionId
                      << " | User: " << session->username
                      << " | Idle: " << elapsed << "s"
                      << " | Timeout: " << session->timeoutSeconds << "s"
                      << " | Expired: " << (session->isExpired() ? "Yes" : "No")
                      << std::endl;
        }
        std::cout << "===========================================" << std::endl;
    }
};

// Demo / test
int main() {
    SessionManager manager;

    // Add sessions
    manager.addSession("sess_001", "alice", 3600);
    manager.addSession("sess_002", "bob", 2);      // 2-second timeout for testing
    manager.addSession("sess_003", "charlie", 3600);

    std::cout << "After adding 3 sessions:" << std::endl;
    manager.printSessions();

    // Access a session
    Session* s = manager.getSession("sess_001");
    if (s) {
        std::cout << "Accessed session for user: " << s->username << std::endl;
    }

    // Check existence
    std::cout << "Has sess_002: " << (manager.hasSession("sess_002") ? "yes" : "no") << std::endl;
    std::cout << "Has sess_999: " << (manager.hasSession("sess_999") ? "yes" : "no") << std::endl;

    // Remove a session manually
    manager.removeSession("sess_003");
    std::cout << "\nAfter removing sess_003:" << std::endl;
    manager.printSessions();

    // Wait for sess_002 to expire
    std::cout << "\nWaiting for sess_002 to expire..." << std::endl;
    // Simulate passage of time by sleeping
    auto start = std::chrono::steady_clock::now();
    while (std::chrono::duration_cast<std::chrono::seconds>(
               std::chrono::steady_clock::now() - start).count() < 3) {
        // busy wait
    }

    // Cleanup expired sessions
    int cleaned = manager.cleanupExpiredSessions();
    std::cout << "Cleaned up " << cleaned << " expired session(s)." << std::endl;
    manager.printSessions();

    // Get active session IDs
    auto activeIds = manager.getActiveSessionIds();
    std::cout << "Active sessions: ";
    for (const auto& id : activeIds) {
        std::cout << id << " ";
    }
    std::cout << std::endl;

    std::cout << "\nTotal sessions: " << manager.getSessionCount() << std::endl;

    // Destructor will clean up remaining sessions
    return 0;
}