# Generated by anthropic (claude-opus-4-6)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdio.h>
#include <string.h>

typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    float vibration;
    uint32_t timestamp;
    uint8_t sensor_status;
    uint8_t data_ready;
} SensorData_t;

volatile SensorData_t sensor_data = {0};

SemaphoreHandle_t xSensorMutex;

TaskHandle_t xSensorReadTaskHandle = NULL;
TaskHandle_t xControlLogicTaskHandle = NULL;

/* Simulated hardware sensor read functions */
static float read_temperature_sensor(void)
{
    /* Replace with actual hardware register read */
    static float temp = 25.0f;
    temp += 0.1f;
    if (temp > 80.0f) temp = 25.0f;
    return temp;
}

static float read_pressure_sensor(void)
{
    static float pressure = 101.3f;
    pressure += 0.05f;
    if (pressure > 110.0f) pressure = 101.3f;
    return pressure;
}

static float read_flow_rate_sensor(void)
{
    static float flow = 50.0f;
    flow += 0.2f;
    if (flow > 100.0f) flow = 50.0f;
    return flow;
}

static float read_vibration_sensor(void)
{
    static float vib = 0.5f;
    vib += 0.01f;
    if (vib > 5.0f) vib = 0.5f;
    return vib;
}

static uint32_t get_system_timestamp(void)
{
    return xTaskGetTickCount();
}

/* Control output functions */
static void actuate_cooling_system(float duty_cycle)
{
    (void)duty_cycle;
    /* Replace with actual PWM/DAC output */
}

static void actuate_pressure_valve(float opening_pct)
{
    (void)opening_pct;
    /* Replace with actual valve control */
}

static void trigger_emergency_shutdown(void)
{
    /* Replace with actual emergency stop logic */
    printf("[ALARM] Emergency shutdown triggered!\n");
}

static void report_system_status(const SensorData_t *data, float cooling, float valve)
{
    printf("[STATUS] T=%.1f P=%.1f F=%.1f V=%.2f Cool=%.1f%% Valve=%.1f%% @%lu\n",
           data->temperature, data->pressure, data->flow_rate,
           data->vibration, cooling, valve, (unsigned long)data->timestamp);
}

/*
 * Task 1: Sensor Read Task
 * Priority: High (time-critical sensor acquisition)
 * Period: 10ms (100 Hz sampling rate)
 */
void vSensorReadTask(void *pvParameters)
{
    (void)pvParameters;
    TickType_t xLastWakeTime;
    const TickType_t xPeriod = pdMS_TO_TICKS(10);
    float temp, pressure, flow, vibration;
    uint32_t timestamp;
    uint8_t status;

    xLastWakeTime = xTaskGetTickCount();

    for (;;)
    {
        /* Read all sensors outside the critical section to minimize lock time */
        temp = read_temperature_sensor();
        pressure = read_pressure_sensor();
        flow = read_flow_rate_sensor();
        vibration = read_vibration_sensor();
        timestamp = get_system_timestamp();

        /* Validate sensor readings */
        status = 0x00;
        if (temp < -40.0f || temp > 150.0f)
            status |= 0x01;
        if (pressure < 0.0f || pressure > 200.0f)
            status |= 0x02;
        if (flow < 0.0f || flow > 500.0f)
            status |= 0x04;
        if (vibration < 0.0f || vibration > 50.0f)
            status |= 0x08;

        /* Acquire mutex with a bounded timeout to avoid indefinite blocking */
        if (xSemaphoreTake(xSensorMutex, pdMS_TO_TICKS(5)) == pdTRUE)
        {
            /* Update the shared struct atomically from the consumer's perspective */
            sensor_data.temperature = temp;
            sensor_data.pressure = pressure;
            sensor_data.flow_rate = flow;
            sensor_data.vibration = vibration;
            sensor_data.timestamp = timestamp;
            sensor_data.sensor_status = status;

            /* Memory barrier to ensure all writes are visible before setting flag */
            __asm volatile ("dmb" ::: "memory");

            sensor_data.data_ready = 1;

            xSemaphoreGive(xSensorMutex);

            /* Notify control task that new data is available */
            xTaskNotifyGive(xControlLogicTaskHandle);
        }
        else
        {
            /* Mutex timeout - log error, sensor data dropped this cycle */
            printf("[ERROR] Sensor task mutex timeout at tick %lu\n",
                   (unsigned long)xTaskGetTickCount());
        }

        /* Use vTaskDelayUntil for deterministic periodic execution */
        vTaskDelayUntil(&xLastWakeTime, xPeriod);
    }
}

/*
 * Task 2: Control Logic Task
 * Priority: Medium (runs after sensor data is updated)
 * Trigger: Notification from sensor task, with 50ms max wait
 */
void vControlLogicTask(void *pvParameters)
{
    (void)pvParameters;

    SensorData_t local_data;
    float cooling_duty = 0.0f;
    float valve_opening = 50.0f;

    /* Control parameters */
    const float TEMP_SETPOINT = 45.0f;
    const float TEMP_KP = 2.0f;
    const float TEMP_KI = 0.1f;
    const float PRESSURE_SETPOINT = 105.0f;
    const float PRESSURE_KP = 1.5f;
    const float TEMP_CRITICAL = 75.0f;
    const float PRESSURE_CRITICAL = 115.0f;
    const float VIBRATION_CRITICAL = 4.0f;

    float temp_integral = 0.0f;
    float temp_error_prev = 0.0f;

    for (;;)
    {
        /* Wait for notification from sensor task with timeout */
        uint32_t notification = ulTaskNotifyTake(pdTRUE, pdMS_TO_TICKS(50));

        if (notification > 0)
        {
            /* Acquire mutex and copy data to local struct quickly */
            if (xSemaphoreTake(xSensorMutex, pdMS_TO_TICKS(5)) == pdTRUE)
            {
                /* Read barrier before copying */
                __asm volatile ("dmb" ::: "memory");

                if (sensor_data.data_ready)
                {
                    memcpy((void *)&local_data, (const void *)&sensor_data, sizeof(SensorData_t));
                    sensor_data.data_ready = 0;
                }

                xSemaphoreGive(xSensorMutex);
            }
            else
            {
                printf("[ERROR] Control task mutex timeout at tick %lu\n",
                       (unsigned long)xTaskGetTickCount());
                continue;
            }

            /* Check for sensor faults */
            if (local_data.sensor_status != 0x00)
            {
                printf("[WARN] Sensor fault detected: status=0x%02X\n",
                       local_data.sensor_status);
                /* Use last known good actuator values, don't update */
                continue;
            }

            /* === EMERGENCY CHECKS (highest priority) === */
            if (local_data.temperature > TEMP_CRITICAL ||
                local_data.pressure > PRESSURE_CRITICAL ||
                local_data.vibration > VIBRATION_CRITICAL)
            {
                trigger_emergency_shutdown();
                cooling_duty = 100.0f;
                valve_opening = 100.0f;
                actuate_cooling_system(cooling_duty);
                actuate_pressure_valve(valve_opening);
                continue;
            }

            /* === TEMPERATURE PI CONTROL === */
            float temp_error = local_data.temperature - TEMP_SETPOINT;
            temp_integral += temp_error * 0.01f; /* dt = 10ms = 0.01s */

            /* Anti-windup clamp */
            if (temp_integral > 50.0f) temp_integral = 50.0f;
            if (temp_integral < -50.0f) temp_integral = -50.0f;

            cooling_duty = (TEMP_KP * temp_error) + (TEMP_KI * temp_integral);

            /* Clamp output */
            if (cooling_duty < 0.0f) cooling_duty = 0.0f;
            if (cooling_duty > 100.0f) cooling_duty = 100.0f;

            temp_error_prev = temp_error;

            /* === PRESSURE P CONTROL === */
            float pressure_error = local_data.pressure - PRESSURE_SETPOINT;
            valve_opening = 50.0f + (PRESSURE_KP * pressure_error);

            if (valve_opening < 0.0f) valve_opening = 0.0f;
            if (valve_opening > 100.0f) valve_opening = 100.0f;

            /* === APPLY ACTUATOR OUTPUTS === */
            actuate_cooling_system(cooling_duty);
            actuate_pressure_valve(valve_opening);

            /* Periodic status report every ~1 second (every 100 cycles at 10ms) */
            static uint32_t report_counter = 0;
            report_counter++;
            if (report_counter >= 100)
            {
                report_system_status(&local_data, cooling_duty, valve_opening);
                report_counter = 0;
            }
        }
        else
        {
            /* Notification timeout - sensor task may have stalled */
            printf("[ERROR] No sensor data received within timeout at tick %lu\n",
                   (unsigned long)xTaskGetTickCount());

            /* Fail-safe: maintain current actuator outputs or go to safe state */
        }
    }
}

/*
 * Watchdog task: monitors both tasks are running
 */
void vWatchdogTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        eTaskState sensor_state = eTaskGetState(xSensorReadTaskHandle);
        eTaskState control_state = eTaskGetState(xControlLogicTaskHandle);

        if (sensor_state == eSuspended || sensor_state == eDeleted)
        {
            printf("[CRITICAL] Sensor task not running! State=%d\n", sensor_state);
            trigger_emergency_shutdown();
        }

        if (control_state == eSuspended || control_state == eDeleted)
        {
            printf("[CRITICAL] Control task not running! State=%d\n", control_state);
            trigger_emergency_shutdown();
        }

        vTaskDelay(pdMS_TO_TICKS(1000));
    }
}

int main(void)
{
    /* Initialize the shared data structure */
    memset((void *)&sensor_data, 0, sizeof(SensorData_t));

    /* Create the mutex for shared data protection */
    xSensorMutex = xSemaphoreCreateMutex();
    if (xSensorMutex == NULL)
    {
        printf("[FATAL] Failed to create sensor mutex\n");
        for (;;);
    }

    /* Create sensor read task - highest priority for deterministic sampling */
    BaseType_t ret;
    ret = xTaskCreate(
        vSensorReadTask,
        "SensorRead",
        configMINIMAL_STACK_SIZE * 2,
        NULL,
        configMAX_PRIORITIES - 1,   /* Highest application priority */
        &xSensorReadTaskHandle
    );

    if (ret != pdPASS)
    {
        printf("[FATAL] Failed to create sensor read task\n");
        for (;;);
    }

    /* Create control logic task - one level below sensor task */
    ret = xTaskCreate(
        vControlLogicTask,
        "ControlLogic",
        configMINIMAL_STACK_SIZE * 4,
        NULL,
        configMAX_PRIORITIES - 2,
        &xControlLogicTaskHandle
    );

    if (ret != pdPASS)
    {
        printf("[FATAL] Failed to create control logic task\n");
        for (;;);
    }

    /* Create watchdog task - lowest priority */
    ret = xTaskCreate(
        vWatchdogTask,
        "Watchdog",
        configMINIMAL_STACK_SIZE,
        NULL,
        tskIDLE_PRIORITY + 1,
        NULL
    );

    if (ret != pdPASS)
    {
        printf("[FATAL] Failed to create watchdog task\n");
        for (;;);
    }

    printf("[INIT] Industrial control system starting...\n");
    printf("[INIT] Sensor task period: 10ms\n");
    printf("[INIT] Control task: event-driven with 50ms timeout\n");

    /* Start the FreeRTOS scheduler */
    vTaskStartScheduler();

    /* Should never reach here */
    printf("[FATAL] Scheduler exited unexpectedly\n");
    for (;;);

    return 0;
}

/* FreeRTOS required hooks */
void vApplicationMallocFailedHook(void)
{
    printf("[FATAL] Memory allocation failed\n");
    for (;;);
}

void vApplicationStackOverflowHook(TaskHandle_t xTask, char *pcTaskName)
{
    (void)xTask;
    printf("[FATAL] Stack overflow in task: %s\n", pcTaskName);
    for (;;);
}

void vApplicationIdleHook(void)
{
    /* Low power mode can be entered here */
}

void vApplicationTickHook(void)
{
    /* Tick hook for timing diagnostics if needed */
}