# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <memory>
#include <algorithm>
#include <numeric>
#include <cmath>
#include <iostream>
#include <chrono>

// Represents raw data coming into the pipeline
struct RawDataPoint {
    double x;
    double y;
    double z;
    int category;
    std::string label;
};

// Intermediate normalized representation
struct NormalizedData {
    double nx;
    double ny;
    double nz;
    double magnitude;
    int category;
    std::string label;

    NormalizedData(const RawDataPoint& raw) {
        magnitude = std::sqrt(raw.x * raw.x + raw.y * raw.y + raw.z * raw.z);
        if (magnitude > 0.0) {
            nx = raw.x / magnitude;
            ny = raw.y / magnitude;
            nz = raw.z / magnitude;
        } else {
            nx = ny = nz = 0.0;
        }
        category = raw.category;
        label = raw.label;
    }
};

// Intermediate filtered representation
struct FilteredData {
    double nx;
    double ny;
    double nz;
    double magnitude;
    double weight;
    std::string label;

    FilteredData(const NormalizedData& norm, double w)
        : nx(norm.nx), ny(norm.ny), nz(norm.nz),
          magnitude(norm.magnitude), weight(w), label(norm.label) {}
};

// Final transformed output
struct TransformedResult {
    double score;
    double weighted_magnitude;
    std::string label;
};

// BAD VERSION: Creates temporary objects on every call in the hot path
// This causes excessive allocations (especially due to std::string copies
// and vector reallocations) and is not suitable for high-throughput use.
std::vector<TransformedResult> transform_data_bad(const std::vector<RawDataPoint>& input) {
    std::vector<TransformedResult> results;

    for (const auto& raw : input) {
        // Step 1: Normalize - allocates a temporary NormalizedData with string copy
        auto* normalized = new NormalizedData(raw);

        // Step 2: Filter - allocates another temporary with string copy
        double weight = 1.0 / (1.0 + std::exp(-normalized->magnitude));
        auto* filtered = new FilteredData(*normalized, weight);

        delete normalized; // cleanup step 1 temp

        // Step 3: Compute final result - yet another temporary with string copy
        auto* result = new TransformedResult();
        result->score = filtered->nx * filtered->weight +
                        filtered->ny * filtered->weight +
                        filtered->nz * filtered->weight;
        result->weighted_magnitude = filtered->magnitude * filtered->weight;
        result->label = filtered->label; // another string copy

        delete filtered; // cleanup step 2 temp

        // vector may reallocate on every push_back
        results.push_back(*result);
        delete result;
    }

    return results;
}

// GOOD VERSION: Avoids unnecessary heap allocations, reuses buffers,
// minimizes copies, reserves vector capacity upfront.
class DataTransformer {
public:
    // Pre-allocated intermediate buffers
    void reserve(size_t capacity) {
        normalized_buffer_.reserve(capacity);
        filtered_buffer_.reserve(capacity);
        results_buffer_.reserve(capacity);
    }

    const std::vector<TransformedResult>& transform_data(const std::vector<RawDataPoint>& input) {
        const size_t n = input.size();

        // Reuse pre-allocated buffers instead of allocating each time
        normalized_buffer_.clear();
        filtered_buffer_.clear();
        results_buffer_.clear();

        // Ensure capacity without repeated reallocation
        if (normalized_buffer_.capacity() < n) {
            normalized_buffer_.reserve(n);
            filtered_buffer_.reserve(n);
            results_buffer_.reserve(n);
        }

        // Step 1: Normalize all — stack-like temporaries stored in contiguous buffer
        for (const auto& raw : input) {
            normalized_buffer_.emplace_back(raw);
        }

        // Step 2: Filter — use move semantics for strings to avoid copies
        for (auto& norm : normalized_buffer_) {
            double weight = 1.0 / (1.0 + std::exp(-norm.magnitude));
            filtered_buffer_.emplace_back(norm, weight);
        }

        // Release normalized buffer memory contents early (strings)
        normalized_buffer_.clear();

        // Step 3: Produce final results — move strings from filtered data
        for (auto& filt : filtered_buffer_) {
            TransformedResult result;
            result.score = filt.nx * filt.weight +
                           filt.ny * filt.weight +
                           filt.nz * filt.weight;
            result.weighted_magnitude = filt.magnitude * filt.weight;
            result.label = std::move(filt.label); // move instead of copy
            results_buffer_.push_back(std::move(result));
        }

        filtered_buffer_.clear();

        return results_buffer_;
    }

private:
    std::vector<NormalizedData> normalized_buffer_;
    std::vector<FilteredData> filtered_buffer_;
    std::vector<TransformedResult> results_buffer_;
};

// Even more optimized: single-pass, no intermediate buffers at all
class DataTransformerFused {
public:
    void reserve(size_t capacity) {
        results_buffer_.reserve(capacity);
    }

    const std::vector<TransformedResult>& transform_data(const std::vector<RawDataPoint>& input) {
        const size_t n = input.size();
        results_buffer_.clear();
        if (results_buffer_.capacity() < n) {
            results_buffer_.reserve(n);
        }

        for (const auto& raw : input) {
            // All intermediates on the stack — no heap allocation
            double magnitude = std::sqrt(raw.x * raw.x + raw.y * raw.y + raw.z * raw.z);
            double inv_mag = (magnitude > 0.0) ? (1.0 / magnitude) : 0.0;
            double nx = raw.x * inv_mag;
            double ny = raw.y * inv_mag;
            double nz = raw.z * inv_mag;
            double weight = 1.0 / (1.0 + std::exp(-magnitude));

            TransformedResult result;
            result.score = (nx + ny + nz) * weight;
            result.weighted_magnitude = magnitude * weight;
            result.label = raw.label; // single copy (unavoidable if we need our own copy)
            results_buffer_.push_back(std::move(result));
        }

        return results_buffer_;
    }

private:
    std::vector<TransformedResult> results_buffer_;
};

// Benchmark harness
int main() {
    // Generate test data
    const size_t DATA_SIZE = 100000;
    const int ITERATIONS = 100;

    std::vector<RawDataPoint> test_data(DATA_SIZE);
    for (size_t i = 0; i < DATA_SIZE; ++i) {
        test_data[i] = {
            static_cast<double>(i % 100) * 0.1,
            static_cast<double>(i % 50) * 0.2,
            static_cast<double>(i % 25) * 0.3,
            static_cast<int>(i % 5),
            "item_" + std::to_string(i)
        };
    }

    // Benchmark BAD version
    {
        auto start = std::chrono::high_resolution_clock::now();
        for (int iter = 0; iter < ITERATIONS; ++iter) {
            auto results = transform_data_bad(test_data);
            // Prevent optimization
            if (results.empty()) std::cout << "unexpected\n";
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "BAD  (temp objects, new/delete per item): " << ms << " ms for "
                  << ITERATIONS << " iterations" << std::endl;
    }

    // Benchmark GOOD version (buffered)
    {
        DataTransformer transformer;
        transformer.reserve(DATA_SIZE);

        auto start = std::chrono::high_resolution_clock::now();
        for (int iter = 0; iter < ITERATIONS; ++iter) {
            const auto& results = transformer.transform_data(test_data);
            if (results.empty()) std::cout << "unexpected\n";
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "GOOD (reused buffers, batch processing):  " << ms << " ms for "
                  << ITERATIONS << " iterations" << std::endl;
    }

    // Benchmark BEST version (fused single-pass)
    {
        DataTransformerFused transformer;
        transformer.reserve(DATA_SIZE);

        auto start = std::chrono::high_resolution_clock::now();
        for (int iter = 0; iter < ITERATIONS; ++iter) {
            const auto& results = transformer.transform_data(test_data);
            if (results.empty()) std::cout << "unexpected\n";
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "BEST (fused single-pass, stack temps):    " << ms << " ms for "
                  << ITERATIONS << " iterations" << std::endl;
    }

    return 0;
}