# Generated by anthropic (claude-opus-4-6)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

/* ============================================================================
 * ARM Cortex-M Bootloader
 * Supports: SD Card, UART firmware update, GPIO/magic word entry
 * Target: Generic Cortex-M (STM32-like register layout)
 * ============================================================================ */

/* --------------------------------------------------------------------------
 * Memory Map & Constants
 * -------------------------------------------------------------------------- */
#define BOOTLOADER_BASE         0x08000000
#define BOOTLOADER_SIZE         0x8000          /* 32KB bootloader region */
#define APP_BASE                0x08008000      /* Application start */
#define APP_MAX_SIZE            0x78000         /* 480KB max application */
#define FLASH_PAGE_SIZE         2048
#define SRAM_BASE               0x20000000
#define SRAM_SIZE               0x20000         /* 128KB SRAM */

#define MAGIC_WORD_ADDR         (SRAM_BASE + SRAM_SIZE - 4)
#define MAGIC_WORD_VALUE        0xDEADBEEF
#define FIRMWARE_MAGIC          0x464D5750      /* "FWUP" */

#define UART_BAUD_RATE          115200
#define UART_TIMEOUT_MS         5000
#define SD_FIRMWARE_FILENAME    "firmware.bin"

#define CRC32_POLYNOMIAL        0xEDB88320

/* --------------------------------------------------------------------------
 * Peripheral Base Addresses (STM32-like)
 * -------------------------------------------------------------------------- */
#define RCC_BASE                0x40021000
#define FLASH_R_BASE            0x40022000
#define GPIOA_BASE              0x48000000
#define GPIOB_BASE              0x48000400
#define GPIOC_BASE              0x48000800
#define USART1_BASE             0x40013800
#define SPI1_BASE               0x40013000
#define SYSTICK_BASE            0xE000E010
#define SCB_BASE                0xE000ED00
#define NVIC_BASE               0xE000E100

/* --------------------------------------------------------------------------
 * Register Structures
 * -------------------------------------------------------------------------- */
typedef struct {
    volatile uint32_t CR;
    volatile uint32_t CFGR;
    volatile uint32_t CIR;
    volatile uint32_t APB2RSTR;
    volatile uint32_t APB1RSTR;
    volatile uint32_t AHBENR;
    volatile uint32_t APB2ENR;
    volatile uint32_t APB1ENR;
    volatile uint32_t BDCR;
    volatile uint32_t CSR;
    volatile uint32_t AHBRSTR;
    volatile uint32_t CFGR2;
    volatile uint32_t CFGR3;
} RCC_TypeDef;

typedef struct {
    volatile uint32_t ACR;
    volatile uint32_t KEYR;
    volatile uint32_t OPTKEYR;
    volatile uint32_t SR;
    volatile uint32_t CR;
    volatile uint32_t AR;
    volatile uint32_t RESERVED;
    volatile uint32_t OBR;
    volatile uint32_t WRPR;
} FLASH_TypeDef;

typedef struct {
    volatile uint32_t MODER;
    volatile uint32_t OTYPER;
    volatile uint32_t OSPEEDR;
    volatile uint32_t PUPDR;
    volatile uint32_t IDR;
    volatile uint32_t ODR;
    volatile uint32_t BSRR;
    volatile uint32_t LCKR;
    volatile uint32_t AFR[2];
    volatile uint32_t BRR;
} GPIO_TypeDef;

typedef struct {
    volatile uint32_t CR1;
    volatile uint32_t CR2;
    volatile uint32_t CR3;
    volatile uint32_t BRR_REG;
    volatile uint32_t GTPR;
    volatile uint32_t RTOR;
    volatile uint32_t RQR;
    volatile uint32_t ISR;
    volatile uint32_t ICR;
    volatile uint32_t RDR;
    volatile uint32_t TDR;
} USART_TypeDef;

typedef struct {
    volatile uint32_t CR1;
    volatile uint32_t CR2;
    volatile uint32_t SR;
    volatile uint32_t DR;
    volatile uint32_t CRCPR;
    volatile uint32_t RXCRCR;
    volatile uint32_t TXCRCR;
    volatile uint32_t I2SCFGR;
    volatile uint32_t I2SPR;
} SPI_TypeDef;

typedef struct {
    volatile uint32_t CTRL;
    volatile uint32_t LOAD;
    volatile uint32_t VAL;
    volatile uint32_t CALIB;
} SysTick_TypeDef;

typedef struct {
    volatile uint32_t CPUID;
    volatile uint32_t ICSR;
    volatile uint32_t VTOR;
    volatile uint32_t AIRCR;
    volatile uint32_t SCR;
    volatile uint32_t CCR;
    volatile uint32_t SHP[3];
    volatile uint32_t SHCSR;
} SCB_TypeDef;

#define RCC             ((RCC_TypeDef *)RCC_BASE)
#define FLASH           ((FLASH_TypeDef *)FLASH_R_BASE)
#define GPIOA           ((GPIO_TypeDef *)GPIOA_BASE)
#define GPIOB           ((GPIO_TypeDef *)GPIOB_BASE)
#define GPIOC           ((GPIO_TypeDef *)GPIOC_BASE)
#define USART1          ((USART_TypeDef *)USART1_BASE)
#define SPI1            ((SPI_TypeDef *)SPI1_BASE)
#define SYSTICK         ((SysTick_TypeDef *)SYSTICK_BASE)
#define SCB             ((SCB_TypeDef *)SCB_BASE)

/* Flash keys */
#define FLASH_KEY1              0x45670123
#define FLASH_KEY2              0xCDEF89AB

/* Flash SR bits */
#define FLASH_SR_BSY            (1 << 0)
#define FLASH_SR_EOP            (1 << 5)

/* Flash CR bits */
#define FLASH_CR_PG             (1 << 0)
#define FLASH_CR_PER            (1 << 1)
#define FLASH_CR_STRT           (1 << 6)
#define FLASH_CR_LOCK           (1 << 7)

/* USART ISR bits */
#define USART_ISR_RXNE          (1 << 5)
#define USART_ISR_TXE           (1 << 7)
#define USART_ISR_TC            (1 << 6)

/* GPIO bootloader pin: PC13 (common user button) */
#define BOOT_GPIO_PORT          GPIOC
#define BOOT_GPIO_PIN           13
#define BOOT_GPIO_RCC_BIT       19  /* IOPCEN in AHBENR */

/* LED pin: PA5 (common on discovery/nucleo boards) */
#define LED_GPIO_PORT           GPIOA
#define LED_GPIO_PIN            5

/* SD Card CS pin: PB6 */
#define SD_CS_PORT              GPIOB
#define SD_CS_PIN               6

/* System clock assumed 8MHz HSI for fast boot */
#define SYSTEM_CLOCK            8000000

/* --------------------------------------------------------------------------
 * Firmware Header (placed at start of firmware binary)
 * -------------------------------------------------------------------------- */
typedef struct {
    uint32_t magic;             /* FIRMWARE_MAGIC */
    uint32_t version;           /* Firmware version */
    uint32_t size;              /* Payload size (excluding header) */
    uint32_t crc32;             /* CRC32 of payload */
    uint32_t entry_point;       /* Entry point address */
    uint32_t reserved[3];       /* Future use, pad to 32 bytes */
} FirmwareHeader_t;

#define FW_HEADER_SIZE          sizeof(FirmwareHeader_t)

/* --------------------------------------------------------------------------
 * XMODEM Protocol Constants
 * -------------------------------------------------------------------------- */
#define XMODEM_SOH              0x01
#define XMODEM_STX              0x02
#define XMODEM_EOT              0x04
#define XMODEM_ACK              0x06
#define XMODEM_NAK              0x15
#define XMODEM_CAN              0x18
#define XMODEM_CTRLZ            0x1A
#define XMODEM_BLOCK_SIZE       128
#define XMODEM_1K_BLOCK_SIZE    1024
#define XMODEM_MAX_RETRIES      10

/* --------------------------------------------------------------------------
 * SD Card SPI Commands
 * -------------------------------------------------------------------------- */
#define SD_CMD0     0   /* GO_IDLE_STATE */
#define SD_CMD1     1   /* SEND_OP_COND */
#define SD_CMD8     8   /* SEND_IF_COND */
#define SD_CMD16    16  /* SET_BLOCKLEN */
#define SD_CMD17    17  /* READ_SINGLE_BLOCK */
#define SD_CMD55    55  /* APP_CMD */
#define SD_CMD58    58  /* READ_OCR */
#define SD_ACMD41   41  /* SD_SEND_OP_COND */

#define SD_BLOCK_SIZE   512

/* --------------------------------------------------------------------------
 * Simple FAT16/FAT32 definitions for reading firmware file
 * -------------------------------------------------------------------------- */
typedef struct {
    uint8_t  jump[3];
    uint8_t  oem[8];
    uint16_t bytes_per_sector;
    uint8_t  sectors_per_cluster;
    uint16_t reserved_sectors;
    uint8_t  num_fats;
    uint16_t root_entry_count;
    uint16_t total_sectors_16;
    uint8_t  media_type;
    uint16_t fat_size_16;
    uint16_t sectors_per_track;
    uint16_t num_heads;
    uint32_t hidden_sectors;
    uint32_t total_sectors_32;
    /* FAT32 extended */
    uint32_t fat_size_32;
    uint16_t ext_flags;
    uint16_t fs_version;
    uint32_t root_cluster;
} __attribute__((packed)) BPB_t;

typedef struct {
    char     name[8];
    char     ext[3];
    uint8_t  attr;
    uint8_t  reserved;
    uint8_t  create_time_tenth;
    uint16_t create_time;
    uint16_t create_date;
    uint16_t access_date;
    uint16_t first_cluster_hi;
    uint16_t write_time;
    uint16_t write_date;
    uint16_t first_cluster_lo;
    uint32_t file_size;
} __attribute__((packed)) DirEntry_t;

/* --------------------------------------------------------------------------
 * Global Variables
 * -------------------------------------------------------------------------- */
static volatile uint32_t systick_ms = 0;
static uint8_t sd_buffer[SD_BLOCK_SIZE];
static bool sd_is_sdhc = false;

/* FAT filesystem state */
static uint32_t fat_start_sector;
static uint32_t data_start_sector;
static uint32_t root_dir_sector;
static uint8_t  sectors_per_cluster;
static bool     is_fat32 = false;
static uint32_t fat_size;
static uint32_t root_cluster; /* FAT32 */

/* --------------------------------------------------------------------------
 * Forward Declarations
 * -------------------------------------------------------------------------- */
static void system_init(void);
static void systick_init(void);
static void gpio_init(void);
static void uart_init(void);
static void spi_init(void);
static uint32_t get_tick(void);
static void delay_ms(uint32_t ms);
static bool check_boot_pin(void);
static bool check_magic_word(void);
static void clear_magic_word(void);
static bool check_valid_app(void);
static void jump_to_app(void);
static void led_on(void);
static void led_off(void);
static void led_toggle(void);

/* Flash operations */
static void flash_unlock(void);
static void flash_lock(void);
static bool flash_erase_page(uint32_t page_addr);
static bool flash_write_halfword(uint32_t addr, uint16_t data);
static bool flash_write_block(uint32_t addr, const uint8_t *data, uint32_t len);
static bool flash_erase_app_area(uint32_t size);

/* CRC */
static uint32_t crc32_compute(const uint8_t *data, uint32_t len);
static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t len);

/* UART operations */
static void uart_send_byte(uint8_t b);
static void uart_send_string(const char *str);
static bool uart_recv_byte(uint8_t *b, uint32_t timeout_ms);
static void uart_flush(void);

/* SD Card operations */
static void sd_cs_low(void);
static void sd_cs_high(void);
static uint8_t spi_transfer(uint8_t data);
static bool sd_init(void);
static uint8_t sd_send_command(uint8_t cmd, uint32_t arg);
static bool sd_read_block(uint32_t block, uint8_t *buf);

/* FAT filesystem */
static bool fat_init(void);
static bool fat_find_file(const char *name, uint32_t *cluster, uint32_t *size);
static uint32_t fat_cluster_to_sector(uint32_t cluster);
static uint32_t fat_next_cluster(uint32_t cluster);

/* Update procedures */
static bool update_from_sd(void);
static bool update_from_uart(void);
static bool validate_firmware_header(const FirmwareHeader_t *hdr);
static bool verify_firmware_crc(uint32_t addr, uint32_t size, uint32_t expected_crc);

/* --------------------------------------------------------------------------
 * SysTick Handler
 * -------------------------------------------------------------------------- */
void SysTick_Handler(void)
{
    systick_ms++;
}

/* --------------------------------------------------------------------------
 * System Initialization
 * -------------------------------------------------------------------------- */
static void system_init(void)
{
    /* Use HSI 8MHz for fast startup - no PLL config needed */
    /* Enable GPIO clocks: GPIOA, GPIOB, GPIOC */
    RCC->AHBENR |= (1 << 17) | (1 << 18) | (1 << 19);
    /* Enable USART1 clock */
    RCC->APB2ENR |= (1 << 14);
    /* Enable SPI1 clock */
    RCC->APB2ENR |= (1 << 12);

    /* Small delay for clocks to stabilize */
    for (volatile int i = 0; i < 100; i++);
}

static void systick_init(void)
{
    SYSTICK->LOAD = (SYSTEM_CLOCK / 1000) - 1;  /* 1ms tick */
    SYSTICK->VAL = 0;
    SYSTICK->CTRL = 0x07;  /* Enable, use processor clock, enable interrupt */
}

static uint32_t get_tick(void)
{
    return systick_ms;
}

static void delay_ms(uint32_t ms)
{
    uint32_t start = get_tick();
    while ((get_tick() - start) < ms);
}

/* --------------------------------------------------------------------------
 * GPIO Initialization
 * -------------------------------------------------------------------------- */
static void gpio_init(void)
{
    /* LED PA5 as output */
    LED_GPIO_PORT->MODER &= ~(3 << (LED_GPIO_PIN * 2));
    LED_GPIO_PORT->MODER |= (1 << (LED_GPIO_PIN * 2));
    LED_GPIO_PORT->OSPEEDR |= (3 << (LED_GPIO_PIN * 2));  /* High speed */

    /* Boot pin PC13 as input with pull-up */
    BOOT_GPIO_PORT->MODER &= ~(3 << (BOOT_GPIO_PIN * 2));  /* Input mode */
    BOOT_GPIO_PORT->PUPDR &= ~(3 << (BOOT_GPIO_PIN * 2));
    BOOT_GPIO_PORT->PUPDR |= (1 << (BOOT_GPIO_PIN * 2));   /* Pull-up */

    /* SD CS PB6 as output, default high */
    SD_CS_PORT->MODER &= ~(3 << (SD_CS_PIN * 2));
    SD_CS_PORT->MODER |= (1 << (SD_CS_PIN * 2));
    SD_CS_PORT->OSPEEDR |= (3 << (SD_CS_PIN * 2));
    SD_CS_PORT->BSRR = (1 << SD_CS_PIN);  /* CS high */

    /* SPI1 pins: PA5=SCK, PA6=MISO, PA7=MOSI - Alternate Function 0 (AF0) */
    /* Note: PA5 is shared with LED - reconfigure for SPI when needed */
    /* For bootloader, we use PA5 for LED initially, reconfigure for SPI in spi_init */
}

static void led_on(void)
{
    LED_GPIO_PORT->BSRR = (1 << LED_GPIO_PIN);
}

static void led_off(void)
{
    LED_GPIO_PORT->BSRR = (1 << (LED_GPIO_PIN + 16));
}

static void led_toggle(void)
{
    LED_GPIO_PORT->ODR ^= (1 << LED_GPIO_PIN);
}

/* --------------------------------------------------------------------------
 * UART Initialization & Operations (USART1: PA9=TX, PA10=RX)
 * -------------------------------------------------------------------------- */
static void uart_init(void)
{
    /* PA9 AF1 (USART1_TX), PA10 AF1 (USART1_RX) */
    GPIOA->MODER &= ~((3 << (9 * 2)) | (3 << (10 * 2)));
    GPIOA->MODER |= (2 << (9 * 2)) | (2 << (10 * 2));  /* AF mode */
    GPIOA->AFR[1] &= ~((0xF << ((9 - 8) * 4)) | (0xF << ((10 - 8) * 4)));
    GPIOA->AFR[1] |= (1 << ((9 - 8) * 4)) | (1 << ((10 - 8) * 4));  /* AF1 */
    GPIOA->OSPEEDR |= (3 << (9 * 2)) | (3 << (10 * 2));

    /* Configure USART1 */
    USART1->CR1 = 0;  /* Disable */
    USART1->BRR_REG = SYSTEM_CLOCK / UART_BAUD_RATE;
    USART1->CR1 = (1 << 0) | (1 << 2) | (1 << 3);  /* UE, RE, TE */
}

static void uart_send_byte(uint8_t b)
{
    while (!(USART1->ISR & USART_ISR_TXE));
    USART1->TDR = b;
}

static void uart_send_string(const char *str)
{
    while (*str) {
        uart_send_byte((uint8_t)*str++);
    }
}

static bool uart_recv_byte(uint8_t *b, uint32_t timeout_ms)
{
    uint32_t start = get_tick();
    while (!(USART1->ISR & USART_ISR_RXNE)) {
        if ((get_tick() - start) >= timeout_ms) {
            return false;
        }
    }
    *b = (uint8_t)(USART1->RDR & 0xFF);
    return true;
}

static void uart_flush(void)
{
    while (USART1->ISR & USART_ISR_RXNE) {
        (void)USART1->RDR;
    }
}

/* --------------------------------------------------------------------------
 * SPI Initialization & Operations
 * -------------------------------------------------------------------------- */
static void spi_init(void)
{
    /* Reconfigure PA5 (SCK), PA6 (MISO), PA7 (MOSI) for SPI1 AF0 */
    /* PA5 */
    GPIOA->MODER &= ~(3 << (5 * 2));
    GPIOA->MODER |= (2 << (5 * 2));   /* AF mode */
    GPIOA->AFR[0] &= ~(0xF << (5 * 4));
    GPIOA->AFR[0] |= (0 << (5 * 4));  /* AF0 */
    /* PA6 */
    GPIOA->MODER &= ~(3 << (6 * 2));
    GPIOA->MODER |= (2 << (6 * 2));
    GPIOA->AFR[0] &= ~(0xF << (6 * 4));
    GPIOA->AFR[0] |= (0 << (6 * 4));
    /* PA7 */
    GPIOA->MODER &= ~(3 << (7 * 2));
    GPIOA->MODER |= (2 << (7 * 2));
    GPIOA->AFR[0] &= ~(0xF << (7 * 4));
    GPIOA->AFR[0] |= (0 << (7 * 4));

    GPIOA->OSPEEDR |= (3 << (5 * 2)) | (3 << (6 * 2)) | (3 << (7 * 2));

    /* SPI1 config: Master, CPOL=0, CPHA=0, 8-bit, slow clock initially (fPCLK/256) */
    SPI1->CR1 = 0;
    SPI1->CR1 = (1 << 2)       /* MSTR: Master mode */
              | (7 << 3)       /* BR[2:0] = 111: fPCLK/256 for init */
              | (1 << 8)       /* SSI */
              | (1 << 9);      /* SSM: Software slave management */
    SPI1->CR2 = (7 << 8);     /* DS[3:0] = 0111: 8-bit data */
    SPI1->CR2 |= (1 << 12);   /* FRXTH: RXNE on 8-bit */
    SPI1->CR1 |= (1 << 6);    /* SPE: Enable SPI */
}

static void spi_set_fast(void)
{
    SPI1->CR1 &= ~(1 << 6);   /* Disable SPI */
    SPI1->CR1 &= ~(7 << 3);
    SPI1->CR1 |= (1 << 3);    /* BR = 001: fPCLK/4 = 2MHz */
    SPI1->CR1 |= (1 << 6);    /* Enable SPI */
}

static uint8_t spi_transfer(uint8_t data)
{
    while (!(SPI1->SR & (1 << 1)));  /* Wait TXE */
    *(volatile uint8_t *)&SPI1->DR = data;
    while (!(SPI1->SR & (1 << 0)));  /* Wait RXNE */
    return *(volatile uint8_t *)&SPI1->DR;
}

static void sd_cs_low(void)
{
    SD_CS_PORT->BSRR = (1 << (SD_CS_PIN + 16));
}

static void sd_cs_high(void)
{
    SD_CS_PORT->BSRR = (1 << SD_CS_PIN);
    spi_transfer(0xFF);  /* Extra clocks */
}

/* --------------------------------------------------------------------------
 * SD Card Operations
 * -------------------------------------------------------------------------- */
static uint8_t sd_send_command(uint8_t cmd, uint32_t arg)
{
    uint8_t response;
    uint8_t crc = 0xFF;
    int retries;

    if (cmd == SD_CMD0) crc = 0x95;
    if (cmd == SD_CMD8) crc = 0x87;

    sd_cs_low();
    spi_transfer(0xFF);

    spi_transfer(0x40 | cmd);
    spi_transfer((arg >> 24) & 0xFF);
    spi_transfer((arg >> 16) & 0xFF);
    spi_transfer((arg >> 8) & 0xFF);
    spi_transfer(arg & 0xFF);
    spi_transfer(crc);

    retries = 100;
    do {
        response = spi_transfer(0xFF);
    } while ((response & 0x80) && --retries > 0);

    return response;
}

static bool sd_init(void)
{
    uint8_t r;
    int retries;
    uint32_t start;

    spi_init();

    /* Send 80+ clock pulses with CS high */
    sd_cs_high();
    for (int i = 0; i < 12; i++) {
        spi_transfer(0xFF);
    }

    /* CMD0: Reset */
    retries = 10;
    do {
        r = sd_send_command(SD_CMD0, 0);
        sd_cs_high();
    } while (r != 0x01 && --retries > 0);

    if (r != 0x01) return false;

    /* CMD8: Check voltage */
    r = sd_send_command(SD_CMD8, 0x1AA);
    if (r == 0x01) {
        /* SDv2 card */
        uint8_t ocr[4];
        for (int i = 0; i < 4; i++) ocr[i] = spi_transfer(0xFF);
        sd_cs_high();

        if (ocr[2] != 0x01 || ocr[3] != 0xAA) return false;

        /* ACMD41 with HCS */
        start = get_tick();
        do {
            sd_send_command(SD_CMD55, 0);
            sd_cs_high();
            r = sd_send_command(SD_ACMD41, 0x40000000);
            sd_cs_high();
            if ((get_tick() - start) > 2000) return false;
        } while (r != 0x00);

        /* CMD58: Read OCR for CCS bit */
        r = sd_send_command(SD_CMD58, 0);
        if (r == 0x00) {
            uint8_t ocr2[4];
            for (int i = 0; i < 4; i++) ocr2[i] = spi_transfer(0xFF);
            sd_is_sdhc = (ocr2[0] & 0x40) ? true : false;
        }
        sd_cs_high();
    } else {
        sd_cs_high();
        /* SDv1 or MMC */
        sd_is_sdhc = false;
        start = get_tick();
        do {
            sd_send_command(SD_CMD55, 0);
            sd_cs_high();
            r = sd_send_command(SD_ACMD41, 0);
            sd_cs_high();
            if (r > 0x01) {
                /* Try CMD1 for MMC */
                do {
                    r = sd_send_command(SD_CMD1, 0);
                    sd_cs_high();
                    if ((get_tick() - start) > 2000) return false;
                } while (r != 0x00);
                break;
            }
            if ((get_tick() - start) > 2000) return false;
        } while (r != 0x00);
    }

    /* Set block size to 512 for non-SDHC */
    if (!sd_is_sdhc) {
        r = sd_send_command(SD_CMD16, SD_BLOCK_SIZE);
        sd_cs_high();
        if (r != 0x00) return false;
    }

    /* Switch to fast SPI */
    spi_set_fast();

    return true;
}

static bool sd_read_block(uint32_t block, uint8_t *buf)
{
    uint32_t addr = sd_is_sdhc ? block : (block * SD_BLOCK_SIZE);
    uint8_t r;
    int retries;

    r = sd_send_command(SD_CMD17, addr);
    if (r != 0x00) {
        sd_cs_high();
        return false;
    }

    /* Wait for data token 0xFE */
    retries = 50000;
    do {
        r = spi_transfer(0xFF);
    } while (r == 0xFF && --retries > 0);

    if (r != 0xFE) {
        sd_cs_high();
        return false;
    }

    /* Read 512 bytes */
    for (int i = 0; i < SD_BLOCK_SIZE; i++) {
        buf[i] = spi_transfer(0xFF);
    }

    /* Discard CRC */
    spi_transfer(0xFF);
    spi_transfer(0xFF);

    sd_cs_high();
    return true;
}

/* --------------------------------------------------------------------------
 * FAT Filesystem (minimal FAT16/FAT32 read-only)
 * -------------------------------------------------------------------------- */
static bool fat_init(void)
{
    /* Read MBR / first sector */
    if (!sd_read_block(0, sd_buffer)) return false;

    uint32_t partition_start = 0;

    /* Check if MBR or BPB */
    if (sd_buffer[510] == 0x55 && sd_buffer[511] == 0xAA) {
        /* Check for partition table */
        if (sd_buffer[0] != 0xEB && sd_buffer[0] != 0xE9) {
            /* MBR: read first partition */
            partition_start = *(uint32_t *)&sd_buffer[0x1C6];
            if (!sd_read_block(partition_start, sd_buffer)) return false;
        }
    }

    BPB_t *bpb = (BPB_t *)sd_buffer;

    if (bpb->bytes_per_sector != SD_BLOCK_SIZE) return false;

    sectors_per_cluster = bpb->sectors_per_cluster;

    uint32_t root_dir_sectors;
    if (bpb->fat_size_16 != 0) {
        fat_size = bpb->fat_size_16;
        is_fat32 = false;
    } else {
        fat_size = bpb->fat_size_32;
        is_fat32 = true;
        root_cluster = bpb->root_cluster;
    }

    fat_start_sector = partition_start + bpb->reserved_sectors;
    root_dir_sectors = ((bpb->root_entry_count * 32) + (SD_BLOCK_SIZE - 1)) / SD_BLOCK_SIZE;
    root_dir_sector = fat_start_sector + (bpb->num_fats * fat_size);
    data_start_sector = root_dir_sector + root_dir_sectors;

    return true;
}

static uint32_t fat_cluster_to_sector(uint32_t cluster)
{
    return data_start_sector + (cluster - 2) * sectors_per_cluster;
}

static uint32_t fat_next_cluster(uint32_t cluster)
{
    uint32_t fat_offset;
    uint32_t fat_sector;
    uint32_t entry_offset;

    if (is_fat32) {
        fat_offset = cluster * 4;
    } else {
        fat_offset = cluster * 2;
    }

    fat_sector = fat_start_sector + (fat_offset / SD_BLOCK_SIZE);
    entry_offset = fat_offset % SD_BLOCK_SIZE;

    if (!sd_read_block(fat_sector, sd_buffer)) return 0xFFFFFFFF;

    if (is_fat32) {
        uint32_t next = *(uint32_t *)&sd_buffer[entry_offset] & 0x0FFFFFFF;
        if (next >= 0x0FFFFFF8) return 0xFFFFFFFF;
        return next;
    } else {
        uint16_t next = *(uint16_t *)&sd_buffer[entry_offset];
        if (next >= 0xFFF8) return 0xFFFFFFFF;
        return next;
    }
}

static void fat_name_to_83(const char *name, char *name83)
{
    memset(name83, ' ', 11);
    int i = 0, j = 0;

    /* Name part */
    while (name[i] && name[i] != '.' && j < 8) {
        char c = name[i++];
        if (c >= 'a' && c <= 'z') c -= 32;
        name83[j++] = c;
    }

    /* Skip to extension */
    while (name[i] && name[i] != '.') i++;
    if (name[i] == '.') i++;

    /* Extension part */
    j = 8;
    while (name[i] && j < 11) {
        char c = name[i++];
        if (c >= 'a' && c <= 'z') c -= 32;
        name83[j++] = c;
    }
}

static bool fat_find_file(const char *name, uint32_t *cluster_out, uint32_t *size_out)
{
    char name83[11];
    fat_name_to_83(name, name83);

    if (is_fat32) {
        /* FAT32: root directory is a cluster chain */
        uint32_t clust = root_cluster;
        while (clust != 0xFFFFFFFF) {
            uint32_t sector = fat_cluster_to_sector(clust);
            for (uint8_t s = 0; s < sectors_per_cluster; s++) {
                if (!sd_read_block(sector + s, sd_buffer)) return false;
                DirEntry_t *dir = (DirEntry_t *)sd_buffer;
                for (int e = 0; e < SD_BLOCK_SIZE / 32; e++) {
                    if (dir[e].name[0] == 0x00) return false;   /* End of directory */
                    if (dir[e].name[0] == 0xE5) continue;       /* Deleted */
                    if (dir[e].attr & 0x0F) continue;           /* LFN entry */
                    if (memcmp(dir[e].name, name83, 8) == 0 &&
                        memcmp(dir[e].ext, name83 + 8, 3) == 0) {
                        *cluster_out = ((uint32_t)dir[e].first_cluster_hi << 16) |
                                       dir[e].first_cluster_lo;
                        *size_out = dir[e].file_size;
                        return true;
                    }
                }
            }
            clust = fat_next_cluster(clust);
        }
    } else {
        /* FAT16: root directory is fixed location */
        uint32_t root_sectors = (512 * 32 + SD_BLOCK_SIZE - 1) / SD_BLOCK_SIZE; /* Typical 512 entries */
        for (uint32_t s = 0; s < root_sectors; s++) {
            if (!sd_read_block(root_dir_sector + s, sd_buffer)) return false;
            DirEntry_t *dir = (DirEntry_t *)sd_buffer;
            for (int e = 0; e < SD_BLOCK_SIZE / 32; e++) {
                if (dir[e].name[0] == 0x00) return false;
                if (dir[e].name[0] == 0xE5) continue;
                if (dir[e].attr & 0x0F) continue;
                if (memcmp(dir[e].name, name83, 8) == 0 &&
                    memcmp(dir[e].ext, name83 + 8, 3) == 0) {
                    *cluster_out = dir[e].first_cluster_lo;
                    *size_out = dir[e].file_size;
                    return true;
                }
            }
        }
    }
    return false;
}

/* --------------------------------------------------------------------------
 * Flash Operations
 * -------------------------------------------------------------------------- */
static void flash_unlock(void)
{
    if (FLASH->CR & FLASH_CR_LOCK) {
        FLASH->KEYR = FLASH_KEY1;
        FLASH->KEYR = FLASH_KEY2;
    }
}

static void flash_lock(void)
{
    FLASH->CR |= FLASH_CR_LOCK;
}

static bool flash_erase_page(uint32_t page_addr)
{
    while (FLASH->SR & FLASH_SR_BSY);

    FLASH->CR |= FLASH_CR_PER;
    FLASH->AR = page_addr;
    FLASH->CR |= FLASH_CR_STRT;

    while (FLASH->SR & FLASH_SR_BSY);

    if (FLASH->SR & FLASH_SR_EOP) {
        FLASH->SR = FLASH_SR_EOP;
    }

    FLASH->CR &= ~FLASH_CR_PER;

    /* Verify erase */
    for (uint32_t i = 0; i < FLASH_PAGE_SIZE; i += 4) {
        if (*(volatile uint32_t *)(page_addr + i) != 0xFFFFFFFF) {
            return false;
        }
    }
    return true;
}

static bool flash_write_halfword(uint32_t addr, uint16_t data)
{
    while (FLASH->SR & FLASH_SR_BSY);

    FLASH->CR |= FLASH_CR_PG;

    *(volatile uint16_t *)addr = data;

    while (FLASH->SR & FLASH_SR_BSY);

    if (FLASH->SR & FLASH_SR_EOP) {
        FLASH->SR = FLASH_SR_EOP;
    }

    FLASH->CR &= ~FLASH_CR_PG;

    return (*(volatile uint16_t *)addr == data);
}

static bool flash_write_block(uint32_t addr, const uint8_t *data, uint32_t len)
{
    for (uint32_t i = 0; i < len; i += 2) {
        uint16_t hw;
        if (i + 1 < len) {
            hw = data[i] | ((uint16_t)data[i + 1] << 8);
        } else {
            hw = data[i] | 0xFF00;  /* Pad last byte */
        }
        if (!flash_write_halfword(addr + i, hw)) {
            return false;
        }
    }
    return true;
}

static bool flash_erase_app_area(uint32_t size)
{
    uint32_t pages = (size + FLASH_PAGE_SIZE - 1) / FLASH_PAGE_SIZE;
    for (uint32_t i = 0; i < pages; i++) {
        uint32_t page_addr = APP_BASE + (i * FLASH_PAGE_SIZE);
        if (page_addr >= (APP_BASE + APP_MAX_SIZE)) break;
        if (!flash_erase_page(page_addr)) return false;
        /* Toggle LED for progress indication */
        if (i % 4 == 0) led_toggle();
    }
    return true;
}

/* --------------------------------------------------------------------------
 * CRC32 (used for firmware verification)
 * -------------------------------------------------------------------------- */
static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t len)
{
    for (uint32_t i = 0; i < len; i++) {
        crc ^= data[i];
        for (int j = 0; j < 8; j++) {
            if (crc & 1)
                crc = (crc >> 1) ^ CRC32_POLYNOMIAL;
            else
                crc >>= 1;
        }
    }
    return crc;
}

static uint32_t crc32_compute(const uint8_t *data, uint32_t len)
{
    return crc32_update(0xFFFFFFFF, data, len) ^ 0xFFFFFFFF;
}

static bool verify_firmware_crc(uint32_t addr, uint32_t size, uint32_t expected_crc)
{
    uint32_t crc = 0xFFFFFFFF;
    uint32_t remaining = size;
    uint32_t offset = 0;

    while (remaining > 0) {
        uint32_t chunk = (remaining > 256) ? 256 : remaining;
        crc = crc32_update(crc, (const uint8_t *)(addr + offset), chunk);
        offset += chunk;
        remaining -= chunk;
    }

    crc ^= 0xFFFFFFFF;
    return (crc == expected_crc);
}

/* --------------------------------------------------------------------------
 * Boot Condition Checks
 * -------------------------------------------------------------------------- */
static bool check_boot_pin(void)
{
    /* Active low: button pressed = pin LOW = enter bootloader */
    return !(BOOT_GPIO_PORT->IDR & (1 << BOOT_GPIO_PIN));
}

static bool check_magic_word(void)
{
    return (*(volatile uint32_t *)MAGIC_WORD_ADDR == MAGIC_WORD_VALUE);
}

static void clear_magic_word(void)
{
    *(volatile uint32_t *)MAGIC_WORD_ADDR = 0;
}

static bool check_valid_app(void)
{
    /* Check if valid stack pointer at APP_BASE */
    uint32_t sp = *(volatile uint32_t *)APP_BASE;
    if (sp < SRAM_BASE || sp > (SRAM_BASE + SRAM_SIZE)) {
        return false;
    }

    /* Check if reset vector is in valid flash range */
    uint32_t reset = *(volatile uint32_t *)(APP_BASE + 4);
    if (reset < APP_BASE || reset > (APP_BASE + APP_MAX_SIZE)) {
        return false;
    }

    /* Thumb bit must be set */
    if (!(reset & 1)) {
        return false;
    }

    return true;
}

static bool validate_firmware_header(const FirmwareHeader_t *hdr)
{
    if (hdr->magic != FIRMWARE_MAGIC) return false;
    if (hdr->size == 0 || hdr->size > APP_MAX_SIZE) return false;
    return true;
}

/* --------------------------------------------------------------------------
 * Jump to Application
 * -------------------------------------------------------------------------- */
static void jump_to_app(void)
{
    typedef void (*AppEntry_t)(void);

    uint32_t app_sp = *(volatile uint32_t *)APP_BASE;
    uint32_t app_reset = *(volatile uint32_t *)(APP_BASE + 4);

    /* Disable SysTick */
    SYSTICK->CTRL = 0;
    SYSTICK->LOAD = 0;
    SYSTICK->VAL = 0;

    /* Disable all interrupts */
    for (int i = 0; i < 8; i++) {
        ((volatile uint32_t *)(NVIC_BASE + 0x80))[i] = 0xFFFFFFFF;  /* ICER */
    }

    /* Clear pending interrupts */
    for (int i = 0; i < 8; i++) {
        ((volatile uint32_t *)(NVIC_BASE + 0x100))[i] = 0xFFFFFFFF; /* ICPR - offset from NVIC_BASE */
    }

    /* Set vector table offset to application */
    SCB->VTOR = APP_BASE;

    /* Set MSP */
    __asm volatile ("MSR msp, %0" : : "r" (app_sp));

    /* Ensure all memory accesses complete */
    __asm volatile ("DSB");
    __asm volatile ("ISB");

    /* Jump to application reset handler */
    AppEntry_t app_entry = (AppEntry_t)app_reset;
    app_entry();

    /* Should never reach here */
    while (1);
}

/* --------------------------------------------------------------------------
 * SD Card Firmware Update
 * -------------------------------------------------------------------------- */
static bool update_from_sd(void)
{
    uart_send_string("[BL] Checking SD card...\r\n");

    if (!sd_init()) {
        uart_send_string("[BL] SD card not found\r\n");
        return false;
    }
    uart_send_string("[BL] SD card initialized\r\n");

    if (!fat_init()) {
        uart_send_string("[BL] FAT filesystem error\r\n");
        return false;
    }
    uart_send_string("[BL] FAT filesystem mounted\r\n");

    uint32_t file_cluster, file_size;
    if (!fat_find_file(SD_FIRMWARE_FILENAME, &file_cluster, &file_size)) {
        uart_send_string("[BL] firmware.bin not found\r\n");
        return false;
    }

    uart_send_string("[BL] Found firmware.bin\r\n");

    if (file_size < FW_HEADER_SIZE) {
        uart_send_string("[BL] File too small\r\n");
        return false;
    }

    /* Read first sector to get header */
    uint32_t sector = fat_cluster_to_sector(file_cluster);
    if (!sd_read_block(sector, sd_buffer)) {
        uart_send_string("[BL] Read error\r\n");
        return false;
    }

    FirmwareHeader_t hdr;
    memcpy(&hdr, sd_buffer, sizeof(hdr));

    if (!validate_firmware_header(&hdr)) {
        uart_send_string("[BL] Invalid firmware header\r\n");
        return false;
    }

    uart_send_string("[BL] Valid header, erasing flash...\r\n");

    flash_unlock();

    if (!flash_erase_app_area(hdr.size)) {
        uart_send_string("[BL] Erase failed\r\n");
        flash_lock();
        return false;
    }

    uart_send_string("[BL] Programming...\r\n");

    /* Now read and program firmware data (skip header) */
    uint32_t remaining = hdr.size;
    uint32_t flash_addr = APP_BASE;
    uint32_t cluster = file_cluster;
    uint32_t sector_in_cluster = 0;
    bool first_block = true;
    uint32_t crc_accum = 0xFFFFFFFF;

    while (remaining > 0 && cluster != 0xFFFFFFFF) {
        sector = fat_cluster_to_sector(cluster) + sector_in_cluster;

        if (!sd_read_block(sector, sd_buffer)) {
            uart_send_string("[BL] Read error during programming\r\n");
            flash_lock();
            return false;
        }

        uint8_t *data_ptr = sd_buffer;
        uint32_t data_len = SD_BLOCK_SIZE;

        if (first_block) {
            /* Skip header in first block */
            data_ptr += FW_HEADER_SIZE;
            data_len -= FW_HEADER_SIZE;
            first_block = false;
        }

        if (data_len > remaining) {
            data_len = remaining;
        }

        /* Update CRC */
        crc_accum = crc32_update(crc_accum, data_ptr, data_len);

        /* Write to flash */
        if (!flash_write_block(flash_addr, data_ptr, data_len)) {
            uart_send_string("[BL] Write error\r\n");
            flash_lock();
            return false;
        }

        flash_addr += data_len;
        remaining -= data_len;

        /* Progress LED */
        if ((flash_addr & 0xFFF) == 0) led_toggle();

        /* Advance to next sector/cluster */
        sector_in_cluster++;
        if (sector_in_cluster >= sectors_per_cluster) {
            sector_in_cluster = 0;
            cluster = fat_next_cluster(cluster);
        }
    }

    flash_lock();

    /* Verify CRC */
    crc_accum ^= 0xFFFFFFFF;
    if (crc_accum != hdr.crc32) {
        uart_send_string("[BL] CRC mismatch!\r\n");
        return false;
    }

    /* Double-check: verify from flash */
    if (!verify_firmware_crc(APP_BASE, hdr.size, hdr.crc32)) {
        uart_send_string("[BL] Flash verification failed!\r\n");
        return false;
    }

    uart_send_string("[BL] Firmware programmed and verified!\r\n");
    return true;
}

/* --------------------------------------------------------------------------
 * UART Firmware Update (XMODEM-CRC Protocol)
 * -------------------------------------------------------------------------- */
static uint16_t xmodem_crc16(const uint8_t *data, uint32_t len)
{
    uint16_t crc = 0;
    for (uint32_t i = 0; i < len; i++) {
        crc ^= (uint16_t)data[i] << 8;
        for (int j = 0; j < 8; j++) {
            if (crc & 0x8000)
                crc = (crc << 1) ^ 0x1021;
            else
                crc <<= 1;
        }
    }
    return crc;
}

static bool update_from_uart(void)
{
    uart_send_string("\r\n[BL] UART firmware update mode\r\n");
    uart_send_string("[BL] Send firmware via XMODEM-CRC...\r\n");

    /* Buffer to accumulate firmware data */
    static uint8_t page_buf[FLASH_PAGE_SIZE];
    uint32_t page_buf_pos = 0;
    uint32_t flash_addr = APP_BASE;
    uint32_t total_received = 0;
    uint8_t expected_block = 1;
    int retries;
    bool header_parsed = false;
    FirmwareHeader_t fw_hdr;
    uint32_t crc_accum = 0xFFFFFFFF;
    bool header_skip_done = false;
    uint32_t header_bytes_remaining = FW_HEADER_SIZE;

    flash_unlock();

    /* Erase entire app area upfront for speed */
    uart_send_string("[BL] Erasing flash...\r\n");
    if (!flash_erase_app_area(APP_MAX_SIZE)) {
        uart_send_string("[BL] Erase failed\r\n");
        flash_lock();
        return false;
    }
    uart_send_string("[BL] Ready. Start XMODEM transfer.\r\n");

    /* Send initial 'C' to request CRC mode */
    retries = 60;  /* Wait up to 60 seconds */
    uint8_t rx_byte;
    bool transfer_started = false;

    while (!transfer_started && retries > 0) {
        uart_send_byte('C');
        if (uart_recv_byte(&rx_byte, 1000)) {
            if (rx_byte == XMODEM_SOH || rx_byte == XMODEM_STX) {
                transfer_started = true;
                break;
            }
        }
        retries--;
    }

    if (!transfer_started) {
        uart_send_string("[BL] Timeout waiting for sender\r\n");
        flash_lock();
        return false;
    }

    bool done = false;
    int error_count = 0;

    while (!done) {
        uint8_t block_buf[XMODEM_1K_BLOCK_SIZE];
        uint32_t block_size;

        if (rx_byte == XMODEM_SOH) {
            block_size = XMODEM_BLOCK_SIZE;
        } else if (rx_byte == XMODEM_STX) {
            block_size = XMODEM_1K_BLOCK_SIZE;
        } else if (rx_byte == XMODEM_EOT) {
            uart_send_byte(XMODEM_ACK);
            done = true;
            break;
        } else if (rx_byte == XMODEM_CAN) {
            /* Check for double CAN */
            if (uart_recv_byte(&rx_byte, 1000) && rx_byte == XMODEM_CAN) {
                uart_send_byte(XMODEM_ACK);
                uart_send_string("[BL] Transfer cancelled by sender\r\n");
                flash_lock();
                return false;
            }
            continue;
        } else {
            /* Unexpected byte, NAK */
            uart_flush();
            uart_send_byte(XMODEM_NAK);
            error_count++;
            if (error_count > XMODEM_MAX_RETRIES) {
                uart_send_string("[BL] Too many errors\r\n");
                flash_lock();
                return false;
            }
            if (!uart_recv_byte(&rx_byte, 10000)) {
                flash_lock();
                return false;
            }
            continue;
        }

        /* Read block number */
        uint8_t blk_num, blk_num_inv;
        if (!uart_recv_byte(&blk_num, UART_TIMEOUT_MS) ||
            !uart_recv_byte(&blk_num_inv, UART_TIMEOUT_MS)) {
            uart_flush();
            uart_send_byte(XMODEM_NAK);
            error_count++;
            if (error_count > XMODEM_MAX_RETRIES) { flash_lock(); return false; }
            if (!uart_recv_byte(&rx_byte, 10000)) { flash_lock(); return false; }
            continue;
        }

        if ((blk_num + blk_num_inv) != 0xFF) {
            /* Bad block numbers */
            for (uint32_t i = 0; i < block_size + 2; i++) {
                uart_recv_byte(&rx_byte, 100);
            }
            uart_send_byte(XMODEM_NAK);
            error_count++;
            if (error_count > XMODEM_MAX_RETRIES) { flash_lock(); return false; }
            if (!uart_recv_byte(&rx_byte, 10000)) { flash_lock(); return false; }
            continue;
        }

        /* Read data */
        bool read_ok = true;
        for (uint32_t i = 0; i < block_size; i++) {
            if (!uart_recv_byte(&block_buf[i], UART_TIMEOUT_MS)) {
                read_ok = false;
                break;
            }
        }

        /* Read CRC16 */
        uint8_t crc_hi, crc_lo;
        if (!read_ok ||
            !uart_recv_byte(&crc_hi, UART_TIMEOUT_MS) ||
            !uart_recv_byte(&crc_lo, UART_TIMEOUT_MS)) {
            uart_flush();
            uart_send_byte(XMODEM_NAK);
            error_count++;
            if (error_count > XMODEM_MAX_RETRIES) { flash_lock(); return false; }
            if (!uart_recv_byte(&rx_byte, 10000)) { flash_lock(); return false; }
            continue;
        }

        /* Verify CRC */
        uint16_t received_crc = ((uint16_t)crc_hi << 8) | crc_lo;
        uint16_t calc_crc = xmodem_crc16(block_buf, block_size);

        if (received_crc != calc_crc) {
            uart_send_byte(XMODEM_NAK);
            error_count++;
            if (error_count > XMODEM_MAX_RETRIES) { flash_lock(); return false; }
            if (!uart_recv_byte(&rx_byte, 10000)) { flash_lock(); return false; }
            continue;
        }

        /* Check block sequence */
        if (blk_num != expected_block) {
            if (blk_num == (uint8_t)(expected_block - 1)) {
                /* Duplicate, ACK but don't process */
                uart_send_byte(XMODEM_ACK);
                if (!uart_recv_byte(&rx_byte, 10000)) {
                    done = true;
                }
                continue;
            }
            uart_send_byte(XMODEM_NAK);
            error_count++;
            if (error_count > XMODEM_MAX_RETRIES) { flash_lock(); return false; }
            if (!uart_recv_byte(&rx_byte, 10000)) { flash_lock(); return false; }
            continue;
        }

        /* Process received data */
        uint8_t *data_ptr = block_buf;
        uint32_t data_len = block_size;

        /* Extract header from first data */
        if (!header_parsed) {
            if (total_received + data_len >= FW_HEADER_SIZE) {
                /* We have enough for header */
                uint32_t hdr_offset = 0;
                if (total_received < FW_HEADER_SIZE) {
                    uint32_t hdr_copy = FW_HEADER_SIZE - total_received;
                    memcpy(((uint8_t *)&fw_hdr) + total_received, data_ptr, hdr_copy);
                    data_ptr += hdr_copy;
                    data_len -= hdr_copy;
                    header_skip_done = true;
                }
                if (!validate_firmware_header(&fw_hdr)) {
                    uart_send_byte(XMODEM_CAN);
                    uart_send_byte(XMODEM_CAN);
                    uart_send_string("[BL] Invalid firmware header\r\n");
                    flash_lock();
                    return false;
                }
                header_parsed = true;
                uart_send_string("[BL] Header OK, receiving...\r\n");
            } else {
                memcpy(((uint8_t *)&fw_hdr) + total_received, data_ptr, data_len);
                data_ptr += data_len;
                data_len = 0;
            }
        } else if (!header_skip_done) {
            /* Header already parsed but we need to track skip */
            header_skip_done = true;
        }

        /* Write data to flash (skip header bytes) */
        if (data_len > 0 && header_parsed) {
            /* Limit to firmware size */
            uint32_t payload_received = flash_addr - APP_BASE;
            if (payload_received + data_len > fw_hdr.size) {
                data_len = fw_hdr.size - payload_received;
            }

            if (data_len > 0) {
                /* Update CRC */
                crc_accum = crc32_update(crc_accum, data_ptr, data_len);

                /* Accumulate into page buffer for efficient writing */
                uint32_t copy_len;
                while (data_len > 0) {
                    copy_len = FLASH_PAGE_SIZE - page_buf_pos;
                    if (copy_len > data_len) copy_len = data_len;

                    memcpy(page_buf + page_buf_pos, data_ptr, copy_len);
                    page_buf_pos += copy_len;
                    data_ptr += copy_len;
                    data_len -= copy_len;

                    if (page_buf_pos == FLASH_PAGE_SIZE) {
                        if (!flash_write_block(flash_addr, page_buf, FLASH_PAGE_SIZE)) {
                            uart_send_byte(XMODEM_CAN);
                            uart_send_byte(XMODEM_CAN);
                            uart_send_string("[BL] Flash write error\r\n");
                            flash_lock();
                            return false;
                        }
                        flash_addr += FLASH_PAGE_SIZE;
                        page_buf_pos = 0;
                        led_toggle();
                    }
                }
            }
        }

        total_received += block_size;
        expected_block++;
        error_count = 0;

        uart_send_byte(XMODEM_ACK);

        /* Wait for next block header */
        if (!uart_recv_byte(&rx_byte, 10000)) {
            done = true;
        }
    }

    /* Write remaining data in page buffer */
    if (page_buf_pos > 0 && header_parsed) {
        if (!flash_write_block(flash_addr, page_buf, page_buf_pos)) {
            uart_send_string("[BL] Final write error\r\n");
            flash_lock();
            return false;
        }
    }

    flash_lock();

    if (!header_parsed) {
        uart_send_string("[BL] No valid header received\r\n");
        return false;
    }

    /* Verify CRC */
    crc_accum ^= 0xFFFFFFFF;
    if (crc_accum != fw_hdr.crc32) {
        uart_send_string("[BL] CRC verification failed!\r\n");
        return false;
    }

    /* Double-check from flash */
    if (!verify_firmware_crc(APP_BASE, fw_hdr.size, fw_hdr.crc32)) {
        uart_send_string("[BL] Flash CRC verification failed!\r\n");
        return false;
    }

    uart_send_string("[BL] Firmware update complete!\r\n");
    return true;
}

/* --------------------------------------------------------------------------
 * Bootloader Main Menu (when in update mode)
 * -------------------------------------------------------------------------- */
static void bootloader_menu(void)
{
    bool updated = false;

    while (!updated) {
        uart_send_string("\r\n=============================\r\n");
        uart_send_string("  ARM Cortex-M Bootloader\r\n");
        uart_send_string("=============================\r\n");
        uart_send_string("  1. Update from SD card\r\n