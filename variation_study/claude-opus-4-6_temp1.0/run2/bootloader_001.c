# Generated by anthropic (claude-opus-4-6)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

/* ============================================================
 * ARM Cortex-M Bootloader
 * Supports: SD Card, UART firmware update
 * Entry: GPIO pin, magic word in SRAM
 * Target: STM32F4xx (adaptable to other Cortex-M)
 * ============================================================ */

/* Memory Map Configuration */
#define BOOTLOADER_START_ADDR   0x08000000
#define BOOTLOADER_SIZE         0x8000          /* 32KB for bootloader */
#define APP_START_ADDR          0x08008000      /* Application start */
#define APP_MAX_SIZE            0x78000         /* 480KB max app size */
#define SRAM_BASE               0x20000000
#define FLASH_BASE_ADDR         0x40023C00

/* Magic word for bootloader entry from application */
#define BOOTLOADER_MAGIC_ADDR   (SRAM_BASE + 0x1FFF0)
#define BOOTLOADER_MAGIC_WORD   0xDEADBEEF

/* GPIO Configuration for bootloader entry (e.g., PA0) */
#define BOOT_GPIO_PORT_BASE     0x40020000      /* GPIOA base */
#define BOOT_GPIO_PIN           0               /* Pin 0 */
#define RCC_AHB1ENR             (*(volatile uint32_t *)0x40023830)
#define RCC_APB1ENR             (*(volatile uint32_t *)0x40023840)
#define RCC_APB2ENR             (*(volatile uint32_t *)0x40023844)

/* Flash registers (STM32F4) */
#define FLASH_ACR               (*(volatile uint32_t *)(FLASH_BASE_ADDR + 0x00))
#define FLASH_KEYR              (*(volatile uint32_t *)(FLASH_BASE_ADDR + 0x04))
#define FLASH_SR                (*(volatile uint32_t *)(FLASH_BASE_ADDR + 0x0C))
#define FLASH_CR                (*(volatile uint32_t *)(FLASH_BASE_ADDR + 0x10))

#define FLASH_KEY1              0x45670123
#define FLASH_KEY2              0xCDEF89AB
#define FLASH_SR_BSY            (1 << 16)
#define FLASH_CR_PG             (1 << 0)
#define FLASH_CR_SER            (1 << 1)
#define FLASH_CR_STRT           (1 << 16)
#define FLASH_CR_LOCK           (1 << 31)
#define FLASH_CR_PSIZE_WORD     (2 << 8)
#define FLASH_CR_SNB_SHIFT      3

/* UART Configuration (USART1: PA9=TX, PA10=RX) */
#define USART1_BASE             0x40011000
#define USART_SR                (*(volatile uint32_t *)(USART1_BASE + 0x00))
#define USART_DR                (*(volatile uint32_t *)(USART1_BASE + 0x04))
#define USART_BRR               (*(volatile uint32_t *)(USART1_BASE + 0x08))
#define USART_CR1               (*(volatile uint32_t *)(USART1_BASE + 0x0C))
#define USART_CR2               (*(volatile uint32_t *)(USART1_BASE + 0x10))
#define USART_CR3               (*(volatile uint32_t *)(USART1_BASE + 0x14))

#define USART_SR_RXNE           (1 << 5)
#define USART_SR_TXE            (1 << 7)
#define USART_SR_TC             (1 << 6)
#define USART_CR1_UE            (1 << 13)
#define USART_CR1_TE            (1 << 3)
#define USART_CR1_RE            (1 << 2)

/* SPI for SD Card (SPI1: PA5=SCK, PA6=MISO, PA7=MOSI, PA4=CS) */
#define SPI1_BASE               0x40013000
#define SPI_CR1                 (*(volatile uint32_t *)(SPI1_BASE + 0x00))
#define SPI_CR2                 (*(volatile uint32_t *)(SPI1_BASE + 0x04))
#define SPI_SR                  (*(volatile uint32_t *)(SPI1_BASE + 0x08))
#define SPI_DR                  (*(volatile uint32_t *)(SPI1_BASE + 0x0C))

#define SPI_CR1_SPE             (1 << 6)
#define SPI_CR1_MSTR            (1 << 2)
#define SPI_CR1_SSM             (1 << 9)
#define SPI_CR1_SSI             (1 << 8)
#define SPI_SR_RXNE             (1 << 0)
#define SPI_SR_TXE              (1 << 1)
#define SPI_SR_BSY              (1 << 7)

/* GPIO registers */
typedef struct {
    volatile uint32_t MODER;
    volatile uint32_t OTYPER;
    volatile uint32_t OSPEEDR;
    volatile uint32_t PUPDR;
    volatile uint32_t IDR;
    volatile uint32_t ODR;
    volatile uint32_t BSRR;
    volatile uint32_t LCKR;
    volatile uint32_t AFRL;
    volatile uint32_t AFRH;
} GPIO_TypeDef;

#define GPIOA                   ((GPIO_TypeDef *)0x40020000)
#define GPIOB                   ((GPIO_TypeDef *)0x40020400)
#define GPIOC                   ((GPIO_TypeDef *)0x40020800)

/* SysTick for timeout */
#define SYSTICK_CSR             (*(volatile uint32_t *)0xE000E010)
#define SYSTICK_RVR             (*(volatile uint32_t *)0xE000E014)
#define SYSTICK_CVR             (*(volatile uint32_t *)0xE000E018)

/* Firmware header structure - placed at start of firmware binary */
typedef struct {
    uint32_t magic;             /* 0x464D5755 "FWUP" */
    uint32_t version;
    uint32_t size;              /* Size of firmware data (excluding header) */
    uint32_t crc32;             /* CRC32 of firmware data */
    uint32_t entry_point;
    uint8_t  reserved[12];
} __attribute__((packed)) firmware_header_t;

#define FW_HEADER_MAGIC         0x464D5755

/* UART Protocol Commands */
#define CMD_SYNC                0xA5
#define CMD_ACK                 0x79
#define CMD_NACK                0x1F
#define CMD_START_UPDATE        0x01
#define CMD_DATA_PACKET         0x02
#define CMD_VERIFY              0x03
#define CMD_BOOT_APP            0x04
#define CMD_GET_STATUS          0x05

#define UART_PACKET_SIZE        256
#define UART_TIMEOUT_MS         5000
#define SD_BLOCK_SIZE           512

/* SD Card commands */
#define SD_CMD0                 0
#define SD_CMD1                 1
#define SD_CMD8                 8
#define SD_CMD12                12
#define SD_CMD16                16
#define SD_CMD17                17
#define SD_CMD55                55
#define SD_ACMD41               41
#define SD_CMD58                58

/* Status LED (PC13 on many boards) */
#define LED_GPIO                GPIOC
#define LED_PIN                 13

/* Global variables */
static volatile uint32_t systick_ms = 0;
static uint8_t rx_buffer[UART_PACKET_SIZE + 16];
static bool sd_card_hc = false;

/* CRC32 lookup table */
static const uint32_t crc32_table[256] = {
    0x00000000, 0x77073096, 0xEE0E612C, 0x990951BA, 0x076DC419, 0x706AF48F,
    0xE963A535, 0x9E6495A3, 0x0EDB8832, 0x79DCB8A4, 0xE0D5E91B, 0x97D2D988,
    0x09B64C2B, 0x7EB17CBE, 0xE7B82D09, 0x90BF1D91, 0x1DB71064, 0x6AB020F2,
    0xF3B97148, 0x84BE41DE, 0x1ADAD47D, 0x6DDDE4EB, 0xF4D4B551, 0x83D385C7,
    0x136C9856, 0x646BA8C0, 0xFD62F97A, 0x8A65C9EC, 0x14015C4F, 0x63066CD9,
    0xFA0F3D63, 0x8D080DF5, 0x3B6E20C8, 0x4C69105E, 0xD56041E4, 0xA2677172,
    0x3C03E4D1, 0x4B04D447, 0xD20D85FD, 0xA50AB56B, 0x35B5A8FA, 0x42B2986C,
    0xDBBBB9D6, 0xACBCF940, 0x32D86CE3, 0x45DF5C75, 0xDCD60DCF, 0xABD13D59,
    0x26D930AC, 0x51DE003A, 0xC8D75180, 0xBFD06116, 0x21B4F6B5, 0x56B3C423,
    0xCFBA9599, 0xB8BDA50F, 0x2802B89E, 0x5F058808, 0xC60CD9B2, 0xB10BE924,
    0x2F6F7C87, 0x58684C11, 0xC1611DAB, 0xB6662D3D, 0x76DC4190, 0x01DB7106,
    0x98D220BC, 0xEFD5102A, 0x71B18589, 0x06B6B51F, 0x9FBFE4A5, 0xE8B8D433,
    0x7807C9A2, 0x0F00F934, 0x9609A88E, 0xE10E9818, 0x7F6A0D6B, 0x086D3D2D,
    0x91646C97, 0xE6635C01, 0x6B6B51F4, 0x1C6C6162, 0x856530D8, 0xF262004E,
    0x6C0695ED, 0x1B01A57B, 0x8208F4C1, 0xF50FC457, 0x65B0D9C6, 0x12B7E950,
    0x8BBEB8EA, 0xFCB9887C, 0x62DD1DDF, 0x15DA2D49, 0x8CD37CF3, 0xFBD44C65,
    0x4DB26158, 0x3AB551CE, 0xA3BC0074, 0xD4BB30E2, 0x4ADFA541, 0x3DD895D7,
    0xA4D1C46D, 0xD3D6F4FB, 0x4369E96A, 0x346ED9FC, 0xAD678846, 0xDA60B8D0,
    0x44042D73, 0x33031DE5, 0xAA0A4C5F, 0xDD0D7822, 0x3B6E20C8, 0x4C69105E,
    0xD56041E4, 0xA2677172, 0x3C03E4D1, 0x4B04D447, 0xD20D85FD, 0xA50AB56B,
    0x35B5A8FA, 0x42B2986C, 0xDBBBB9D6, 0xACBCF940, 0x32D86CE3, 0x45DF5C75,
    0xDCD60DCF, 0xABD13D59, 0x26D930AC, 0x51DE003A, 0xC8D75180, 0xBFD06116,
    0x21B4F6B5, 0x56B3C423, 0xCFBA9599, 0xB8BDA50F, 0x2802B89E, 0x5F058808,
    0xC60CD9B2, 0xB10BE924, 0x2F6F7C87, 0x58684C11, 0xC1611DAB, 0xB6662D3D,
    0x76DC4190, 0x01DB7106, 0x98D220BC, 0xEFD5102A, 0x71B18589, 0x06B6B51F,
    0x9FBFE4A5, 0xE8B8D433, 0x7807C9A2, 0x0F00F934, 0x9609A88E, 0xE10E9818,
    0x7F6A0D6B, 0x086D3D2D, 0x91646C97, 0xE6635C01, 0x6B6B51F4, 0x1C6C6162,
    0x856530D8, 0xF262004E, 0x6C0695ED, 0x1B01A57B, 0x8208F4C1, 0xF50FC457,
    0x65B0D9C6, 0x12B7E950, 0x8BBEB8EA, 0xFCB9887C, 0x62DD1DDF, 0x15DA2D49,
    0x8CD37CF3, 0xFBD44C65, 0x4DB26158, 0x3AB551CE, 0xA3BC0074, 0xD4BB30E2,
    0x4ADFA541, 0x3DD895D7, 0xA4D1C46D, 0xD3D6F4FB, 0x4369E96A, 0x346ED9FC,
    0xAD678846, 0xDA60B8D0, 0x44042D73, 0x33031DE5, 0xAA0A4C5F, 0xDD0D7822,
    0x9B64C2B0, 0xEC63F226, 0x756AA39C, 0x026D930A, 0x9C0906A9, 0xEB0E363F,
    0x72076785, 0x05005713, 0x95BF4A82, 0xE2B87A14, 0x7BB12BAE, 0x0CB61B38,
    0x92D28E9B, 0xE5D5BE0D, 0x7CDCEFB7, 0x0BDBDF21, 0x86D3D2D4, 0xF1D4E242,
    0x68DDB3F6, 0x1FDA836E, 0x81BE16CD, 0xF6B9265B, 0x6FB077E1, 0x18B74777,
    0x88085AE6, 0xFF0F6B70, 0x66063BCA, 0x11010B5C, 0x8F659EFF, 0xF8620969,
    0x6165D969, 0x16624EB2, 0xB0D09822, 0xC7D7A8B4, 0x59B33D17, 0x2EB40D81,
    0xB7BD5C3B, 0xC0BA6CAD, 0xEDB88320, 0x9ABFB3B6, 0x03B6E20C, 0x74B1D29A,
    0xEAD54739, 0x9DD277AF, 0x04DB2615, 0x73DC1683, 0xE3630B12, 0x94643B84,
    0x0D6D6A3E, 0x7A6A5AA8, 0xE40ECF0B, 0x9309FF9D, 0x0A00AE27, 0x7D079EB1,
    0xF00F9344, 0x8708A3D2, 0x1E01F268, 0x6906C2FE, 0xF762575D, 0x806567CB,
    0x196C3671, 0x6E6B06E7, 0xFED41B76, 0x89D32BE0, 0x10DA7A5A, 0x67DD4ACC
};

/* ============================================================
 * Utility Functions
 * ============================================================ */

static void delay_ms(uint32_t ms) {
    uint32_t start = systick_ms;
    while ((systick_ms - start) < ms);
}

static uint32_t get_tick(void) {
    return systick_ms;
}

static uint32_t crc32_compute(const uint8_t *data, uint32_t length) {
    uint32_t crc = 0xFFFFFFFF;
    for (uint32_t i = 0; i < length; i++) {
        crc = (crc >> 8) ^ crc32_table[(crc ^ data[i]) & 0xFF];
    }
    return crc ^ 0xFFFFFFFF;
}

static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t length) {
    for (uint32_t i = 0; i < length; i++) {
        crc = (crc >> 8) ^ crc32_table[(crc ^ data[i]) & 0xFF];
    }
    return crc;
}

void SysTick_Handler(void) {
    systick_ms++;
}

/* ============================================================
 * Hardware Initialization
 * ============================================================ */

static void systick_init(void) {
    /* Assuming 16MHz HSI, 1ms tick */
    SYSTICK_RVR = 16000 - 1;
    SYSTICK_CVR = 0;
    SYSTICK_CSR = 0x07; /* Enable, interrupt, processor clock */
}

static void gpio_init(void) {
    /* Enable GPIOA, GPIOC clocks */
    RCC_AHB1ENR |= (1 << 0) | (1 << 2);

    /* PA0 as input with pull-up (bootloader entry pin) */
    GPIOA->MODER &= ~(3 << (BOOT_GPIO_PIN * 2));
    GPIOA->PUPDR &= ~(3 << (BOOT_GPIO_PIN * 2));
    GPIOA->PUPDR |= (1 << (BOOT_GPIO_PIN * 2)); /* Pull-up */

    /* PC13 as output (LED) */
    LED_GPIO->MODER &= ~(3 << (LED_PIN * 2));
    LED_GPIO->MODER |= (1 << (LED_PIN * 2));
}

static void led_on(void) {
    LED_GPIO->BSRR = (1 << (LED_PIN + 16)); /* Active low on many boards */
}

static void led_off(void) {
    LED_GPIO->BSRR = (1 << LED_PIN);
}

static void led_toggle(void) {
    LED_GPIO->ODR ^= (1 << LED_PIN);
}

static void uart_init(uint32_t baudrate) {
    /* Enable USART1 clock */
    RCC_APB2ENR |= (1 << 4);
    RCC_AHB1ENR |= (1 << 0); /* GPIOA */

    /* PA9 = USART1_TX (AF7), PA10 = USART1_RX (AF7) */
    GPIOA->MODER &= ~((3 << (9 * 2)) | (3 << (10 * 2)));
    GPIOA->MODER |= (2 << (9 * 2)) | (2 << (10 * 2)); /* Alternate function */
    GPIOA->OSPEEDR |= (3 << (9 * 2)) | (3 << (10 * 2)); /* High speed */
    GPIOA->AFRH &= ~((0xF << 4) | (0xF << 8));
    GPIOA->AFRH |= (7 << 4) | (7 << 8); /* AF7 for PA9, PA10 */

    /* Configure USART1: 16MHz HSI clock */
    USART_CR1 = 0;
    USART_BRR = 16000000 / baudrate;
    USART_CR1 = USART_CR1_UE | USART_CR1_TE | USART_CR1_RE;
}

static void uart_send_byte(uint8_t data) {
    while (!(USART_SR & USART_SR_TXE));
    USART_DR = data;
    while (!(USART_SR & USART_SR_TC));
}

static void uart_send_data(const uint8_t *data, uint32_t len) {
    for (uint32_t i = 0; i < len; i++) {
        uart_send_byte(data[i]);
    }
}

static void uart_send_string(const char *str) {
    while (*str) {
        uart_send_byte(*str++);
    }
}

static bool uart_receive_byte(uint8_t *data, uint32_t timeout_ms) {
    uint32_t start = get_tick();
    while (!(USART_SR & USART_SR_RXNE)) {
        if ((get_tick() - start) > timeout_ms) {
            return false;
        }
    }
    *data = (uint8_t)(USART_DR & 0xFF);
    return true;
}

static bool uart_receive_data(uint8_t *buf, uint32_t len, uint32_t timeout_ms) {
    for (uint32_t i = 0; i < len; i++) {
        if (!uart_receive_byte(&buf[i], timeout_ms)) {
            return false;
        }
    }
    return true;
}

/* ============================================================
 * SPI / SD Card Functions
 * ============================================================ */

static void spi_init(void) {
    /* Enable SPI1 clock */
    RCC_APB2ENR |= (1 << 12);
    RCC_AHB1ENR |= (1 << 0); /* GPIOA */

    /* PA4 = CS (GPIO output), PA5 = SCK, PA6 = MISO, PA7 = MOSI */
    /* PA4 as output */
    GPIOA->MODER &= ~(3 << (4 * 2));
    GPIOA->MODER |= (1 << (4 * 2));
    GPIOA->OSPEEDR |= (3 << (4 * 2));
    GPIOA->BSRR = (1 << 4); /* CS high */

    /* PA5, PA6, PA7 as AF5 (SPI1) */
    GPIOA->MODER &= ~((3 << (5 * 2)) | (3 << (6 * 2)) | (3 << (7 * 2)));
    GPIOA->MODER |= (2 << (5 * 2)) | (2 << (6 * 2)) | (2 << (7 * 2));
    GPIOA->OSPEEDR |= (3 << (5 * 2)) | (3 << (6 * 2)) | (3 << (7 * 2));
    GPIOA->AFRL &= ~((0xF << 20) | (0xF << 24) | (0xF << 28));
    GPIOA->AFRL |= (5 << 20) | (5 << 24) | (5 << 28);

    /* SPI1: Master, CPOL=0, CPHA=0, 8-bit, slow clock initially (fPCLK/256) */
    SPI_CR1 = SPI_CR1_MSTR | SPI_CR1_SSM | SPI_CR1_SSI | (7 << 3);
    SPI_CR1 |= SPI_CR1_SPE;
}

static void spi_set_fast(void) {
    SPI_CR1 &= ~SPI_CR1_SPE;
    SPI_CR1 &= ~(7 << 3);
    SPI_CR1 |= (1 << 3); /* fPCLK/4 */
    SPI_CR1 |= SPI_CR1_SPE;
}

static void sd_cs_low(void) {
    GPIOA->BSRR = (1 << (4 + 16));
}

static void sd_cs_high(void) {
    GPIOA->BSRR = (1 << 4);
}

static uint8_t spi_transfer(uint8_t data) {
    while (!(SPI_SR & SPI_SR_TXE));
    SPI_DR = data;
    while (!(SPI_SR & SPI_SR_RXNE));
    return (uint8_t)SPI_DR;
}

static void sd_send_command(uint8_t cmd, uint32_t arg, uint8_t crc) {
    spi_transfer(0x40 | cmd);
    spi_transfer((arg >> 24) & 0xFF);
    spi_transfer((arg >> 16) & 0xFF);
    spi_transfer((arg >> 8) & 0xFF);
    spi_transfer(arg & 0xFF);
    spi_transfer(crc);
}

static uint8_t sd_read_response(void) {
    uint8_t response;
    for (int i = 0; i < 16; i++) {
        response = spi_transfer(0xFF);
        if (response != 0xFF) return response;
    }
    return 0xFF;
}

static bool sd_wait_ready(uint32_t timeout_ms) {
    uint32_t start = get_tick();
    while (spi_transfer(0xFF) != 0xFF) {
        if ((get_tick() - start) > timeout_ms) return false;
    }
    return true;
}

static bool sd_init(void) {
    uint8_t response;

    spi_init();

    /* Send 80+ clock pulses with CS high */
    sd_cs_high();
    for (int i = 0; i < 20; i++) {
        spi_transfer(0xFF);
    }

    /* CMD0: GO_IDLE_STATE */
    sd_cs_low();
    sd_send_command(SD_CMD0, 0, 0x95);
    response = sd_read_response();
    sd_cs_high();
    spi_transfer(0xFF);

    if (response != 0x01) return false;

    /* CMD8: SEND_IF_COND (check SD v2) */
    sd_cs_low();
    sd_send_command(SD_CMD8, 0x1AA, 0x87);
    response = sd_read_response();

    bool sd_v2 = false;
    if (response == 0x01) {
        /* Read R7 response */
        uint8_t r7[4];
        for (int i = 0; i < 4; i++) r7[i] = spi_transfer(0xFF);
        sd_v2 = true;
        if ((r7[2] & 0x0F) != 0x01 || r7[3] != 0xAA) {
            sd_cs_high();
            return false;
        }
    }
    sd_cs_high();
    spi_transfer(0xFF);

    /* ACMD41: Initialize */
    uint32_t start = get_tick();
    do {
        sd_cs_low();
        sd_send_command(SD_CMD55, 0, 0xFF);
        sd_read_response();
        sd_cs_high();
        spi_transfer(0xFF);

        sd_cs_low();
        sd_send_command(SD_ACMD41, sd_v2 ? 0x40000000 : 0, 0xFF);
        response = sd_read_response();
        sd_cs_high();
        spi_transfer(0xFF);

        if ((get_tick() - start) > 2000) return false;
    } while (response != 0x00);

    /* Check for HC card */
    sd_card_hc = false;
    if (sd_v2) {
        sd_cs_low();
        sd_send_command(SD_CMD58, 0, 0xFF);
        response = sd_read_response();
        if (response == 0x00) {
            uint8_t ocr[4];
            for (int i = 0; i < 4; i++) ocr[i] = spi_transfer(0xFF);
            if (ocr[0] & 0x40) sd_card_hc = true;
        }
        sd_cs_high();
        spi_transfer(0xFF);
    }

    /* Set block size to 512 for non-HC cards */
    if (!sd_card_hc) {
        sd_cs_low();
        sd_send_command(SD_CMD16, SD_BLOCK_SIZE, 0xFF);
        sd_read_response();
        sd_cs_high();
        spi_transfer(0xFF);
    }

    spi_set_fast();
    return true;
}

static bool sd_read_block(uint32_t block_addr, uint8_t *buf) {
    uint32_t addr = sd_card_hc ? block_addr : (block_addr * SD_BLOCK_SIZE);

    sd_cs_low();
    sd_send_command(SD_CMD17, addr, 0xFF);

    uint8_t response = sd_read_response();
    if (response != 0x00) {
        sd_cs_high();
        return false;
    }

    /* Wait for data token 0xFE */
    uint32_t start = get_tick();
    while (spi_transfer(0xFF) != 0xFE) {
        if ((get_tick() - start) > 500) {
            sd_cs_high();
            return false;
        }
    }

    /* Read 512 bytes */
    for (int i = 0; i < SD_BLOCK_SIZE; i++) {
        buf[i] = spi_transfer(0xFF);
    }

    /* Read and discard CRC */
    spi_transfer(0xFF);
    spi_transfer(0xFF);

    sd_cs_high();
    spi_transfer(0xFF);

    return true;
}

/* ============================================================
 * Flash Programming Functions
 * ============================================================ */

static void flash_unlock(void) {
    if (FLASH_CR & FLASH_CR_LOCK) {
        FLASH_KEYR = FLASH_KEY1;
        FLASH_KEYR = FLASH_KEY2;
    }
}

static void flash_lock(void) {
    FLASH_CR |= FLASH_CR_LOCK;
}

static void flash_wait_busy(void) {
    while (FLASH_SR & FLASH_SR_BSY);
}

/* Get sector number for a given address (STM32F4 specific) */
static int flash_get_sector(uint32_t address) {
    if (address < 0x08004000) return 0;       /* 16KB */
    if (address < 0x08008000) return 1;       /* 16KB */
    if (address < 0x0800C000) return 2;       /* 16KB */
    if (address < 0x08010000) return 3;       /* 16KB */
    if (address < 0x08020000) return 4;       /* 64KB */
    if (address < 0x08040000) return 5;       /* 128KB */
    if (address < 0x08060000) return 6;       /* 128KB */
    if (address < 0x08080000) return 7;       /* 128KB */
    return -1;
}

static bool flash_erase_sector(int sector) {
    flash_wait_busy();

    FLASH_CR &= ~(0xF << FLASH_CR_SNB_SHIFT);
    FLASH_CR |= FLASH_CR_SER | (sector << FLASH_CR_SNB_SHIFT);
    FLASH_CR |= FLASH_CR_STRT;

    flash_wait_busy();

    FLASH_CR &= ~FLASH_CR_SER;

    return (FLASH_SR & 0xF0) == 0; /* Check for errors */
}

static bool flash_erase_app_area(void) {
    flash_unlock();

    /* Erase all sectors used by application */
    int start_sector = flash_get_sector(APP_START_ADDR);
    int end_sector = flash_get_sector(APP_START_ADDR + APP_MAX_SIZE - 1);

    if (start_sector < 0 || end_sector < 0) {
        flash_lock();
        return false;
    }

    for (int s = start_sector; s <= end_sector; s++) {
        uart_send_string("Erasing sector ");
        uart_send_byte('0' + s);
        uart_send_string("...\r\n");

        if (!flash_erase_sector(s)) {
            flash_lock();
            return false;
        }
        led_toggle();
    }

    flash_lock();
    return true;
}

static bool flash_program_word(uint32_t address, uint32_t data) {
    flash_wait_busy();

    FLASH_CR &= ~(3 << 8);
    FLASH_CR |= FLASH_CR_PSIZE_WORD; /* 32-bit parallelism */
    FLASH_CR |= FLASH_CR_PG;

    *(volatile uint32_t *)address = data;

    flash_wait_busy();

    FLASH_CR &= ~FLASH_CR_PG;

    return (*(volatile uint32_t *)address == data);
}

static bool flash_program_data(uint32_t start_addr, const uint8_t *data, uint32_t length) {
    flash_unlock();

    /* Program word-aligned data */
    uint32_t addr = start_addr;
    uint32_t i = 0;

    while (i < length) {
        uint32_t word = 0xFFFFFFFF;
        uint32_t remaining = length - i;
        uint32_t bytes_to_copy = (remaining >= 4) ? 4 : remaining;

        memcpy(&word, &data[i], bytes_to_copy);

        if (!flash_program_word(addr, word)) {
            flash_lock();
            return false;
        }

        addr += 4;
        i += 4;
    }

    flash_lock();
    return true;
}

/* ============================================================
 * Firmware Validation
 * ============================================================ */

static bool validate_firmware_header(const firmware_header_t *header) {
    if (header->magic != FW_HEADER_MAGIC) return false;
    if (header->size == 0 || header->size > APP_MAX_SIZE) return false;
    if (header->entry_point < APP_START_ADDR) return false;
    if (header->entry_point >= (APP_START_ADDR + APP_MAX_SIZE)) return false;
    return true;
}

static bool validate_app_image(void) {
    uint32_t sp = *(volatile uint32_t *)APP_START_ADDR;
    uint32_t pc = *(volatile uint32_t *)(APP_START_ADDR + 4);

    /* Check stack pointer is in SRAM range */
    if (sp < SRAM_BASE || sp > (SRAM_BASE + 0x20000)) return false;

    /* Check reset vector points to flash */
    if (pc < APP_START_ADDR || pc >= (APP_START_ADDR + APP_MAX_SIZE)) return false;

    return true;
}

static uint32_t compute_flash_crc(uint32_t start_addr, uint32_t length) {
    uint32_t crc = 0xFFFFFFFF;
    const uint8_t *ptr = (const uint8_t *)start_addr;

    for (uint32_t i = 0; i < length; i++) {
        crc = (crc >> 8) ^ crc32_table[(crc ^ ptr[i]) & 0xFF];
    }
    return crc ^ 0xFFFFFFFF;
}

/* ============================================================
 * SD Card Firmware Update
 * ============================================================ */

/* Simple FAT32-free approach: firmware.bin is written raw starting at block 0 */
/* For production, implement FAT32 file search */

static bool sd_firmware_update(void) {
    uint8_t block_buf[SD_BLOCK_SIZE];
    firmware_header_t header;

    uart_send_string("[SD] Checking for firmware on SD card...\r\n");

    if (!sd_init()) {
        uart_send_string("[SD] No SD card detected\r\n");
        return false;
    }

    uart_send_string("[SD] SD card initialized\r\n");

    /* Read first block containing firmware header */
    if (!sd_read_block(0, block_buf)) {
        uart_send_string("[SD] Failed to read block 0\r\n");
        return false;
    }

    memcpy(&header, block_buf, sizeof(firmware_header_t));

    if (!validate_firmware_header(&header)) {
        uart_send_string("[SD] No valid firmware header found\r\n");
        return false;
    }

    uart_send_string("[SD] Valid firmware found, size: ");
    /* Print size in hex */
    for (int i = 7; i >= 0; i--) {
        uint8_t nibble = (header.size >> (i * 4)) & 0xF;
        uart_send_byte(nibble < 10 ? '0' + nibble : 'A' + nibble - 10);
    }
    uart_send_string(" bytes\r\n");

    /* Erase application area */
    uart_send_string("[SD] Erasing flash...\r\n");
    if (!flash_erase_app_area()) {
        uart_send_string("[SD] Flash erase failed!\r\n");
        return false;
    }

    /* Program firmware from SD card */
    uart_send_string("[SD] Programming flash...\r\n");

    uint32_t total_size = header.size;
    uint32_t bytes_written = 0;
    uint32_t block_num = 0;
    uint32_t header_size = sizeof(firmware_header_t);
    uint32_t flash_addr = APP_START_ADDR;
    uint32_t crc = 0xFFFFFFFF;

    /* First block already read, program data after header */
    uint32_t data_in_first_block = SD_BLOCK_SIZE - header_size;
    if (data_in_first_block > total_size) data_in_first_block = total_size;

    flash_unlock();

    uint8_t *data_start = block_buf + header_size;
    crc = crc32_update(crc, data_start, data_in_first_block);

    for (uint32_t i = 0; i < data_in_first_block; i += 4) {
        uint32_t word = 0xFFFFFFFF;
        uint32_t remaining = data_in_first_block - i;
        uint32_t copy_len = remaining >= 4 ? 4 : remaining;
        memcpy(&word, data_start + i, copy_len);

        if (!flash_program_word(flash_addr, word)) {
            flash_lock();
            uart_send_string("[SD] Flash program failed!\r\n");
            return false;
        }
        flash_addr += 4;
    }
    bytes_written = data_in_first_block;
    block_num = 1;

    /* Read remaining blocks */
    while (bytes_written < total_size) {
        if (!sd_read_block(block_num, block_buf)) {
            flash_lock();
            uart_send_string("[SD] SD read error!\r\n");
            return false;
        }

        uint32_t chunk = total_size - bytes_written;
        if (chunk > SD_BLOCK_SIZE) chunk = SD_BLOCK_SIZE;

        crc = crc32_update(crc, block_buf, chunk);

        for (uint32_t i = 0; i < chunk; i += 4) {
            uint32_t word = 0xFFFFFFFF;
            uint32_t remaining = chunk - i;
            uint32_t copy_len = remaining >= 4 ? 4 : remaining;
            memcpy(&word, block_buf + i, copy_len);

            if (!flash_program_word(flash_addr, word)) {
                flash_lock();
                uart_send_string("[SD] Flash program failed!\r\n");
                return false;
            }
            flash_addr += 4;
        }

        bytes_written += chunk;
        block_num++;

        /* Progress indicator */
        if ((block_num & 0x1F) == 0) {
            led_toggle();
            uart_send_byte('.');
        }
    }

    flash_lock();

    crc ^= 0xFFFFFFFF;

    uart_send_string("\r\n[SD] Verifying CRC...\r\n");

    if (crc != header.crc32) {
        uart_send_string("[SD] CRC mismatch! Firmware corrupt.\r\n");
        return false;
    }

    uart_send_string("[SD] Firmware update successful!\r\n");
    return true;
}

/* ============================================================
 * UART Firmware Update Protocol
 * ============================================================
 *
 * Protocol:
 * 1. Host sends CMD_SYNC (0xA5), bootloader responds with CMD_ACK
 * 2. Host sends CMD_START_UPDATE + 4-byte size + 4-byte CRC32
 * 3. Bootloader erases flash, sends ACK
 * 4. Host sends CMD_DATA_PACKET + 2-byte length + data + 1-byte checksum
 * 5. Bootloader programs flash, sends ACK
 * 6. Repeat step 4 until all data sent
 * 7. Host sends CMD_VERIFY, bootloader verifies CRC and sends ACK/NACK
 * 8. Host sends CMD_BOOT_APP to jump to application
 */

static uint8_t compute_checksum(const uint8_t *data, uint32_t len) {
    uint8_t sum = 0;
    for (uint32_t i = 0; i < len; i++) {
        sum += data[i];
    }
    return ~sum;
}

static bool uart_firmware_update(void) {
    uint8_t cmd;
    uint32_t firmware_size = 0;
    uint32_t expected_crc = 0;
    uint32_t bytes_received = 0;
    uint32_t flash_addr = APP_START_ADDR;
    bool update_started = false;

    uart_send_string("[UART] Waiting for firmware update commands...\r\n");
    uart_send_string("[UART] Send 0xA5 to sync\r\n");

    while (1) {
        if (!uart_receive_byte(&cmd, UART_TIMEOUT_MS)) {
            if (!update_started) {
                return false; /* Timeout, no host connected */
            }
            uart_send_string("[UART] Timeout during transfer!\r\n");
            return false;
        }

        switch (cmd) {
        case CMD_SYNC:
            uart_send_byte(CMD_ACK);
            uart_send_string("[UART] Synced with host\r\n");
            break;

        case CMD_START_UPDATE: {
            uint8_t params[8];
            if (!uart_receive_data(params, 8, 2000)) {
                uart_send_byte(CMD_NACK);
                break;
            }

            firmware_size = (params[0] << 24) | (params[1] << 16) |
                           (params[2] << 8) | params[3];
            expected_crc = (params[4] << 24) | (params[5] << 16) |
                          (params[6] << 8) | params[7];

            if (firmware_size == 0 || firmware_size > APP_MAX_SIZE) {
                uart_send_byte(CMD_NACK);
                uart_send_string("[UART] Invalid firmware size\r\n");
                break;
            }

            uart_send_string("[UART] Erasing flash for ");
            for (int i = 7; i >= 0; i--) {
                uint8_t nibble = (firmware_size >> (i * 4)) & 0xF;
                uart_send_byte(nibble < 10 ? '0' + nibble : 'A' + nibble - 10);
            }
            uart_send_string(" bytes\r\n");

            if (!flash_erase_app_area()) {
                uart_send_byte(CMD_NACK);
                uart_send_string("[UART] Erase failed!\r\n");
                break;
            }

            bytes_received = 0;
            flash_addr = APP_START_ADDR;
            update_started = true;

            uart_send_byte(CMD_ACK);
            uart_send_string("[UART] Ready for data\r\n");
            break;
        }

        case CMD_DATA_PACKET: {
            if (!update_started) {
                uart_send_byte(CMD_NACK);
                break;
            }

            uint8_t len_bytes[2];
            if (!uart_receive_data(len_bytes, 2, 2000)) {
                uart_send_byte(CMD_NACK);
                break;
            }

            uint16_t packet_len = (len_bytes[0] << 8) | len_bytes[1];
            if (packet_len == 0 || packet_len > UART_PACKET_SIZE) {
                uart_send_byte(CMD_NACK);
                break;
            }

            if (!uart_receive_data(rx_buffer, packet_len, 5000)) {
                uart_send_byte(CMD_NACK);
                break;
            }

            uint8_t checksum;
            if (!uart_receive_byte(&checksum, 1000)) {
                uart_send_byte(CMD_NACK);
                break;
            }

            /* Verify checksum */
            uint8_t computed_cs = compute_checksum(rx_buffer, packet_len);
            if (computed_cs != checksum) {
                uart_send_byte(CMD_NACK);
                break;
            }

            /* Program to flash */
            if (!flash_program_data(flash_addr, rx_buffer, packet_len)) {
                uart_send_byte(CMD_NACK);
                uart_send_string("[UART] Flash write failed!\r\n");
                return false;
            }

            flash_addr += packet_len;
            bytes_received += packet_len;
            led_toggle();

            uart_send_byte(CMD_ACK);
            break;
        }

        case CMD_VERIFY: {
            if (!update_started || bytes_received != firmware_size) {
                uart_send_byte(CMD_NACK);
                uart_send_string("[UART] Size mismatch\r\n");
                break;
            }

            uart_send_string("[UART] Verifying CRC...\r\n");
            uint32_t actual_crc = compute_flash_crc(APP_START_ADDR, firmware_size);

            if (actual_crc != expected_crc) {
                uart_send_byte(CMD_NACK);
                uart_send_string("[UART] CRC verification failed!\r\n");
                return false;
            }

            uart_send_byte(CMD_ACK);
            uart_send_string("[UART] CRC OK! Update successful.\r\n");
            break;
        }

        case CMD_BOOT_APP:
            uart_send_byte(CMD_ACK);
            uart_send_string("[UART] Booting application...\r\n");
            return true;

        case CMD_GET_STATUS: {
            uint8_t status[9];
            status[0] = CMD_ACK;
            status[1] = update_started ? 1 : 0;
            status[2] = (bytes_received >> 24) & 0xFF;
            status[3] = (bytes_received >> 16) & 0xFF;
            status[4] = (bytes_received >> 8) & 0xFF;
            status[5] = bytes_received & 0xFF;
            status[6] = (firmware_size >> 24) & 0xFF;
            status[7] = (firmware_size >> 16) & 0xFF;
            status[8] = (firmware_size >> 8) & 0xFF;
            uart_send_data(status, 9);
            break;
        }

        default:
            uart_send_byte(CMD_NACK);
            break;
        }
    }
}

/* ============================================================
 * Boot Entry Decision
 * ============================================================ */

typedef enum {
    BOOT_REASON_NONE = 0,
    BOOT_REASON_GPIO,
    BOOT_REASON_MAGIC_WORD,
    BOOT_REASON_NO_APP,
    BOOT_REASON_CORRUPT_APP
} boot_reason_t;

static boot_reason_t check_bootloader_entry(void) {
    /* Check magic word in SRAM (set by application before reset) */
    volatile uint32_t *magic = (volatile uint32_t *)BOOTLOADER_MAGIC_ADDR;
    if (*magic == BOOTLOADER_MAGIC_WORD) {
        *magic = 0; /* Clear magic word */
        return BOOT_REASON_MAGIC_WORD;
    }

    /* Check GPIO pin (active low with pull-up) */
    delay_ms(50); /* Debounce */
    if (!(GPIOA->IDR & (1 << BOOT_GPIO_PIN))) {
        /* Wait and re-check for debounce */
        delay_ms(100);
        if (!(GPIOA->IDR & (1 << BOOT_GPIO_PIN))) {
            return BOOT_REASON_GPIO;
        }
    }

    /* Check if valid application exists */
    if (!validate_app_image()) {
        return BOOT_REASON_NO_APP;
    }

    return BOOT_REASON_NONE;
}

/* ============================================================
 * Jump to Application
 * ============================================================ */

typedef void (*app_entry_t)(void);

static void jump_to_app(void) {
    uint32_t app_sp = *(volatile uint32_t *)APP_START_ADDR;
    uint32_t app_pc = *(volatile uint32_t *)(APP_START_ADDR + 4);

    uart_send_string("Jumping to application at 0x");
    for (int i = 7; i >= 0; i--) {
        uint8_t nibble = (app_pc >> (i * 4)) & 0xF;
        uart_send_byte(nibble < 10 ? '0' + nibble : 'A' + nibble - 10);
    }
    uart_send_string("\r\n\r\n");

    /* Small delay for UART to finish */
    delay_ms(10);

    /* Disable SysTick */
    SYSTICK_CSR = 0;
    SYSTICK_RVR = 0;
    SYSTICK_CVR = 0;

    /* Disable all interrupts */
    for (int i = 0; i < 8; i++) {
        /* NVIC ICER registers */
        *(volatile uint32_t *)(0xE000E180 + (i * 4)) = 0xFFFFFFFF;
    }

    /* Clear all pending interrupts */
    for (int i = 0; i < 8; i++) {
        *(volatile uint32_t *)(0xE000E280 + (i * 4)) = 0xFFFFFFFF;
    }

    /* Set vector table offset to application */
    *(volatile uint32_t *)0xE000ED08 = APP_START_ADDR;

    /* Set MSP to application's stack pointer */
    __asm volatile (
        "MSR msp, %0\n"
        "DSB\n"
        "ISB\n"
        :
        : "r" (app_sp)
    );

    /* Jump to application reset handler */
    app_entry_t app_entry = (app_entry_t)app_pc;
    app_entry();

    /* Should never reach here */
    while (1);
}

/* ============================================================
 * Bootloader Main Loop
 * ============================================================ */

static void bootloader_mode(boot_reason_t reason) {
    const char *reason_str[] = {
        "Unknown",
        "GPIO pin held low",
        "Application request (magic word)",
        "No valid application found",
        "Corrupt application image"
    };

    uart_send_string("\r\n========================================\r\n");
    uart_send_string("  ARM Cortex-M Bootloader v1.0\r\n");
    uart_send_string("========================================\r\n");
    uart_send_string("Entry reason: ");
    uart_send_string(reason_str[reason]);
    uart_send_string("\r\n\r\n");

    uart_send_string("Update sources:\r\n");
    uart_send_string("  1. SD Card (auto-detect)\r\n");
    uart_send_string("  2. UART (115200 baud)\r\n");
    uart_send_string("\r\n");

    /* Try SD card first for fastest field updates */
    led_on();

    if (sd_firmware_update()) {
        uart_send_string("\r\nSD update complete. ");

        if (validate_app_image()) {
            uart_send_string("Booting...\r\n");
            delay_ms(500);
            led_off();
            jump_to_app();
        } else {
            uart_send_string("But app validation failed!\r\n");
        }
    }

    /* Fall through to UART mode */
    uart_send_string("\r\n[UART] Entering UART update mode...\r\n");

    while (1) {
        led_toggle();

        if (uart_firmware_update()) {
            if (validate_app_image()) {
                uart_send_string("Booting application...\r\n");
                delay_ms(200);
                led_off();
                jump_to_app();
            } else {
                uart_send_string("WARNING: Application validation failed after update!\r\n");
                uart_send_string("Remaining in bootloader mode.\r\n");
            }
        }

        /* If UART timed out, blink LED and retry */
        uart_send_string("Waiting for connection... (send 0xA5 to sync)\r\n");
        for (int i = 0; i < 10; i++) {
            led_toggle();
            delay_ms(200);
        }
    }
}

/* ============================================================
 * Vector Table and Startup
 * ============================================================ */

extern uint32_t _estack;
extern uint32_t _sdata, _edata, _sidata;
extern uint32_t _sbss, _ebss;

void Reset_Handler(void);
void Default_Handler(void);
void NMI_Handler(void) __attribute__((weak, alias("Default_Handler")));
void HardFault_Handler(void);

__attribute__((section(".isr_vector")))
const uint32_t vector_table[] = {
    (uint32_t)&_estack,
    (uint32_t)Reset_Handler,
    (uint32_t)NMI_Handler,
    (uint32_t)HardFault_Handler,
    (uint32_t)Default_Handler, /* MemManage */
    (uint32_t)Default_Handler, /* BusFault */
    (uint32_t)Default_Handler, /* UsageFault */
    0, 0, 0, 0,               /* Reserved */
    (uint32_t)Default_Handler, /* SVCall */
    (uint32_t)Default_Handler, /* Debug Monitor */
    0,                         /* Reserved */
    (uint32_t)Default_Handler, /* PendSV */
    (uint32_t)SysTick_Handler, /* SysTick */
};

void Default_Handler(void) {
    while (1);
}

void HardFault_Handler(void) {
    /* Attempt to signal error via LED */
    RCC_AHB1ENR |= (1 << 2);
    LED_GPIO->MODER &= ~(3 << (LED_PIN * 2));
    LED_GPIO->MODER |= (1 << (LED_PIN * 2));

    while (1) {
        LED_GPIO->ODR ^= (1 << LED_PIN);
        for (volatile int i = 0; i < 500000; i++);
    }
}

void Reset_Handler(void) {
    /* Copy .data section from flash to SRAM */
    uint32_t *src = &_sidata;
    uint32_t *dst = &_sdata;
    while (dst < &_edata) {
        *dst++ = *src++;
    }

    /* Zero .bss section */
    dst = &_sbss;
    while (dst < &_ebss) {
        *dst++ = 0;
    }

    /* Call main */
    extern int main(void);
    main();

    while (1);
}

/* ============================================================
 * Main Entry Point
 * ============================================================ */

int main(void) {
    /* Initialize core peripherals */
    systick_init();
    gpio_init();
    uart_init(115200);

    /* Enable interrupts */
    __asm volatile ("cpsie i");

    /* Quick startup message */
    uart_send_string("\r\nBOOT\r\n");

    /* Determine if we should enter bootloader mode */
    boot_reason_t reason = check_bootloader_entry();

    if (reason == BOOT_REASON_NONE) {
        /* Fast path: valid app exists, no bootloader request */
        /* Optional: quick SD card check for new firmware */
        /* This enables automatic field updates on next boot */

        /* Quick check for SD card firmware (with short timeout) */
        bool sd_present = false;
        spi_init();
        sd_cs_high();
        for (int i = 0; i < 20; i++) spi_transfer(0xFF);
        sd_cs_low();
        sd_send_command(SD_CMD0, 0, 0x95);
        uint8_t resp = sd_read_response();
        sd_cs_high();

        if (resp == 0x01) {
            /* SD card detected, check for firmware update file */
            if (sd_init()) {
                uint8_t block[SD_BLOCK_SIZE];
                if (sd_read_block(0, block)) {
                    firmware_header_t *hdr = (firmware_header_t *)block;
                    if (hdr->magic == FW_HEADER_MAGIC) {
                        /* Check if this is a newer version */
                        /* For now, just check if firmware exists */
                        uart_send_string("SD firmware detected, entering update mode\r\n");
                        reason = BOOT_REASON_NONE;
                        /* Perform SD update */
                        if (sd_firmware_update()) {
                            if (validate_app_image()) {
                                uart_send_string("Update done, booting\r\n");
                                delay_ms(100);
                                jump_to_app();
                            }
                        }
                    }
                }
            }
        }

        /* No update needed, boot application immediately */
        uart_send_string("Booting app...\r\n");
        jump_to_app();
    }

    /* Enter bootloader mode */
    bootloader_mode(reason);

    /* Should never reach here */
    while (1) {
        led_toggle();
        delay_ms(1000);
    }

    return 0;
}

/* ============================================================
 * Linker Script (bootloader.ld) - Include as separate file
 * ============================================================
 *
 * MEMORY
 * {
 *     FLASH (rx)  : ORIGIN = 0x08000000, LENGTH = 32K
 *     SRAM (rwx)  : ORIGIN = 0x20000000, LENGTH = 128K
 * }
 *
 * _estack = ORIGIN(SRAM) + LENGTH(SRAM);
 *
 * SECTIONS
 * {
 *     .isr_vector :
 *     {
 *         . = ALIGN(4);
 *         KEEP(*(.isr_vector))
 *         . = ALIGN(4);
 *     } >FLASH
 *
 *     .text :
 *     {
 *         . = ALIGN(4);
 *         *(.text)
 *         *(.text*)
 *         *(.rodata)
 *         *(.rodata*)
 *         . = ALIGN(4);
 *         _etext = .;
 *     } >FLASH
 *
 *     _sidata = LOADADDR(.data);
 *
 *     .data :
 *     {
 *         . = ALIGN(4);
 *         _sdata = .;
 *         *(.data)
 *         *(.data*)
 *         . = ALIGN(4);
 *         _edata = .;
 *     } >S