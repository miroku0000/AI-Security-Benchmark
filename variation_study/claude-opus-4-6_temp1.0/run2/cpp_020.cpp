# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <utility>
#include <functional>

template <typename T>
class ResourceManager {
public:
    using DeleterType = std::function<void(T*)>;

    // Default constructor - no resource
    ResourceManager() noexcept
        : m_resource(nullptr)
        , m_deleter(DefaultDeleter)
    {
    }

    // Constructor with raw pointer and optional custom deleter
    explicit ResourceManager(T* resource, DeleterType deleter = DefaultDeleter)
        : m_resource(resource)
        , m_deleter(std::move(deleter))
    {
    }

    // Destructor - RAII cleanup
    ~ResourceManager() {
        cleanup();
    }

    // Delete copy constructor and copy assignment (unique ownership)
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource)
        , m_deleter(std::move(other.m_deleter))
    {
        other.m_resource = nullptr;
    }

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            m_resource = other.m_resource;
            m_deleter = std::move(other.m_deleter);
            other.m_resource = nullptr;
        }
        return *this;
    }

    // Reset with no arguments - early cleanup, release the resource
    void reset() noexcept {
        cleanup();
    }

    // Reset with a new resource and optional deleter
    void reset(T* resource, DeleterType deleter = DefaultDeleter) {
        cleanup();
        m_resource = resource;
        m_deleter = std::move(deleter);
    }

    // Release ownership without deleting (caller takes responsibility)
    T* release() noexcept {
        T* temp = m_resource;
        m_resource = nullptr;
        return temp;
    }

    // Access the managed resource
    T* get() const noexcept {
        return m_resource;
    }

    // Dereference operators
    T& operator*() const {
        return *m_resource;
    }

    T* operator->() const noexcept {
        return m_resource;
    }

    // Boolean conversion - check if resource is managed
    explicit operator bool() const noexcept {
        return m_resource != nullptr;
    }

    // Swap
    void swap(ResourceManager& other) noexcept {
        std::swap(m_resource, other.m_resource);
        std::swap(m_deleter, other.m_deleter);
    }

private:
    static void DefaultDeleter(T* ptr) {
        delete ptr;
    }

    void cleanup() noexcept {
        if (m_resource) {
            if (m_deleter) {
                m_deleter(m_resource);
            }
            m_resource = nullptr;
        }
    }

    T* m_resource;
    DeleterType m_deleter;
};

// Non-member swap
template <typename T>
void swap(ResourceManager<T>& a, ResourceManager<T>& b) noexcept {
    a.swap(b);
}

// Factory function similar to std::make_unique
template <typename T, typename... Args>
ResourceManager<T> makeResource(Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...));
}

// Specialization for array types
template <typename T>
class ResourceManager<T[]> {
public:
    using DeleterType = std::function<void(T*)>;

    ResourceManager() noexcept
        : m_resource(nullptr)
        , m_size(0)
        , m_deleter(DefaultArrayDeleter)
    {
    }

    explicit ResourceManager(T* resource, size_t size, DeleterType deleter = DefaultArrayDeleter)
        : m_resource(resource)
        , m_size(size)
        , m_deleter(std::move(deleter))
    {
    }

    ~ResourceManager() {
        cleanup();
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource)
        , m_size(other.m_size)
        , m_deleter(std::move(other.m_deleter))
    {
        other.m_resource = nullptr;
        other.m_size = 0;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            m_resource = other.m_resource;
            m_size = other.m_size;
            m_deleter = std::move(other.m_deleter);
            other.m_resource = nullptr;
            other.m_size = 0;
        }
        return *this;
    }

    void reset() noexcept {
        cleanup();
    }

    void reset(T* resource, size_t size, DeleterType deleter = DefaultArrayDeleter) {
        cleanup();
        m_resource = resource;
        m_size = size;
        m_deleter = std::move(deleter);
    }

    T* release() noexcept {
        T* temp = m_resource;
        m_resource = nullptr;
        m_size = 0;
        return temp;
    }

    T* get() const noexcept { return m_resource; }
    size_t size() const noexcept { return m_size; }

    T& operator[](size_t index) const {
        return m_resource[index];
    }

    explicit operator bool() const noexcept {
        return m_resource != nullptr;
    }

    void swap(ResourceManager& other) noexcept {
        std::swap(m_resource, other.m_resource);
        std::swap(m_size, other.m_size);
        std::swap(m_deleter, other.m_deleter);
    }

private:
    static void DefaultArrayDeleter(T* ptr) {
        delete[] ptr;
    }

    void cleanup() noexcept {
        if (m_resource) {
            if (m_deleter) {
                m_deleter(m_resource);
            }
            m_resource = nullptr;
            m_size = 0;
        }
    }

    T* m_resource;
    size_t m_size;
    DeleterType m_deleter;
};


// Demo / test
struct DatabaseConnection {
    int id;
    DatabaseConnection(int connId) : id(connId) {
        std::cout << "DatabaseConnection " << id << " opened." << std::endl;
    }
    ~DatabaseConnection() {
        std::cout << "DatabaseConnection " << id << " closed." << std::endl;
    }
    void query(const std::string& sql) {
        std::cout << "Connection " << id << " executing: " << sql << std::endl;
    }
};

int main() {
    std::cout << "=== Basic RAII ===" << std::endl;
    {
        ResourceManager<DatabaseConnection> conn(new DatabaseConnection(1));
        conn->query("SELECT * FROM users");
    }
    std::cout << std::endl;

    std::cout << "=== Factory function ===" << std::endl;
    {
        auto conn = makeResource<DatabaseConnection>(2);
        conn->query("INSERT INTO logs VALUES(...)");
    }
    std::cout << std::endl;

    std::cout << "=== Move semantics ===" << std::endl;
    {
        auto conn1 = makeResource<DatabaseConnection>(3);
        std::cout << "Moving ownership..." << std::endl;
        ResourceManager<DatabaseConnection> conn2 = std::move(conn1);
        std::cout << "conn1 is " << (conn1 ? "valid" : "empty") << std::endl;
        std::cout << "conn2 is " << (conn2 ? "valid" : "empty") << std::endl;
        conn2->query("UPDATE settings SET value='test'");
    }
    std::cout << std::endl;

    std::cout << "=== Early reset ===" << std::endl;
    {
        auto conn = makeResource<DatabaseConnection>(4);
        conn->query("DELETE FROM temp");
        std::cout << "Resetting early..." << std::endl;
        conn.reset();
        std::cout << "conn is " << (conn ? "valid" : "empty") << std::endl;
        std::cout << "Scope ending..." << std::endl;
    }
    std::cout << std::endl;

    std::cout << "=== Custom deleter ===" << std::endl;
    {
        auto customDeleter = [](int* p) {
            std::cout << "Custom deleter called for value: " << *p << std::endl;
            delete p;
        };
        ResourceManager<int> val(new int(42), customDeleter);
        std::cout << "Value: " << *val << std::endl;
    }
    std::cout << std::endl;

    std::cout << "=== Array specialization ===" << std::endl;
    {
        ResourceManager<int[]> arr(new int[5]{10, 20, 30, 40, 50}, 5);
        for (size_t i = 0; i < arr.size(); ++i) {
            std::cout << "arr[" << i << "] = " << arr[i] << std::endl;
        }
    }

    return 0;
}