# Generated by anthropic (claude-opus-4-6)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/mutex.h>
#include <string.h>

/* Priority and stack definitions */
#define ADMIN_STACK_SIZE 2048
#define USER_STACK_SIZE 2048
#define ADMIN_PRIORITY 5
#define USER_PRIORITY 7

/* Privilege levels */
#define PRIV_NONE       0x00
#define PRIV_READ       0x01
#define PRIV_WRITE      0x02
#define PRIV_EXECUTE    0x04
#define PRIV_ADMIN      (PRIV_READ | PRIV_WRITE | PRIV_EXECUTE)
#define PRIV_USER       (PRIV_READ)

/* Operation types */
#define OP_FLASH_WRITE       1
#define OP_CONFIG_MODIFY     2
#define OP_CONFIG_READ       3
#define OP_STATUS_REQUEST    4

/* Operation result codes */
#define OP_SUCCESS           0
#define OP_DENIED           -1
#define OP_INVALID          -2
#define OP_FAILED           -3

/* System config max entries */
#define MAX_CONFIG_ENTRIES   16
#define CONFIG_KEY_LEN       32
#define CONFIG_VAL_LEN       64

/* Flash simulation */
#define SIMULATED_FLASH_SIZE 256

/* Message queue for privilege requests */
#define MSG_QUEUE_SIZE 8

K_THREAD_STACK_DEFINE(admin_stack, ADMIN_STACK_SIZE);
K_THREAD_STACK_DEFINE(user_stack, USER_STACK_SIZE);

static struct k_thread admin_thread_data;
static struct k_thread user_thread_data;

/* Privilege request message */
struct priv_request {
    uint32_t operation;
    uint32_t requester_id;
    uint32_t requester_priv;
    uint8_t data[64];
    uint32_t data_len;
    uint32_t flash_offset;
};

/* Privilege response message */
struct priv_response {
    int32_t result;
    uint8_t data[64];
    uint32_t data_len;
};

/* System configuration entry */
struct config_entry {
    char key[CONFIG_KEY_LEN];
    char value[CONFIG_VAL_LEN];
    bool in_use;
    uint32_t min_priv_read;
    uint32_t min_priv_write;
};

/* Task identity */
struct task_identity {
    uint32_t id;
    uint32_t privilege;
    char name[32];
};

/* Simulated flash memory */
static uint8_t simulated_flash[SIMULATED_FLASH_SIZE];
static struct k_mutex flash_mutex;

/* System configuration storage */
static struct config_entry system_config[MAX_CONFIG_ENTRIES];
static struct k_mutex config_mutex;

/* Message queues for inter-task communication */
K_MSGQ_DEFINE(request_queue, sizeof(struct priv_request), MSG_QUEUE_SIZE, 4);
K_MSGQ_DEFINE(response_queue, sizeof(struct priv_response), MSG_QUEUE_SIZE, 4);

/* Semaphore to synchronize request/response */
K_SEM_DEFINE(request_sem, 0, 1);
K_SEM_DEFINE(response_sem, 0, 1);

/* Audit log */
#define AUDIT_LOG_SIZE 32

struct audit_entry {
    uint32_t timestamp;
    uint32_t requester_id;
    uint32_t operation;
    int32_t result;
    bool granted;
};

static struct audit_entry audit_log[AUDIT_LOG_SIZE];
static uint32_t audit_index = 0;
static struct k_mutex audit_mutex;

/* ---- Initialization ---- */

static void init_simulated_flash(void)
{
    k_mutex_init(&flash_mutex);
    memset(simulated_flash, 0xFF, SIMULATED_FLASH_SIZE);
    printk("[FLASH] Simulated flash initialized (%d bytes)\n", SIMULATED_FLASH_SIZE);
}

static void init_system_config(void)
{
    k_mutex_init(&config_mutex);
    memset(system_config, 0, sizeof(system_config));

    /* Initialize default config entries */
    strncpy(system_config[0].key, "system.hostname", CONFIG_KEY_LEN - 1);
    strncpy(system_config[0].value, "zephyr-node-01", CONFIG_VAL_LEN - 1);
    system_config[0].in_use = true;
    system_config[0].min_priv_read = PRIV_READ;
    system_config[0].min_priv_write = PRIV_WRITE;

    strncpy(system_config[1].key, "network.ip", CONFIG_KEY_LEN - 1);
    strncpy(system_config[1].value, "192.168.1.100", CONFIG_VAL_LEN - 1);
    system_config[1].in_use = true;
    system_config[1].min_priv_read = PRIV_READ;
    system_config[1].min_priv_write = PRIV_WRITE;

    strncpy(system_config[2].key, "security.level", CONFIG_KEY_LEN - 1);
    strncpy(system_config[2].value, "high", CONFIG_VAL_LEN - 1);
    system_config[2].in_use = true;
    system_config[2].min_priv_read = PRIV_READ;
    system_config[2].min_priv_write = PRIV_ADMIN;

    strncpy(system_config[3].key, "admin.secret_key", CONFIG_KEY_LEN - 1);
    strncpy(system_config[3].value, "supersecret123", CONFIG_VAL_LEN - 1);
    system_config[3].in_use = true;
    system_config[3].min_priv_read = PRIV_ADMIN;
    system_config[3].min_priv_write = PRIV_ADMIN;

    printk("[CONFIG] System configuration initialized with default entries\n");
}

static void init_audit_log(void)
{
    k_mutex_init(&audit_mutex);
    memset(audit_log, 0, sizeof(audit_log));
    printk("[AUDIT] Audit log initialized\n");
}

/* ---- Audit logging ---- */

static void log_audit(uint32_t requester_id, uint32_t operation, int32_t result, bool granted)
{
    k_mutex_lock(&audit_mutex, K_FOREVER);

    struct audit_entry *entry = &audit_log[audit_index % AUDIT_LOG_SIZE];
    entry->timestamp = k_uptime_get_32();
    entry->requester_id = requester_id;
    entry->operation = operation;
    entry->result = result;
    entry->granted = granted;
    audit_index++;

    k_mutex_unlock(&audit_mutex);

    printk("[AUDIT] ts=%u requester=%u op=%u result=%d granted=%s\n",
           entry->timestamp, requester_id, operation, result,
           granted ? "YES" : "NO");
}

/* ---- Privilege checking ---- */

static bool check_privilege(uint32_t required_priv, uint32_t actual_priv)
{
    return (actual_priv & required_priv) == required_priv;
}

static const char *priv_to_string(uint32_t priv)
{
    if (priv == PRIV_ADMIN) return "ADMIN(RWX)";
    if (priv == PRIV_USER) return "USER(R)";
    if (priv == (PRIV_READ | PRIV_WRITE)) return "RW";
    if (priv == PRIV_READ) return "R";
    if (priv == PRIV_WRITE) return "W";
    if (priv == PRIV_EXECUTE) return "X";
    if (priv == PRIV_NONE) return "NONE";
    return "UNKNOWN";
}

static const char *op_to_string(uint32_t op)
{
    switch (op) {
    case OP_FLASH_WRITE: return "FLASH_WRITE";
    case OP_CONFIG_MODIFY: return "CONFIG_MODIFY";
    case OP_CONFIG_READ: return "CONFIG_READ";
    case OP_STATUS_REQUEST: return "STATUS_REQUEST";
    default: return "UNKNOWN";
    }
}

/* ---- Flash operations (admin only) ---- */

static int flash_write(uint32_t offset, const uint8_t *data, uint32_t len,
                       uint32_t requester_priv, uint32_t requester_id)
{
    if (!check_privilege(PRIV_WRITE, requester_priv)) {
        printk("[FLASH] DENIED: Requester %u (priv=%s) lacks WRITE privilege\n",
               requester_id, priv_to_string(requester_priv));
        log_audit(requester_id, OP_FLASH_WRITE, OP_DENIED, false);
        return OP_DENIED;
    }

    if (offset + len > SIMULATED_FLASH_SIZE) {
        printk("[FLASH] ERROR: Write out of bounds (offset=%u, len=%u)\n", offset, len);
        log_audit(requester_id, OP_FLASH_WRITE, OP_INVALID, false);
        return OP_INVALID;
    }

    k_mutex_lock(&flash_mutex, K_FOREVER);
    memcpy(&simulated_flash[offset], data, len);
    k_mutex_unlock(&flash_mutex);

    printk("[FLASH] SUCCESS: Written %u bytes at offset %u by requester %u\n",
           len, offset, requester_id);
    log_audit(requester_id, OP_FLASH_WRITE, OP_SUCCESS, true);
    return OP_SUCCESS;
}

static int flash_read(uint32_t offset, uint8_t *data, uint32_t len,
                      uint32_t requester_priv, uint32_t requester_id)
{
    if (!check_privilege(PRIV_READ, requester_priv)) {
        printk("[FLASH] DENIED: Requester %u lacks READ privilege for flash\n", requester_id);
        return OP_DENIED;
    }

    if (offset + len > SIMULATED_FLASH_SIZE) {
        return OP_INVALID;
    }

    k_mutex_lock(&flash_mutex, K_FOREVER);
    memcpy(data, &simulated_flash[offset], len);
    k_mutex_unlock(&flash_mutex);

    return OP_SUCCESS;
}

/* ---- Config operations ---- */

static int config_read(const char *key, char *value, uint32_t val_size,
                       uint32_t requester_priv, uint32_t requester_id)
{
    k_mutex_lock(&config_mutex, K_FOREVER);

    for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
        if (system_config[i].in_use &&
            strncmp(system_config[i].key, key, CONFIG_KEY_LEN) == 0) {

            if (!check_privilege(system_config[i].min_priv_read, requester_priv)) {
                printk("[CONFIG] DENIED: Requester %u (priv=%s) cannot read '%s' (requires %s)\n",
                       requester_id, priv_to_string(requester_priv),
                       key, priv_to_string(system_config[i].min_priv_read));
                k_mutex_unlock(&config_mutex);
                log_audit(requester_id, OP_CONFIG_READ, OP_DENIED, false);
                return OP_DENIED;
            }

            strncpy(value, system_config[i].value, val_size - 1);
            value[val_size - 1] = '\0';
            k_mutex_unlock(&config_mutex);

            printk("[CONFIG] SUCCESS: Requester %u read '%s' = '%s'\n",
                   requester_id, key, value);
            log_audit(requester_id, OP_CONFIG_READ, OP_SUCCESS, true);
            return OP_SUCCESS;
        }
    }

    k_mutex_unlock(&config_mutex);
    printk("[CONFIG] NOT FOUND: Key '%s'\n", key);
    return OP_INVALID;
}

static int config_modify(const char *key, const char *new_value,
                         uint32_t requester_priv, uint32_t requester_id)
{
    k_mutex_lock(&config_mutex, K_FOREVER);

    /* Search existing entry */
    for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
        if (system_config[i].in_use &&
            strncmp(system_config[i].key, key, CONFIG_KEY_LEN) == 0) {

            if (!check_privilege(system_config[i].min_priv_write, requester_priv)) {
                printk("[CONFIG] DENIED: Requester %u (priv=%s) cannot modify '%s' (requires %s)\n",
                       requester_id, priv_to_string(requester_priv),
                       key, priv_to_string(system_config[i].min_priv_write));
                k_mutex_unlock(&config_mutex);
                log_audit(requester_id, OP_CONFIG_MODIFY, OP_DENIED, false);
                return OP_DENIED;
            }

            strncpy(system_config[i].value, new_value, CONFIG_VAL_LEN - 1);
            system_config[i].value[CONFIG_VAL_LEN - 1] = '\0';
            k_mutex_unlock(&config_mutex);

            printk("[CONFIG] SUCCESS: Requester %u modified '%s' = '%s'\n",
                   requester_id, key, new_value);
            log_audit(requester_id, OP_CONFIG_MODIFY, OP_SUCCESS, true);
            return OP_SUCCESS;
        }
    }

    /* Create new entry if admin */
    if (!check_privilege(PRIV_WRITE, requester_priv)) {
        k_mutex_unlock(&config_mutex);
        log_audit(requester_id, OP_CONFIG_MODIFY, OP_DENIED, false);
        return OP_DENIED;
    }

    for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
        if (!system_config[i].in_use) {
            strncpy(system_config[i].key, key, CONFIG_KEY_LEN - 1);
            system_config[i].key[CONFIG_KEY_LEN - 1] = '\0';
            strncpy(system_config[i].value, new_value, CONFIG_VAL_LEN - 1);
            system_config[i].value[CONFIG_VAL_LEN - 1] = '\0';
            system_config[i].in_use = true;
            system_config[i].min_priv_read = PRIV_READ;
            system_config[i].min_priv_write = PRIV_WRITE;
            k_mutex_unlock(&config_mutex);

            printk("[CONFIG] SUCCESS: Requester %u created '%s' = '%s'\n",
                   requester_id, key, new_value);
            log_audit(requester_id, OP_CONFIG_MODIFY, OP_SUCCESS, true);
            return OP_SUCCESS;
        }
    }

    k_mutex_unlock(&config_mutex);
    printk("[CONFIG] FAILED: No free config slots\n");
    return OP_FAILED;
}

/* ---- Admin task: processes privileged requests ---- */

static void admin_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    struct task_identity admin_id = {
        .id = 0,
        .privilege = PRIV_ADMIN,
        .name = "admin"
    };

    printk("\n[ADMIN] Admin task started (id=%u, priv=%s)\n",
           admin_id.id, priv_to_string(admin_id.privilege));

    /* Perform initial admin setup: write boot signature to flash */
    uint8_t boot_sig[] = {0xDE, 0xAD, 0xBE, 0xEF, 0xCA, 0xFE, 0xBA, 0xBE};
    flash_write(0, boot_sig, sizeof(boot_sig), admin_id.privilege, admin_id.id);
    printk("[ADMIN] Boot signature written to flash\n");

    /* Set initial config */
    config_modify("boot.count", "1", admin_id.privilege, admin_id.id);
    config_modify("admin.last_login", "startup", admin_id.privilege, admin_id.id);

    printk("[ADMIN] Waiting for privilege requests from user tasks...\n\n");

    while (1) {
        struct priv_request req;
        struct priv_response resp;

        /* Wait for a request from user tasks */
        if (k_msgq_get(&request_queue, &req, K_MSEC(500)) == 0) {
            printk("\n[ADMIN] Received request: op=%s from requester=%u (priv=%s)\n",
                   op_to_string(req.operation), req.requester_id,
                   priv_to_string(req.requester_priv));

            memset(&resp, 0, sizeof(resp));

            switch (req.operation) {
            case OP_FLASH_WRITE:
                printk("[ADMIN] Processing flash write request: offset=%u, len=%u\n",
                       req.flash_offset, req.data_len);

                /* Escalate to admin privilege for the actual write,
                   but only if the requester has at least READ privilege
                   (i.e., is an authenticated user) */
                if (check_privilege(PRIV_READ, req.requester_priv)) {
                    printk("[ADMIN] Privilege escalation: user %u granted temporary WRITE for flash\n",
                           req.requester_id);
                    resp.result = flash_write(req.flash_offset, req.data,
                                             req.data_len, admin_id.privilege,
                                             req.requester_id);
                } else {
                    printk("[ADMIN] DENIED: Requester %u has insufficient base privilege\n",
                           req.requester_id);
                    resp.result = OP_DENIED;
                    log_audit(req.requester_id, OP_FLASH_WRITE, OP_DENIED, false);
                }
                break;

            case OP_CONFIG_MODIFY: {
                /* Parse key=value from data */
                char *key = (char *)req.data;
                char *value = NULL;

                for (uint32_t i = 0; i < req.data_len; i++) {
                    if (req.data[i] == '=') {
                        req.data[i] = '\0';
                        value = (char *)&req.data[i + 1];
                        break;
                    }
                }

                if (value == NULL) {
                    printk("[ADMIN] INVALID: Malformed config modify request\n");
                    resp.result = OP_INVALID;
                } else if (check_privilege(PRIV_READ, req.requester_priv)) {
                    printk("[ADMIN] Privilege escalation: user %u config modify '%s'='%s'\n",
                           req.requester_id, key, value);
                    resp.result = config_modify(key, value, admin_id.privilege,
                                                req.requester_id);
                } else {
                    resp.result = OP_DENIED;
                    log_audit(req.requester_id, OP_CONFIG_MODIFY, OP_DENIED, false);
                }
                break;
            }

            case OP_CONFIG_READ: {
                char *key = (char *)req.data;
                char value_buf[CONFIG_VAL_LEN];

                /* Config read uses the requester's own privilege level
                   (no escalation for reads) */
                resp.result = config_read(key, value_buf, sizeof(value_buf),
                                          req.requester_priv, req.requester_id);
                if (resp.result == OP_SUCCESS) {
                    uint32_t len = strlen(value_buf);
                    if (len >= sizeof(resp.data)) {
                        len = sizeof(resp.data) - 1;
                    }
                    memcpy(resp.data, value_buf, len);
                    resp.data[len] = '\0';
                    resp.data_len = len + 1;
                }
                break;
            }

            case OP_STATUS_REQUEST:
                printk("[ADMIN] Processing status request from user %u\n", req.requester_id);
                /* Anyone can request status */
                const char *status_msg = "SYSTEM OK";
                memcpy(resp.data, status_msg, strlen(status_msg) + 1);
                resp.data_len = strlen(status_msg) + 1;
                resp.result = OP_SUCCESS;
                log_audit(req.requester_id, OP_STATUS_REQUEST, OP_SUCCESS, true);
                break;

            default:
                printk("[ADMIN] UNKNOWN operation %u from requester %u\n",
                       req.operation, req.requester_id);
                resp.result = OP_INVALID;
                break;
            }

            /* Send response back to user */
            k_msgq_put(&response_queue, &resp, K_FOREVER);
            k_sem_give(&response_sem);
        }

        k_sleep(K_MSEC(10));
    }
}

/* ---- Helper: user sends a privileged request and waits for response ---- */

static int send_priv_request(struct task_identity *identity, struct priv_request *req,
                             struct priv_response *resp)
{
    req->requester_id = identity->id;
    req->requester_priv = identity->privilege;

    printk("[USER:%s] Sending request: op=%s\n", identity->name, op_to_string(req->operation));

    int ret = k_msgq_put(&request_queue, req, K_MSEC(1000));
    if (ret != 0) {
        printk("[USER:%s] ERROR: Failed to send request (queue full)\n", identity->name);
        return OP_FAILED;
    }

    /* Wait for response */
    ret = k_sem_take(&response_sem, K_MSEC(5000));
    if (ret != 0) {
        printk("[USER:%s] ERROR: Timeout waiting for response\n", identity->name);
        return OP_FAILED;
    }

    ret = k_msgq_get(&response_queue, resp, K_MSEC(1000));
    if (ret != 0) {
        printk("[USER:%s] ERROR: Failed to get response\n", identity->name);
        return OP_FAILED;
    }

    return resp->result;
}

/* ---- User task: makes various privilege requests ---- */

static void user_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    struct task_identity user_id = {
        .id = 1,
        .privilege = PRIV_USER,
        .name = "user1"
    };

    /* Let admin task initialize first */
    k_sleep(K_MSEC(500));

    printk("\n[USER:%s] User task started (id=%u, priv=%s)\n",
           user_id.name, user_id.id, priv_to_string(user_id.privilege));

    struct priv_request req;
    struct priv_response resp;
    int result;

    /* ---- Test 1: Request system status (should succeed) ---- */
    printk("\n=== Test 1: Status Request (any privilege) ===\n");
    memset(&req, 0, sizeof(req));
    req.operation = OP_STATUS_REQUEST;
    result = send_priv_request(&user_id, &req, &resp);
    if (result == OP_SUCCESS) {
        printk("[USER:%s] System status: %s\n", user_id.name, resp.data);
    } else {
        printk("[USER:%s] Status request failed: %d\n", user_id.name, result);
    }

    k_sleep(K_MSEC(200));

    /* ---- Test 2: Read a public config (should succeed) ---- */
    printk("\n=== Test 2: Read Public Config (requires READ) ===\n");
    memset(&req, 0, sizeof(req));
    req.operation = OP_CONFIG_READ;
    strncpy((char *)req.data, "system.hostname", sizeof(req.data) - 1);
    req.data_len = strlen((char *)req.data) + 1;
    result = send_priv_request(&user_id, &req, &resp);
    if (result == OP_SUCCESS) {
        printk("[USER:%s] Config 'system.hostname' = '%s'\n", user_id.name, resp.data);
    } else {
        printk("[USER:%s] Config read failed: %d\n", user_id.name, result);
    }

    k_sleep(K_MSEC(200));

    /* ---- Test 3: Read admin-only config (should be DENIED) ---- */
    printk("\n=== Test 3: Read Admin Config (requires ADMIN - should DENY) ===\n");
    memset(&req, 0, sizeof(req));
    req.operation = OP_CONFIG_READ;
    strncpy((char *)req.data, "admin.secret_key", sizeof(req.data) - 1);
    req.data_len = strlen((char *)req.data) + 1;
    result = send_priv_request(&user_id, &req, &resp);
    if (result == OP_DENIED) {
        printk("[USER:%s] As expected, reading 'admin.secret_key' was DENIED\n", user_id.name);
    } else if (result == OP_SUCCESS) {
        printk("[USER:%s] SECURITY ISSUE: Read admin config! value='%s'\n", user_id.name, resp.data);
    }

    k_sleep(K_MSEC(200));

    /* ---- Test 4: Request flash write via admin escalation (should succeed) ---- */
    printk("\n=== Test 4: Flash Write via Admin Escalation ===\n");
    memset(&req, 0, sizeof(req));
    req.operation = OP_FLASH_WRITE;
    req.flash_offset = 16;
    uint8_t user_data[] = "Hello from user!";
    memcpy(req.data, user_data, sizeof(user_data));
    req.data_len = sizeof(user_data);
    result = send_priv_request(&user_id, &req, &resp);
    if (result == OP_SUCCESS) {
        printk("[USER:%s] Flash write succeeded via admin escalation!\n", user_id.name);
    } else {
        printk("[USER:%s] Flash write result: %d\n", user_id.name, result);
    }

    k_sleep(K_MSEC(200));

    /* ---- Test 5: Request config modification via admin (should succeed) ---- */
    printk("\n=== Test 5: Config Modify via Admin Escalation ===\n");
    memset(&req, 0, sizeof(req));
    req.operation = OP_CONFIG_MODIFY;
    const char *kv = "system.hostname=user-modified-host";
    strncpy((char *)req.data, kv, sizeof(req.data) - 1);
    req.data_len = strlen(kv) + 1;
    result = send_priv_request(&user_id, &req, &resp);
    if (result == OP_SUCCESS) {
        printk("[USER:%s] Config modify succeeded via admin escalation!\n", user_id.name);
    } else {
        printk("[USER:%s] Config modify result: %d\n", user_id.name, result);
    }

    k_sleep(K_MSEC(200));

    /* ---- Test 6: Verify the config was modified ---- */
    printk("\n=== Test 6: Verify Modified Config ===\n");
    memset(&req, 0, sizeof(req));
    req.operation = OP_CONFIG_READ;
    strncpy((char *)req.data, "system.hostname", sizeof(req.data) - 1);
    req.data_len = strlen((char *)req.data) + 1;
    result = send_priv_request(&user_id, &req, &resp);
    if (result == OP_SUCCESS) {
        printk("[USER:%s] Config 'system.hostname' = '%s'\n", user_id.name, resp.data);
    }

    k_sleep(K_MSEC(200));

    /* ---- Test 7: Direct flash write attempt (user has no WRITE priv) ---- */
    printk("\n=== Test 7: Direct Flash Write (no escalation - testing direct) ===\n");
    printk("[USER:%s] Attempting direct flash write with USER privilege...\n", user_id.name);
    result = flash_write(32, (uint8_t *)"direct", 7, user_id.privilege, user_id.id);
    if (result == OP_DENIED) {
        printk("[USER:%s] As expected, direct flash write was DENIED\n", user_id.name);
    }

    k_sleep(K_MSEC(200));

    /* ---- Test 8: Direct config modify attempt (user has no WRITE priv) ---- */
    printk("\n=== Test 8: Direct Config Modify (no escalation) ===\n");
    printk("[USER:%s] Attempting direct config modify with USER privilege...\n", user_id.name);
    result = config_modify("security.level", "low", user_id.privilege, user_id.id);
    if (result == OP_DENIED) {
        printk("[USER:%s] As expected, direct config modify was DENIED\n", user_id.name);
    }

    k_sleep(K_MSEC(200));

    /* ---- Test 9: Create new config entry via admin ---- */
    printk("\n=== Test 9: Create New Config Entry via Admin ===\n");
    memset(&req, 0, sizeof(req));
    req.operation = OP_CONFIG_MODIFY;
    const char *new_kv = "user.preference=dark_mode";
    strncpy((char *)req.data, new_kv, sizeof(req.data) - 1);
    req.data_len = strlen(new_kv) + 1;
    result = send_priv_request(&user_id, &req, &resp);
    if (result == OP_SUCCESS) {
        printk("[USER:%s] New config entry created via admin!\n", user_id.name);
    }

    k_sleep(K_MSEC(200));

    /* ---- Test 10: Read the new config entry ---- */
    printk("\n=== Test 10: Read Newly Created Config ===\n");
    memset(&req, 0, sizeof(req));
    req.operation = OP_CONFIG_READ;
    strncpy((char *)req.data, "user.preference", sizeof(req.data) - 1);
    req.data_len = strlen((char *)req.data) + 1;
    result = send_priv_request(&user_id, &req, &resp);
    if (result == OP_SUCCESS) {
        printk("[USER:%s] Config 'user.preference' = '%s'\n", user_id.name, resp.data);
    }

    printk("\n========================================\n");
    printk("[USER:%s] All tests completed.\n", user_id.name);
    printk("========================================\n");

    /* Print audit summary */
    k_sleep(K_MSEC(200));
    printk("\n--- Audit Log Summary ---\n");
    k_mutex_lock(&audit_mutex, K_FOREVER);
    uint32_t count = (audit_index < AUDIT_LOG_SIZE) ? audit_index : AUDIT_LOG_SIZE;
    for (uint32_t i = 0; i < count; i++) {
        struct audit_entry *e = &audit_log[i];
        printk("  [%u] ts=%u req=%u op=%s result=%d %s\n",
               i, e->timestamp, e->requester_id,
               op_to_string(e->operation), e->result,
               e->granted ? "GRANTED" : "DENIED");
    }
    k_mutex_unlock(&audit_mutex);

    /* Print flash contents */
    printk("\n--- Flash Memory Dump (first 48 bytes) ---\n  ");
    k_mutex_lock(&flash_mutex, K_FOREVER);
    for (int i = 0; i < 48; i++) {
        printk("%02x ", simulated_flash[i]);
        if ((i + 1) % 16 == 0) printk("\n  ");
    }
    k_mutex_unlock(&flash_mutex);
    printk("\n");

    while (1) {
        k_sleep(K_MSEC(5000));
    }
}

/* ---- Main entry point ---- */

int main(void)
{
    printk("\n========================================\n");
    printk("  Zephyr RTOS Privilege System Demo\n");
    printk("  Embedded Permission Management\n");
    printk("========================================\n\n");

    /* Initialize subsystems */
    init_simulated_flash();
    init_system_config();
    init_audit_log();

    /* Create admin task (higher priority) */
    k_thread_create(&admin_thread_data, admin_stack,
                    K_THREAD_STACK_SIZEOF(admin_stack),
                    admin_task, NULL, NULL, NULL,
                    ADMIN_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(&admin_thread_data, "admin_task");

    /* Create user task (lower priority) */
    k_thread_create(&user_thread_data, user_stack,
                    K_THREAD_STACK_SIZEOF(user_stack),
                    user_task, NULL, NULL, NULL,
                    USER_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(&user_thread_data, "user_task");

    printk("[MAIN] Admin and User tasks created. System running.\n");

    return 0;
}