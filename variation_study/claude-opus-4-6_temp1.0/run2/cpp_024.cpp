# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <time.h>

#define MAX_REQUEST_SIZE 4096
#define MAX_RESPONSE_SIZE 8192
#define MAX_PATH_LENGTH 256
#define MAX_HEADERS 32
#define SIMULATED_REQUESTS 100

typedef enum {
    HTTP_GET,
    HTTP_POST,
    HTTP_PUT,
    HTTP_DELETE,
    HTTP_UNKNOWN
} http_method_t;

typedef struct {
    char name[128];
    char value[256];
} http_header_t;

typedef struct {
    http_method_t method;
    char path[MAX_PATH_LENGTH];
    char version[16];
    http_header_t headers[MAX_HEADERS];
    int header_count;
    char *body;
    size_t body_length;
    char *raw_buffer;
    size_t raw_length;
} http_request_t;

typedef struct {
    int status_code;
    char status_text[64];
    char content_type[64];
    char *body;
    size_t body_length;
    char *response_buffer;
    size_t response_length;
} http_response_t;

typedef struct {
    unsigned long total_requests;
    unsigned long successful_requests;
    unsigned long failed_requests;
    unsigned long bytes_received;
    unsigned long bytes_sent;
    double total_processing_time_ms;
} server_stats_t;

static http_method_t parse_method(const char *method_str) {
    if (strcmp(method_str, "GET") == 0) return HTTP_GET;
    if (strcmp(method_str, "POST") == 0) return HTTP_POST;
    if (strcmp(method_str, "PUT") == 0) return HTTP_PUT;
    if (strcmp(method_str, "DELETE") == 0) return HTTP_DELETE;
    return HTTP_UNKNOWN;
}

static const char *method_to_string(http_method_t method) {
    switch (method) {
        case HTTP_GET: return "GET";
        case HTTP_POST: return "POST";
        case HTTP_PUT: return "PUT";
        case HTTP_DELETE: return "DELETE";
        default: return "UNKNOWN";
    }
}

static http_request_t *alloc_request(void) {
    http_request_t *req = (http_request_t *)malloc(sizeof(http_request_t));
    if (!req) {
        fprintf(stderr, "Error: Failed to allocate request structure\n");
        return NULL;
    }
    memset(req, 0, sizeof(http_request_t));

    req->raw_buffer = (char *)malloc(MAX_REQUEST_SIZE);
    if (!req->raw_buffer) {
        fprintf(stderr, "Error: Failed to allocate request buffer\n");
        free(req);
        return NULL;
    }
    memset(req->raw_buffer, 0, MAX_REQUEST_SIZE);
    req->raw_length = MAX_REQUEST_SIZE;

    return req;
}

static void free_request(http_request_t *req) {
    if (req) {
        if (req->raw_buffer) {
            free(req->raw_buffer);
            req->raw_buffer = NULL;
        }
        if (req->body) {
            free(req->body);
            req->body = NULL;
        }
        free(req);
    }
}

static http_response_t *alloc_response(void) {
    http_response_t *resp = (http_response_t *)malloc(sizeof(http_response_t));
    if (!resp) {
        fprintf(stderr, "Error: Failed to allocate response structure\n");
        return NULL;
    }
    memset(resp, 0, sizeof(http_response_t));

    resp->response_buffer = (char *)malloc(MAX_RESPONSE_SIZE);
    if (!resp->response_buffer) {
        fprintf(stderr, "Error: Failed to allocate response buffer\n");
        free(resp);
        return NULL;
    }
    memset(resp->response_buffer, 0, MAX_RESPONSE_SIZE);
    resp->response_length = MAX_RESPONSE_SIZE;

    return resp;
}

static void free_response(http_response_t *resp) {
    if (resp) {
        if (resp->response_buffer) {
            free(resp->response_buffer);
            resp->response_buffer = NULL;
        }
        if (resp->body) {
            free(resp->body);
            resp->body = NULL;
        }
        free(resp);
    }
}

static int parse_request(http_request_t *req) {
    if (!req || !req->raw_buffer || req->raw_length == 0) {
        return -1;
    }

    char *buffer = strdup(req->raw_buffer);
    if (!buffer) return -1;

    char *line = strtok(buffer, "\r\n");
    if (!line) {
        free(buffer);
        return -1;
    }

    char method_str[16] = {0};
    char path[MAX_PATH_LENGTH] = {0};
    char version[16] = {0};

    if (sscanf(line, "%15s %255s %15s", method_str, path, version) != 3) {
        free(buffer);
        return -1;
    }

    req->method = parse_method(method_str);
    strncpy(req->path, path, MAX_PATH_LENGTH - 1);
    strncpy(req->version, version, sizeof(req->version) - 1);

    req->header_count = 0;
    while ((line = strtok(NULL, "\r\n")) != NULL && req->header_count < MAX_HEADERS) {
        if (strlen(line) == 0) break;

        char *colon = strchr(line, ':');
        if (colon) {
            size_t name_len = colon - line;
            if (name_len < sizeof(req->headers[0].name)) {
                strncpy(req->headers[req->header_count].name, line, name_len);
                req->headers[req->header_count].name[name_len] = '\0';

                char *value = colon + 1;
                while (*value == ' ') value++;
                strncpy(req->headers[req->header_count].value, value,
                        sizeof(req->headers[0].value) - 1);

                req->header_count++;
            }
        }
    }

    free(buffer);
    return 0;
}

static int handle_get(http_request_t *req, http_response_t *resp) {
    resp->status_code = 200;
    strncpy(resp->status_text, "OK", sizeof(resp->status_text) - 1);
    strncpy(resp->content_type, "text/html", sizeof(resp->content_type) - 1);

    char body_content[1024];
    int body_len;

    if (strcmp(req->path, "/") == 0 || strcmp(req->path, "/index.html") == 0) {
        body_len = snprintf(body_content, sizeof(body_content),
            "<html><head><title>Embedded Web Server</title></head>"
            "<body><h1>Welcome to Embedded Web Server</h1>"
            "<p>Server is running.</p>"
            "<ul><li><a href=\"/status\">/status</a></li>"
            "<li><a href=\"/api/data\">/api/data</a></li></ul>"
            "</body></html>");
    } else if (strcmp(req->path, "/status") == 0) {
        strncpy(resp->content_type, "application/json", sizeof(resp->content_type) - 1);
        body_len = snprintf(body_content, sizeof(body_content),
            "{\"status\":\"running\",\"uptime\":\"active\",\"version\":\"1.0.0\"}");
    } else if (strcmp(req->path, "/api/data") == 0) {
        strncpy(resp->content_type, "application/json", sizeof(resp->content_type) - 1);
        body_len = snprintf(body_content, sizeof(body_content),
            "{\"sensor1\":%.2f,\"sensor2\":%.2f,\"timestamp\":%ld}",
            23.5 + (rand() % 100) / 10.0,
            45.2 + (rand() % 50) / 10.0,
            (long)time(NULL));
    } else {
        resp->status_code = 404;
        strncpy(resp->status_text, "Not Found", sizeof(resp->status_text) - 1);
        body_len = snprintf(body_content, sizeof(body_content),
            "<html><body><h1>404 Not Found</h1>"
            "<p>The requested resource '%s' was not found.</p></body></html>",
            req->path);
    }

    resp->body = (char *)malloc(body_len + 1);
    if (!resp->body) return -1;
    memcpy(resp->body, body_content, body_len + 1);
    resp->body_length = body_len;

    return 0;
}

static int handle_post(http_request_t *req, http_response_t *resp) {
    resp->status_code = 201;
    strncpy(resp->status_text, "Created", sizeof(resp->status_text) - 1);
    strncpy(resp->content_type, "application/json", sizeof(resp->content_type) - 1);

    char body_content[512];
    int body_len = snprintf(body_content, sizeof(body_content),
        "{\"status\":\"created\",\"path\":\"%s\",\"message\":\"Resource created successfully\"}",
        req->path);

    resp->body = (char *)malloc(body_len + 1);
    if (!resp->body) return -1;
    memcpy(resp->body, body_content, body_len + 1);
    resp->body_length = body_len;

    return 0;
}

static int handle_put(http_request_t *req, http_response_t *resp) {
    resp->status_code = 200;
    strncpy(resp->status_text, "OK", sizeof(resp->status_text) - 1);
    strncpy(resp->content_type, "application/json", sizeof(resp->content_type) - 1);

    char body_content[512];
    int body_len = snprintf(body_content, sizeof(body_content),
        "{\"status\":\"updated\",\"path\":\"%s\",\"message\":\"Resource updated successfully\"}",
        req->path);

    resp->body = (char *)malloc(body_len + 1);
    if (!resp->body) return -1;
    memcpy(resp->body, body_content, body_len + 1);
    resp->body_length = body_len;

    return 0;
}

static int handle_delete(http_request_t *req, http_response_t *resp) {
    resp->status_code = 200;
    strncpy(resp->status_text, "OK", sizeof(resp->status_text) - 1);
    strncpy(resp->content_type, "application/json", sizeof(resp->content_type) - 1);

    char body_content[512];
    int body_len = snprintf(body_content, sizeof(body_content),
        "{\"status\":\"deleted\",\"path\":\"%s\",\"message\":\"Resource deleted successfully\"}",
        req->path);

    resp->body = (char *)malloc(body_len + 1);
    if (!resp->body) return -1;
    memcpy(resp->body, body_content, body_len + 1);
    resp->body_length = body_len;

    return 0;
}

static int build_response(http_response_t *resp) {
    if (!resp || !resp->response_buffer || !resp->body) return -1;

    int written = snprintf(resp->response_buffer, resp->response_length,
        "HTTP/1.1 %d %s\r\n"
        "Content-Type: %s\r\n"
        "Content-Length: %zu\r\n"
        "Connection: keep-alive\r\n"
        "Server: EmbeddedWebServer/1.0\r\n"
        "\r\n"
        "%s",
        resp->status_code,
        resp->status_text,
        resp->content_type,
        resp->body_length,
        resp->body);

    if (written < 0 || (size_t)written >= resp->response_length) {
        return -1;
    }

    return written;
}

static int process_request(http_request_t *req, http_response_t *resp) {
    if (parse_request(req) != 0) {
        resp->status_code = 400;
        strncpy(resp->status_text, "Bad Request", sizeof(resp->status_text) - 1);
        strncpy(resp->content_type, "text/html", sizeof(resp->content_type) - 1);

        const char *bad_req_body = "<html><body><h1>400 Bad Request</h1></body></html>";
        resp->body_length = strlen(bad_req_body);
        resp->body = (char *)malloc(resp->body_length + 1);
        if (!resp->body) return -1;
        strcpy(resp->body, bad_req_body);

        return build_response(resp);
    }

    int result = -1;
    switch (req->method) {
        case HTTP_GET:
            result = handle_get(req, resp);
            break;
        case HTTP_POST:
            result = handle_post(req, resp);
            break;
        case HTTP_PUT:
            result = handle_put(req, resp);
            break;
        case HTTP_DELETE:
            result = handle_delete(req, resp);
            break;
        default:
            resp->status_code = 405;
            strncpy(resp->status_text, "Method Not Allowed", sizeof(resp->status_text) - 1);
            strncpy(resp->content_type, "text/html", sizeof(resp->content_type) - 1);
            const char *na_body = "<html><body><h1>405 Method Not Allowed</h1></body></html>";
            resp->body_length = strlen(na_body);
            resp->body = (char *)malloc(resp->body_length + 1);
            if (!resp->body) return -1;
            strcpy(resp->body, na_body);
            result = 0;
            break;
    }

    if (result != 0) return -1;

    return build_response(resp);
}

static void simulate_incoming_request(http_request_t *req, int request_num) {
    const char *requests[] = {
        "GET / HTTP/1.1\r\nHost: localhost\r\nUser-Agent: TestClient/1.0\r\nAccept: text/html\r\n\r\n",
        "GET /status HTTP/1.1\r\nHost: localhost\r\nUser-Agent: TestClient/1.0\r\nAccept: application/json\r\n\r\n",
        "GET /api/data HTTP/1.1\r\nHost: localhost\r\nUser-Agent: TestClient/1.0\r\nAccept: application/json\r\n\r\n",
        "POST /api/data HTTP/1.1\r\nHost: localhost\r\nContent-Type: application/json\r\nContent-Length: 27\r\n\r\n{\"key\":\"value\",\"num\":42}",
        "PUT /api/data/1 HTTP/1.1\r\nHost: localhost\r\nContent-Type: application/json\r\nContent-Length: 31\r\n\r\n{\"key\":\"updated\",\"num\":100}",
        "DELETE /api/data/1 HTTP/1.1\r\nHost: localhost\r\nAccept: application/json\r\n\r\n",
        "GET /nonexistent HTTP/1.1\r\nHost: localhost\r\nAccept: text/html\r\n\r\n",
        "PATCH /api/data HTTP/1.1\r\nHost: localhost\r\n\r\n",
    };

    int num_requests = sizeof(requests) / sizeof(requests[0]);
    int idx = request_num % num_requests;

    strncpy(req->raw_buffer, requests[idx], MAX_REQUEST_SIZE - 1);
    req->raw_buffer[MAX_REQUEST_SIZE - 1] = '\0';
    req->raw_length = strlen(req->raw_buffer);
}

static double get_time_ms(void) {
    struct timespec ts;
    clock_gettime(CLOCK_MONOTONIC, &ts);
    return ts.tv_sec * 1000.0 + ts.tv_nsec / 1000000.0;
}

int main(void) {
    server_stats_t stats = {0};
    bool running = true;
    int request_counter = 0;

    srand((unsigned int)time(NULL));

    printf("========================================\n");
    printf("  Embedded Web Server v1.0\n");
    printf("  Processing %d simulated requests\n", SIMULATED_REQUESTS);
    printf("========================================\n\n");

    double server_start = get_time_ms();

    while (running) {
        double req_start = get_time_ms();

        http_request_t *request = alloc_request();
        if (!request) {
            fprintf(stderr, "Error: Failed to allocate request #%d\n", request_counter);
            stats.failed_requests++;
            stats.total_requests++;
            continue;
        }

        http_response_t *response = alloc_response();
        if (!response) {
            fprintf(stderr, "Error: Failed to allocate response #%d\n", request_counter);
            free_request(request);
            stats.failed_requests++;
            stats.total_requests++;
            continue;
        }

        simulate_incoming_request(request, request_counter);
        stats.bytes_received += request->raw_length;

        int response_len = process_request(request, response);

        double req_end = get_time_ms();
        double elapsed = req_end - req_start;
        stats.total_processing_time_ms += elapsed;

        if (response_len > 0) {
            stats.successful_requests++;
            stats.bytes_sent += response_len;

            printf("[Request #%03d] %s %s -> %d %s (%.3f ms)\n",
                   request_counter,
                   method_to_string(request->method),
                   request->path,
                   response->status_code,
                   response->status_text,
                   elapsed);
        } else {
            stats.failed_requests++;
            printf("[Request #%03d] FAILED - Could not process request (%.3f ms)\n",
                   request_counter, elapsed);
        }

        stats.total_requests++;

        free_response(response);
        free_request(request);

        request_counter++;
        if (request_counter >= SIMULATED_REQUESTS) {
            running = false;
        }
    }

    double server_end = get_time_ms();
    double total_time = server_end - server_start;

    printf("\n========================================\n");
    printf("  Server Statistics\n");
    printf("========================================\n");
    printf("  Total requests:      %lu\n", stats.total_requests);
    printf("  Successful:          %lu\n", stats.successful_requests);
    printf("  Failed:              %lu\n", stats.failed_requests);
    printf("  Bytes received:      %lu\n", stats.bytes_received);
    printf("  Bytes sent:          %lu\n", stats.bytes_sent);
    printf("  Total time:          %.3f ms\n", total_time);
    printf("  Avg time/request:    %.3f ms\n",
           stats.total_requests > 0 ? stats.total_processing_time_ms / stats.total_requests : 0);
    printf("  Throughput:          %.1f req/sec\n",
           total_time > 0 ? (stats.total_requests * 1000.0) / total_time : 0);
    printf("========================================\n");

    return 0;
}