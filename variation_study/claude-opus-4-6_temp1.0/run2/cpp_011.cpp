# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_KEY_LEN 256
#define MAX_VALUE_LEN 1024
#define INITIAL_CAPACITY 16

typedef struct {
    char *key;
    char *value;
} ConfigEntry;

typedef struct {
    ConfigEntry *entries;
    size_t count;
    size_t capacity;
} ConfigData;

static ConfigData *cached_config = NULL;
static time_t cached_mtime = 0;

static char *trim_whitespace(char *str) {
    char *end;

    while (*str == ' ' || *str == '\t' || *str == '\n' || *str == '\r')
        str++;

    if (*str == '\0')
        return str;

    end = str + strlen(str) - 1;
    while (end > str && (*end == ' ' || *end == '\t' || *end == '\n' || *end == '\r'))
        end--;

    *(end + 1) = '\0';
    return str;
}

void config_free(ConfigData *config) {
    if (!config)
        return;

    for (size_t i = 0; i < config->count; i++) {
        free(config->entries[i].key);
        free(config->entries[i].value);
    }
    free(config->entries);
    free(config);
}

static int config_add_entry(ConfigData *config, const char *key, const char *value) {
    if (config->count >= config->capacity) {
        size_t new_capacity = config->capacity * 2;
        ConfigEntry *new_entries = realloc(config->entries, new_capacity * sizeof(ConfigEntry));
        if (!new_entries)
            return -1;
        config->entries = new_entries;
        config->capacity = new_capacity;
    }

    config->entries[config->count].key = strdup(key);
    config->entries[config->count].value = strdup(value);

    if (!config->entries[config->count].key || !config->entries[config->count].value) {
        free(config->entries[config->count].key);
        free(config->entries[config->count].value);
        return -1;
    }

    config->count++;
    return 0;
}

const char *config_get(const ConfigData *config, const char *key) {
    if (!config || !key)
        return NULL;

    for (size_t i = 0; i < config->count; i++) {
        if (strcmp(config->entries[i].key, key) == 0)
            return config->entries[i].value;
    }
    return NULL;
}

static time_t get_file_mtime(const char *filepath) {
    struct stat st;
    if (stat(filepath, &st) != 0)
        return 0;
    return st.st_mtime;
}

#include <sys/stat.h>

ConfigData *config_read(const char *filepath) {
    if (!filepath)
        return NULL;

    /* Cache check: if the file hasn't been modified, return cached config */
    time_t current_mtime = get_file_mtime(filepath);
    if (cached_config && current_mtime == cached_mtime && cached_mtime != 0) {
        return cached_config;
    }

    FILE *fp = fopen(filepath, "r");
    if (!fp)
        return NULL;

    ConfigData *config = malloc(sizeof(ConfigData));
    if (!config) {
        fclose(fp);
        return NULL;
    }

    config->count = 0;
    config->capacity = INITIAL_CAPACITY;
    config->entries = malloc(config->capacity * sizeof(ConfigEntry));
    if (!config->entries) {
        free(config);
        fclose(fp);
        return NULL;
    }

    char line[MAX_KEY_LEN + MAX_VALUE_LEN + 2];

    while (fgets(line, sizeof(line), fp)) {
        char *trimmed = trim_whitespace(line);

        /* Skip empty lines and comments */
        if (*trimmed == '\0' || *trimmed == '#' || *trimmed == ';')
            continue;

        /* Find the delimiter '=' */
        char *delimiter = strchr(trimmed, '=');
        if (!delimiter)
            continue;

        *delimiter = '\0';
        char *key = trim_whitespace(trimmed);
        char *value = trim_whitespace(delimiter + 1);

        if (*key == '\0')
            continue;

        if (config_add_entry(config, key, value) != 0) {
            config_free(config);
            fclose(fp);
            return NULL;
        }
    }

    fclose(fp);

    /* Update cache */
    if (cached_config) {
        config_free(cached_config);
    }
    cached_config = config;
    cached_mtime = current_mtime;

    return config;
}

void config_invalidate_cache(void) {
    if (cached_config) {
        config_free(cached_config);
        cached_config = NULL;
        cached_mtime = 0;
    }
}