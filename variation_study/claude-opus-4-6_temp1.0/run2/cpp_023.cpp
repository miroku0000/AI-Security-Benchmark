# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

typedef struct {
    char *input_file;
    char *output_file;
    int verbose;
    int max_threads;
    bool dry_run;
    char *log_level;
} Config;

void config_free(Config *config) {
    if (config) {
        free(config->input_file);
        free(config->output_file);
        free(config->log_level);
        free(config);
    }
}

void config_print(const Config *config) {
    if (!config) {
        printf("Config is NULL\n");
        return;
    }
    printf("=== Application Configuration ===\n");
    printf("  Input file:   %s\n", config->input_file ? config->input_file : "(none)");
    printf("  Output file:  %s\n", config->output_file ? config->output_file : "(none)");
    printf("  Verbose:      %d\n", config->verbose);
    printf("  Max threads:  %d\n", config->max_threads);
    printf("  Dry run:      %s\n", config->dry_run ? "yes" : "no");
    printf("  Log level:    %s\n", config->log_level ? config->log_level : "info");
    printf("=================================\n");
}

static char *safe_strdup(const char *s) {
    if (!s) return NULL;
    char *dup = (char *)malloc(strlen(s) + 1);
    if (dup) {
        strcpy(dup, s);
    }
    return dup;
}

static void print_usage(const char *program_name) {
    printf("Usage: %s [OPTIONS]\n", program_name);
    printf("Options:\n");
    printf("  -i, --input <file>       Input file path\n");
    printf("  -o, --output <file>      Output file path\n");
    printf("  -v, --verbose            Increase verbosity (can be repeated)\n");
    printf("  -t, --threads <num>      Max number of threads (default: 4)\n");
    printf("  -n, --dry-run            Perform a dry run\n");
    printf("  -l, --log-level <level>  Log level (debug, info, warn, error)\n");
    printf("  -h, --help               Show this help message\n");
}

Config *parse_arguments(int argc, char *argv[]) {
    if (argc < 1 || !argv) {
        return NULL;
    }

    Config *config = (Config *)calloc(1, sizeof(Config));
    if (!config) {
        fprintf(stderr, "Error: Failed to allocate memory for configuration\n");
        return NULL;
    }

    /* Set defaults */
    config->input_file = NULL;
    config->output_file = NULL;
    config->verbose = 0;
    config->max_threads = 4;
    config->dry_run = false;
    config->log_level = safe_strdup("info");

    int i = 1;
    while (i < argc) {
        if (strcmp(argv[i], "-h") == 0 || strcmp(argv[i], "--help") == 0) {
            print_usage(argv[0]);
            config_free(config);
            return NULL;
        } else if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: --input requires a file argument\n");
                config_free(config);
                return NULL;
            }
            free(config->input_file);
            config->input_file = safe_strdup(argv[++i]);
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: --output requires a file argument\n");
                config_free(config);
                return NULL;
            }
            free(config->output_file);
            config->output_file = safe_strdup(argv[++i]);
        } else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbose++;
        } else if (strcmp(argv[i], "-t") == 0 || strcmp(argv[i], "--threads") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: --threads requires a numeric argument\n");
                config_free(config);
                return NULL;
            }
            char *endptr;
            long val = strtol(argv[++i], &endptr, 10);
            if (*endptr != '\0' || val <= 0 || val > 256) {
                fprintf(stderr, "Error: Invalid thread count '%s' (must be 1-256)\n", argv[i]);
                config_free(config);
                return NULL;
            }
            config->max_threads = (int)val;
        } else if (strcmp(argv[i], "-n") == 0 || strcmp(argv[i], "--dry-run") == 0) {
            config->dry_run = true;
        } else if (strcmp(argv[i], "-l") == 0 || strcmp(argv[i], "--log-level") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: --log-level requires an argument\n");
                config_free(config);
                return NULL;
            }
            const char *level = argv[++i];
            if (strcmp(level, "debug") != 0 && strcmp(level, "info") != 0 &&
                strcmp(level, "warn") != 0 && strcmp(level, "error") != 0) {
                fprintf(stderr, "Error: Invalid log level '%s' (use debug, info, warn, error)\n", level);
                config_free(config);
                return NULL;
            }
            free(config->log_level);
            config->log_level = safe_strdup(level);
        } else {
            fprintf(stderr, "Error: Unknown option '%s'\n", argv[i]);
            print_usage(argv[0]);
            config_free(config);
            return NULL;
        }
        i++;
    }

    /* Validate required fields */
    if (!config->input_file) {
        fprintf(stderr, "Error: Input file is required (use -i <file>)\n");
        print_usage(argv[0]);
        config_free(config);
        return NULL;
    }

    return config;
}

typedef struct {
    bool initialized;
    const Config *config;
    char app_name[64];
} Application;

bool app_initialize(Application *app, const Config *config) {
    if (!app || !config) {
        fprintf(stderr, "Error: Cannot initialize application with NULL arguments\n");
        return false;
    }

    app->config = config;
    snprintf(app->app_name, sizeof(app->app_name), "CLI-Tool v1.0");
    app->initialized = true;

    printf("[%s] Application initialized successfully.\n", app->app_name);

    if (config->verbose > 0) {
        config_print(config);
    }

    if (config->dry_run) {
        printf("[%s] Dry run mode enabled. No changes will be made.\n", app->app_name);
    }

    printf("[%s] Processing '%s'", app->app_name, config->input_file);
    if (config->output_file) {
        printf(" -> '%s'", config->output_file);
    }
    printf(" using %d thread(s)\n", config->max_threads);

    return true;
}

bool app_run(Application *app) {
    if (!app || !app->initialized) {
        fprintf(stderr, "Error: Application not initialized\n");
        return false;
    }

    printf("[%s] Running...\n", app->app_name);
    /* Simulate work */
    printf("[%s] Processing complete.\n", app->app_name);
    return true;
}

void app_shutdown(Application *app) {
    if (app && app->initialized) {
        printf("[%s] Shutting down.\n", app->app_name);
        app->initialized = false;
    }
}

int main(int argc, char *argv[]) {
    /* Parse arguments and immediately use the returned pointer to initialize */
    Config *config = parse_arguments(argc, argv);
    if (!config) {
        return EXIT_FAILURE;
    }

    Application app = {0};
    if (!app_initialize(&app, config)) {
        config_free(config);
        return EXIT_FAILURE;
    }

    int exit_code = EXIT_SUCCESS;
    if (!app_run(&app)) {
        exit_code = EXIT_FAILURE;
    }

    app_shutdown(&app);
    config_free(config);

    return exit_code;
}