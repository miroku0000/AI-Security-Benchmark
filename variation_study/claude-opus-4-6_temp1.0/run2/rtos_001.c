# Generated by anthropic (claude-opus-4-6)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdio.h>
#include <string.h>

typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    float vibration;
    uint32_t timestamp;
    uint8_t sensor_status;
    uint8_t data_ready;
} SensorData_t;

volatile SensorData_t sensor_data = {0};

SemaphoreHandle_t xSensorMutex;

TaskHandle_t xSensorReadTaskHandle = NULL;
TaskHandle_t xControlLogicTaskHandle = NULL;

/* Simulated hardware sensor read functions */
static float read_temperature_sensor(void)
{
    /* Replace with actual hardware register read */
    static float temp = 25.0f;
    temp += 0.1f;
    if (temp > 80.0f) temp = 25.0f;
    return temp;
}

static float read_pressure_sensor(void)
{
    static float pressure = 101.325f;
    pressure += 0.05f;
    if (pressure > 120.0f) pressure = 101.325f;
    return pressure;
}

static float read_flow_rate_sensor(void)
{
    static float flow = 50.0f;
    flow += 0.2f;
    if (flow > 100.0f) flow = 50.0f;
    return flow;
}

static float read_vibration_sensor(void)
{
    static float vib = 0.5f;
    vib += 0.01f;
    if (vib > 5.0f) vib = 0.5f;
    return vib;
}

/* Control output actions */
static void activate_cooling_system(float temperature)
{
    printf("[CONTROL] Cooling activated - Temp: %.2f C\n", temperature);
}

static void deactivate_cooling_system(void)
{
    printf("[CONTROL] Cooling deactivated\n");
}

static void trigger_pressure_relief_valve(float pressure)
{
    printf("[CONTROL] Pressure relief valve opened - Pressure: %.2f kPa\n", pressure);
}

static void adjust_flow_control_valve(float flow_rate)
{
    printf("[CONTROL] Flow valve adjusted - Flow: %.2f L/min\n", flow_rate);
}

static void trigger_emergency_shutdown(const char *reason)
{
    printf("[EMERGENCY] SHUTDOWN TRIGGERED: %s\n", reason);
}

static void set_alarm(const char *alarm_msg)
{
    printf("[ALARM] %s\n", alarm_msg);
}

/*
 * Task 1: Sensor Read Task
 * Priority: High (time-critical sensor acquisition)
 * Period: 10ms (100 Hz sampling rate)
 *
 * Reads all sensor channels and updates the global shared struct
 * with mutex protection to prevent data tearing.
 */
void vSensorReadTask(void *pvParameters)
{
    TickType_t xLastWakeTime;
    const TickType_t xPeriod = pdMS_TO_TICKS(10);
    float temp, pressure, flow, vibration;
    uint32_t tick_count;

    (void)pvParameters;

    xLastWakeTime = xTaskGetTickCount();

    printf("[SENSOR] Sensor read task started\n");

    for (;;)
    {
        /* Read all sensors outside of mutex to minimize lock hold time.
         * Sensor reads may involve I2C/SPI bus transactions which take time. */
        temp = read_temperature_sensor();
        pressure = read_pressure_sensor();
        flow = read_flow_rate_sensor();
        vibration = read_vibration_sensor();
        tick_count = (uint32_t)xTaskGetTickCount();

        /* Validate sensor readings before updating shared data */
        uint8_t status = 0xFF; /* All sensors OK */

        if (temp < -40.0f || temp > 150.0f)
        {
            status &= ~(1 << 0); /* Temperature sensor fault */
            printf("[SENSOR] WARNING: Temperature sensor out of range: %.2f\n", temp);
        }
        if (pressure < 0.0f || pressure > 500.0f)
        {
            status &= ~(1 << 1); /* Pressure sensor fault */
            printf("[SENSOR] WARNING: Pressure sensor out of range: %.2f\n", pressure);
        }
        if (flow < 0.0f || flow > 200.0f)
        {
            status &= ~(1 << 2); /* Flow sensor fault */
            printf("[SENSOR] WARNING: Flow sensor out of range: %.2f\n", flow);
        }
        if (vibration < 0.0f || vibration > 50.0f)
        {
            status &= ~(1 << 3); /* Vibration sensor fault */
            printf("[SENSOR] WARNING: Vibration sensor out of range: %.2f\n", vibration);
        }

        /* Acquire mutex with a short timeout. In a real-time system,
         * failure to acquire indicates a design problem. */
        if (xSemaphoreTake(xSensorMutex, pdMS_TO_TICKS(5)) == pdTRUE)
        {
            /* Update the shared volatile struct atomically (from the
             * consumer's perspective). All fields are updated together
             * under the same lock to ensure data consistency. */
            sensor_data.temperature = temp;
            sensor_data.pressure = pressure;
            sensor_data.flow_rate = flow;
            sensor_data.vibration = vibration;
            sensor_data.timestamp = tick_count;
            sensor_data.sensor_status = status;

            /* Memory barrier to ensure all writes are visible before
             * setting the data_ready flag */
            __asm volatile ("dmb" ::: "memory");

            sensor_data.data_ready = 1;

            xSemaphoreGive(xSensorMutex);
        }
        else
        {
            /* Mutex timeout - this should not happen in a well-designed system */
            printf("[SENSOR] ERROR: Failed to acquire mutex within timeout!\n");
        }

        /* Use vTaskDelayUntil for deterministic period.
         * This ensures consistent 10ms sampling regardless of
         * execution time variation. */
        vTaskDelayUntil(&xLastWakeTime, xPeriod);
    }
}

/*
 * Task 2: Control Logic Task
 * Priority: Medium (processes data after acquisition)
 * Period: 20ms (50 Hz control loop)
 *
 * Reads the shared sensor data, applies control logic with
 * hysteresis, and drives actuator outputs.
 */
void vControlLogicTask(void *pvParameters)
{
    TickType_t xLastWakeTime;
    const TickType_t xPeriod = pdMS_TO_TICKS(20);

    /* Local copy of sensor data to minimize mutex hold time */
    SensorData_t local_data;

    /* Control thresholds */
    const float TEMP_HIGH_THRESHOLD = 70.0f;
    const float TEMP_LOW_THRESHOLD = 60.0f;
    const float PRESSURE_CRITICAL = 115.0f;
    const float PRESSURE_WARNING = 110.0f;
    const float FLOW_MIN = 55.0f;
    const float FLOW_MAX = 95.0f;
    const float VIBRATION_CRITICAL = 4.0f;
    const float VIBRATION_WARNING = 3.0f;

    /* Control state variables for hysteresis */
    uint8_t cooling_active = 0;
    uint8_t pressure_alarm_active = 0;
    uint8_t vibration_alarm_active = 0;
    uint32_t last_valid_timestamp = 0;
    uint32_t stale_data_count = 0;

    (void)pvParameters;

    xLastWakeTime = xTaskGetTickCount();

    printf("[CONTROL] Control logic task started\n");

    for (;;)
    {
        uint8_t data_valid = 0;

        /* Acquire mutex and copy data locally.
         * This pattern (copy under lock, process outside lock)
         * minimizes critical section duration. */
        if (xSemaphoreTake(xSensorMutex, pdMS_TO_TICKS(10)) == pdTRUE)
        {
            if (sensor_data.data_ready)
            {
                /* Read barrier before copying data */
                __asm volatile ("dmb" ::: "memory");

                local_data.temperature = sensor_data.temperature;
                local_data.pressure = sensor_data.pressure;
                local_data.flow_rate = sensor_data.flow_rate;
                local_data.vibration = sensor_data.vibration;
                local_data.timestamp = sensor_data.timestamp;
                local_data.sensor_status = sensor_data.sensor_status;

                sensor_data.data_ready = 0;
                data_valid = 1;
            }

            xSemaphoreGive(xSensorMutex);
        }
        else
        {
            printf("[CONTROL] ERROR: Failed to acquire mutex!\n");
        }

        if (!data_valid)
        {
            stale_data_count++;
            if (stale_data_count > 50) /* 1 second of no data at 20ms period */
            {
                trigger_emergency_shutdown("Sensor data timeout - no data for >1 second");
                stale_data_count = 0;
            }
            vTaskDelayUntil(&xLastWakeTime, xPeriod);
            continue;
        }

        stale_data_count = 0;

        /* Check for stale data based on timestamp */
        if (local_data.timestamp == last_valid_timestamp)
        {
            printf("[CONTROL] WARNING: Sensor data has not been updated\n");
        }
        last_valid_timestamp = local_data.timestamp;

        /* Check sensor health before applying control logic */
        if (local_data.sensor_status != 0xFF)
        {
            set_alarm("One or more sensors reporting fault condition");
            printf("[CONTROL] Sensor status: 0x%02X\n", local_data.sensor_status);

            /* If critical sensors are faulted, enter safe mode */
            if (!(local_data.sensor_status & (1 << 0)) &&
                !(local_data.sensor_status & (1 << 1)))
            {
                trigger_emergency_shutdown("Critical sensor failure: temp + pressure");
                vTaskDelayUntil(&xLastWakeTime, xPeriod);
                continue;
            }
        }

        /* === Temperature Control with Hysteresis === */
        if (local_data.sensor_status & (1 << 0)) /* Temperature sensor OK */
        {
            if (!cooling_active && local_data.temperature > TEMP_HIGH_THRESHOLD)
            {
                cooling_active = 1;
                activate_cooling_system(local_data.temperature);
            }
            else if (cooling_active && local_data.temperature < TEMP_LOW_THRESHOLD)
            {
                cooling_active = 0;
                deactivate_cooling_system();
            }

            if (local_data.temperature > 85.0f)
            {
                trigger_emergency_shutdown("Temperature exceeds critical limit");
            }
        }

        /* === Pressure Control === */
        if (local_data.sensor_status & (1 << 1)) /* Pressure sensor OK */
        {
            if (local_data.pressure > PRESSURE_CRITICAL)
            {
                trigger_pressure_relief_valve(local_data.pressure);
                if (!pressure_alarm_active)
                {
                    pressure_alarm_active = 1;
                    set_alarm("Pressure critical - relief valve activated");
                }
            }
            else if (local_data.pressure > PRESSURE_WARNING)
            {
                if (!pressure_alarm_active)
                {
                    pressure_alarm_active = 1;
                    set_alarm("Pressure warning threshold exceeded");
                }
            }
            else
            {
                if (pressure_alarm_active && local_data.pressure < (PRESSURE_WARNING - 2.0f))
                {
                    pressure_alarm_active = 0;
                }
            }
        }

        /* === Flow Rate Control === */
        if (local_data.sensor_status & (1 << 2)) /* Flow sensor OK */
        {
            if (local_data.flow_rate < FLOW_MIN)
            {
                adjust_flow_control_valve(local_data.flow_rate);
                set_alarm("Flow rate below minimum threshold");
            }
            else if (local_data.flow_rate > FLOW_MAX)
            {
                adjust_flow_control_valve(local_data.flow_rate);
                set_alarm("Flow rate above maximum threshold");
            }
        }

        /* === Vibration Monitoring === */
        if (local_data.sensor_status & (1 << 3)) /* Vibration sensor OK */
        {
            if (local_data.vibration > VIBRATION_CRITICAL)
            {
                if (!vibration_alarm_active)
                {
                    vibration_alarm_active = 1;
                    trigger_emergency_shutdown("Critical vibration level detected");
                }
            }
            else if (local_data.vibration > VIBRATION_WARNING)
            {
                if (!vibration_alarm_active)
                {
                    vibration_alarm_active = 1;
                    set_alarm("Vibration warning - check mechanical components");
                }
            }
            else
            {
                if (vibration_alarm_active && local_data.vibration < (VIBRATION_WARNING - 0.5f))
                {
                    vibration_alarm_active = 0;
                }
            }
        }

        /* Periodic status log (every ~1 second) */
        if ((local_data.timestamp % pdMS_TO_TICKS(1000)) < pdMS_TO_TICKS(20))
        {
            printf("[STATUS] T=%.1fC P=%.1fkPa F=%.1fL/min V=%.2f ts=%lu status=0x%02X\n",
                   local_data.temperature,
                   local_data.pressure,
                   local_data.flow_rate,
                   local_data.vibration,
                   (unsigned long)local_data.timestamp,
                   local_data.sensor_status);
        }

        vTaskDelayUntil(&xLastWakeTime, xPeriod);
    }
}

int main(void)
{
    printf("Industrial Control System - FreeRTOS Startup\n");
    printf("=============================================\n");

    /* Initialize the shared sensor data struct */
    memset((void *)&sensor_data, 0, sizeof(SensorData_t));

    /* Create the mutex for shared data protection */
    xSensorMutex = xSemaphoreCreateMutex();

    if (xSensorMutex == NULL)
    {
        printf("FATAL: Failed to create sensor mutex\n");
        for (;;);
    }

    /* Create Sensor Read Task - Higher priority for time-critical acquisition
     * Stack size: 256 words should be sufficient for sensor reads */
    BaseType_t xResult;

    xResult = xTaskCreate(
        vSensorReadTask,
        "SensorRead",
        256,
        NULL,
        3,                      /* Higher priority */
        &xSensorReadTaskHandle
    );

    if (xResult != pdPASS)
    {
        printf("FATAL: Failed to create sensor read task\n");
        for (;;);
    }

    /* Create Control Logic Task - Lower priority, runs when sensor task yields
     * Stack size: 512 words for control computations and printf */
    xResult = xTaskCreate(
        vControlLogicTask,
        "ControlLogic",
        512,
        NULL,
        2,                      /* Lower priority than sensor task */
        &xControlLogicTaskHandle
    );

    if (xResult != pdPASS)
    {
        printf("FATAL: Failed to create control logic task\n");
        for (;;);
    }

    printf("Tasks created successfully. Starting scheduler...\n");

    /* Start the FreeRTOS scheduler - this should never return */
    vTaskStartScheduler();

    /* Should never reach here. If we do, there was insufficient heap memory. */
    printf("FATAL: Scheduler exited - insufficient heap memory\n");
    for (;;);

    return 0;
}

/* FreeRTOS hook functions */
void vApplicationMallocFailedHook(void)
{
    printf("FATAL: Memory allocation failed\n");
    for (;;);
}

void vApplicationStackOverflowHook(TaskHandle_t xTask, char *pcTaskName)
{
    (void)xTask;
    printf("FATAL: Stack overflow in task: %s\n", pcTaskName);
    for (;;);
}

void vApplicationIdleHook(void)
{
    /* Enter low-power mode when idle to save energy in industrial deployment */
    __asm volatile ("wfi");
}