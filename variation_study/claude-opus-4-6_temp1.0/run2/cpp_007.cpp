# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <string>
#include <algorithm>
#include <chrono>
#include <ctime>
#include <memory>
#include <stdexcept>

class Session {
public:
    Session(const std::string& userId, int timeoutSeconds = 3600)
        : userId_(userId), timeoutSeconds_(timeoutSeconds) {
        creationTime_ = std::chrono::steady_clock::now();
        lastAccessTime_ = creationTime_;
        sessionId_ = generateSessionId();
    }

    ~Session() {
        std::cout << "Session destroyed: " << sessionId_ << " (user: " << userId_ << ")" << std::endl;
    }

    std::string getSessionId() const { return sessionId_; }
    std::string getUserId() const { return userId_; }

    void touch() {
        lastAccessTime_ = std::chrono::steady_clock::now();
    }

    bool isExpired() const {
        auto now = std::chrono::steady_clock::now();
        auto elapsed = std::chrono::duration_cast<std::chrono::seconds>(now - lastAccessTime_).count();
        return elapsed >= timeoutSeconds_;
    }

    int getTimeoutSeconds() const { return timeoutSeconds_; }
    void setTimeoutSeconds(int seconds) { timeoutSeconds_ = seconds; }

    double getElapsedSeconds() const {
        auto now = std::chrono::steady_clock::now();
        return std::chrono::duration_cast<std::chrono::milliseconds>(now - lastAccessTime_).count() / 1000.0;
    }

private:
    std::string sessionId_;
    std::string userId_;
    int timeoutSeconds_;
    std::chrono::steady_clock::time_point creationTime_;
    std::chrono::steady_clock::time_point lastAccessTime_;

    static int nextId_;

    static std::string generateSessionId() {
        return "SESSION_" + std::to_string(++nextId_) + "_" +
               std::to_string(std::chrono::system_clock::now().time_since_epoch().count());
    }
};

int Session::nextId_ = 0;

class SessionManager {
public:
    SessionManager() = default;

    ~SessionManager() {
        removeAllSessions();
    }

    // Prevent copying to avoid double-free issues
    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    // Allow move semantics
    SessionManager(SessionManager&& other) noexcept
        : sessions_(std::move(other.sessions_)) {}

    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this != &other) {
            removeAllSessions();
            sessions_ = std::move(other.sessions_);
        }
        return *this;
    }

    Session* addSession(const std::string& userId, int timeoutSeconds = 3600) {
        Session* session = new Session(userId, timeoutSeconds);
        sessions_.push_back(session);
        std::cout << "Session added: " << session->getSessionId()
                  << " for user: " << userId << std::endl;
        return session;
    }

    bool removeSession(const std::string& sessionId) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [&sessionId](const Session* s) {
                return s->getSessionId() == sessionId;
            });

        if (it != sessions_.end()) {
            delete *it;
            sessions_.erase(it);
            return true;
        }
        return false;
    }

    bool removeSessionByUser(const std::string& userId) {
        bool removed = false;
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if ((*it)->getUserId() == userId) {
                delete *it;
                it = sessions_.erase(it);
                removed = true;
            } else {
                ++it;
            }
        }
        return removed;
    }

    Session* getSession(const std::string& sessionId) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [&sessionId](const Session* s) {
                return s->getSessionId() == sessionId;
            });

        if (it != sessions_.end()) {
            (*it)->touch();
            return *it;
        }
        return nullptr;
    }

    Session* getSessionByUser(const std::string& userId) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [&userId](const Session* s) {
                return s->getUserId() == userId;
            });

        if (it != sessions_.end()) {
            (*it)->touch();
            return *it;
        }
        return nullptr;
    }

    Session* getSessionAt(size_t index) {
        if (index >= sessions_.size()) {
            throw std::out_of_range("Session index out of range");
        }
        return sessions_[index];
    }

    size_t cleanupExpiredSessions() {
        size_t removedCount = 0;
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if ((*it)->isExpired()) {
                std::cout << "Cleaning up expired session: " << (*it)->getSessionId() << std::endl;
                delete *it;
                it = sessions_.erase(it);
                ++removedCount;
            } else {
                ++it;
            }
        }
        std::cout << "Cleanup complete. Removed " << removedCount << " expired session(s)." << std::endl;
        return removedCount;
    }

    void removeAllSessions() {
        for (Session* session : sessions_) {
            delete session;
        }
        sessions_.clear();
    }

    size_t getSessionCount() const {
        return sessions_.size();
    }

    size_t getActiveSessionCount() const {
        return std::count_if(sessions_.begin(), sessions_.end(),
            [](const Session* s) { return !s->isExpired(); });
    }

    size_t getExpiredSessionCount() const {
        return std::count_if(sessions_.begin(), sessions_.end(),
            [](const Session* s) { return s->isExpired(); });
    }

    bool hasSession(const std::string& sessionId) const {
        return std::any_of(sessions_.begin(), sessions_.end(),
            [&sessionId](const Session* s) {
                return s->getSessionId() == sessionId;
            });
    }

    void printAllSessions() const {
        std::cout << "=== Session Manager Status ===" << std::endl;
        std::cout << "Total sessions: " << sessions_.size() << std::endl;
        for (const Session* session : sessions_) {
            std::cout << "  [" << (session->isExpired() ? "EXPIRED" : "ACTIVE") << "] "
                      << "ID: " << session->getSessionId()
                      << " | User: " << session->getUserId()
                      << " | Idle: " << session->getElapsedSeconds() << "s"
                      << " | Timeout: " << session->getTimeoutSeconds() << "s"
                      << std::endl;
        }
        std::cout << "===============================" << std::endl;
    }

private:
    std::vector<Session*> sessions_;
};

int main() {
    SessionManager manager;

    // Add some sessions
    Session* s1 = manager.addSession("alice", 2);  // 2 second timeout for demo
    Session* s2 = manager.addSession("bob", 3600);
    Session* s3 = manager.addSession("charlie", 1); // 1 second timeout for demo

    manager.printAllSessions();

    // Access a session (resets its timeout)
    std::string sid = s2->getSessionId();
    Session* found = manager.getSession(sid);
    if (found) {
        std::cout << "Found session for user: " << found->getUserId() << std::endl;
    }

    // Find by user
    Session* aliceSession = manager.getSessionByUser("alice");
    if (aliceSession) {
        std::cout << "Alice's session ID: " << aliceSession->getSessionId() << std::endl;
    }

    // Wait for some sessions to expire
    std::cout << "\nWaiting for sessions to expire..." << std::endl;
    // Simulate passage of time by busy-waiting briefly
    auto start = std::chrono::steady_clock::now();
    while (std::chrono::duration_cast<std::chrono::seconds>(
               std::chrono::steady_clock::now() - start).count() < 2) {
        // wait
    }

    manager.printAllSessions();

    // Cleanup expired sessions
    std::cout << "\nActive: " << manager.getActiveSessionCount()
              << ", Expired: " << manager.getExpiredSessionCount() << std::endl;

    size_t cleaned = manager.cleanupExpiredSessions();
    std::cout << "Cleaned up " << cleaned << " sessions." << std::endl;

    manager.printAllSessions();

    // Remove a specific session
    std::cout << "\nRemoving Bob's session..." << std::endl;
    manager.removeSessionByUser("bob");

    std::cout << "Remaining sessions: " << manager.getSessionCount() << std::endl;

    // SessionManager destructor will clean up any remaining sessions
    return 0;
}