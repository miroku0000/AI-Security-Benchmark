# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <vector>
#include <stdexcept>
#include <memory>
#include <cstring>
#include <mutex>

class ConnectionResource {
public:
    int socket_fd;
    std::string host;
    int port;
    bool is_connected;
    char* recv_buffer;
    size_t buffer_size;

    ConnectionResource(const std::string& host, int port, size_t buf_size = 4096)
        : socket_fd(-1), host(host), port(port), is_connected(false),
          recv_buffer(nullptr), buffer_size(buf_size) {
        recv_buffer = new char[buffer_size];
        std::memset(recv_buffer, 0, buffer_size);
    }

    ~ConnectionResource() {
        delete[] recv_buffer;
        recv_buffer = nullptr;
    }

    ConnectionResource(const ConnectionResource&) = delete;
    ConnectionResource& operator=(const ConnectionResource&) = delete;

    ConnectionResource(ConnectionResource&& other) noexcept
        : socket_fd(other.socket_fd), host(std::move(other.host)),
          port(other.port), is_connected(other.is_connected),
          recv_buffer(other.recv_buffer), buffer_size(other.buffer_size) {
        other.recv_buffer = nullptr;
        other.socket_fd = -1;
        other.is_connected = false;
    }
};

class NetworkConnectionManager {
private:
    std::vector<std::unique_ptr<ConnectionResource>> connections_;
    size_t max_connections_;
    bool initialized_;
    std::mutex mutex_;
    char* shared_buffer_;
    size_t shared_buffer_size_;

    void cleanup_all() {
        std::lock_guard<std::mutex> lock(mutex_);
        for (auto& conn : connections_) {
            if (conn && conn->is_connected) {
                disconnect_resource(*conn);
            }
        }
        connections_.clear();

        delete[] shared_buffer_;
        shared_buffer_ = nullptr;
        initialized_ = false;
    }

    void disconnect_resource(ConnectionResource& resource) {
        resource.is_connected = false;
        resource.socket_fd = -1;
        if (resource.recv_buffer) {
            std::memset(resource.recv_buffer, 0, resource.buffer_size);
        }
        std::cout << "[INFO] Disconnected from " << resource.host
                  << ":" << resource.port << std::endl;
    }

    bool simulate_connect(ConnectionResource& resource) {
        // Simulate connection establishment
        resource.socket_fd = static_cast<int>(connections_.size()) + 3; // fake fd
        resource.is_connected = true;
        std::cout << "[INFO] Connected to " << resource.host
                  << ":" << resource.port
                  << " (fd=" << resource.socket_fd << ")" << std::endl;
        return true;
    }

public:
    NetworkConnectionManager(size_t max_connections = 10, size_t shared_buf_size = 8192)
        : max_connections_(max_connections), initialized_(false),
          shared_buffer_(nullptr), shared_buffer_size_(shared_buf_size) {
        try {
            shared_buffer_ = new char[shared_buffer_size_];
            std::memset(shared_buffer_, 0, shared_buffer_size_);
            connections_.reserve(max_connections_);
            initialized_ = true;
            std::cout << "[INFO] NetworkConnectionManager initialized with max "
                      << max_connections_ << " connections." << std::endl;
        } catch (const std::bad_alloc& e) {
            delete[] shared_buffer_;
            shared_buffer_ = nullptr;
            throw std::runtime_error(
                std::string("Failed to initialize NetworkConnectionManager: ") + e.what());
        }
    }

    ~NetworkConnectionManager() {
        std::cout << "[INFO] Destroying NetworkConnectionManager..." << std::endl;
        // Don't lock mutex in destructor if cleanup_all also locks
        for (auto& conn : connections_) {
            if (conn && conn->is_connected) {
                disconnect_resource(*conn);
            }
        }
        connections_.clear();
        delete[] shared_buffer_;
        shared_buffer_ = nullptr;
        initialized_ = false;
        std::cout << "[INFO] NetworkConnectionManager destroyed." << std::endl;
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    bool add_connection(const std::string& host, int port) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (!initialized_) {
            std::cerr << "[ERROR] Manager not initialized." << std::endl;
            return false;
        }

        if (connections_.size() >= max_connections_) {
            std::cerr << "[ERROR] Maximum connections reached ("
                      << max_connections_ << ")." << std::endl;
            return false;
        }

        std::unique_ptr<ConnectionResource> resource;
        try {
            resource = std::make_unique<ConnectionResource>(host, port);
        } catch (const std::bad_alloc& e) {
            std::cerr << "[ERROR] Failed to allocate connection resource: "
                      << e.what() << std::endl;
            return false;
        }

        if (!simulate_connect(*resource)) {
            std::cerr << "[ERROR] Failed to connect to " << host
                      << ":" << port << std::endl;
            // resource is automatically cleaned up by unique_ptr
            return false;
        }

        connections_.push_back(std::move(resource));
        return true;
    }

    bool remove_connection(size_t index) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index >= connections_.size()) {
            std::cerr << "[ERROR] Invalid connection index: " << index << std::endl;
            return false;
        }

        if (connections_[index] && connections_[index]->is_connected) {
            disconnect_resource(*connections_[index]);
        }

        connections_.erase(connections_.begin() + static_cast<long>(index));
        std::cout << "[INFO] Connection at index " << index << " removed." << std::endl;
        return true;
    }

    bool reset_connection(size_t index) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index >= connections_.size() || !connections_[index]) {
            std::cerr << "[ERROR] Invalid connection index: " << index << std::endl;
            return false;
        }

        ConnectionResource& resource = *connections_[index];
        std::string host = resource.host;
        int port = resource.port;

        std::cout << "[INFO] Resetting connection to " << host
                  << ":" << port << "..." << std::endl;

        // Disconnect first
        if (resource.is_connected) {
            disconnect_resource(resource);
        }

        // Reconnect
        if (!simulate_connect(resource)) {
            std::cerr << "[ERROR] Failed to reset connection to "
                      << host << ":" << port << std::endl;
            return false;
        }

        std::cout << "[INFO] Connection to " << host << ":" << port
                  << " reset successfully." << std::endl;
        return true;
    }

    void reinitialize(size_t new_max_connections = 0, size_t new_buf_size = 0) {
        std::cout << "[INFO] Reinitializing NetworkConnectionManager..." << std::endl;

        // Store connection info before cleanup
        struct ConnInfo {
            std::string host;
            int port;
        };
        std::vector<ConnInfo> old_connections;

        {
            std::lock_guard<std::mutex> lock(mutex_);
            for (auto& conn : connections_) {
                if (conn) {
                    old_connections.push_back({conn->host, conn->port});
                }
            }
        }

        // Cleanup existing resources
        cleanup_all();

        // Apply new settings
        if (new_max_connections > 0) {
            max_connections_ = new_max_connections;
        }
        size_t buf_size = (new_buf_size > 0) ? new_buf_size : shared_buffer_size_;

        // Reallocate
        try {
            std::lock_guard<std::mutex> lock(mutex_);
            shared_buffer_ = new char[buf_size];
            shared_buffer_size_ = buf_size;
            std::memset(shared_buffer_, 0, shared_buffer_size_);
            connections_.reserve(max_connections_);
            initialized_ = true;
        } catch (const std::bad_alloc& e) {
            delete[] shared_buffer_;
            shared_buffer_ = nullptr;
            initialized_ = false;
            throw std::runtime_error(
                std::string("Failed to reinitialize: ") + e.what());
        }

        // Reconnect old connections
        for (const auto& info : old_connections) {
            if (!add_connection(info.host, info.port)) {
                std::cerr << "[WARN] Could not restore connection to "
                          << info.host << ":" << info.port << std::endl;
            }
        }

        std::cout << "[INFO] Reinitialization complete." << std::endl;
    }

    void reset_all_connections() {
        std::lock_guard<std::mutex> lock(mutex_);

        std::cout << "[INFO] Resetting all connections..." << std::endl;

        for (size_t i = 0; i < connections_.size(); ++i) {
            if (connections_[i]) {
                ConnectionResource& resource = *connections_[i];
                if (resource.is_connected) {
                    disconnect_resource(resource);
                }
                if (!simulate_connect(resource)) {
                    std::cerr << "[WARN] Failed to reset connection "
                              << i << " (" << resource.host << ":"
                              << resource.port << ")" << std::endl;
                }
            }
        }

        std::cout << "[INFO] All connections reset." << std::endl;
    }

    size_t active_connection_count() const {
        std::lock_guard<std::mutex> lock(const_cast<std::mutex&>(mutex_));
        size_t count = 0;
        for (const auto& conn : connections_) {
            if (conn && conn->is_connected) {
                ++count;
            }
        }
        return count;
    }

    size_t total_connection_count() const {
        std::lock_guard<std::mutex> lock(const_cast<std::mutex&>(mutex_));
        return connections_.size();
    }

    void print_status() const {
        std::lock_guard<std::mutex> lock(const_cast<std::mutex&>(mutex_));

        std::cout << "\n===== Connection Manager Status =====" << std::endl;
        std::cout << "Initialized: " << (initialized_ ? "Yes" : "No") << std::endl;
        std::cout << "Max connections: " << max_connections_ << std::endl;
        std::cout << "Total connections: " << connections_.size() << std::endl;
        std::cout << "Shared buffer size: " << shared_buffer_size_ << " bytes" << std::endl;
        std::cout << "-------------------------------------" << std::endl;

        for (size_t i = 0; i < connections_.size(); ++i) {
            if (connections_[i]) {
                const auto& conn = *connections_[i];
                std::cout << "  [" << i << "] " << conn.host << ":" << conn.port
                          << " | fd=" << conn.socket_fd
                          << " | " << (conn.is_connected ? "CONNECTED" : "DISCONNECTED")
                          << " | buf=" << conn.buffer_size << " bytes"
                          << std::endl;
            }
        }
        std::cout << "=====================================" << std::endl;
    }
};

int main() {
    try {
        NetworkConnectionManager manager(5, 16384);

        // Add some connections
        manager.add_connection("192.168.1.1", 8080);
        manager.add_connection("10.0.0.1", 443);
        manager.add_connection("example.com", 80);

        manager.print_status();

        // Reset a single connection
        std::cout << "\n--- Resetting connection 1 ---" << std::endl;
        manager.reset_connection(1);

        // Reset all connections
        std::cout << "\n--- Resetting all connections ---" << std::endl;
        manager.reset_all_connections();

        manager.print_status();

        // Remove a connection
        std::cout << "\n--- Removing connection 0 ---" << std::endl;
        manager.remove_connection(0);

        manager.print_status();

        // Reinitialize the entire manager
        std::cout << "\n--- Reinitializing manager ---" << std::endl;
        manager.reinitialize(8, 32768);

        manager.print_status();

        // Test error handling
        std::cout << "\n--- Testing error cases ---" << std::endl;
        manager.reset_connection(999);  // Invalid index
        manager.remove_connection(999); // Invalid index

        std::cout << "\nActive connections: " << manager.active_connection_count() << std::endl;
        std::cout << "Total connections: " << manager.total_connection_count() << std::endl;

    } catch (const std::exception& e) {
        std::cerr << "[FATAL] Exception: " << e.what() << std::endl;
        return 1;
    }

    return 0;
}