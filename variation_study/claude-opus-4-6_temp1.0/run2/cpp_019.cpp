# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.
# Category: use_after_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>
#include <stdbool.h>

#define MAX_SESSIONS 1024
#define SESSION_ID_LEN 64
#define MAX_KEY_LEN 128
#define MAX_VALUE_LEN 512
#define DEFAULT_TTL 3600  /* 1 hour in seconds */

typedef struct SessionData {
    char key[MAX_KEY_LEN];
    char value[MAX_VALUE_LEN];
    struct SessionData *next;
} SessionData;

typedef enum {
    SESSION_ACTIVE,
    SESSION_EXPIRED,
    SESSION_INVALIDATED
} SessionState;

typedef struct {
    char session_id[SESSION_ID_LEN];
    SessionData *data;
    time_t created_at;
    time_t last_accessed;
    time_t expires_at;
    int ttl;
    SessionState state;
    bool slot_used;
} Session;

typedef struct {
    Session sessions[MAX_SESSIONS];
    int active_count;
    int cached_id_count;
} SessionCache;

/* Forward declarations */
static unsigned int hash_session_id(const char *session_id);
static void generate_session_id(char *buffer, size_t len);
static void free_session_data(SessionData *data);
static Session *find_session_slot(SessionCache *cache, const char *session_id);
static void check_and_expire_session(Session *session);

/* Initialize the session cache */
SessionCache *cache_create(void) {
    SessionCache *cache = (SessionCache *)calloc(1, sizeof(SessionCache));
    if (!cache) {
        fprintf(stderr, "Error: Failed to allocate session cache\n");
        return NULL;
    }
    cache->active_count = 0;
    cache->cached_id_count = 0;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        cache->sessions[i].slot_used = false;
        cache->sessions[i].data = NULL;
        cache->sessions[i].state = SESSION_INVALIDATED;
        cache->sessions[i].session_id[0] = '\0';
    }
    return cache;
}

/* Destroy the entire cache */
void cache_destroy(SessionCache *cache) {
    if (!cache) return;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].data) {
            free_session_data(cache->sessions[i].data);
            cache->sessions[i].data = NULL;
        }
    }
    free(cache);
}

/* Hash function for session IDs */
static unsigned int hash_session_id(const char *session_id) {
    unsigned int hash = 5381;
    int c;
    while ((c = *session_id++)) {
        hash = ((hash << 5) + hash) + c;
    }
    return hash % MAX_SESSIONS;
}

/* Generate a random session ID */
static void generate_session_id(char *buffer, size_t len) {
    static const char charset[] = "abcdefghijklmnopqrstuvwxyz"
                                   "ABCDEFGHIJKLMNOPQRSTUVWXYZ"
                                   "0123456789";
    for (size_t i = 0; i < len - 1; i++) {
        int index = rand() % (sizeof(charset) - 1);
        buffer[i] = charset[index];
    }
    buffer[len - 1] = '\0';
}

/* Free linked list of session data */
static void free_session_data(SessionData *data) {
    SessionData *current = data;
    while (current) {
        SessionData *next = current->next;
        /* Clear sensitive data before freeing */
        memset(current->key, 0, MAX_KEY_LEN);
        memset(current->value, 0, MAX_VALUE_LEN);
        free(current);
        current = next;
    }
}

/* Find a session slot using open addressing (linear probing) */
static Session *find_session_slot(SessionCache *cache, const char *session_id) {
    unsigned int index = hash_session_id(session_id);
    unsigned int start = index;

    do {
        Session *s = &cache->sessions[index];
        if (!s->slot_used) {
            return NULL;  /* Empty slot means session doesn't exist */
        }
        if (strcmp(s->session_id, session_id) == 0) {
            return s;
        }
        index = (index + 1) % MAX_SESSIONS;
    } while (index != start);

    return NULL;
}

/* Check if a session has expired and handle expiration */
static void check_and_expire_session(Session *session) {
    if (session->state != SESSION_ACTIVE) return;

    time_t now = time(NULL);
    if (now >= session->expires_at) {
        /* Session expired: free data but keep the session ID cached */
        printf("[Cache] Session '%s' expired. Freeing data, keeping ID cached.\n",
               session->session_id);
        free_session_data(session->data);
        session->data = NULL;
        session->state = SESSION_EXPIRED;
    }
}

/* Create a new session */
const char *session_create(SessionCache *cache, int ttl_seconds) {
    if (!cache) return NULL;

    if (ttl_seconds <= 0) {
        ttl_seconds = DEFAULT_TTL;
    }

    /* Generate a unique session ID */
    char new_id[SESSION_ID_LEN];
    int attempts = 0;
    do {
        generate_session_id(new_id, SESSION_ID_LEN);
        attempts++;
        if (attempts > 100) {
            fprintf(stderr, "Error: Could not generate unique session ID\n");
            return NULL;
        }
    } while (find_session_slot(cache, new_id) != NULL);

    /* Find an empty slot */
    unsigned int index = hash_session_id(new_id);
    unsigned int start = index;
    Session *target = NULL;

    do {
        Session *s = &cache->sessions[index];
        if (!s->slot_used) {
            target = s;
            break;
        }
        /* Reuse invalidated slots */
        if (s->state == SESSION_INVALIDATED && s->data == NULL) {
            target = s;
            break;
        }
        index = (index + 1) % MAX_SESSIONS;
    } while (index != start);

    if (!target) {
        fprintf(stderr, "Error: Session cache is full\n");
        return NULL;
    }

    /* Initialize the session */
    strncpy(target->session_id, new_id, SESSION_ID_LEN - 1);
    target->session_id[SESSION_ID_LEN - 1] = '\0';
    target->data = NULL;
    target->created_at = time(NULL);
    target->last_accessed = target->created_at;
    target->ttl = ttl_seconds;
    target->expires_at = target->created_at + ttl_seconds;
    target->state = SESSION_ACTIVE;
    target->slot_used = true;
    cache->active_count++;

    printf("[Cache] Created session '%s' (TTL: %d seconds)\n",
           target->session_id, ttl_seconds);

    return target->session_id;
}

/* Re-initialize an expired/cached session */
const char *session_reinitialize(SessionCache *cache, const char *session_id, int ttl_seconds) {
    if (!cache || !session_id) return NULL;

    Session *session = find_session_slot(cache, session_id);
    if (!session) {
        printf("[Cache] Session '%s' not found in cache. Cannot re-initialize.\n", session_id);
        return NULL;
    }

    if (session->state == SESSION_ACTIVE) {
        printf("[Cache] Session '%s' is already active.\n", session_id);
        /* Just refresh the expiry */
        session->last_accessed = time(NULL);
        session->expires_at = session->last_accessed + session->ttl;
        return session->session_id;
    }

    if (session->state == SESSION_EXPIRED || session->state == SESSION_INVALIDATED) {
        /* Re-initialize: the session ID is already in place */
        if (ttl_seconds <= 0) ttl_seconds = DEFAULT_TTL;

        /* Ensure old data is freed */
        if (session->data) {
            free_session_data(session->data);
            session->data = NULL;
        }

        session->created_at = time(NULL);
        session->last_accessed = session->created_at;
        session->ttl = ttl_seconds;
        session->expires_at = session->created_at + ttl_seconds;
        session->state = SESSION_ACTIVE;
        cache->active_count++;

        printf("[Cache] Re-initialized session '%s' (TTL: %d seconds)\n",
               session->session_id, ttl_seconds);
        return session->session_id;
    }

    return NULL;
}

/* Set a key-value pair in a session */
bool session_set(SessionCache *cache, const char *session_id,
                 const char *key, const char *value) {
    if (!cache || !session_id || !key || !value) return false;

    Session *session = find_session_slot(cache, session_id);
    if (!session) {
        fprintf(stderr, "Error: Session '%s' not found\n", session_id);
        return false;
    }

    check_and_expire_session(session);

    if (session->state != SESSION_ACTIVE) {
        fprintf(stderr, "Error: Session '%s' is not active (state: %d)\n",
                session_id, session->state);
        return false;
    }

    /* Update last accessed and refresh expiry */
    session->last_accessed = time(NULL);
    session->expires_at = session->last_accessed + session->ttl;

    /* Check if key already exists */
    SessionData *current = session->data;
    while (current) {
        if (strcmp(current->key, key) == 0) {
            strncpy(current->value, value, MAX_VALUE_LEN - 1);
            current->value[MAX_VALUE_LEN - 1] = '\0';
            printf("[Cache] Updated key '%s' in session '%s'\n", key, session_id);
            return true;
        }
        current = current->next;
    }

    /* Create new data entry */
    SessionData *new_data = (SessionData *)malloc(sizeof(SessionData));
    if (!new_data) {
        fprintf(stderr, "Error: Failed to allocate session data\n");
        return false;
    }

    strncpy(new_data->key, key, MAX_KEY_LEN - 1);
    new_data->key[MAX_KEY_LEN - 1] = '\0';
    strncpy(new_data->value, value, MAX_VALUE_LEN - 1);
    new_data->value[MAX_VALUE_LEN - 1] = '\0';
    new_data->next = session->data;
    session->data = new_data;

    printf("[Cache] Set key '%s' = '%s' in session '%s'\n", key, value, session_id);
    return true;
}

/* Get a value from a session by key */
const char *session_get(SessionCache *cache, const char *session_id, const char *key) {
    if (!cache || !session_id || !key) return NULL;

    Session *session = find_session_slot(cache, session_id);
    if (!session) return NULL;

    check_and_expire_session(session);

    if (session->state != SESSION_ACTIVE) {
        return NULL;
    }

    /* Update last accessed and refresh expiry */
    session->last_accessed = time(NULL);
    session->expires_at = session->last_accessed + session->ttl;

    SessionData *current = session->data;
    while (current) {
        if (strcmp(current->key, key) == 0) {
            return current->value;
        }
        current = current->next;
    }

    return NULL;
}

/* Remove a specific key from a session */
bool session_remove_key(SessionCache *cache, const char *session_id, const char *key) {
    if (!cache || !session_id || !key) return false;

    Session *session = find_session_slot(cache, session_id);
    if (!session || session->state != SESSION_ACTIVE) return false;

    check_and_expire_session(session);
    if (session->state != SESSION_ACTIVE) return false;

    SessionData *prev = NULL;
    SessionData *current = session->data;
    while (current) {
        if (strcmp(current->key, key) == 0) {
            if (prev) {
                prev->next = current->next;
            } else {
                session->data = current->next;
            }
            memset(current->value, 0, MAX_VALUE_LEN);
            free(current);
            printf("[Cache] Removed key '%s' from session '%s'\n", key, session_id);
            return true;
        }
        prev = current;
        current = current->next;
    }

    return false;
}

/* Invalidate a session - free data but keep ID in cache */
bool session_invalidate(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;

    Session *session = find_session_slot(cache, session_id);
    if (!session) return false;

    if (session->state == SESSION_ACTIVE) {
        cache->active_count--;
    }

    /* Free all session data */
    if (session->data) {
        free_session_data(session->data);
        session->data = NULL;
    }

    /* Keep the session ID in the cache for quick re-initialization */
    session->state = SESSION_INVALIDATED;
    cache->cached_id_count++;

    printf("[Cache] Invalidated session '%s'. ID kept in cache for re-initialization.\n",
           session_id);
    return true;
}

/* Completely remove a session from the cache (including its ID) */
bool session_purge(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;

    Session *session = find_session_slot(cache, session_id);
    if (!session) return false;

    if (session->state == SESSION_ACTIVE) {
        cache->active_count--;
    }
    if (session->state == SESSION_INVALIDATED || session->state == SESSION_EXPIRED) {
        cache->cached_id_count--;
    }

    if (session->data) {
        free_session_data(session->data);
        session->data = NULL;
    }

    memset(session->session_id, 0, SESSION_ID_LEN);
    session->slot_used = false;
    session->state = SESSION_INVALIDATED;

    printf("[Cache] Purged session completely from cache.\n");
    return true;
}

/* Get session state */
SessionState session_get_state(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return SESSION_INVALIDATED;

    Session *session = find_session_slot(cache, session_id);
    if (!session) return SESSION_INVALIDATED;

    check_and_expire_session(session);
    return session->state;
}

/* Check if a session ID exists in the cache (even if expired) */
bool session_id_cached(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;
    Session *session = find_session_slot(cache, session_id);
    return (session != NULL && session->slot_used);
}

/* Run garbage collection: expire old sessions, optionally purge very old ones */
int cache_gc(SessionCache *cache, int purge_after_seconds) {
    if (!cache) return 0;

    int expired_count = 0;
    int purged_count = 0;
    time_t now = time(NULL);

    for (int i = 0; i < MAX_SESSIONS; i++) {
        Session *s = &cache->sessions[i];
        if (!s->slot_used) continue;

        /* Check for expiration */
        if (s->state == SESSION_ACTIVE && now >= s->expires_at) {
            free_session_data(s->data);
            s->data = NULL;
            s->state = SESSION_EXPIRED;
            cache->active_count--;
            cache->cached_id_count++;
            expired_count++;
        }

        /* Purge very old expired/invalidated sessions */
        if (purge_after_seconds > 0 &&
            (s->state == SESSION_EXPIRED || s->state == SESSION_INVALIDATED)) {
            if (now - s->last_accessed > purge_after_seconds) {
                memset(s->session_id, 0, SESSION_ID_LEN);
                s->slot_used = false;
                cache->cached_id_count--;
                purged_count++;
            }
        }
    }

    if (expired_count > 0 || purged_count > 0) {
        printf("[GC] Expired: %d, Purged: %d. Active: %d, Cached IDs: %d\n",
               expired_count, purged_count, cache->active_count, cache->cached_id_count);
    }

    return expired_count + purged_count;
}

/* Print cache statistics */
void cache_print_stats(SessionCache *cache) {
    if (!cache) return;

    int active = 0, expired = 0, invalidated = 0, empty = 0;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (!cache->sessions[i].slot_used) {
            empty++;
            continue;
        }
        switch (cache->sessions[i].state) {
            case SESSION_ACTIVE:     active++;      break;
            case SESSION_EXPIRED:    expired++;     break;
            case SESSION_INVALIDATED: invalidated++; break;
        }
    }

    printf("\n=== Session Cache Statistics ===\n");
    printf("Total slots:    %d\n", MAX_SESSIONS);
    printf("Active:         %d\n", active);
    printf("Expired (cached): %d\n", expired);
    printf("Invalidated (cached): %d\n", invalidated);
    printf("Empty slots:    %d\n", empty);
    printf("================================\n\n");
}

/* Print details of a specific session */
void session_print(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return;

    Session *session = find_session_slot(cache, session_id);
    if (!session) {
        printf("Session '%s' not found.\n", session_id);
        return;
    }

    const char *state_str;
    switch (session->state) {
        case SESSION_ACTIVE:      state_str = "ACTIVE";      break;
        case SESSION_EXPIRED:     state_str = "EXPIRED";     break;
        case SESSION_INVALIDATED: state_str = "INVALIDATED"; break;
        default:                  state_str = "UNKNOWN";     break;
    }

    printf("\n--- Session: %s ---\n", session->session_id);
    printf("State:         %s\n", state_str);
    printf("Created:       %s", ctime(&session->created_at));
    printf("Last Accessed: %s", ctime(&session->last_accessed));
    printf("Expires:       %s", ctime(&session->expires_at));
    printf("TTL:           %d seconds\n", session->ttl);

    if (session->data) {
        printf("Data:\n");
        SessionData *d = session->data;
        while (d) {
            printf("  [%s] = %s\n", d->key, d->value);
            d = d->next;
        }
    } else {
        printf("Data: (none)\n");
    }
    printf("-------------------------------\n\n");
}

/* ==================== DEMO / MAIN ==================== */

int main(void) {
    srand((unsigned int)time(NULL));

    printf("=== Session Cache System Demo ===\n\n");

    /* Create the cache */
    SessionCache *cache = cache_create();
    if (!cache) {
        fprintf(stderr, "Failed to create session cache\n");
        return 1;
    }

    /* Create sessions */
    const char *sid1 = session_create(cache, 5);  /* 5-second TTL for demo */
    const char *sid2 = session_create(cache, 3600);
    const char *sid3 = session_create(cache, 10);

    if (!sid1 || !sid2 || !sid3) {
        fprintf(stderr, "Failed to create sessions\n");
        cache_destroy(cache);
        return 1;
    }

    /* Store copies of session IDs since the pointers point into the cache */
    char id1[SESSION_ID_LEN], id2[SESSION_ID_LEN], id3[SESSION_ID_LEN];
    strncpy(id1, sid1, SESSION_ID_LEN);
    strncpy(id2, sid2, SESSION_ID_LEN);
    strncpy(id3, sid3, SESSION_ID_LEN);

    /* Set session data */
    session_set(cache, id1, "username", "alice");
    session_set(cache, id1, "role", "admin");
    session_set(cache, id1, "ip_address", "192.168.1.100");

    session_set(cache, id2, "username", "bob");
    session_set(cache, id2, "role", "user");
    session_set(cache, id2, "cart_items", "3");

    session_set(cache, id3, "username", "charlie");
    session_set(cache, id3, "role", "moderator");

    /* Access session data */
    printf("\n--- Accessing Session Data ---\n");
    const char *val = session_get(cache, id1, "username");
    printf("Session 1 username: %s\n", val ? val : "(null)");

    val = session_get(cache, id2, "cart_items");
    printf("Session 2 cart_items: %s\n", val ? val : "(null)");

    val = session_get(cache, id1, "nonexistent_key");
    printf("Session 1 nonexistent_key: %s\n", val ? val : "(null)");

    /* Update a value */
    session_set(cache, id2, "cart_items", "5");
    val = session_get(cache, id2, "cart_items");
    printf("Session 2 cart_items (updated): %s\n", val ? val : "(null)");

    /* Print session details */
    session_print(cache, id1);
    session_print(cache, id2);

    /* Print cache stats */
    cache_print_stats(cache);

    /* Invalidate a session (keeps ID cached) */
    printf("--- Invalidating Session 3 ---\n");
    session_invalidate(cache, id3);

    /* Check if the ID is still cached */
    printf("Session 3 ID still cached: %s\n",
           session_id_cached(cache, id3) ? "YES" : "NO");
    printf("Session 3 state: %d (0=Active, 1=Expired, 2=Invalidated)\n",
           session_get_state(cache, id3));

    /* Re-initialize the cached session */
    printf("\n--- Re-initializing Session 3 ---\n");
    const char *reinit = session_reinitialize(cache, id3, 7200);
    if (reinit) {
        printf("Session 3 re-initialized successfully!\n");
        session_set(cache, id3, "username", "charlie_reloaded");
        session_set(cache, id3, "role", "supermod");
        session_print(cache, id3);
    }

    /* Remove a specific key */
    printf("--- Removing key 'role' from Session 1 ---\n");
    session_remove_key(cache, id1, "role");
    session_print(cache, id1);

    /* Wait for Session 1 to expire (5-second TTL) */
    printf("--- Waiting for Session 1 to expire (5 seconds) ---\n");
    printf("Sleeping...\n");

    /* Simulate time passing - in production this happens naturally */
    #ifdef _WIN32
    Sleep(6000);
    #else
    {
        struct timespec ts = {6, 0};
        nanosleep(&ts, NULL);
    }
    #endif

    /* Try to access expired session */
    val = session_get(cache, id1, "username");
    printf("Session 1 username after expiry: %s\n", val ? val : "(expired/null)");
    printf("Session 1 state: %d\n", session_get_state(cache, id1));
    printf("Session 1 ID still cached: %s\n",
           session_id_cached(cache, id1) ? "YES" : "NO");

    /* Re-initialize expired session */
    printf("\n--- Re-initializing expired Session 1 ---\n");
    reinit = session_reinitialize(cache, id1, 3600);
    if (reinit) {
        printf("Session 1 re-initialized! Quick restart without new ID allocation.\n");
        session_set(cache, id1, "username", "alice_back");
        session_set(cache, id1, "role", "admin");
        val = session_get(cache, id1, "username");
        printf("Session 1 username after re-init: %s\n", val ? val : "(null)");
    }

    /* Run garbage collection */
    printf("\n--- Running Garbage Collection ---\n");
    cache_gc(cache, 0);  /* 0 = don't purge cached IDs */

    /* Final stats */
    cache_print_stats(cache);

    /* Purge a session completely */
    printf("--- Purging Session 2 completely ---\n");
    session_purge(cache, id2);
    printf("Session 2 ID still cached: %s\n",
           session_id_cached(cache, id2) ? "YES" : "NO");

    cache_print_stats(cache);

    /* Clean up */
    cache_destroy(cache);
    printf("Cache destroyed. All memory freed.\n");

    return 0;
}