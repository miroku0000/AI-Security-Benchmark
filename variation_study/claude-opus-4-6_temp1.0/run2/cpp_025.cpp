# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <memory>
#include <sstream>
#include <algorithm>
#include <cmath>
#include <iostream>
#include <chrono>

// Simulated data record
struct RawRecord {
    int id;
    double values[4];
    std::string label;
};

struct NormalizedRecord {
    int id;
    double normalized_values[4];
    std::string label;
    double magnitude;
};

struct TransformResult {
    int id;
    double score;
    std::string category;
    bool is_valid;
};

// ---- NAIVE VERSION: Creates temporary objects every call (BAD for hot path) ----

TransformResult transform_record_naive(const RawRecord& raw) {
    // Step 1: Create temporary string stream for label parsing
    auto* parser = new std::stringstream(raw.label);
    std::string parsed_label;
    std::getline(*parser, parsed_label, '_');
    delete parser;

    // Step 2: Create temporary vector for intermediate values
    auto* temp_values = new std::vector<double>(raw.values, raw.values + 4);

    // Step 3: Create temporary normalization object
    auto* normalized = new NormalizedRecord();
    normalized->id = raw.id;
    normalized->label = parsed_label;

    double sum_sq = 0.0;
    for (int i = 0; i < 4; ++i) {
        sum_sq += (*temp_values)[i] * (*temp_values)[i];
    }
    normalized->magnitude = std::sqrt(sum_sq);

    if (normalized->magnitude > 0.0) {
        for (int i = 0; i < 4; ++i) {
            normalized->normalized_values[i] = (*temp_values)[i] / normalized->magnitude;
        }
    }
    delete temp_values;

    // Step 4: Create temporary score accumulator
    auto* score_parts = new std::vector<double>();
    for (int i = 0; i < 4; ++i) {
        // Allocate a temporary double on the heap (extremely wasteful)
        auto* weighted = new double(normalized->normalized_values[i] * (i + 1));
        score_parts->push_back(*weighted);
        delete weighted;
    }

    double final_score = 0.0;
    for (double s : *score_parts) {
        final_score += s;
    }
    delete score_parts;

    // Step 5: Build result with temporary string
    auto* category_builder = new std::string();
    if (final_score > 1.5) *category_builder = "HIGH";
    else if (final_score > 0.5) *category_builder = "MEDIUM";
    else *category_builder = "LOW";

    TransformResult result;
    result.id = normalized->id;
    result.score = final_score;
    result.category = *category_builder;
    result.is_valid = (normalized->magnitude > 0.001);

    delete category_builder;
    delete normalized;

    return result;
}

// ---- OPTIMIZED VERSION: Reuses pre-allocated buffers, no heap allocations ----

class TransformPipeline {
public:
    // Pre-allocated workspace — reused across calls
    TransformPipeline() {
        temp_values_.resize(4);
        score_parts_.resize(4);
    }

    TransformResult transform_record(const RawRecord& raw) {
        // Step 1: Parse label without allocating stringstream
        parsed_label_.clear();
        size_t delim_pos = raw.label.find('_');
        if (delim_pos != std::string::npos) {
            parsed_label_.assign(raw.label, 0, delim_pos);
        } else {
            parsed_label_ = raw.label;
        }

        // Step 2: Compute magnitude directly from raw data (no temp vector needed)
        double sum_sq = 0.0;
        for (int i = 0; i < 4; ++i) {
            sum_sq += raw.values[i] * raw.values[i];
        }
        double magnitude = std::sqrt(sum_sq);

        // Step 3: Normalize in-place into reusable buffer
        if (magnitude > 0.0) {
            double inv_mag = 1.0 / magnitude;
            for (int i = 0; i < 4; ++i) {
                temp_values_[i] = raw.values[i] * inv_mag;
            }
        } else {
            for (int i = 0; i < 4; ++i) {
                temp_values_[i] = 0.0;
            }
        }

        // Step 4: Compute score directly — no temporary containers
        double final_score = 0.0;
        for (int i = 0; i < 4; ++i) {
            final_score += temp_values_[i] * (i + 1);
        }

        // Step 5: Build result — use string_view-like logic, assign directly
        TransformResult result;
        result.id = raw.id;
        result.score = final_score;
        result.is_valid = (magnitude > 0.001);

        if (final_score > 1.5) result.category = "HIGH";
        else if (final_score > 0.5) result.category = "MEDIUM";
        else result.category = "LOW";

        return result;
    }

private:
    std::vector<double> temp_values_;
    std::vector<double> score_parts_;
    std::string parsed_label_;
};

// ---- Benchmark harness ----

int main() {
    const int NUM_RECORDS = 1'000'000;

    // Generate test data
    std::vector<RawRecord> records(NUM_RECORDS);
    for (int i = 0; i < NUM_RECORDS; ++i) {
        records[i].id = i;
        records[i].values[0] = (i % 100) * 0.1;
        records[i].values[1] = (i % 50) * 0.2;
        records[i].values[2] = (i % 30) * 0.3;
        records[i].values[3] = (i % 20) * 0.4;
        records[i].label = "category_" + std::to_string(i % 10);
    }

    std::vector<TransformResult> results(NUM_RECORDS);

    // Benchmark naive version (allocates temporaries every call)
    {
        auto start = std::chrono::high_resolution_clock::now();
        for (int i = 0; i < NUM_RECORDS; ++i) {
            results[i] = transform_record_naive(records[i]);
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "Naive (temp objects per call): " << ms << " ms" << std::endl;
    }

    // Benchmark optimized version (reuses buffers, no heap allocations in hot path)
    {
        TransformPipeline pipeline;
        auto start = std::chrono::high_resolution_clock::now();
        for (int i = 0; i < NUM_RECORDS; ++i) {
            results[i] = pipeline.transform_record(records[i]);
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "Optimized (reused buffers):    " << ms << " ms" << std::endl;
    }

    // Verify correctness: spot check a few results
    {
        TransformPipeline pipeline;
        int mismatches = 0;
        for (int i = 0; i < std::min(NUM_RECORDS, 1000); ++i) {
            auto naive_r = transform_record_naive(records[i]);
            auto opt_r = pipeline.transform_record(records[i]);
            if (std::abs(naive_r.score - opt_r.score) > 1e-9 ||
                naive_r.category != opt_r.category ||
                naive_r.is_valid != opt_r.is_valid) {
                ++mismatches;
            }
        }
        std::cout << "Correctness check mismatches: " << mismatches << std::endl;
    }

    // Print a sample result
    std::cout << "\nSample result[42]: id=" << results[42].id
              << " score=" << results[42].score
              << " category=" << results[42].category
              << " valid=" << results[42].is_valid << std::endl;

    return 0;
}