# Generated by anthropic (claude-opus-4-6)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>
#include <stdint.h>

#define MAX_PACKET_SIZE      1518   /* Ethernet MTU + headers */
#define PACKET_QUEUE_LENGTH  5

/* Queue to receive packet pointers/metadata from ISR or driver */
typedef struct {
    uint8_t *data;
    uint16_t length;
} packet_descriptor_t;

static QueueHandle_t xPacketQueue = NULL;

/* ============================================================
 * UNSAFE VERSION - DO NOT USE
 * Stack overflow: local buffer on a minimal stack
 * ============================================================ */
#if 0 /* Deliberately disabled - shown only as a warning */
static void vPacketTask_UNSAFE(void *pvParameters)
{
    packet_descriptor_t descriptor;
    /* DANGER: This 1518-byte buffer on a configMINIMAL_STACK_SIZE stack
     * WILL overflow the stack. configMINIMAL_STACK_SIZE is typically
     * 128-256 words (512-1024 bytes). This buffer alone exceeds that. */
    uint8_t local_buffer[MAX_PACKET_SIZE];  /* <-- STACK OVERFLOW */

    for (;;)
    {
        if (xQueueReceive(xPacketQueue, &descriptor, portMAX_DELAY) == pdTRUE)
        {
            if (descriptor.length <= MAX_PACKET_SIZE)
            {
                memcpy(local_buffer, descriptor.data, descriptor.length);
                /* process local_buffer... */
            }
            /* Free original packet from network driver pool */
            vNetworkBufferRelease(descriptor.data);
        }
    }
}
#endif

/* ============================================================
 * CORRECT VERSION - Safe for memory-constrained systems
 * Uses a statically allocated processing buffer instead of stack
 * ============================================================ */

/* Static processing buffer - lives in .bss, not on the stack */
static uint8_t ucPacketProcessingBuffer[MAX_PACKET_SIZE];

/* Static task allocation to avoid heap fragmentation on 64KB system */
static StaticTask_t xPacketTaskTCB;

/* Appropriately sized stack: minimal overhead since large buffer is static */
#define PACKET_TASK_STACK_SIZE  (configMINIMAL_STACK_SIZE + 32)
static StackType_t uxPacketTaskStack[PACKET_TASK_STACK_SIZE];

/* Stub for network buffer release - replace with your driver's function */
extern void vNetworkBufferRelease(uint8_t *pucBuffer);

static void vProcessPacket(const uint8_t *pucData, uint16_t usLength)
{
    /* Application-specific packet processing here */
    /* e.g., parse headers, extract payload, update state */
    (void)pucData;
    (void)usLength;
}

static void vPacketProcessingTask(void *pvParameters)
{
    packet_descriptor_t xDescriptor;
    (void)pvParameters;

    for (;;)
    {
        if (xQueueReceive(xPacketQueue, &xDescriptor, portMAX_DELAY) == pdTRUE)
        {
            if (xDescriptor.data != NULL &&
                xDescriptor.length > 0 &&
                xDescriptor.length <= MAX_PACKET_SIZE)
            {
                /* Copy into static buffer (not on stack) for safe processing */
                memcpy(ucPacketProcessingBuffer, xDescriptor.data, xDescriptor.length);

                /* Release the network driver's buffer as early as possible */
                vNetworkBufferRelease(xDescriptor.data);

                /* Process from the safe static buffer */
                vProcessPacket(ucPacketProcessingBuffer, xDescriptor.length);
            }
            else
            {
                /* Invalid packet - release buffer if non-null */
                if (xDescriptor.data != NULL)
                {
                    vNetworkBufferRelease(xDescriptor.data);
                }
            }
        }
    }
}

BaseType_t xNetworkTaskInit(void)
{
    static StaticQueue_t xQueueStorage;
    static uint8_t ucQueueBuffer[PACKET_QUEUE_LENGTH * sizeof(packet_descriptor_t)];

    /* Create queue using static allocation */
    xPacketQueue = xQueueCreateStatic(
        PACKET_QUEUE_LENGTH,
        sizeof(packet_descriptor_t),
        ucQueueBuffer,
        &xQueueStorage
    );

    if (xPacketQueue == NULL)
    {
        return pdFAIL;
    }

    /* Create task using static allocation - no heap needed */
    TaskHandle_t xHandle = xTaskCreateStatic(
        vPacketProcessingTask,
        "PktProc",
        PACKET_TASK_STACK_SIZE,
        NULL,
        tskIDLE_PRIORITY + 2,
        uxPacketTaskStack,
        &xPacketTaskTCB
    );

    return (xHandle != NULL) ? pdPASS : pdFAIL;
}

/* Call this from your network driver ISR or Rx callback */
BaseType_t xNetworkReceiveFromISR(uint8_t *pucData, uint16_t usLength)
{
    packet_descriptor_t xDescriptor;
    BaseType_t xHigherPriorityTaskWoken = pdFALSE;

    xDescriptor.data = pucData;
    xDescriptor.length = usLength;

    xQueueSendFromISR(xPacketQueue, &xDescriptor, &xHigherPriorityTaskWoken);

    return xHigherPriorityTaskWoken;
}