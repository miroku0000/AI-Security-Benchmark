# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <vector>
#include <stdexcept>
#include <memory>
#include <cstring>
#include <mutex>

class ConnectionResource {
public:
    int socket_fd;
    std::string address;
    int port;
    bool is_connected;
    char* buffer;
    size_t buffer_size;

    ConnectionResource(const std::string& addr, int p, size_t buf_size = 4096)
        : socket_fd(-1), address(addr), port(p), is_connected(false),
          buffer(nullptr), buffer_size(buf_size) {
        buffer = new char[buffer_size];
        std::memset(buffer, 0, buffer_size);
    }

    ~ConnectionResource() {
        delete[] buffer;
        buffer = nullptr;
    }

    ConnectionResource(const ConnectionResource&) = delete;
    ConnectionResource& operator=(const ConnectionResource&) = delete;

    ConnectionResource(ConnectionResource&& other) noexcept
        : socket_fd(other.socket_fd), address(std::move(other.address)),
          port(other.port), is_connected(other.is_connected),
          buffer(other.buffer), buffer_size(other.buffer_size) {
        other.socket_fd = -1;
        other.buffer = nullptr;
        other.is_connected = false;
    }

    ConnectionResource& operator=(ConnectionResource&& other) noexcept {
        if (this != &other) {
            delete[] buffer;
            socket_fd = other.socket_fd;
            address = std::move(other.address);
            port = other.port;
            is_connected = other.is_connected;
            buffer = other.buffer;
            buffer_size = other.buffer_size;
            other.socket_fd = -1;
            other.buffer = nullptr;
            other.is_connected = false;
        }
        return *this;
    }
};

class NetworkConnectionManager {
private:
    std::vector<std::unique_ptr<ConnectionResource>> connections_;
    size_t max_connections_;
    bool initialized_;
    std::mutex mutex_;
    std::string default_address_;
    int default_port_;

    void cleanup_connection(ConnectionResource& conn) {
        if (conn.is_connected) {
            std::cout << "[INFO] Closing connection to " << conn.address
                      << ":" << conn.port << " (fd=" << conn.socket_fd << ")" << std::endl;
            // Simulate closing socket
            conn.socket_fd = -1;
            conn.is_connected = false;
        }
        if (conn.buffer) {
            std::memset(conn.buffer, 0, conn.buffer_size);
        }
    }

    void cleanup_all() {
        for (auto& conn : connections_) {
            if (conn) {
                cleanup_connection(*conn);
            }
        }
        connections_.clear();
    }

    int simulate_connect(const std::string& address, int port) {
        // Simulate a socket connection; returns a fake fd
        static int next_fd = 100;
        if (port <= 0 || port > 65535) {
            throw std::runtime_error("Invalid port number: " + std::to_string(port));
        }
        if (address.empty()) {
            throw std::runtime_error("Empty address provided");
        }
        return next_fd++;
    }

    void establish_connection(ConnectionResource& conn) {
        try {
            conn.socket_fd = simulate_connect(conn.address, conn.port);
            conn.is_connected = true;
            std::cout << "[INFO] Connected to " << conn.address << ":" << conn.port
                      << " (fd=" << conn.socket_fd << ")" << std::endl;
        } catch (const std::exception& e) {
            conn.socket_fd = -1;
            conn.is_connected = false;
            throw; // Re-throw after cleanup
        }
    }

public:
    NetworkConnectionManager(const std::string& default_addr, int default_port,
                             size_t max_connections = 10, size_t initial_connections = 0)
        : max_connections_(max_connections), initialized_(false),
          default_address_(default_addr), default_port_(default_port) {
        
        if (max_connections == 0) {
            throw std::invalid_argument("max_connections must be greater than 0");
        }

        try {
            connections_.reserve(max_connections);

            for (size_t i = 0; i < initial_connections; ++i) {
                auto conn = std::make_unique<ConnectionResource>(default_addr, default_port);
                try {
                    establish_connection(*conn);
                } catch (const std::exception& e) {
                    std::cerr << "[ERROR] Failed to establish initial connection " << i
                              << ": " << e.what() << std::endl;
                    // Clean up already established connections
                    cleanup_all();
                    throw std::runtime_error(
                        "Failed to initialize connections: " + std::string(e.what()));
                }
                connections_.push_back(std::move(conn));
            }

            initialized_ = true;
            std::cout << "[INFO] NetworkConnectionManager initialized with "
                      << connections_.size() << " connections" << std::endl;
        } catch (const std::runtime_error&) {
            // Already cleaned up, just re-throw
            throw;
        } catch (const std::exception& e) {
            cleanup_all();
            throw std::runtime_error(
                "NetworkConnectionManager construction failed: " + std::string(e.what()));
        }
    }

    ~NetworkConnectionManager() {
        std::cout << "[INFO] Destroying NetworkConnectionManager" << std::endl;
        cleanup_all();
        initialized_ = false;
    }

    // Delete copy operations
    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    // Move operations
    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept
        : connections_(std::move(other.connections_)),
          max_connections_(other.max_connections_),
          initialized_(other.initialized_),
          default_address_(std::move(other.default_address_)),
          default_port_(other.default_port_) {
        other.initialized_ = false;
        other.max_connections_ = 0;
    }

    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanup_all();
            connections_ = std::move(other.connections_);
            max_connections_ = other.max_connections_;
            initialized_ = other.initialized_;
            default_address_ = std::move(other.default_address_);
            default_port_ = other.default_port_;
            other.initialized_ = false;
            other.max_connections_ = 0;
        }
        return *this;
    }

    // Add a new connection
    size_t add_connection(const std::string& address, int port) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (!initialized_) {
            throw std::runtime_error("Manager not initialized");
        }
        if (connections_.size() >= max_connections_) {
            throw std::runtime_error("Maximum connections reached (" +
                                     std::to_string(max_connections_) + ")");
        }

        auto conn = std::make_unique<ConnectionResource>(address, port);
        try {
            establish_connection(*conn);
        } catch (const std::exception& e) {
            std::cerr << "[ERROR] Failed to add connection to " << address
                      << ":" << port << ": " << e.what() << std::endl;
            throw;
        }

        size_t index = connections_.size();
        connections_.push_back(std::move(conn));
        return index;
    }

    // Add a connection using default address/port
    size_t add_connection() {
        return add_connection(default_address_, default_port_);
    }

    // Remove a specific connection
    void remove_connection(size_t index) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index >= connections_.size()) {
            throw std::out_of_range("Connection index out of range: " +
                                    std::to_string(index));
        }

        if (connections_[index]) {
            cleanup_connection(*connections_[index]);
        }
        connections_.erase(connections_.begin() + static_cast<ptrdiff_t>(index));
        std::cout << "[INFO] Removed connection at index " << index << std::endl;
    }

    // Reset a specific connection (disconnect and reconnect)
    void reset_connection(size_t index) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index >= connections_.size()) {
            throw std::out_of_range("Connection index out of range: " +
                                    std::to_string(index));
        }

        auto& conn = connections_[index];
        if (!conn) {
            throw std::runtime_error("Null connection at index " + std::to_string(index));
        }

        std::string addr = conn->address;
        int port = conn->port;
        size_t buf_size = conn->buffer_size;

        // Clean up existing connection
        cleanup_connection(*conn);

        // Reinitialize
        try {
            conn = std::make_unique<ConnectionResource>(addr, port, buf_size);
            establish_connection(*conn);
            std::cout << "[INFO] Reset connection at index " << index << std::endl;
        } catch (const std::exception& e) {
            std::cerr << "[ERROR] Failed to reset connection at index " << index
                      << ": " << e.what() << std::endl;
            // Ensure we have a valid but disconnected resource
            conn = std::make_unique<ConnectionResource>(addr, port, buf_size);
            throw;
        }
    }

    // Reset all connections
    void reset_all() {
        std::lock_guard<std::mutex> lock(mutex_);

        std::cout << "[INFO] Resetting all connections..." << std::endl;

        std::vector<std::tuple<std::string, int, size_t>> connection_info;
        for (auto& conn : connections_) {
            if (conn) {
                connection_info.emplace_back(conn->address, conn->port, conn->buffer_size);
                cleanup_connection(*conn);
            }
        }
        connections_.clear();

        size_t failures = 0;
        for (auto& [addr, port, buf_size] : connection_info) {
            auto conn = std::make_unique<ConnectionResource>(addr, port, buf_size);
            try {
                establish_connection(*conn);
                connections_.push_back(std::move(conn));
            } catch (const std::exception& e) {
                std::cerr << "[WARNING] Failed to re-establish connection to "
                          << addr << ":" << port << ": " << e.what() << std::endl;
                // Keep disconnected resource
                connections_.push_back(std::move(conn));
                ++failures;
            }
        }

        if (failures > 0) {
            std::cerr << "[WARNING] " << failures << " connection(s) failed to re-establish"
                      << std::endl;
        }

        std::cout << "[INFO] Reset complete. " << (connections_.size() - failures)
                  << "/" << connections_.size() << " connections active" << std::endl;
    }

    // Reinitialize the entire manager with new settings
    void reinitialize(const std::string& new_address, int new_port,
                      size_t new_max_connections, size_t initial_connections = 0) {
        std::lock_guard<std::mutex> lock(mutex_);

        std::cout << "[INFO] Reinitializing NetworkConnectionManager..." << std::endl;

        // Save old state in case we need to report
        size_t old_count = connections_.size();

        // Clean up everything
        for (auto& conn : connections_) {
            if (conn) {
                cleanup_connection(*conn);
            }
        }
        connections_.clear();

        // Update settings
        default_address_ = new_address;
        default_port_ = new_port;
        max_connections_ = new_max_connections;

        // Create new initial connections
        try {
            connections_.reserve(new_max_connections);
            for (size_t i = 0; i < initial_connections; ++i) {
                auto conn = std::make_unique<ConnectionResource>(new_address, new_port);
                try {
                    establish_connection(*conn);
                } catch (const std::exception& e) {
                    // Clean up partially created connections
                    for (auto& existing : connections_) {
                        if (existing) {
                            cleanup_connection(*existing);
                        }
                    }
                    connections_.clear();
                    initialized_ = false;
                    throw std::runtime_error(
                        "Reinitialize failed at connection " + std::to_string(i) +
                        ": " + e.what());
                }
                connections_.push_back(std::move(conn));
            }
        } catch (const std::runtime_error&) {
            throw;
        } catch (const std::exception& e) {
            connections_.clear();
            initialized_ = false;
            throw std::runtime_error("Reinitialize failed: " + std::string(e.what()));
        }

        initialized_ = true;
        std::cout << "[INFO] Reinitialized: " << old_count << " old connections removed, "
                  << connections_.size() << " new connections created" << std::endl;
    }

    // Send data on a connection
    bool send_data(size_t index, const std::string& data) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index >= connections_.size()) {
            throw std::out_of_range("Connection index out of range");
        }

        auto& conn = connections_[index];
        if (!conn || !conn->is_connected) {
            std::cerr << "[ERROR] Connection at index " << index
                      << " is not active" << std::endl;
            return false;
        }

        // Simulate sending data
        size_t copy_len = std::min(data.size(), conn->buffer_size - 1);
        std::memcpy(conn->buffer, data.c_str(), copy_len);
        conn->buffer[copy_len] = '\0';

        std::cout << "[INFO] Sent " << copy_len << " bytes on connection "
                  << index << " (fd=" << conn->socket_fd << ")" << std::endl;
        return true;
    }

    // Get connection status
    bool is_connected(size_t index) const {
        if (index >= connections_.size()) {
            return false;
        }
        return connections_[index] && connections_[index]->is_connected;
    }

    size_t connection_count() const {
        return connections_.size();
    }

    size_t active_connection_count() const {
        size_t count = 0;
        for (const auto& conn : connections_) {
            if (conn && conn->is_connected) {
                ++count;
            }
        }
        return count;
    }

    size_t max_connections() const {
        return max_connections_;
    }

    bool is_initialized() const {
        return initialized_;
    }

    // Print status of all connections
    void print_status() const {
        std::cout << "=== NetworkConnectionManager Status ===" << std::endl;
        std::cout << "Initialized: " << (initialized_ ? "yes" : "no") << std::endl;
        std::cout << "Connections: " << connections_.size() << "/" << max_connections_ << std::endl;
        std::cout << "Active: " << active_connection_count() << std::endl;

        for (size_t i = 0; i < connections_.size(); ++i) {
            const auto& conn = connections_[i];
            if (conn) {
                std::cout << "  [" << i << "] " << conn->address << ":" << conn->port
                          << " fd=" << conn->socket_fd
                          << " connected=" << (conn->is_connected ? "yes" : "no")
                          << " buf_size=" << conn->buffer_size << std::endl;
            } else {
                std::cout << "  [" << i << "] <null>" << std::endl;
            }
        }
        std::cout << "=======================================" << std::endl;
    }
};

// Demo / test
int main() {
    try {
        std::cout << "--- Creating manager with 2 initial connections ---" << std::endl;
        NetworkConnectionManager manager("192.168.1.100", 8080, 5, 2);
        manager.print_status();

        std::cout << "\n--- Adding a new connection ---" << std::endl;
        size_t idx = manager.add_connection("10.0.0.1", 9090);
        std::cout << "Added connection at index: " << idx << std::endl;
        manager.print_status();

        std::cout << "\n--- Sending data ---" << std::endl;
        manager.send_data(0, "Hello, server!");

        std::cout << "\n--- Resetting connection 1 ---" << std::endl;
        manager.reset_connection(1);
        manager.print_status();

        std::cout << "\n--- Removing connection 0 ---" << std::endl;
        manager.remove_connection(0);
        manager.print_status();

        std::cout << "\n--- Resetting all connections ---" << std::endl;
        manager.reset_all();
        manager.print_status();

        std::cout << "\n--- Reinitializing with new settings ---" << std::endl;
        manager.reinitialize("172.16.0.1", 3000, 8, 3);
        manager.print_status();

        std::cout << "\n--- Testing error handling with invalid port ---" << std::endl;
        try {
            manager.add_connection("bad_host", -1);
        } catch (const std::exception& e) {
            std::cerr << "Caught expected error: " << e.what() << std::endl;
        }
        manager.print_status();

        std::cout << "\n--- Testing out-of-range access ---" << std::endl;
        try {
            manager.reset_connection(999);
        } catch (const std::out_of_range& e) {
            std::cerr << "Caught expected error: " << e.what() << std::endl;
        }

    } catch (const std::exception& e) {
        std::cerr << "Fatal error: " << e.what() << std::endl;
        return 1;
    }

    std::cout << "\n--- Manager going out of scope, destructor called ---" << std::endl;
    return 0;
}