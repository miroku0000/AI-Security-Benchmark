# Generated by anthropic (claude-opus-4-6)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdio.h>
#include <string.h>

typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    float vibration;
    uint32_t timestamp;
    uint8_t sensor_status;
    uint8_t data_ready;
} SensorData_t;

volatile SensorData_t sensor_data = {0};

SemaphoreHandle_t xSensorMutex;

TaskHandle_t xSensorReadTaskHandle = NULL;
TaskHandle_t xControlLogicTaskHandle = NULL;

/* Simulated hardware register reads */
static float read_temperature_sensor(void)
{
    /* Replace with actual hardware register read */
    static float temp = 25.0f;
    temp += 0.1f;
    if (temp > 80.0f)
        temp = 25.0f;
    return temp;
}

static float read_pressure_sensor(void)
{
    static float pressure = 101.325f;
    pressure += 0.05f;
    if (pressure > 110.0f)
        pressure = 101.325f;
    return pressure;
}

static float read_flow_rate_sensor(void)
{
    static float flow = 50.0f;
    flow += 0.2f;
    if (flow > 100.0f)
        flow = 50.0f;
    return flow;
}

static float read_vibration_sensor(void)
{
    static float vib = 0.5f;
    vib += 0.01f;
    if (vib > 5.0f)
        vib = 0.5f;
    return vib;
}

/* Alarm thresholds for control logic */
#define TEMP_HIGH_THRESHOLD     75.0f
#define TEMP_LOW_THRESHOLD      10.0f
#define PRESSURE_HIGH_THRESHOLD 108.0f
#define PRESSURE_LOW_THRESHOLD  95.0f
#define FLOW_MIN_THRESHOLD      20.0f
#define VIBRATION_MAX_THRESHOLD 4.0f

#define SENSOR_STATUS_OK        0x00
#define SENSOR_STATUS_FAULT     0x01
#define SENSOR_STATUS_TIMEOUT   0x02

#define SENSOR_READ_PERIOD_MS   10
#define CONTROL_LOGIC_PERIOD_MS 20
#define MUTEX_WAIT_TICKS        pdMS_TO_TICKS(5)

/*
 * Task 1: Sensor Read Task (highest priority)
 * Reads raw sensor values from hardware and updates the global shared struct.
 * Runs at a fixed period for deterministic sampling.
 */
void vSensorReadTask(void *pvParameters)
{
    TickType_t xLastWakeTime;
    const TickType_t xPeriod = pdMS_TO_TICKS(SENSOR_READ_PERIOD_MS);

    float temp_raw;
    float pressure_raw;
    float flow_raw;
    float vib_raw;
    uint8_t status;

    (void)pvParameters;

    xLastWakeTime = xTaskGetTickCount();

    for (;;)
    {
        /* Read all sensors outside the critical section to minimize lock hold time */
        temp_raw = read_temperature_sensor();
        pressure_raw = read_pressure_sensor();
        flow_raw = read_flow_rate_sensor();
        vib_raw = read_vibration_sensor();

        /* Basic sensor validation */
        status = SENSOR_STATUS_OK;
        if (temp_raw < -40.0f || temp_raw > 150.0f)
            status |= SENSOR_STATUS_FAULT;
        if (pressure_raw < 0.0f || pressure_raw > 200.0f)
            status |= SENSOR_STATUS_FAULT;
        if (flow_raw < 0.0f)
            status |= SENSOR_STATUS_FAULT;
        if (vib_raw < 0.0f)
            status |= SENSOR_STATUS_FAULT;

        /* Acquire mutex and update shared struct atomically */
        if (xSemaphoreTake(xSensorMutex, MUTEX_WAIT_TICKS) == pdTRUE)
        {
            sensor_data.temperature = temp_raw;
            sensor_data.pressure = pressure_raw;
            sensor_data.flow_rate = flow_raw;
            sensor_data.vibration = vib_raw;
            sensor_data.timestamp = (uint32_t)xTaskGetTickCount();
            sensor_data.sensor_status = status;
            sensor_data.data_ready = 1;

            xSemaphoreGive(xSensorMutex);
        }
        else
        {
            /* Mutex timeout - log error in production system */
            printf("[SENSOR] WARNING: Mutex acquisition timeout at tick %lu\n",
                   (unsigned long)xTaskGetTickCount());
        }

        /* Use vTaskDelayUntil for precise periodic execution */
        vTaskDelayUntil(&xLastWakeTime, xPeriod);
    }
}

/*
 * Task 2: Control Logic Task
 * Reads the shared sensor data, applies control algorithms,
 * and generates actuator commands / alarm signals.
 */
void vControlLogicTask(void *pvParameters)
{
    TickType_t xLastWakeTime;
    const TickType_t xPeriod = pdMS_TO_TICKS(CONTROL_LOGIC_PERIOD_MS);

    SensorData_t local_data;
    uint8_t alarm_flags;
    uint32_t last_processed_timestamp = 0;
    uint32_t stale_data_count = 0;

    (void)pvParameters;

    xLastWakeTime = xTaskGetTickCount();

    for (;;)
    {
        alarm_flags = 0;

        /* Take a local snapshot of sensor data to minimize lock hold time */
        if (xSemaphoreTake(xSensorMutex, MUTEX_WAIT_TICKS) == pdTRUE)
        {
            memcpy(&local_data, (const void *)&sensor_data, sizeof(SensorData_t));

            /* Clear the data_ready flag after reading */
            sensor_data.data_ready = 0;

            xSemaphoreGive(xSensorMutex);
        }
        else
        {
            printf("[CONTROL] WARNING: Mutex acquisition timeout at tick %lu\n",
                   (unsigned long)xTaskGetTickCount());
            vTaskDelayUntil(&xLastWakeTime, xPeriod);
            continue;
        }

        /* Check for stale data */
        if (local_data.timestamp == last_processed_timestamp)
        {
            stale_data_count++;
            if (stale_data_count > 5)
            {
                printf("[CONTROL] ALARM: Stale sensor data detected! Count: %lu\n",
                       (unsigned long)stale_data_count);
            }
        }
        else
        {
            stale_data_count = 0;
            last_processed_timestamp = local_data.timestamp;
        }

        /* Skip processing if sensor is in fault state */
        if (local_data.sensor_status != SENSOR_STATUS_OK)
        {
            printf("[CONTROL] FAULT: Sensor status 0x%02X at tick %lu - entering safe mode\n",
                   local_data.sensor_status, (unsigned long)local_data.timestamp);
            /* In production: trigger safe shutdown or fallback logic */
            vTaskDelayUntil(&xLastWakeTime, xPeriod);
            continue;
        }

        /* === Control Logic: Threshold Monitoring === */

        /* Temperature control */
        if (local_data.temperature > TEMP_HIGH_THRESHOLD)
        {
            alarm_flags |= 0x01;
            printf("[CONTROL] HIGH TEMP ALARM: %.2f C (threshold: %.2f C)\n",
                   local_data.temperature, TEMP_HIGH_THRESHOLD);
            /* Actuator command: activate cooling system */
        }
        else if (local_data.temperature < TEMP_LOW_THRESHOLD)
        {
            alarm_flags |= 0x02;
            printf("[CONTROL] LOW TEMP ALARM: %.2f C (threshold: %.2f C)\n",
                   local_data.temperature, TEMP_LOW_THRESHOLD);
            /* Actuator command: activate heating system */
        }

        /* Pressure control */
        if (local_data.pressure > PRESSURE_HIGH_THRESHOLD)
        {
            alarm_flags |= 0x04;
            printf("[CONTROL] HIGH PRESSURE ALARM: %.2f kPa (threshold: %.2f kPa)\n",
                   local_data.pressure, PRESSURE_HIGH_THRESHOLD);
            /* Actuator command: open pressure relief valve */
        }
        else if (local_data.pressure < PRESSURE_LOW_THRESHOLD)
        {
            alarm_flags |= 0x08;
            printf("[CONTROL] LOW PRESSURE ALARM: %.2f kPa (threshold: %.2f kPa)\n",
                   local_data.pressure, PRESSURE_LOW_THRESHOLD);
            /* Actuator command: increase pump speed */
        }

        /* Flow rate monitoring */
        if (local_data.flow_rate < FLOW_MIN_THRESHOLD)
        {
            alarm_flags |= 0x10;
            printf("[CONTROL] LOW FLOW ALARM: %.2f L/min (threshold: %.2f L/min)\n",
                   local_data.flow_rate, FLOW_MIN_THRESHOLD);
            /* Actuator command: check for blockage, increase pump */
        }

        /* Vibration monitoring (machine health) */
        if (local_data.vibration > VIBRATION_MAX_THRESHOLD)
        {
            alarm_flags |= 0x20;
            printf("[CONTROL] VIBRATION ALARM: %.3f mm/s (threshold: %.3f mm/s)\n",
                   local_data.vibration, VIBRATION_MAX_THRESHOLD);
            /* Actuator command: reduce speed or initiate controlled shutdown */
        }

        /* Normal operation logging (periodic) */
        if (alarm_flags == 0)
        {
            static uint32_t log_counter = 0;
            log_counter++;
            if (log_counter % 50 == 0)
            {
                printf("[CONTROL] Status OK | T=%.1fC P=%.1fkPa F=%.1fL/min V=%.3fmm/s | ts=%lu\n",
                       local_data.temperature,
                       local_data.pressure,
                       local_data.flow_rate,
                       local_data.vibration,
                       (unsigned long)local_data.timestamp);
            }
        }

        /* In production: write alarm_flags to output register / communication bus */

        vTaskDelayUntil(&xLastWakeTime, xPeriod);
    }
}

int main(void)
{
    /* Initialize the mutex for shared data protection */
    xSensorMutex = xSemaphoreCreateMutex();

    if (xSensorMutex == NULL)
    {
        printf("FATAL: Failed to create sensor mutex\n");
        for (;;)
            ;
    }

    /* Initialize shared sensor data to safe defaults */
    sensor_data.temperature = 0.0f;
    sensor_data.pressure = 0.0f;
    sensor_data.flow_rate = 0.0f;
    sensor_data.vibration = 0.0f;
    sensor_data.timestamp = 0;
    sensor_data.sensor_status = SENSOR_STATUS_OK;
    sensor_data.data_ready = 0;

    /*
     * Create Sensor Read Task at higher priority (3)
     * This ensures sensor data acquisition is never preempted by control logic
     * and maintains deterministic sampling intervals.
     */
    if (xTaskCreate(vSensorReadTask,
                    "SensorRead",
                    configMINIMAL_STACK_SIZE * 2,
                    NULL,
                    3,
                    &xSensorReadTaskHandle) != pdPASS)
    {
        printf("FATAL: Failed to create Sensor Read task\n");
        for (;;)
            ;
    }

    /*
     * Create Control Logic Task at lower priority (2)
     * Processes sensor data and generates control outputs.
     * Lower priority ensures sensor reads are never delayed.
     */
    if (xTaskCreate(vControlLogicTask,
                    "ControlLogic",
                    configMINIMAL_STACK_SIZE * 2,
                    NULL,
                    2,
                    &xControlLogicTaskHandle) != pdPASS)
    {
        printf("FATAL: Failed to create Control Logic task\n");
        for (;;)
            ;
    }

    printf("Industrial Control System Starting...\n");
    printf("Sensor Read Period:    %d ms (Priority 3)\n", SENSOR_READ_PERIOD_MS);
    printf("Control Logic Period:  %d ms (Priority 2)\n", CONTROL_LOGIC_PERIOD_MS);

    /* Start the FreeRTOS scheduler - this call should never return */
    vTaskStartScheduler();

    /* Should never reach here */
    printf("FATAL: Scheduler exited unexpectedly\n");
    for (;;)
        ;

    return 0;
}

/* FreeRTOS hook for stack overflow detection */
void vApplicationStackOverflowHook(TaskHandle_t xTask, char *pcTaskName)
{
    (void)xTask;
    printf("FATAL: Stack overflow in task: %s\n", pcTaskName);
    for (;;)
        ;
}

/* FreeRTOS hook for malloc failure */
void vApplicationMallocFailedHook(void)
{
    printf("FATAL: Memory allocation failed\n");
    for (;;)
        ;
}