# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <memory>
#include <sstream>
#include <algorithm>
#include <cmath>
#include <iostream>
#include <chrono>

// Represents raw input data
struct RawRecord {
    int id;
    double values[4];
    std::string label;
};

// Intermediate transformation objects
struct NormalizedRecord {
    int id;
    double normalized_values[4];
    std::string label;
    double magnitude;
};

struct EnrichedRecord {
    int id;
    double normalized_values[4];
    std::string label;
    double magnitude;
    double score;
    std::string category;
};

// Final output
struct OutputRecord {
    int id;
    double score;
    std::string category;
    std::string summary;
};

// BAD VERSION: Creates temporary objects on every call - wasteful in a hot path
OutputRecord transform_record_bad(const RawRecord& input) {
    // Step 1: Normalize - allocates a temporary NormalizedRecord each time
    auto* normalized = new NormalizedRecord();
    normalized->id = input.id;
    normalized->magnitude = 0.0;
    for (int i = 0; i < 4; ++i) {
        normalized->magnitude += input.values[i] * input.values[i];
    }
    normalized->magnitude = std::sqrt(normalized->magnitude);
    for (int i = 0; i < 4; ++i) {
        normalized->normalized_values[i] = (normalized->magnitude > 0.0)
            ? input.values[i] / normalized->magnitude
            : 0.0;
    }
    normalized->label = input.label; // string copy

    // Step 2: Enrich - allocates another temporary
    auto* enriched = new EnrichedRecord();
    enriched->id = normalized->id;
    for (int i = 0; i < 4; ++i) {
        enriched->normalized_values[i] = normalized->normalized_values[i];
    }
    enriched->label = std::move(normalized->label);
    enriched->magnitude = normalized->magnitude;
    enriched->score = enriched->normalized_values[0] * 0.4
                    + enriched->normalized_values[1] * 0.3
                    + enriched->normalized_values[2] * 0.2
                    + enriched->normalized_values[3] * 0.1;
    enriched->score *= enriched->magnitude;

    // Temporary string allocation for categorization
    std::string* temp_category = new std::string();
    if (enriched->score > 75.0) {
        *temp_category = "high";
    } else if (enriched->score > 25.0) {
        *temp_category = "medium";
    } else {
        *temp_category = "low";
    }
    enriched->category = *temp_category;
    delete temp_category;

    // Step 3: Build output - yet another temporary + string stream allocation
    std::stringstream* ss = new std::stringstream();
    *ss << "Record " << enriched->id << ": " << enriched->category
        << " (score=" << enriched->score << ")";

    OutputRecord output;
    output.id = enriched->id;
    output.score = enriched->score;
    output.category = std::move(enriched->category);
    output.summary = ss->str();

    delete ss;
    delete enriched;
    delete normalized;

    return output;
}

// GOOD VERSION: Reuses pre-allocated workspace, avoids heap allocations in hot path
struct TransformWorkspace {
    NormalizedRecord normalized;
    EnrichedRecord enriched;
    std::string temp_category;
    std::string summary_buffer;

    TransformWorkspace() {
        // Pre-reserve string buffers
        temp_category.reserve(16);
        summary_buffer.reserve(128);
    }

    void reset() {
        temp_category.clear();
        summary_buffer.clear();
    }
};

OutputRecord transform_record_good(const RawRecord& input, TransformWorkspace& workspace) {
    workspace.reset();

    // Step 1: Normalize - reuse workspace.normalized (no allocation)
    NormalizedRecord& norm = workspace.normalized;
    norm.id = input.id;
    norm.magnitude = 0.0;
    for (int i = 0; i < 4; ++i) {
        norm.magnitude += input.values[i] * input.values[i];
    }
    norm.magnitude = std::sqrt(norm.magnitude);
    double inv_mag = (norm.magnitude > 0.0) ? 1.0 / norm.magnitude : 0.0;
    for (int i = 0; i < 4; ++i) {
        norm.normalized_values[i] = input.values[i] * inv_mag;
    }
    // Avoid copying label string if we only need to read it
    // norm.label reference not needed, read directly from input

    // Step 2: Enrich - reuse workspace.enriched (no allocation)
    EnrichedRecord& enr = workspace.enriched;
    enr.id = norm.id;
    for (int i = 0; i < 4; ++i) {
        enr.normalized_values[i] = norm.normalized_values[i];
    }
    enr.magnitude = norm.magnitude;
    enr.score = enr.normalized_values[0] * 0.4
              + enr.normalized_values[1] * 0.3
              + enr.normalized_values[2] * 0.2
              + enr.normalized_values[3] * 0.1;
    enr.score *= enr.magnitude;

    // Categorize using pre-allocated string buffer
    const char* cat;
    if (enr.score > 75.0) {
        cat = "high";
    } else if (enr.score > 25.0) {
        cat = "medium";
    } else {
        cat = "low";
    }

    // Step 3: Build output - reuse summary buffer (no stringstream allocation)
    std::string& buf = workspace.summary_buffer;
    buf.append("Record ");
    // Fast integer to string without allocating stringstream
    char num_buf[32];
    int len = std::snprintf(num_buf, sizeof(num_buf), "%d", enr.id);
    buf.append(num_buf, len);
    buf.append(": ");
    buf.append(cat);
    buf.append(" (score=");
    len = std::snprintf(num_buf, sizeof(num_buf), "%.2f", enr.score);
    buf.append(num_buf, len);
    buf.append(")");

    OutputRecord output;
    output.id = enr.id;
    output.score = enr.score;
    output.category = cat;  // short string, likely SSO
    output.summary = std::move(buf); // move instead of copy

    return output;
}

// Batch processing for even better throughput
std::vector<OutputRecord> transform_batch_good(
    const std::vector<RawRecord>& inputs,
    TransformWorkspace& workspace)
{
    std::vector<OutputRecord> outputs;
    outputs.reserve(inputs.size());

    for (const auto& input : inputs) {
        outputs.push_back(transform_record_good(input, workspace));
    }

    return outputs;
}

// Benchmark
int main() {
    // Generate test data
    const int NUM_RECORDS = 1000000;
    std::vector<RawRecord> records(NUM_RECORDS);
    for (int i = 0; i < NUM_RECORDS; ++i) {
        records[i].id = i;
        records[i].values[0] = static_cast<double>(i % 100);
        records[i].values[1] = static_cast<double>((i * 7) % 100);
        records[i].values[2] = static_cast<double>((i * 13) % 100);
        records[i].values[3] = static_cast<double>((i * 31) % 100);
        records[i].label = "item_" + std::to_string(i);
    }

    // Benchmark BAD version (temporary allocations each call)
    {
        auto start = std::chrono::high_resolution_clock::now();
        std::vector<OutputRecord> results;
        results.reserve(NUM_RECORDS);
        for (const auto& rec : records) {
            results.push_back(transform_record_bad(rec));
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "BAD  (temp allocs per call): " << ms << " ms, "
                  << results.size() << " records" << std::endl;
    }

    // Benchmark GOOD version (reused workspace)
    {
        TransformWorkspace workspace;
        auto start = std::chrono::high_resolution_clock::now();
        std::vector<OutputRecord> results;
        results.reserve(NUM_RECORDS);
        for (const auto& rec : records) {
            results.push_back(transform_record_good(rec, workspace));
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "GOOD (reused workspace):     " << ms << " ms, "
                  << results.size() << " records" << std::endl;
    }

    // Benchmark GOOD batch version
    {
        TransformWorkspace workspace;
        auto start = std::chrono::high_resolution_clock::now();
        auto results = transform_batch_good(records, workspace);
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "GOOD (batch):                " << ms << " ms, "
                  << results.size() << " records" << std::endl;
    }

    return 0;
}