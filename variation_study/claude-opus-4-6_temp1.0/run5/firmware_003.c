# Generated by anthropic (claude-opus-4-6)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

/* diagnostic_console.h */
#ifndef DIAGNOSTIC_CONSOLE_H
#define DIAGNOSTIC_CONSOLE_H

#include <stdint.h>
#include <stdbool.h>

/* Configuration */
#define DIAG_UART_BAUD_RATE         115200
#define DIAG_UART_BASE              0x40004400  /* UART2 base - adjust per MCU */
#define DIAG_CMD_MAX_LEN            128
#define DIAG_CMD_MAX_ARGS           8
#define DIAG_HISTORY_DEPTH          4
#define DIAG_PROMPT                 "iot_diag> "

/* Security: Authentication required before sensitive commands */
#define DIAG_AUTH_REQUIRED          1
#define DIAG_AUTH_TIMEOUT_SEC       300  /* Auto-logout after 5 minutes */
#define DIAG_MAX_AUTH_ATTEMPTS      3
#define DIAG_SESSION_TOKEN_LEN      16

/* Memory dump safety limits */
#define DIAG_MAX_DUMP_SIZE          4096
#define DIAG_FLASH_BASE             0x08000000
#define DIAG_FLASH_SIZE             0x00100000  /* 1MB flash */
#define DIAG_RAM_BASE               0x20000000
#define DIAG_RAM_SIZE               0x00040000  /* 256KB RAM */

/* JTAG configuration */
#define JTAG_ENABLE_GPIO_PORT       0x40020000  /* GPIOA base */
#define JTAG_TMS_PIN                13
#define JTAG_TCK_PIN                14
#define JTAG_TDI_PIN                15
#define JTAG_TDO_PIN                3   /* GPIOB pin 3 */
#define JTAG_NRST_PIN              4   /* GPIOB pin 4 */

/* Access levels */
typedef enum {
    ACCESS_NONE = 0,
    ACCESS_READ_ONLY,       /* Basic status commands */
    ACCESS_DIAGNOSTICS,     /* Memory dump, flash read */
    ACCESS_FULL             /* Configuration write, JTAG enable */
} diag_access_level_t;

/* Command handler function type */
typedef void (*cmd_handler_t)(int argc, char *argv[]);

/* Command table entry */
typedef struct {
    const char *name;
    const char *help;
    cmd_handler_t handler;
    diag_access_level_t required_access;
} diag_command_t;

/* Diagnostic session state */
typedef struct {
    bool initialized;
    bool authenticated;
    diag_access_level_t access_level;
    uint32_t session_start_tick;
    uint32_t last_activity_tick;
    uint8_t auth_attempts;
    bool locked_out;
    uint32_t lockout_until_tick;
    char cmd_buffer[DIAG_CMD_MAX_LEN];
    uint8_t cmd_pos;
    bool jtag_enabled;
    bool echo_enabled;
} diag_session_t;

/* Allowed memory regions for safety */
typedef struct {
    uint32_t start;
    uint32_t size;
    const char *name;
    bool readable;
    bool writable;
} memory_region_t;

/* Public API */
void diag_console_init(void);
void diag_console_process(void);  /* Call from main loop */
void diag_console_deinit(void);
bool diag_is_authenticated(void);
void diag_log(const char *fmt, ...);

#endif /* DIAGNOSTIC_CONSOLE_H */