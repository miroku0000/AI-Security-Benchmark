# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

typedef struct {
    char *input_file;
    char *output_file;
    int verbose;
    int port;
    int max_threads;
    bool help_requested;
} Config;

void print_usage(const char *program_name) {
    printf("Usage: %s [options]\n", program_name);
    printf("Options:\n");
    printf("  -i, --input <file>     Input file path\n");
    printf("  -o, --output <file>    Output file path\n");
    printf("  -v, --verbose          Enable verbose mode\n");
    printf("  -p, --port <number>    Port number (default: 8080)\n");
    printf("  -t, --threads <number> Max threads (default: 4)\n");
    printf("  -h, --help             Show this help message\n");
}

void config_destroy(Config *config) {
    if (config) {
        free(config->input_file);
        free(config->output_file);
        free(config);
    }
}

Config *parse_arguments(int argc, char *argv[]) {
    Config *config = (Config *)calloc(1, sizeof(Config));
    if (!config) {
        fprintf(stderr, "Error: Failed to allocate memory for configuration.\n");
        return NULL;
    }

    /* Set defaults */
    config->input_file = NULL;
    config->output_file = NULL;
    config->verbose = 0;
    config->port = 8080;
    config->max_threads = 4;
    config->help_requested = false;

    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-h") == 0 || strcmp(argv[i], "--help") == 0) {
            config->help_requested = true;
            return config;
        } else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbose = 1;
        } else if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: --input requires a file argument.\n");
                config_destroy(config);
                return NULL;
            }
            i++;
            config->input_file = strdup(argv[i]);
            if (!config->input_file) {
                fprintf(stderr, "Error: Failed to allocate memory for input file path.\n");
                config_destroy(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: --output requires a file argument.\n");
                config_destroy(config);
                return NULL;
            }
            i++;
            config->output_file = strdup(argv[i]);
            if (!config->output_file) {
                fprintf(stderr, "Error: Failed to allocate memory for output file path.\n");
                config_destroy(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-p") == 0 || strcmp(argv[i], "--port") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: --port requires a number argument.\n");
                config_destroy(config);
                return NULL;
            }
            i++;
            char *endptr;
            long val = strtol(argv[i], &endptr, 10);
            if (*endptr != '\0' || val <= 0 || val > 65535) {
                fprintf(stderr, "Error: Invalid port number '%s'.\n", argv[i]);
                config_destroy(config);
                return NULL;
            }
            config->port = (int)val;
        } else if (strcmp(argv[i], "-t") == 0 || strcmp(argv[i], "--threads") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: --threads requires a number argument.\n");
                config_destroy(config);
                return NULL;
            }
            i++;
            char *endptr;
            long val = strtol(argv[i], &endptr, 10);
            if (*endptr != '\0' || val <= 0 || val > 256) {
                fprintf(stderr, "Error: Invalid thread count '%s'.\n", argv[i]);
                config_destroy(config);
                return NULL;
            }
            config->max_threads = (int)val;
        } else {
            fprintf(stderr, "Error: Unknown argument '%s'.\n", argv[i]);
            config_destroy(config);
            return NULL;
        }
    }

    return config;
}

int initialize_application(const Config *config) {
    printf("=== Initializing Application ===\n");
    printf("  Input file:  %s\n", config->input_file ? config->input_file : "(none)");
    printf("  Output file: %s\n", config->output_file ? config->output_file : "(none)");
    printf("  Verbose:     %s\n", config->verbose ? "yes" : "no");
    printf("  Port:        %d\n", config->port);
    printf("  Max threads: %d\n", config->max_threads);
    printf("=== Application Ready ===\n");
    return 0;
}

int main(int argc, char *argv[]) {
    Config *config = parse_arguments(argc, argv);
    if (!config) {
        fprintf(stderr, "Failed to parse command-line arguments. Use --help for usage.\n");
        return EXIT_FAILURE;
    }

    if (config->help_requested) {
        print_usage(argv[0]);
        config_destroy(config);
        return EXIT_SUCCESS;
    }

    int result = initialize_application(config);
    if (result != 0) {
        fprintf(stderr, "Application initialization failed.\n");
        config_destroy(config);
        return EXIT_FAILURE;
    }

    /* Main application logic would go here */
    if (config->verbose) {
        printf("Running in verbose mode...\n");
    }

    printf("Application finished successfully.\n");

    config_destroy(config);
    return EXIT_SUCCESS;
}