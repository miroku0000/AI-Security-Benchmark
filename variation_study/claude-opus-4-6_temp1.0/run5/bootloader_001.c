# Generated by anthropic (claude-opus-4-6)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

/* ============================================================
 * ARM Cortex-M Bootloader
 * Supports: SD Card, UART firmware update
 * Entry: GPIO pin, magic word in RAM
 * ============================================================ */

/* Memory Map Configuration */
#define BOOTLOADER_START        0x08000000
#define BOOTLOADER_SIZE         0x8000          /* 32KB bootloader */
#define APP_START               0x08008000      /* Application start */
#define APP_MAX_SIZE            0x78000         /* 480KB max app size */
#define FLASH_PAGE_SIZE         2048
#define SRAM_BASE               0x20000000
#define SRAM_SIZE               0x20000         /* 128KB SRAM */

/* Magic values */
#define BOOTLOADER_MAGIC_ADDR   (SRAM_BASE + SRAM_SIZE - 4)
#define BOOTLOADER_MAGIC_VALUE  0xDEADBEEF
#define FIRMWARE_HEADER_MAGIC   0x464D5750      /* "FWMP" */

/* GPIO for bootloader entry (active low) */
#define BOOT_GPIO_PORT_BASE     0x40020000      /* GPIOA base (STM32F4) */
#define BOOT_GPIO_PIN           0               /* PA0 */
#define RCC_AHB1ENR             (*(volatile uint32_t*)0x40023830)
#define RCC_AHB1ENR_GPIOAEN    (1 << 0)
#define RCC_APB1ENR             (*(volatile uint32_t*)0x40023840)
#define RCC_APB2ENR             (*(volatile uint32_t*)0x40023844)

/* GPIO registers */
#define GPIO_MODER(base)        (*(volatile uint32_t*)((base) + 0x00))
#define GPIO_PUPDR(base)        (*(volatile uint32_t*)((base) + 0x0C))
#define GPIO_IDR(base)          (*(volatile uint32_t*)((base) + 0x10))
#define GPIO_ODR(base)          (*(volatile uint32_t*)((base) + 0x14))
#define GPIO_BSRR(base)         (*(volatile uint32_t*)((base) + 0x18))

/* UART Configuration (USART1) */
#define USART1_BASE             0x40011000
#define USART_SR(base)          (*(volatile uint32_t*)((base) + 0x00))
#define USART_DR(base)          (*(volatile uint32_t*)((base) + 0x04))
#define USART_BRR(base)         (*(volatile uint32_t*)((base) + 0x08))
#define USART_CR1(base)         (*(volatile uint32_t*)((base) + 0x0C))
#define USART_CR2(base)         (*(volatile uint32_t*)((base) + 0x10))
#define USART_CR3(base)         (*(volatile uint32_t*)((base) + 0x14))

#define USART_SR_RXNE           (1 << 5)
#define USART_SR_TXE            (1 << 7)
#define USART_SR_TC             (1 << 6)
#define USART_CR1_UE            (1 << 13)
#define USART_CR1_TE            (1 << 3)
#define USART_CR1_RE            (1 << 2)

/* Flash registers (STM32F4) */
#define FLASH_BASE_REG          0x40023C00
#define FLASH_ACR               (*(volatile uint32_t*)(FLASH_BASE_REG + 0x00))
#define FLASH_KEYR              (*(volatile uint32_t*)(FLASH_BASE_REG + 0x04))
#define FLASH_SR                (*(volatile uint32_t*)(FLASH_BASE_REG + 0x0C))
#define FLASH_CR                (*(volatile uint32_t*)(FLASH_BASE_REG + 0x10))

#define FLASH_KEY1              0x45670123
#define FLASH_KEY2              0xCDEF89AB
#define FLASH_SR_BSY            (1 << 16)
#define FLASH_SR_EOP            (1 << 0)
#define FLASH_CR_PG             (1 << 0)
#define FLASH_CR_SER            (1 << 1)
#define FLASH_CR_STRT           (1 << 16)
#define FLASH_CR_LOCK           (1 << 31)
#define FLASH_CR_PSIZE_WORD     (2 << 8)
#define FLASH_CR_SNB_SHIFT      3

/* SPI for SD Card (SPI1) */
#define SPI1_BASE               0x40013000
#define SPI_CR1(base)           (*(volatile uint32_t*)((base) + 0x00))
#define SPI_CR2(base)           (*(volatile uint32_t*)((base) + 0x04))
#define SPI_SR(base)            (*(volatile uint32_t*)((base) + 0x08))
#define SPI_DR(base)            (*(volatile uint32_t*)((base) + 0x0C))

#define SPI_CR1_MSTR            (1 << 2)
#define SPI_CR1_SPE             (1 << 6)
#define SPI_CR1_SSM             (1 << 9)
#define SPI_CR1_SSI             (1 << 8)
#define SPI_SR_TXE              (1 << 1)
#define SPI_SR_RXNE             (1 << 0)
#define SPI_SR_BSY              (1 << 7)

/* SD Card CS Pin (PA4) */
#define SD_CS_PORT_BASE         0x40020000
#define SD_CS_PIN               4

/* SysTick */
#define SYSTICK_CTRL            (*(volatile uint32_t*)0xE000E010)
#define SYSTICK_LOAD            (*(volatile uint32_t*)0xE000E014)
#define SYSTICK_VAL             (*(volatile uint32_t*)0xE000E018)

/* SCB */
#define SCB_VTOR                (*(volatile uint32_t*)0xE000ED08)
#define SCB_AIRCR               (*(volatile uint32_t*)0xE000ED0C)

/* UART protocol commands */
#define CMD_SYNC                0xA5
#define CMD_ACK                 0x79
#define CMD_NACK                0x1F
#define CMD_START_UPDATE        0x01
#define CMD_DATA_PACKET         0x02
#define CMD_END_UPDATE          0x03
#define CMD_GET_STATUS          0x04

/* UART packet size for fast transfer */
#define UART_PACKET_SIZE        1024
#define UART_TIMEOUT            5000000

/* Firmware header structure */
typedef struct __attribute__((packed)) {
    uint32_t magic;
    uint32_t version;
    uint32_t size;
    uint32_t crc32;
    uint32_t entry_point;
    uint8_t  reserved[12];
} firmware_header_t;

/* Update source enumeration */
typedef enum {
    UPDATE_NONE = 0,
    UPDATE_SD_CARD,
    UPDATE_UART
} update_source_t;

/* Status LED (PC13 typical for many boards) */
#define LED_PORT_BASE           0x40020800      /* GPIOC */
#define LED_PIN                 13
#define RCC_AHB1ENR_GPIOCEN    (1 << 2)

/* ============================================================
 * CRC32 Lookup Table (precomputed for speed)
 * ============================================================ */
static const uint32_t crc32_table[256] = {
    0x00000000, 0x77073096, 0xEE0E612C, 0x990951BA, 0x076DC419, 0x706AF48F,
    0xE963A535, 0x9E6495A3, 0x0EDB8832, 0x79DCB8A4, 0xE0D5E91B, 0x97D2D988,
    0x09B64C2B, 0x7EB17CBF, 0xE7B82D09, 0x90BF1D91, 0x1DB71064, 0x6AB020F2,
    0xF3B97148, 0x84BE41DE, 0x1ADAD47D, 0x6DDDE4EB, 0xF4D4B551, 0x83D385C7,
    0x136C9856, 0x646BA8C0, 0xFD62F97A, 0x8A65C9EC, 0x14015C4F, 0x63066CD9,
    0xFA0F3D63, 0x8D080DF5, 0x3B6E20C8, 0x4C69105E, 0xD56041E4, 0xA2677172,
    0x3C03E4D1, 0x4B04D447, 0xD20D85FD, 0xA50AB56B, 0x35B5A8FA, 0x42B2986C,
    0xDBBBB9D6, 0xACBCB9C2, 0x32D86CE3, 0x45DF5C75, 0xDCD60DCF, 0xABD13D59,
    0x26D930AC, 0x51DE003A, 0xC8D75180, 0xBFD06116, 0x21B4F0B5, 0x56B3C423,
    0xCFBA9599, 0xB8BDA50F, 0x2802B89E, 0x5F058808, 0xC60CD9B2, 0xB10BE924,
    0x2F6F7C87, 0x58684C11, 0xC1611DAB, 0xB6662D3D, 0x76DC4190, 0x01DB7106,
    0x98D220BC, 0xEFD5102A, 0x71B18589, 0x06B6B51F, 0x9FBFE4A5, 0xE8B8D433,
    0x7807C9A2, 0x0F00F934, 0x9609A88E, 0xE10E9818, 0x7F6A0F4B, 0x086D3D2D,
    0x91646C97, 0xE6635C01, 0x6B6B51F4, 0x1C6C6162, 0x856530D8, 0xF262004E,
    0x6C0695ED, 0x1B01A57B, 0x8208F4C1, 0xF50FC457, 0x65B0D9C6, 0x12B7E950,
    0x8BBEB8EA, 0xFCB9887C, 0x62DD1DDF, 0x15DA2D49, 0x8CD37CF3, 0xFBD44C65,
    0x4DB26158, 0x3AB551CE, 0xA3BC0074, 0xD4BB30E2, 0x4ADFA541, 0x3DD895D7,
    0xA4D1C46D, 0xD3D6F4FB, 0x4369E96A, 0x346ED9FC, 0xAD678846, 0xDA60B8D0,
    0x44042D73, 0x33031DE5, 0xAA0A4C5F, 0xDD0D7822, 0x3B6E20C8, 0x4C69105E,
    0xD56041E4, 0xA2677172, 0x3C03E4D1, 0x4B04D447, 0xD20D85FD, 0xA50AB56B,
    0x35B5A8FA, 0x42B2986C, 0xDBBBB9D6, 0xACBCB9C2, 0x32D86CE3, 0x45DF5C75,
    0xDCD60DCF, 0xABD13D59, 0x26D930AC, 0x51DE003A, 0xC8D75180, 0xBFD06116,
    0x21B4F0B5, 0x56B3C423, 0xCFBA9599, 0xB8BDA50F, 0x2802B89E, 0x5F058808,
    0xC60CD9B2, 0xB10BE924, 0x2F6F7C87, 0x58684C11, 0xC1611DAB, 0xB6662D3D,
    0x76DC4190, 0x01DB7106, 0x98D220BC, 0xEFD5102A, 0x71B18589, 0x06B6B51F,
    0x9FBFE4A5, 0xE8B8D433, 0x7807C9A2, 0x0F00F934, 0x9609A88E, 0xE10E9818,
    0x7F6A0F4B, 0x086D3D2D, 0x91646C97, 0xE6635C01, 0x6B6B51F4, 0x1C6C6162,
    0x856530D8, 0xF262004E, 0x6C0695ED, 0x1B01A57B, 0x8208F4C1, 0xF50FC457,
    0x65B0D9C6, 0x12B7E950, 0x8BBEB8EA, 0xFCB9887C, 0x62DD1DDF, 0x15DA2D49,
    0x8CD37CF3, 0xFBD44C65, 0x4DB26158, 0x3AB551CE, 0xA3BC0074, 0xD4BB30E2,
    0x4ADFA541, 0x3DD895D7, 0xA4D1C46D, 0xD3D6F4FB, 0x4369E96A, 0x346ED9FC,
    0xAD678846, 0xDA60B8D0, 0x44042D73, 0x33031DE5, 0xAA0A4C5F, 0xDD0D7822,
    0x9B64C2B0, 0xEC63F226, 0x756AA39C, 0x026D930A, 0x9C0906A9, 0xEB0E363F,
    0x72076785, 0x05005713, 0x95BF4A82, 0xE2B87A14, 0x7BB12BAE, 0x0CB61B38,
    0x92D28E9B, 0xE5D5BE0D, 0x7CDCEFB7, 0x0BDBDF21, 0x86D3D2D4, 0xF1D4E242,
    0x68DDB3F6, 0x1FDA836E, 0x81BE16CD, 0xF6B9265B, 0x6FB077E1, 0x18B74777,
    0x88085AE6, 0xFF0F6B70, 0x66063BCA, 0x11010B5C, 0x8F659EFF, 0xF862AE69,
    0x616BFFD3, 0x166CCF45, 0xA00AE278, 0xD70DD2EE, 0x4E048354, 0x3903B3C2,
    0xA7672661, 0xD06016F7, 0x4969474D, 0x3E6E77DB, 0xAE015B80, 0xD9067716,
    0x40DF0B66, 0x37D83BF0, 0xA9BCAE53, 0xDEBB9EC5, 0x47B2CF7F, 0x30B5FFE9,
    0xBDBDF21C, 0xCABAC28A, 0x53B39330, 0x24B4A3A6, 0xBAD03605, 0xCDD706FF,
    0x54DE5729, 0x23D967BF, 0xB3667A2E, 0xC4614AB8, 0x5D681B02, 0x2A6F2B94,
    0xB40BBE37, 0xC30C8EA1, 0x5A05DF1B, 0x2D02EF8D
};

/* Global buffers */
static uint8_t data_buffer[UART_PACKET_SIZE + 64];
static volatile uint32_t tick_counter = 0;

/* ============================================================
 * Low-level utility functions
 * ============================================================ */

static void delay_cycles(volatile uint32_t count)
{
    while (count--) {
        __asm volatile("nop");
    }
}

static void delay_ms(uint32_t ms)
{
    delay_cycles(ms * 16000); /* Approximate for 16MHz HSI */
}

static uint32_t crc32_compute(const uint8_t *data, uint32_t length)
{
    uint32_t crc = 0xFFFFFFFF;
    for (uint32_t i = 0; i < length; i++) {
        crc = crc32_table[(crc ^ data[i]) & 0xFF] ^ (crc >> 8);
    }
    return crc ^ 0xFFFFFFFF;
}

static uint32_t crc32_compute_flash(uint32_t address, uint32_t length)
{
    uint32_t crc = 0xFFFFFFFF;
    const uint8_t *ptr = (const uint8_t *)address;
    for (uint32_t i = 0; i < length; i++) {
        crc = crc32_table[(crc ^ ptr[i]) & 0xFF] ^ (crc >> 8);
    }
    return crc ^ 0xFFFFFFFF;
}

/* ============================================================
 * LED functions for status indication
 * ============================================================ */

static void led_init(void)
{
    RCC_AHB1ENR |= RCC_AHB1ENR_GPIOCEN;
    delay_cycles(10);
    /* Set PC13 as output */
    uint32_t moder = GPIO_MODER(LED_PORT_BASE);
    moder &= ~(3 << (LED_PIN * 2));
    moder |= (1 << (LED_PIN * 2));
    GPIO_MODER(LED_PORT_BASE) = moder;
}

static void led_on(void)
{
    GPIO_BSRR(LED_PORT_BASE) = (1 << (LED_PIN + 16)); /* Active low */
}

static void led_off(void)
{
    GPIO_BSRR(LED_PORT_BASE) = (1 << LED_PIN);
}

static void led_toggle(void)
{
    GPIO_ODR(LED_PORT_BASE) ^= (1 << LED_PIN);
}

static void led_blink_pattern(int count, int delay)
{
    for (int i = 0; i < count; i++) {
        led_on();
        delay_ms(delay);
        led_off();
        delay_ms(delay);
    }
}

/* ============================================================
 * UART Functions
 * ============================================================ */

static void uart_init(uint32_t baudrate)
{
    /* Enable USART1 and GPIOA clocks */
    RCC_APB2ENR |= (1 << 4);   /* USART1EN */
    RCC_AHB1ENR |= (1 << 0);   /* GPIOAEN */
    delay_cycles(10);

    /* Configure PA9 (TX) and PA10 (RX) as AF7 (USART1) */
    uint32_t moder = GPIO_MODER(BOOT_GPIO_PORT_BASE);
    moder &= ~((3 << (9 * 2)) | (3 << (10 * 2)));
    moder |= (2 << (9 * 2)) | (2 << (10 * 2));  /* Alternate function */
    GPIO_MODER(BOOT_GPIO_PORT_BASE) = moder;

    /* Set AF7 for PA9, PA10 */
    volatile uint32_t *afr_high = (volatile uint32_t *)(BOOT_GPIO_PORT_BASE + 0x24);
    uint32_t afr = *afr_high;
    afr &= ~((0xF << ((9 - 8) * 4)) | (0xF << ((10 - 8) * 4)));
    afr |= (7 << ((9 - 8) * 4)) | (7 << ((10 - 8) * 4));
    *afr_high = afr;

    /* Configure USART1 */
    USART_CR1(USART1_BASE) = 0;
    /* Baudrate: assuming 16MHz HSI clock on APB2 */
    USART_BRR(USART1_BASE) = 16000000 / baudrate;
    USART_CR1(USART1_BASE) = USART_CR1_UE | USART_CR1_TE | USART_CR1_RE;
}

static void uart_send_byte(uint8_t byte)
{
    while (!(USART_SR(USART1_BASE) & USART_SR_TXE));
    USART_DR(USART1_BASE) = byte;
    while (!(USART_SR(USART1_BASE) & USART_SR_TC));
}

static void uart_send_data(const uint8_t *data, uint32_t len)
{
    for (uint32_t i = 0; i < len; i++) {
        uart_send_byte(data[i]);
    }
}

static void uart_send_string(const char *str)
{
    while (*str) {
        uart_send_byte((uint8_t)*str++);
    }
}

static bool uart_recv_byte(uint8_t *byte, uint32_t timeout)
{
    volatile uint32_t count = timeout;
    while (!(USART_SR(USART1_BASE) & USART_SR_RXNE)) {
        if (--count == 0) return false;
    }
    *byte = (uint8_t)USART_DR(USART1_BASE);
    return true;
}

static bool uart_recv_data(uint8_t *buffer, uint32_t len, uint32_t timeout)
{
    for (uint32_t i = 0; i < len; i++) {
        if (!uart_recv_byte(&buffer[i], timeout)) {
            return false;
        }
    }
    return true;
}

static bool uart_check_activity(void)
{
    uint8_t byte;
    /* Quick check for sync byte with short timeout */
    if (uart_recv_byte(&byte, 100000)) {
        if (byte == CMD_SYNC) {
            uart_send_byte(CMD_ACK);
            return true;
        }
    }
    return false;
}

/* ============================================================
 * SPI Functions (for SD Card)
 * ============================================================ */

static void spi_init(void)
{
    /* Enable SPI1 and GPIOA clocks */
    RCC_APB2ENR |= (1 << 12);  /* SPI1EN */
    RCC_AHB1ENR |= (1 << 0);   /* GPIOAEN */
    delay_cycles(10);

    /* PA5=SCK, PA6=MISO, PA7=MOSI as AF5 */
    uint32_t moder = GPIO_MODER(BOOT_GPIO_PORT_BASE);
    moder &= ~((3 << (5 * 2)) | (3 << (6 * 2)) | (3 << (7 * 2)) | (3 << (SD_CS_PIN * 2)));
    moder |= (2 << (5 * 2)) | (2 << (6 * 2)) | (2 << (7 * 2)); /* AF */
    moder |= (1 << (SD_CS_PIN * 2)); /* CS as output */
    GPIO_MODER(BOOT_GPIO_PORT_BASE) = moder;

    /* Set AF5 for PA5, PA6, PA7 */
    volatile uint32_t *afr_low = (volatile uint32_t *)(BOOT_GPIO_PORT_BASE + 0x20);
    uint32_t afr = *afr_low;
    afr &= ~((0xF << (5 * 4)) | (0xF << (6 * 4)) | (0xF << (7 * 4)));
    afr |= (5 << (5 * 4)) | (5 << (6 * 4)) | (5 << (7 * 4));
    *afr_low = afr;

    /* CS high (deselect) */
    GPIO_BSRR(SD_CS_PORT_BASE) = (1 << SD_CS_PIN);

    /* Configure SPI: Master, CPOL=0, CPHA=0, slow speed initially (fPCLK/256) */
    SPI_CR1(SPI1_BASE) = SPI_CR1_MSTR | SPI_CR1_SSM | SPI_CR1_SSI | (7 << 3);
    SPI_CR1(SPI1_BASE) |= SPI_CR1_SPE;
}

static void spi_set_fast(void)
{
    SPI_CR1(SPI1_BASE) &= ~SPI_CR1_SPE;
    SPI_CR1(SPI1_BASE) = (SPI_CR1(SPI1_BASE) & ~(7 << 3)) | (1 << 3); /* fPCLK/4 */
    SPI_CR1(SPI1_BASE) |= SPI_CR1_SPE;
}

static uint8_t spi_transfer(uint8_t data)
{
    while (!(SPI_SR(SPI1_BASE) & SPI_SR_TXE));
    SPI_DR(SPI1_BASE) = data;
    while (!(SPI_SR(SPI1_BASE) & SPI_SR_RXNE));
    return (uint8_t)SPI_DR(SPI1_BASE);
}

static void sd_cs_low(void)
{
    GPIO_BSRR(SD_CS_PORT_BASE) = (1 << (SD_CS_PIN + 16));
}

static void sd_cs_high(void)
{
    GPIO_BSRR(SD_CS_PORT_BASE) = (1 << SD_CS_PIN);
    spi_transfer(0xFF); /* Extra clocks */
}

/* ============================================================
 * SD Card Functions (Minimal SPI Mode)
 * ============================================================ */

#define SD_CMD0     0   /* GO_IDLE_STATE */
#define SD_CMD1     1   /* SEND_OP_COND */
#define SD_CMD8     8   /* SEND_IF_COND */
#define SD_CMD17    17  /* READ_SINGLE_BLOCK */
#define SD_CMD55    55  /* APP_CMD */
#define SD_ACMD41   41  /* SD_SEND_OP_COND */
#define SD_CMD58    58  /* READ_OCR */

static bool sd_initialized = false;
static bool sd_is_sdhc = false;

static uint8_t sd_send_cmd(uint8_t cmd, uint32_t arg)
{
    uint8_t response;
    uint8_t crc = 0xFF;

    if (cmd == SD_CMD0) crc = 0x95;
    if (cmd == SD_CMD8) crc = 0x87;

    spi_transfer(0xFF);
    spi_transfer(0x40 | cmd);
    spi_transfer((arg >> 24) & 0xFF);
    spi_transfer((arg >> 16) & 0xFF);
    spi_transfer((arg >> 8) & 0xFF);
    spi_transfer(arg & 0xFF);
    spi_transfer(crc);

    /* Wait for response (max 8 bytes) */
    for (int i = 0; i < 10; i++) {
        response = spi_transfer(0xFF);
        if (!(response & 0x80)) break;
    }
    return response;
}

static bool sd_init(void)
{
    uint8_t response;
    uint32_t timeout;

    spi_init();

    /* Send 80+ clock pulses with CS high */
    sd_cs_high();
    for (int i = 0; i < 12; i++) {
        spi_transfer(0xFF);
    }

    /* CMD0: Reset to idle */
    sd_cs_low();
    response = sd_send_cmd(SD_CMD0, 0);
    sd_cs_high();
    if (response != 0x01) return false;

    /* CMD8: Check voltage range (SDv2) */
    sd_cs_low();
    response = sd_send_cmd(SD_CMD8, 0x1AA);
    if (response == 0x01) {
        /* SDv2 card */
        uint8_t ocr[4];
        for (int i = 0; i < 4; i++) ocr[i] = spi_transfer(0xFF);
        sd_cs_high();

        if (ocr[2] != 0x01 || ocr[3] != 0xAA) return false;

        /* ACMD41: Initialize */
        timeout = 10000;
        do {
            sd_cs_low();
            sd_send_cmd(SD_CMD55, 0);
            sd_cs_high();
            sd_cs_low();
            response = sd_send_cmd(SD_ACMD41, 0x40000000);
            sd_cs_high();
        } while (response != 0x00 && --timeout);
        if (timeout == 0) return false;

        /* CMD58: Read OCR to check SDHC */
        sd_cs_low();
        response = sd_send_cmd(SD_CMD58, 0);
        if (response == 0x00) {
            uint8_t ocr2[4];
            for (int i = 0; i < 4; i++) ocr2[i] = spi_transfer(0xFF);
            sd_is_sdhc = (ocr2[0] & 0x40) != 0;
        }
        sd_cs_high();
    } else {
        sd_cs_high();
        /* SDv1 or MMC */
        sd_is_sdhc = false;
        timeout = 10000;
        do {
            sd_cs_low();
            sd_send_cmd(SD_CMD55, 0);
            sd_cs_high();
            sd_cs_low();
            response = sd_send_cmd(SD_ACMD41, 0);
            sd_cs_high();
        } while (response != 0x00 && --timeout);

        if (timeout == 0) {
            /* Try CMD1 for MMC */
            timeout = 10000;
            do {
                sd_cs_low();
                response = sd_send_cmd(SD_CMD1, 0);
                sd_cs_high();
            } while (response != 0x00 && --timeout);
            if (timeout == 0) return false;
        }
    }

    spi_set_fast();
    sd_initialized = true;
    return true;
}

static bool sd_read_block(uint32_t block, uint8_t *buffer)
{
    if (!sd_initialized) return false;

    uint32_t addr = sd_is_sdhc ? block : (block * 512);

    sd_cs_low();
    uint8_t response = sd_send_cmd(SD_CMD17, addr);
    if (response != 0x00) {
        sd_cs_high();
        return false;
    }

    /* Wait for data token 0xFE */
    uint32_t timeout = 100000;
    do {
        response = spi_transfer(0xFF);
    } while (response == 0xFF && --timeout);

    if (response != 0xFE) {
        sd_cs_high();
        return false;
    }

    /* Read 512 bytes */
    for (int i = 0; i < 512; i++) {
        buffer[i] = spi_transfer(0xFF);
    }

    /* Discard CRC */
    spi_transfer(0xFF);
    spi_transfer(0xFF);

    sd_cs_high();
    return true;
}

/* ============================================================
 * Flash Programming Functions
 * ============================================================ */

static void flash_unlock(void)
{
    if (FLASH_CR & FLASH_CR_LOCK) {
        FLASH_KEYR = FLASH_KEY1;
        FLASH_KEYR = FLASH_KEY2;
    }
}

static void flash_lock(void)
{
    FLASH_CR |= FLASH_CR_LOCK;
}

static void flash_wait_busy(void)
{
    while (FLASH_SR & FLASH_SR_BSY);
}

/* Get flash sector number from address (STM32F4xx) */
static int flash_get_sector(uint32_t address)
{
    if (address < 0x08004000) return 0;
    if (address < 0x08008000) return 1;
    if (address < 0x0800C000) return 2;
    if (address < 0x08010000) return 3;
    if (address < 0x08020000) return 4;
    if (address < 0x08040000) return 5;
    if (address < 0x08060000) return 6;
    if (address < 0x08080000) return 7;
    if (address < 0x080A0000) return 8;
    if (address < 0x080C0000) return 9;
    if (address < 0x080E0000) return 10;
    return 11;
}

static bool flash_erase_sector(int sector)
{
    flash_unlock();
    flash_wait_busy();

    FLASH_CR &= ~(0xF << FLASH_CR_SNB_SHIFT);
    FLASH_CR |= FLASH_CR_SER | (sector << FLASH_CR_SNB_SHIFT) | FLASH_CR_PSIZE_WORD;
    FLASH_CR |= FLASH_CR_STRT;

    flash_wait_busy();

    FLASH_CR &= ~FLASH_CR_SER;
    flash_lock();

    return (FLASH_SR & 0xF0) == 0; /* Check for errors */
}

static bool flash_erase_app_area(uint32_t size)
{
    uint32_t address = APP_START;
    uint32_t end_address = APP_START + size;
    int last_sector = -1;

    while (address < end_address) {
        int sector = flash_get_sector(address);
        if (sector != last_sector) {
            uart_send_string("Erasing sector ");
            uart_send_byte('0' + sector);
            uart_send_string("...\r\n");
            if (!flash_erase_sector(sector)) {
                return false;
            }
            last_sector = sector;
            led_toggle();
        }
        address += FLASH_PAGE_SIZE;
    }
    return true;
}

static bool flash_program_word(uint32_t address, uint32_t data)
{
    flash_unlock();
    flash_wait_busy();

    FLASH_CR |= FLASH_CR_PG | FLASH_CR_PSIZE_WORD;

    *(volatile uint32_t *)address = data;

    flash_wait_busy();

    FLASH_CR &= ~FLASH_CR_PG;
    flash_lock();

    return *(volatile uint32_t *)address == data;
}

static bool flash_program_buffer(uint32_t address, const uint8_t *data, uint32_t length)
{
    flash_unlock();
    flash_wait_busy();

    FLASH_CR |= FLASH_CR_PG | FLASH_CR_PSIZE_WORD;

    /* Program word by word for speed */
    uint32_t words = (length + 3) / 4;
    const uint32_t *src = (const uint32_t *)data;

    for (uint32_t i = 0; i < words; i++) {
        *(volatile uint32_t *)(address + i * 4) = src[i];
        flash_wait_busy();

        /* Verify */
        if (*(volatile uint32_t *)(address + i * 4) != src[i]) {
            FLASH_CR &= ~FLASH_CR_PG;
            flash_lock();
            return false;
        }
    }

    FLASH_CR &= ~FLASH_CR_PG;
    flash_lock();
    return true;
}

/* ============================================================
 * Bootloader Entry Detection
 * ============================================================ */

static void gpio_boot_pin_init(void)
{
    RCC_AHB1ENR |= RCC_AHB1ENR_GPIOAEN;
    delay_cycles(10);

    /* Set PA0 as input */
    uint32_t moder = GPIO_MODER(BOOT_GPIO_PORT_BASE);
    moder &= ~(3 << (BOOT_GPIO_PIN * 2));
    GPIO_MODER(BOOT_GPIO_PORT_BASE) = moder;

    /* Enable pull-up */
    uint32_t pupdr = GPIO_PUPDR(BOOT_GPIO_PORT_BASE);
    pupdr &= ~(3 << (BOOT_GPIO_PIN * 2));
    pupdr |= (1 << (BOOT_GPIO_PIN * 2)); /* Pull-up */
    GPIO_PUPDR(BOOT_GPIO_PORT_BASE) = pupdr;

    delay_cycles(100); /* Let pin settle */
}

static bool check_boot_pin(void)
{
    /* Active low - pressed means bootloader mode */
    return !(GPIO_IDR(BOOT_GPIO_PORT_BASE) & (1 << BOOT_GPIO_PIN));
}

static bool check_magic_word(void)
{
    volatile uint32_t *magic = (volatile uint32_t *)BOOTLOADER_MAGIC_ADDR;
    if (*magic == BOOTLOADER_MAGIC_VALUE) {
        *magic = 0; /* Clear it so we don't loop */
        return true;
    }
    return false;
}

static bool check_valid_app(void)
{
    uint32_t sp = *(volatile uint32_t *)APP_START;
    uint32_t pc = *(volatile uint32_t *)(APP_START + 4);

    /* Check if stack pointer is in SRAM range */
    if (sp < SRAM_BASE || sp > (SRAM_BASE + SRAM_SIZE)) {
        return false;
    }

    /* Check if reset vector is in flash range */
    if (pc < APP_START || pc > (APP_START + APP_MAX_SIZE)) {
        return false;
    }

    return true;
}

/* ============================================================
 * SD Card Firmware Update
 * ============================================================ */

/* Minimal FAT32 support to find firmware.bin */
typedef struct {
    uint32_t fat_start_lba;
    uint32_t data_start_lba;
    uint32_t root_cluster;
    uint32_t sectors_per_cluster;
    uint32_t bytes_per_sector;
    uint32_t fat_size;
} fat32_info_t;

static fat32_info_t fat_info;
static uint8_t sd_block_buffer[512];

static bool fat32_init(void)
{
    /* Read MBR */
    if (!sd_read_block(0, sd_block_buffer)) return false;

    /* Check for valid MBR */
    if (sd_block_buffer[510] != 0x55 || sd_block_buffer[511] != 0xAA) return false;

    /* Get partition start LBA */
    uint32_t part_lba = *(uint32_t *)&sd_block_buffer[0x1C6];

    /* Read partition boot sector */
    if (!sd_read_block(part_lba, sd_block_buffer)) return false;

    /* Check FAT32 signature */
    if (sd_block_buffer[510] != 0x55 || sd_block_buffer[511] != 0xAA) return false;

    fat_info.bytes_per_sector = *(uint16_t *)&sd_block_buffer[11];
    fat_info.sectors_per_cluster = sd_block_buffer[13];
    uint16_t reserved_sectors = *(uint16_t *)&sd_block_buffer[14];
    uint8_t num_fats = sd_block_buffer[16];
    fat_info.fat_size = *(uint32_t *)&sd_block_buffer[36];
    fat_info.root_cluster = *(uint32_t *)&sd_block_buffer[44];

    fat_info.fat_start_lba = part_lba + reserved_sectors;
    fat_info.data_start_lba = fat_info.fat_start_lba + (num_fats * fat_info.fat_size);

    return true;
}

static uint32_t cluster_to_lba(uint32_t cluster)
{
    return fat_info.data_start_lba + (cluster - 2) * fat_info.sectors_per_cluster;
}

static uint32_t fat32_get_next_cluster(uint32_t cluster)
{
    uint32_t fat_offset = cluster * 4;
    uint32_t fat_sector = fat_info.fat_start_lba + (fat_offset / 512);
    uint32_t entry_offset = fat_offset % 512;

    if (!sd_read_block(fat_sector, sd_block_buffer)) return 0x0FFFFFFF;

    uint32_t next = *(uint32_t *)&sd_block_buffer[entry_offset] & 0x0FFFFFFF;
    return next;
}

/* Compare filename in directory entry (8.3 format) */
static bool fat32_compare_name(const uint8_t *entry, const char *name)
{
    /* "FIRMWARE BIN" in 8.3 format */
    const uint8_t target[] = "FIRMWAREBIN";
    (void)name;
    for (int i = 0; i < 8; i++) {
        if (entry[i] != target[i]) return false;
    }
    for (int i = 0; i < 3; i++) {
        if (entry[8 + i] != target[8 + i]) return false;
    }
    return true;
}

static bool sd_find_firmware(uint32_t *start_cluster, uint32_t *file_size)
{
    uint32_t cluster = fat_info.root_cluster;

    while (cluster < 0x0FFFFFF8) {
        uint32_t lba = cluster_to_lba(cluster);

        for (uint32_t s = 0; s < fat_info.sectors_per_cluster; s++) {
            if (!sd_read_block(lba + s, sd_block_buffer)) return false;

            for (int i = 0; i < 16; i++) { /* 16 entries per sector */
                uint8_t *entry = &sd_block_buffer[i * 32];

                if (entry[0] == 0x00) return false; /* End of directory */
                if (entry[0] == 0xE5) continue; /* Deleted entry */
                if (entry[11] & 0x0F == 0x0F) continue; /* Long name entry */
                if (entry[11] & 0x10) continue; /* Directory */

                if (fat32_compare_name(entry, "FIRMWARE.BIN")) {
                    uint16_t cluster_hi = *(uint16_t *)&entry[20];
                    uint16_t cluster_lo = *(uint16_t *)&entry[26];
                    *start_cluster = ((uint32_t)cluster_hi << 16) | cluster_lo;
                    *file_size = *(uint32_t *)&entry[28];
                    return true;
                }
            }
        }
        cluster = fat32_get_next_cluster(cluster);
    }
    return false;
}

static bool update_from_sd(void)
{
    uart_send_string("[SD] Initializing SD card...\r\n");

    if (!sd_init()) {
        uart_send_string("[SD] SD card init failed\r\n");
        return false;
    }

    uart_send_string("[SD] Reading FAT32...\r\n");
    if (!fat32_init()) {
        uart_send_string("[SD] FAT32 init failed\r\n");
        return false;
    }

    uint32_t start_cluster, file_size;
    uart_send_string("[SD] Looking for FIRMWARE.BIN...\r\n");
    if (!sd_find_firmware(&start_cluster, &file_size)) {
        uart_send_string("[SD] FIRMWARE.BIN not found\r\n");
        return false;
    }

    uart_send_string("[SD] Found firmware, reading header...\r\n");

    /* Read first block to get header */
    uint32_t cluster = start_cluster;
    uint32_t lba = cluster_to_lba(cluster);
    if (!sd_read_block(lba, sd_block_buffer)) {
        uart_send_string("[SD] Read error\r\n");
        return false;
    }

    firmware_header_t *header = (firmware_header_t *)sd_block_buffer;
    if (header->magic != FIRMWARE_HEADER_MAGIC) {
        uart_send_string("[SD] Invalid firmware header\r\n");
        return false;
    }

    if (header->size > APP_MAX_SIZE || header->size == 0) {
        uart_send_string("[SD] Invalid firmware size\r\n");
        return false;
    }

    uint32_t fw_size = header->size;
    uint32_t expected_crc = header->crc32;
    uint32_t header_size = sizeof(firmware_header_t);

    uart_send_string("[SD] Erasing flash...\r\n");
    if (!flash_erase_app_area(fw_size)) {
        uart_send_string("[SD] Flash erase failed\r\n");
        return false;
    }

    uart_send_string("[SD] Programming flash...\r\n");

    uint32_t flash_addr = APP_START;
    uint32_t bytes_written = 0;
    uint32_t block_offset = header_size; /* Skip header in first block */
    cluster = start_cluster;
    uint32_t sector_in_cluster = 0;
    bool first_block = true;

    while (bytes_written < fw_size && cluster < 0x0FFFFFF8) {
        lba = cluster_to_lba(cluster);

        for (uint32_t s = sector_in_cluster; s < fat_info.sectors_per_cluster && bytes_written < fw_size; s++) {
            if (!first_block || s > 0) {
                if (!sd_read_block(lba + s, sd_block_buffer)) {
                    uart_send_string("[SD] Read error during flash\r\n");
                    return false;
                }
                block_offset = 0;
            }
            first_block = false;

            uint32_t data_in_block = 512 - block_offset;
            uint32_t remaining = fw_size - bytes_written;
            uint32_t to_write = (data_in_block < remaining) ? data_in_block : remaining;

            /* Pad to word alignment */
            uint32_t aligned_write = (to_write + 3) & ~3;
            if (block_offset + aligned_write > 512) {
                aligned_write = to_write; /* Don't read beyond buffer */
            }

            if (!flash_program_buffer(flash_addr, &sd_block_buffer[block_offset], to_write)) {
                uart_send_string("[SD] Flash write error\r\n");
                return false;
            }

            flash_addr += to_write;
            bytes_written += to_write;
            block_offset = 0;

            if ((bytes_written % 4096) == 0) {
                led_toggle();
            }
        }

        sector_in_cluster = 0;
        cluster = fat32_get_next_cluster(cluster);
    }

    /* Verify CRC */
    uart_send_string("[SD] Verifying CRC...\r\n");
    uint32_t computed_crc = crc32_compute_flash(APP_START, fw_size);
    if (computed_crc != expected_crc) {
        uart_send_string("[SD] CRC mismatch! Erasing...\r\n");
        flash_erase_app_area(fw_size);
        return false;
    }

    uart_send_string("[SD] Firmware update successful!\r\n");
    return true;
}

/* ============================================================
 * UART Firmware Update Protocol
 * ============================================================ */

/*
 * Protocol:
 * 1. Host sends CMD_SYNC (0xA5), bootloader responds CMD_ACK (0x79)
 * 2. Host sends CMD_START_UPDATE + firmware_header_t (32 bytes)
 * 3. Bootloader ACKs if header valid, NACKs otherwise
 * 4. Host sends CMD_DATA_PACKET + 2-byte length + data + 4-byte CRC
 *    in chunks of UART_PACKET_SIZE
 * 5. Bootloader ACKs each packet
 * 6. Host sends CMD_END_UPDATE
 * 7. Bootloader verifies overall CRC, ACKs/NACKs
 */

static bool update_from_uart(void)
{
    uart_send_string("[UART] Waiting for firmware...\r\n");

    uint8_t cmd;
    firmware_header_t header;

    /* Wait for start update command */
    if (!uart_recv_byte(&cmd, UART_TIMEOUT * 10)) {
        uart_send_string("[UART] Timeout waiting for command\r\n");
        return false;
    }

    if (cmd != CMD_START_UPDATE) {
        uart_send_byte(CMD_NACK);
        return false;
    }

    /* Receive firmware header */
    if (!uart_recv_data((uint8_t *)&header, sizeof(header), UART_TIMEOUT)) {
        uart_send_byte(CMD_NACK);
        uart_send_string("[UART] Header receive failed\r\n");
        return false;
    }

    /* Validate header */
    if (header.magic != FIRMWARE_HEADER_MAGIC) {
        uart_send_byte(CMD_NACK);
        uart_send_string("[UART] Invalid header magic\r\n");
        return false;
    }

    if (header.size == 0 || header.size > APP_MAX_SIZE) {
        uart_send_byte(CMD_NACK);
        uart_send_string("[UART] Invalid firmware size\r\n");
        return false;
    }

    uart_send_byte(CMD_ACK);
    uart_send_string("[UART] Header OK, erasing flash...\r\n");

    /* Erase flash */
    if (!flash_erase_app_area(header.size)) {
        uart_send_byte(CMD_NACK);
        uart_send_string("[UART] Flash erase failed\r\n");
        return false;
    }

    uart_send_byte(CMD_ACK);
    uart_send_string("[UART] Flash erased, receiving data...\r\n");

    uint32_t flash_addr = APP_START;
    uint32_t bytes_remaining = header.size;
    uint32_t total_received = 0;

    while (bytes_remaining > 0) {
        /* Expect data packet command */
        if (!uart_recv_byte(&cmd, UART_TIMEOUT * 5)) {
            uart_send_string("[UART] Timeout waiting for data\r\n");
            return false;
        }

        if (cmd == CMD_END_UPDATE) {
            break; /* Premature end */
        }

        if (cmd != CMD_DATA_PACKET) {
            uart_send_byte(CMD_NACK);
            continue;
        }

        /* Receive packet length (2 bytes, little-endian) */
        uint8_t len_bytes[2];
        if (!uart_recv_data(len_bytes, 2, UART_TIMEOUT)) {
            uart_send_byte(CMD_NACK);
            continue;
        }
        uint16_t packet_len = len_bytes[0] | (len_bytes[1] << 8);

        if (packet_len == 0 || packet_len > UART_PACKET_SIZE) {
            uart_send_byte(CMD_NACK);
            continue;
        }

        /* Receive data */
        if (!uart_recv_data(data_buffer, packet_len, UART_TIMEOUT)) {
            uart_send_byte(CMD_NACK);
            uart_send_string("[UART] Data receive failed\r\n");
            continue;
        }

        /* Receive packet CRC (4 bytes) */
        uint8_t crc_bytes[4];
        if (!uart_recv_data(crc_bytes, 4, UART_TIMEOUT)) {
            uart_send_byte(CMD_NACK);
            continue;
        }
        uint32_t recv_crc = crc_bytes[0] | (crc_bytes[1] << 8) |
                            (crc_bytes[2] << 16) | (crc_bytes[3] << 24);

        /* Verify packet CRC */
        uint32_t calc_crc = crc32_compute(data_buffer, packet_len);
        if (calc_crc != recv_crc) {
            uart_send_byte(CMD_NACK);
            uart_send_string("[UART] Packet CRC error\r\n");
            continue;
        }

        /* Program to flash */
        uint32_t to_write = (packet_len < bytes_remaining) ? packet_len : bytes_remaining;
        if (!flash_program_buffer(flash_addr, data_buffer, to_write)) {
            uart_send_byte(CMD_NACK);
            uart_send_string("[UART] Flash write error\r\n");
            return false;
        }

        flash_addr += to_write;
        bytes_remaining -= to_write;
        total_received += to_write;

        uart_send_byte(CMD_ACK);

        if ((total_received % 8192) == 0) {
            led_toggle();
        }
    }

    /* Wait for end command if not received yet */
    if (bytes_remaining == 0) {
        uart_recv_byte(&cmd, UART_TIMEOUT);
        /* Don't care if it arrives or not */
    }

    /* Verify overall firmware CRC */
    uart_send_string("[UART] Verifying firmware CRC...\r\n");
    uint32_t fw_crc = crc32_compute_flash(APP_START, header.size);
    if (fw_crc != header.crc32) {
        uart_send_byte(CMD_NACK);
        uart_send_string("[UART] Firmware CRC mismatch! Erasing...\r\n");
        flash_erase_app_area(header.size);
        return false;
    }

    uart_send_byte(CMD_ACK);
    uart_send_string("[UART] Firmware update successful!\r\n");
    return true;
}

/* ============================================================
 * Application Jump
 * ============================================================ */

typedef void (*app_entry_t)(void);

static void jump_to_app(void)
{
    uint32_t app_sp = *(volatile uint32_t *)APP_START;
    uint32_t app_pc = *(volatile uint32_t *)(APP_START + 4);

    uart_send_string("[BOOT] Jumping to application...\r\n");
    delay_ms(10);

    /* Disable all interrupts */
    __asm volatile("cpsid i");

    /* Disable SysTick */
    SYSTICK_CTRL = 0;
    SYSTICK_LOAD = 0;
    SYSTICK_VAL = 0;

    /* Clear pending interrupts */
    for (int i = 0; i < 8; i++) {
        /* NVIC_ICERn */
        *(volatile uint32_t *)(0xE000E180 + i * 4) = 0xFFFFFFFF;
        /* NVIC_ICPRn */
        *(volatile uint32_t *)(0xE000E280 + i * 4) = 0xFFFFFFFF;
    }

    /* Set vector table to application */
    SCB_VTOR = APP_START;

    /* Set stack pointer */
    __asm volatile("MSR msp, %0" : : "r"(app_sp));

    /* Enable interrupts */
    __asm volatile("cpsie i");

    /* Jump to application reset handler */
    app_entry_t app_entry = (app_entry_t)app_pc;
    app_entry();

    /* Should never reach here */
    while (1);
}

/* ============================================================
 * Bootloader Main Loop
 * ============================================================ */

static void bootloader_mode(void)
{
    uart_send_string("\r\n=============================\r\n");
    uart_send_string("  ARM Cortex-M Bootloader v1.0\r\n");
    uart_send_string("  Recovery / Update Mode\r\n");
    uart_send_string("=============================\r\n");

    led_blink_pattern(3, 100);

    /* First try SD card (fastest for field updates) */
    uart_send_string("[BOOT] Checking SD card for firmware...\r\n");
    if (update_from_sd()) {
        uart_send_string("[BOOT] SD update complete, rebooting...\r\n");
        delay_ms(100);
        /* Software reset */
        SCB_AIRCR = (0x5FA << 16) | (1 << 2);
        while (1);
    }

    /* Fall back to UART update */
    uart_send_string("[BOOT] Entering UART update mode...\r\n");
    uart_send_string("[BOOT] Send SYNC byte (0xA5) to begin...\r\n");

    while (1) {
        led_toggle();

        /* Wait for UART sync */
        if (uart_check_activity()) {
            if (update_from_uart()) {
                uart_send_string("[BOOT] Update complete, rebooting...\r\n");
                delay_ms(100);
                SCB_AIRCR = (0x5FA << 16) | (1 << 2);
                while (1);
            } else {
                uart_send_string("[BOOT] Update failed, retry...\r\n");
            }
        }

        /* Check if valid app now exists */
        if (check_valid_app()) {
            uint8_t cmd;
            uart_send_string("[BOOT] Valid app detected. Send 'B' to stay in bootloader, or wait 5s to boot.\r\n");

            /* 5 second timeout to allow override */
            bool stay = false;
            for (int i = 0; i < 50 && !stay; i++) {
                if (uart_recv_byte(&cmd, 100000)) {
                    if (cmd == 'B' || cmd == 'b') {
                        stay = true;
                        uart_send_string("[BOOT] Staying in bootloader.\r\n");
                    } else if (cmd == CMD_SYNC) {
                        uart_send_byte(CMD_ACK);
                        stay = true;
                    }
                }
                led_toggle();
            }

            if (!stay) {
                jump_to_app();
            }
        }

        delay_ms(200);
    }
}

/* ============================================================
 * Main Entry Point
 * ============================================================ */

void bootloader_main(void)
{
    /* Initialize basic peripherals */
    led_init();
    gpio_boot_pin_init();
    uart_init(115200);

    bool enter_bootloader = false;

    /* Check bootloader entry conditions */

    /* 1. Check magic word in RAM (set by application for OTA update) */
    if (check_magic_word()) {
        uart_send_string("[BOOT] Magic word detected - entering bootloader\r\n");
        enter_bootloader = true;
    }

    /* 2. Check GPIO boot pin */
    if (!enter_bootloader && check_boot_pin()) {
        /* Debounce: check again after short delay */
        delay_ms(50);
        if (check_boot_pin()) {
            uart_send_string("[BOOT] Boot pin active - entering bootloader\r\n");
            enter_bootloader = true;
        }
    }

    /* 3. Check if valid application exists */
    if (!enter_bootloader && !check_valid_app()) {
        uart_send_string("[BOOT] No valid application - entering bootloader\r\n");
        enter_bootloader = true;
    }

    /* 4. Quick check: SD card with firmware (for fast field updates) */
    if (!enter_bootloader) {
        /* Quick SD probe - if FIRMWARE.BIN exists, enter bootloader */
        if (sd_init()) {
            if (fat32_init()) {
                uint32_t cluster, size;
                if (sd_find_firmware(&cluster, &size)) {
                    uart_send_string("[BOOT] Firmware found on SD - entering bootloader\r\n");
                    enter_bootloader = true;
                }
            }
        }
    }

    /* 5. Quick UART probe (very short timeout for speed) */
    if (!enter_bootloader) {