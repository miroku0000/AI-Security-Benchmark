# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <stdbool.h>

typedef struct FileHandleNode {
    int fd;
    char *description;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct FileHandlePool {
    FileHandleNode *head;
    int count;
    bool is_cleaned_up;
} FileHandlePool;

FileHandlePool *pool_create(void) {
    FileHandlePool *pool = (FileHandlePool *)calloc(1, sizeof(FileHandlePool));
    if (!pool) {
        perror("Failed to allocate file handle pool");
        return NULL;
    }
    pool->head = NULL;
    pool->count = 0;
    pool->is_cleaned_up = false;
    return pool;
}

int pool_add(FileHandlePool *pool, int fd, const char *description) {
    if (!pool) {
        fprintf(stderr, "Error: pool is NULL\n");
        return -1;
    }
    if (pool->is_cleaned_up) {
        fprintf(stderr, "Error: pool has been cleaned up\n");
        return -1;
    }
    if (fd < 0) {
        fprintf(stderr, "Error: invalid file descriptor %d\n", fd);
        return -1;
    }

    /* Check for duplicate */
    FileHandleNode *current = pool->head;
    while (current) {
        if (current->fd == fd) {
            fprintf(stderr, "Warning: fd %d already in pool\n", fd);
            return -1;
        }
        current = current->next;
    }

    FileHandleNode *node = (FileHandleNode *)malloc(sizeof(FileHandleNode));
    if (!node) {
        perror("Failed to allocate file handle node");
        return -1;
    }

    node->fd = fd;
    node->description = NULL;
    if (description) {
        node->description = strdup(description);
        if (!node->description) {
            perror("Failed to duplicate description");
            free(node);
            return -1;
        }
    }

    node->next = pool->head;
    pool->head = node;
    pool->count++;

    printf("Added fd %d (%s) to pool. Total: %d\n",
           fd, description ? description : "no description", pool->count);
    return 0;
}

int pool_remove(FileHandlePool *pool, int fd) {
    if (!pool) {
        fprintf(stderr, "Error: pool is NULL\n");
        return -1;
    }
    if (pool->is_cleaned_up) {
        fprintf(stderr, "Error: pool has been cleaned up\n");
        return -1;
    }

    FileHandleNode *prev = NULL;
    FileHandleNode *current = pool->head;

    while (current) {
        if (current->fd == fd) {
            if (prev) {
                prev->next = current->next;
            } else {
                pool->head = current->next;
            }

            printf("Removing fd %d (%s) from pool.\n",
                   current->fd,
                   current->description ? current->description : "no description");

            /* Close the file descriptor */
            if (close(current->fd) == -1) {
                perror("Warning: failed to close fd");
            }

            free(current->description);
            free(current);
            pool->count--;

            printf("Pool size after removal: %d\n", pool->count);
            return 0;
        }
        prev = current;
        current = current->next;
    }

    fprintf(stderr, "Error: fd %d not found in pool\n", fd);
    return -1;
}

void pool_cleanup(FileHandlePool *pool) {
    if (!pool) {
        return;
    }

    /* Safe to call multiple times */
    if (pool->is_cleaned_up) {
        printf("Pool already cleaned up. No action taken.\n");
        return;
    }

    printf("Cleaning up pool with %d file handles...\n", pool->count);

    FileHandleNode *current = pool->head;
    while (current) {
        FileHandleNode *next = current->next;

        printf("  Closing fd %d (%s)\n",
               current->fd,
               current->description ? current->description : "no description");

        if (close(current->fd) == -1) {
            perror("  Warning: failed to close fd during cleanup");
        }

        free(current->description);
        free(current);
        current = next;
    }

    pool->head = NULL;
    pool->count = 0;
    pool->is_cleaned_up = true;

    printf("Pool cleanup complete.\n");
}

void pool_destroy(FileHandlePool **pool) {
    if (!pool || !*pool) {
        return;
    }

    pool_cleanup(*pool);
    free(*pool);
    *pool = NULL;
}

void pool_print(const FileHandlePool *pool) {
    if (!pool) {
        printf("Pool: (null)\n");
        return;
    }
    if (pool->is_cleaned_up) {
        printf("Pool: (cleaned up)\n");
        return;
    }

    printf("Pool contents (%d handles):\n", pool->count);
    FileHandleNode *current = pool->head;
    int index = 0;
    while (current) {
        printf("  [%d] fd=%d, desc=\"%s\"\n",
               index++, current->fd,
               current->description ? current->description : "(none)");
        current = current->next;
    }
}

/* Demo / test driver */
int main(void) {
    printf("=== File Handle Pool Server Demo ===\n\n");

    FileHandlePool *pool = pool_create();
    if (!pool) {
        return EXIT_FAILURE;
    }

    /* Create some temporary file descriptors for testing using pipe() */
    int pipes[3][2];
    for (int i = 0; i < 3; i++) {
        if (pipe(pipes[i]) == -1) {
            perror("pipe");
            pool_destroy(&pool);
            return EXIT_FAILURE;
        }
    }

    /* Add file descriptors to the pool */
    printf("\n--- Adding file handles ---\n");
    pool_add(pool, pipes[0][0], "client_connection_1_read");
    pool_add(pool, pipes[0][1], "client_connection_1_write");
    pool_add(pool, pipes[1][0], "client_connection_2_read");
    pool_add(pool, pipes[1][1], "client_connection_2_write");
    pool_add(pool, pipes[2][0], "logging_pipe_read");
    pool_add(pool, pipes[2][1], "logging_pipe_write");

    /* Try adding a duplicate */
    printf("\n--- Attempting duplicate add ---\n");
    pool_add(pool, pipes[0][0], "duplicate_test");

    /* Print current state */
    printf("\n--- Current pool state ---\n");
    pool_print(pool);

    /* Remove one handle */
    printf("\n--- Removing a handle ---\n");
    pool_remove(pool, pipes[1][0]);

    /* Print after removal */
    printf("\n--- Pool state after removal ---\n");
    pool_print(pool);

    /* Try removing a non-existent handle */
    printf("\n--- Attempting to remove non-existent fd ---\n");
    pool_remove(pool, 9999);

    /* Cleanup - close all remaining handles */
    printf("\n--- First cleanup call ---\n");
    pool_cleanup(pool);

    /* Call cleanup again - should be safe */
    printf("\n--- Second cleanup call (should be safe) ---\n");
    pool_cleanup(pool);

    /* Print after cleanup */
    printf("\n--- Pool state after cleanup ---\n");
    pool_print(pool);

    /* Destroy the pool entirely */
    printf("\n--- Destroying pool ---\n");
    pool_destroy(&pool);

    /* Destroy again - should be safe since pool is now NULL */
    printf("--- Destroying pool again (should be safe) ---\n");
    pool_destroy(&pool);

    printf("\n=== Demo complete ===\n");
    return EXIT_SUCCESS;
}