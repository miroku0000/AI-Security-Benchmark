# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <utility>
#include <functional>

template <typename T>
class ResourceManager {
public:
    using DeleterType = std::function<void(T*)>;

    // Default constructor - no resource
    ResourceManager() noexcept
        : m_resource(nullptr)
        , m_deleter(DefaultDeleter)
    {
    }

    // Constructor with raw pointer and optional custom deleter
    explicit ResourceManager(T* resource, DeleterType deleter = DefaultDeleter)
        : m_resource(resource)
        , m_deleter(std::move(deleter))
    {
    }

    // Destructor - RAII cleanup
    ~ResourceManager() {
        cleanup();
    }

    // Delete copy constructor and copy assignment (unique ownership)
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource)
        , m_deleter(std::move(other.m_deleter))
    {
        other.m_resource = nullptr;
    }

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            m_resource = other.m_resource;
            m_deleter = std::move(other.m_deleter);
            other.m_resource = nullptr;
        }
        return *this;
    }

    // Reset with no arguments - early cleanup
    void reset() noexcept {
        cleanup();
    }

    // Reset with new resource and optional new deleter
    void reset(T* resource, DeleterType deleter = DefaultDeleter) {
        cleanup();
        m_resource = resource;
        m_deleter = std::move(deleter);
    }

    // Release ownership without cleanup - caller takes responsibility
    T* release() noexcept {
        T* temp = m_resource;
        m_resource = nullptr;
        return temp;
    }

    // Access the managed resource
    T* get() const noexcept {
        return m_resource;
    }

    // Dereference operators
    T& operator*() const {
        return *m_resource;
    }

    T* operator->() const noexcept {
        return m_resource;
    }

    // Boolean conversion - check if resource is managed
    explicit operator bool() const noexcept {
        return m_resource != nullptr;
    }

    // Swap
    void swap(ResourceManager& other) noexcept {
        using std::swap;
        swap(m_resource, other.m_resource);
        swap(m_deleter, other.m_deleter);
    }

private:
    static void DefaultDeleter(T* ptr) {
        delete ptr;
    }

    void cleanup() noexcept {
        if (m_resource) {
            if (m_deleter) {
                m_deleter(m_resource);
            }
            m_resource = nullptr;
        }
    }

    T* m_resource;
    DeleterType m_deleter;
};

// Non-member swap
template <typename T>
void swap(ResourceManager<T>& lhs, ResourceManager<T>& rhs) noexcept {
    lhs.swap(rhs);
}

// Factory function similar to std::make_unique
template <typename T, typename... Args>
ResourceManager<T> makeResource(Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...));
}


// --- Demo / Usage ---

struct DatabaseConnection {
    std::string connectionString;

    DatabaseConnection(const std::string& connStr) : connectionString(connStr) {
        std::cout << "DatabaseConnection opened: " << connectionString << std::endl;
    }

    ~DatabaseConnection() {
        std::cout << "DatabaseConnection closed: " << connectionString << std::endl;
    }

    void query(const std::string& sql) {
        std::cout << "Executing query on " << connectionString << ": " << sql << std::endl;
    }
};

struct FileHandle {
    FILE* fp;
    std::string filename;

    FileHandle(const std::string& name, const char* mode) : filename(name) {
        fp = fopen(name.c_str(), mode);
        if (fp) {
            std::cout << "File opened: " << filename << std::endl;
        } else {
            std::cout << "Failed to open file: " << filename << std::endl;
        }
    }

    ~FileHandle() {
        if (fp) {
            fclose(fp);
            std::cout << "File closed: " << filename << std::endl;
        }
    }
};

int main() {
    std::cout << "=== Basic RAII usage ===" << std::endl;
    {
        auto db = makeResource<DatabaseConnection>("server=localhost;db=mydb");
        db->query("SELECT * FROM users");
    } // Automatic cleanup here

    std::cout << "\n=== Move semantics ===" << std::endl;
    {
        auto db1 = makeResource<DatabaseConnection>("server=primary");
        std::cout << "db1 valid: " << (db1 ? "yes" : "no") << std::endl;

        ResourceManager<DatabaseConnection> db2 = std::move(db1);
        std::cout << "db1 valid after move: " << (db1 ? "yes" : "no") << std::endl;
        std::cout << "db2 valid: " << (db2 ? "yes" : "no") << std::endl;
        db2->query("SELECT 1");
    }

    std::cout << "\n=== Early cleanup with reset() ===" << std::endl;
    {
        auto db = makeResource<DatabaseConnection>("server=temp");
        db->query("CREATE TEMP TABLE t1");
        std::cout << "Calling reset() for early cleanup..." << std::endl;
        db.reset();
        std::cout << "db valid after reset: " << (db ? "yes" : "no") << std::endl;
        std::cout << "Scope ending, no double-free" << std::endl;
    }

    std::cout << "\n=== Reset with new resource ===" << std::endl;
    {
        auto db = makeResource<DatabaseConnection>("server=first");
        db->query("SELECT 1");
        std::cout << "Resetting with new resource..." << std::endl;
        db.reset(new DatabaseConnection("server=second"));
        db->query("SELECT 2");
    }

    std::cout << "\n=== Custom deleter ===" << std::endl;
    {
        auto customDeleter = [](int* p) {
            std::cout << "Custom deleter called for value: " << *p << std::endl;
            delete p;
        };
        ResourceManager<int> num(new int(42), customDeleter);
        std::cout << "Value: " << *num << std::endl;
    }

    std::cout << "\n=== Release ownership ===" << std::endl;
    {
        auto db = makeResource<DatabaseConnection>("server=released");
        DatabaseConnection* raw = db.release();
        std::cout << "db valid after release: " << (db ? "yes" : "no") << std::endl;
        std::cout << "Manually managing resource now..." << std::endl;
        raw->query("SELECT 1");
        delete raw; // Manual cleanup since we released ownership
    }

    std::cout << "\n=== Swap ===" << std::endl;
    {
        auto r1 = makeResource<DatabaseConnection>("server=A");
        auto r2 = makeResource<DatabaseConnection>("server=B");
        std::cout << "Before swap - r1: " << r1->connectionString << ", r2: " << r2->connectionString << std::endl;
        swap(r1, r2);
        std::cout << "After swap  - r1: " << r1->connectionString << ", r2: " << r2->connectionString << std::endl;
    }

    std::cout << "\nAll resources cleaned up." << std::endl;
    return 0;
}