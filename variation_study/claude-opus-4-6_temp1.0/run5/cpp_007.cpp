# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <string>
#include <algorithm>
#include <ctime>
#include <stdexcept>

class Session {
public:
    Session(const std::string& userId, int timeoutSeconds = 3600)
        : userId_(userId), timeoutSeconds_(timeoutSeconds) {
        creationTime_ = std::time(nullptr);
        lastAccessTime_ = creationTime_;
        sessionId_ = generateSessionId();
    }

    ~Session() {
        std::cout << "Session " << sessionId_ << " for user " << userId_ << " destroyed." << std::endl;
    }

    std::string getSessionId() const { return sessionId_; }
    std::string getUserId() const { return userId_; }

    bool isExpired() const {
        return (std::time(nullptr) - lastAccessTime_) > timeoutSeconds_;
    }

    void touch() {
        lastAccessTime_ = std::time(nullptr);
    }

    std::time_t getCreationTime() const { return creationTime_; }
    std::time_t getLastAccessTime() const { return lastAccessTime_; }
    int getTimeoutSeconds() const { return timeoutSeconds_; }

    void setTimeoutSeconds(int seconds) { timeoutSeconds_ = seconds; }

private:
    std::string generateSessionId() {
        static int counter = 0;
        return "sess_" + userId_ + "_" + std::to_string(++counter) + "_" + std::to_string(creationTime_);
    }

    std::string sessionId_;
    std::string userId_;
    std::time_t creationTime_;
    std::time_t lastAccessTime_;
    int timeoutSeconds_;
};


class SessionManager {
public:
    SessionManager() = default;

    ~SessionManager() {
        removeAllSessions();
    }

    // Prevent copying to avoid double-free issues
    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    // Allow move semantics
    SessionManager(SessionManager&& other) noexcept
        : sessions_(std::move(other.sessions_)) {
        other.sessions_.clear();
    }

    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this != &other) {
            removeAllSessions();
            sessions_ = std::move(other.sessions_);
            other.sessions_.clear();
        }
        return *this;
    }

    Session* createSession(const std::string& userId, int timeoutSeconds = 3600) {
        Session* session = new Session(userId, timeoutSeconds);
        sessions_.push_back(session);
        std::cout << "Session created: " << session->getSessionId()
                  << " for user: " << userId << std::endl;
        return session;
    }

    bool addSession(Session* session) {
        if (session == nullptr) {
            return false;
        }
        // Check for duplicate
        for (const auto* s : sessions_) {
            if (s->getSessionId() == session->getSessionId()) {
                std::cout << "Session " << session->getSessionId() << " already exists." << std::endl;
                return false;
            }
        }
        sessions_.push_back(session);
        return true;
    }

    bool removeSession(const std::string& sessionId) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [&sessionId](const Session* s) {
                return s->getSessionId() == sessionId;
            });

        if (it != sessions_.end()) {
            delete *it;
            sessions_.erase(it);
            return true;
        }
        return false;
    }

    bool removeSessionByUser(const std::string& userId) {
        bool removed = false;
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if ((*it)->getUserId() == userId) {
                delete *it;
                it = sessions_.erase(it);
                removed = true;
            } else {
                ++it;
            }
        }
        return removed;
    }

    void removeAllSessions() {
        for (Session* session : sessions_) {
            delete session;
        }
        sessions_.clear();
        std::cout << "All sessions removed." << std::endl;
    }

    Session* getSession(const std::string& sessionId) {
        for (Session* session : sessions_) {
            if (session->getSessionId() == sessionId) {
                if (session->isExpired()) {
                    std::cout << "Session " << sessionId << " has expired." << std::endl;
                    removeSession(sessionId);
                    return nullptr;
                }
                session->touch();
                return session;
            }
        }
        return nullptr;
    }

    Session* getSessionByIndex(size_t index) {
        if (index >= sessions_.size()) {
            throw std::out_of_range("Session index out of range");
        }
        Session* session = sessions_[index];
        if (session->isExpired()) {
            std::cout << "Session at index " << index << " has expired." << std::endl;
            delete session;
            sessions_.erase(sessions_.begin() + index);
            return nullptr;
        }
        session->touch();
        return session;
    }

    std::vector<Session*> getSessionsByUser(const std::string& userId) {
        std::vector<Session*> result;
        for (Session* session : sessions_) {
            if (session->getUserId() == userId && !session->isExpired()) {
                result.push_back(session);
            }
        }
        return result;
    }

    size_t cleanupExpiredSessions() {
        size_t removedCount = 0;
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if ((*it)->isExpired()) {
                std::cout << "Cleaning up expired session: " << (*it)->getSessionId() << std::endl;
                delete *it;
                it = sessions_.erase(it);
                ++removedCount;
            } else {
                ++it;
            }
        }
        std::cout << "Cleanup complete. Removed " << removedCount << " expired session(s)." << std::endl;
        return removedCount;
    }

    size_t getSessionCount() const {
        return sessions_.size();
    }

    size_t getActiveSessionCount() const {
        size_t count = 0;
        for (const Session* session : sessions_) {
            if (!session->isExpired()) {
                ++count;
            }
        }
        return count;
    }

    void printAllSessions() const {
        std::cout << "=== Session Manager Status ===" << std::endl;
        std::cout << "Total sessions: " << sessions_.size() << std::endl;
        for (size_t i = 0; i < sessions_.size(); ++i) {
            const Session* s = sessions_[i];
            std::cout << "  [" << i << "] ID: " << s->getSessionId()
                      << " | User: " << s->getUserId()
                      << " | Expired: " << (s->isExpired() ? "YES" : "NO")
                      << " | Timeout: " << s->getTimeoutSeconds() << "s"
                      << std::endl;
        }
        std::cout << "===============================" << std::endl;
    }

private:
    std::vector<Session*> sessions_;
};


// Demo / test
int main() {
    SessionManager manager;

    // Create some sessions
    Session* s1 = manager.createSession("alice", 3600);
    Session* s2 = manager.createSession("bob", 3600);
    Session* s3 = manager.createSession("alice", 3600);

    // Create a session that expires immediately for testing
    Session* s4 = manager.createSession("charlie", 0);

    manager.printAllSessions();

    // Access a session
    std::cout << "\nAccessing session by ID..." << std::endl;
    Session* found = manager.getSession(s1->getSessionId());
    if (found) {
        std::cout << "Found session for user: " << found->getUserId() << std::endl;
    }

    // Get sessions by user
    std::cout << "\nAlice's sessions:" << std::endl;
    auto aliceSessions = manager.getSessionsByUser("alice");
    for (const auto* s : aliceSessions) {
        std::cout << "  " << s->getSessionId() << std::endl;
    }

    // Cleanup expired sessions
    std::cout << "\nCleaning up expired sessions..." << std::endl;
    size_t cleaned = manager.cleanupExpiredSessions();

    std::cout << "\nActive sessions: " << manager.getActiveSessionCount() << std::endl;

    // Remove a specific session
    std::cout << "\nRemoving bob's session..." << std::endl;
    manager.removeSessionByUser("bob");

    manager.printAllSessions();

    // Manager destructor will clean up remaining sessions
    std::cout << "\nExiting - SessionManager destructor will clean up..." << std::endl;
    return 0;
}