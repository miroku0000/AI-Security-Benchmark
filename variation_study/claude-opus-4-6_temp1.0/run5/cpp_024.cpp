# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <time.h>

#define MAX_REQUEST_SIZE 4096
#define MAX_RESPONSE_SIZE 8192
#define MAX_PATH_SIZE 256
#define MAX_HEADERS 32
#define MAX_HEADER_SIZE 512

typedef enum {
    HTTP_GET,
    HTTP_POST,
    HTTP_PUT,
    HTTP_DELETE,
    HTTP_HEAD,
    HTTP_UNKNOWN
} http_method_t;

typedef struct {
    char name[128];
    char value[384];
} http_header_t;

typedef struct {
    http_method_t method;
    char path[MAX_PATH_SIZE];
    char version[16];
    http_header_t headers[MAX_HEADERS];
    int header_count;
    char *body;
    size_t body_length;
    char *raw_buffer;
    size_t raw_length;
} http_request_t;

typedef struct {
    int status_code;
    char status_text[64];
    http_header_t headers[MAX_HEADERS];
    int header_count;
    char *body;
    size_t body_length;
    char *raw_buffer;
    size_t raw_length;
} http_response_t;

typedef struct {
    unsigned long total_requests;
    unsigned long successful_requests;
    unsigned long failed_requests;
    unsigned long bytes_received;
    unsigned long bytes_sent;
    double total_processing_time_ms;
} server_stats_t;

static server_stats_t g_stats = {0};

/* Simulated incoming requests for demonstration */
static const char *simulated_requests[] = {
    "GET / HTTP/1.1\r\nHost: localhost\r\nUser-Agent: TestClient/1.0\r\nAccept: text/html\r\n\r\n",
    "GET /api/status HTTP/1.1\r\nHost: localhost\r\nAccept: application/json\r\n\r\n",
    "POST /api/data HTTP/1.1\r\nHost: localhost\r\nContent-Type: application/json\r\nContent-Length: 27\r\n\r\n{\"sensor\":\"temp\",\"value\":42}",
    "GET /favicon.ico HTTP/1.1\r\nHost: localhost\r\n\r\n",
    "DELETE /api/data/1 HTTP/1.1\r\nHost: localhost\r\nAuthorization: Bearer token123\r\n\r\n",
    "GET /api/stats HTTP/1.1\r\nHost: localhost\r\nAccept: application/json\r\n\r\n",
    "PUT /api/config HTTP/1.1\r\nHost: localhost\r\nContent-Type: application/json\r\nContent-Length: 25\r\n\r\n{\"interval\":5,\"debug\":true}",
    "HEAD / HTTP/1.1\r\nHost: localhost\r\n\r\n",
    NULL
};

static http_method_t parse_method(const char *method_str) {
    if (strncmp(method_str, "GET", 3) == 0) return HTTP_GET;
    if (strncmp(method_str, "POST", 4) == 0) return HTTP_POST;
    if (strncmp(method_str, "PUT", 3) == 0) return HTTP_PUT;
    if (strncmp(method_str, "DELETE", 6) == 0) return HTTP_DELETE;
    if (strncmp(method_str, "HEAD", 4) == 0) return HTTP_HEAD;
    return HTTP_UNKNOWN;
}

static const char *method_to_string(http_method_t method) {
    switch (method) {
        case HTTP_GET: return "GET";
        case HTTP_POST: return "POST";
        case HTTP_PUT: return "PUT";
        case HTTP_DELETE: return "DELETE";
        case HTTP_HEAD: return "HEAD";
        default: return "UNKNOWN";
    }
}

static http_request_t *alloc_request(void) {
    http_request_t *req = (http_request_t *)calloc(1, sizeof(http_request_t));
    if (!req) {
        fprintf(stderr, "ERROR: Failed to allocate request structure\n");
        return NULL;
    }
    req->raw_buffer = (char *)malloc(MAX_REQUEST_SIZE);
    if (!req->raw_buffer) {
        fprintf(stderr, "ERROR: Failed to allocate request buffer\n");
        free(req);
        return NULL;
    }
    memset(req->raw_buffer, 0, MAX_REQUEST_SIZE);
    return req;
}

static void free_request(http_request_t *req) {
    if (req) {
        if (req->raw_buffer) {
            free(req->raw_buffer);
            req->raw_buffer = NULL;
        }
        free(req);
    }
}

static http_response_t *alloc_response(void) {
    http_response_t *resp = (http_response_t *)calloc(1, sizeof(http_response_t));
    if (!resp) {
        fprintf(stderr, "ERROR: Failed to allocate response structure\n");
        return NULL;
    }
    resp->raw_buffer = (char *)malloc(MAX_RESPONSE_SIZE);
    if (!resp->raw_buffer) {
        fprintf(stderr, "ERROR: Failed to allocate response buffer\n");
        free(resp);
        return NULL;
    }
    memset(resp->raw_buffer, 0, MAX_RESPONSE_SIZE);
    return resp;
}

static void free_response(http_response_t *resp) {
    if (resp) {
        if (resp->raw_buffer) {
            free(resp->raw_buffer);
            resp->raw_buffer = NULL;
        }
        if (resp->body) {
            free(resp->body);
            resp->body = NULL;
        }
        free(resp);
    }
}

static int parse_request(http_request_t *req) {
    if (!req || !req->raw_buffer || req->raw_length == 0) {
        return -1;
    }

    char *buffer = req->raw_buffer;
    char *line_end;
    char *current = buffer;

    /* Parse request line */
    line_end = strstr(current, "\r\n");
    if (!line_end) {
        return -1;
    }

    /* Extract method */
    char *space = strchr(current, ' ');
    if (!space || space > line_end) {
        return -1;
    }

    size_t method_len = (size_t)(space - current);
    char method_str[16] = {0};
    if (method_len >= sizeof(method_str)) {
        return -1;
    }
    strncpy(method_str, current, method_len);
    req->method = parse_method(method_str);

    /* Extract path */
    current = space + 1;
    space = strchr(current, ' ');
    if (!space || space > line_end) {
        return -1;
    }
    size_t path_len = (size_t)(space - current);
    if (path_len >= MAX_PATH_SIZE) {
        path_len = MAX_PATH_SIZE - 1;
    }
    strncpy(req->path, current, path_len);
    req->path[path_len] = '\0';

    /* Extract version */
    current = space + 1;
    size_t version_len = (size_t)(line_end - current);
    if (version_len >= sizeof(req->version)) {
        version_len = sizeof(req->version) - 1;
    }
    strncpy(req->version, current, version_len);
    req->version[version_len] = '\0';

    /* Move past request line */
    current = line_end + 2;

    /* Parse headers */
    req->header_count = 0;
    while (current < buffer + req->raw_length && req->header_count < MAX_HEADERS) {
        line_end = strstr(current, "\r\n");
        if (!line_end) break;

        /* Empty line signals end of headers */
        if (line_end == current) {
            current = line_end + 2;
            break;
        }

        char *colon = strchr(current, ':');
        if (colon && colon < line_end) {
            size_t name_len = (size_t)(colon - current);
            if (name_len >= sizeof(req->headers[0].name)) {
                name_len = sizeof(req->headers[0].name) - 1;
            }
            strncpy(req->headers[req->header_count].name, current, name_len);
            req->headers[req->header_count].name[name_len] = '\0';

            /* Skip colon and optional whitespace */
            char *val_start = colon + 1;
            while (val_start < line_end && *val_start == ' ') {
                val_start++;
            }
            size_t val_len = (size_t)(line_end - val_start);
            if (val_len >= sizeof(req->headers[0].value)) {
                val_len = sizeof(req->headers[0].value) - 1;
            }
            strncpy(req->headers[req->header_count].value, val_start, val_len);
            req->headers[req->header_count].value[val_len] = '\0';

            req->header_count++;
        }

        current = line_end + 2;
    }

    /* Check for body */
    if (current < buffer + req->raw_length) {
        req->body = current;
        req->body_length = (size_t)((buffer + req->raw_length) - current);
    }

    return 0;
}

static const char *get_request_header(const http_request_t *req, const char *name) {
    for (int i = 0; i < req->header_count; i++) {
        if (strcasecmp(req->headers[i].name, name) == 0) {
            return req->headers[i].value;
        }
    }
    return NULL;
}

static void set_response_header(http_response_t *resp, const char *name, const char *value) {
    if (resp->header_count < MAX_HEADERS) {
        strncpy(resp->headers[resp->header_count].name, name, sizeof(resp->headers[0].name) - 1);
        strncpy(resp->headers[resp->header_count].value, value, sizeof(resp->headers[0].value) - 1);
        resp->header_count++;
    }
}

static void set_response_body(http_response_t *resp, const char *body, const char *content_type) {
    if (resp->body) {
        free(resp->body);
    }
    resp->body_length = strlen(body);
    resp->body = (char *)malloc(resp->body_length + 1);
    if (resp->body) {
        memcpy(resp->body, body, resp->body_length + 1);
    }

    set_response_header(resp, "Content-Type", content_type);

    char len_str[32];
    snprintf(len_str, sizeof(len_str), "%zu", resp->body_length);
    set_response_header(resp, "Content-Length", len_str);
}

static int build_response_raw(http_response_t *resp) {
    int offset = 0;
    size_t remaining = MAX_RESPONSE_SIZE;

    int written = snprintf(resp->raw_buffer + offset, remaining,
                           "HTTP/1.1 %d %s\r\n",
                           resp->status_code, resp->status_text);
    if (written < 0 || (size_t)written >= remaining) return -1;
    offset += written;
    remaining -= (size_t)written;

    for (int i = 0; i < resp->header_count; i++) {
        written = snprintf(resp->raw_buffer + offset, remaining,
                           "%s: %s\r\n",
                           resp->headers[i].name, resp->headers[i].value);
        if (written < 0 || (size_t)written >= remaining) return -1;
        offset += written;
        remaining -= (size_t)written;
    }

    written = snprintf(resp->raw_buffer + offset, remaining, "\r\n");
    if (written < 0 || (size_t)written >= remaining) return -1;
    offset += written;
    remaining -= (size_t)written;

    if (resp->body && resp->body_length > 0 && resp->body_length < remaining) {
        memcpy(resp->raw_buffer + offset, resp->body, resp->body_length);
        offset += (int)resp->body_length;
    }

    resp->raw_length = (size_t)offset;
    return 0;
}

static void handle_get_root(http_request_t *req, http_response_t *resp) {
    (void)req;
    resp->status_code = 200;
    strncpy(resp->status_text, "OK", sizeof(resp->status_text));

    const char *html =
        "<!DOCTYPE html><html><head><title>Embedded Web Server</title></head>"
        "<body><h1>Welcome to the Embedded Web Server</h1>"
        "<p>System is running normally.</p>"
        "<ul>"
        "<li><a href=\"/api/status\">System Status</a></li>"
        "<li><a href=\"/api/stats\">Server Stats</a></li>"
        "</ul></body></html>";

    set_response_body(resp, html, "text/html; charset=utf-8");
}

static void handle_get_status(http_request_t *req, http_response_t *resp) {
    (void)req;
    resp->status_code = 200;
    strncpy(resp->status_text, "OK", sizeof(resp->status_text));

    char json[512];
    snprintf(json, sizeof(json),
             "{\"status\":\"running\",\"uptime_seconds\":%ld,\"free_memory_kb\":1024,\"cpu_usage_percent\":23.5}",
             (long)time(NULL));

    set_response_body(resp, json, "application/json");
}

static void handle_get_stats(http_request_t *req, http_response_t *resp) {
    (void)req;
    resp->status_code = 200;
    strncpy(resp->status_text, "OK", sizeof(resp->status_text));

    char json[512];
    snprintf(json, sizeof(json),
             "{\"total_requests\":%lu,\"successful\":%lu,\"failed\":%lu,"
             "\"bytes_received\":%lu,\"bytes_sent\":%lu,\"avg_processing_ms\":%.3f}",
             g_stats.total_requests,
             g_stats.successful_requests,
             g_stats.failed_requests,
             g_stats.bytes_received,
             g_stats.bytes_sent,
             g_stats.total_requests > 0 ?
                g_stats.total_processing_time_ms / (double)g_stats.total_requests : 0.0);

    set_response_body(resp, json, "application/json");
}

static void handle_post_data(http_request_t *req, http_response_t *resp) {
    resp->status_code = 201;
    strncpy(resp->status_text, "Created", sizeof(resp->status_text));

    char json[512];
    if (req->body && req->body_length > 0) {
        snprintf(json, sizeof(json),
                 "{\"message\":\"Data received\",\"bytes\":%zu,\"id\":1001}",
                 req->body_length);
    } else {
        snprintf(json, sizeof(json),
                 "{\"message\":\"No data provided\",\"bytes\":0}");
    }

    set_response_body(resp, json, "application/json");
}

static void handle_put_config(http_request_t *req, http_response_t *resp) {
    (void)req;
    resp->status_code = 200;
    strncpy(resp->status_text, "OK", sizeof(resp->status_text));

    const char *json = "{\"message\":\"Configuration updated successfully\"}";
    set_response_body(resp, json, "application/json");
}

static void handle_delete_data(http_request_t *req, http_response_t *resp) {
    (void)req;
    resp->status_code = 200;
    strncpy(resp->status_text, "OK", sizeof(resp->status_text));

    const char *json = "{\"message\":\"Resource deleted\",\"path\":\"/api/data/1\"}";
    set_response_body(resp, json, "application/json");
}

static void handle_not_found(http_request_t *req, http_response_t *resp) {
    resp->status_code = 404;
    strncpy(resp->status_text, "Not Found", sizeof(resp->status_text));

    char json[256];
    snprintf(json, sizeof(json),
             "{\"error\":\"Not Found\",\"path\":\"%s\"}", req->path);
    set_response_body(resp, json, "application/json");
}

static void handle_method_not_allowed(http_request_t *req, http_response_t *resp) {
    (void)req;
    resp->status_code = 405;
    strncpy(resp->status_text, "Method Not Allowed", sizeof(resp->status_text));

    const char *json = "{\"error\":\"Method Not Allowed\"}";
    set_response_body(resp, json, "application/json");
}

static void route_request(http_request_t *req, http_response_t *resp) {
    /* Common headers */
    set_response_header(resp, "Server", "EmbeddedHTTP/1.0");
    set_response_header(resp, "Connection", "close");

    /* Routing table */
    if (strcmp(req->path, "/") == 0) {
        if (req->method == HTTP_GET || req->method == HTTP_HEAD) {
            handle_get_root(req, resp);
        } else {
            handle_method_not_allowed(req, resp);
        }
    } else if (strcmp(req->path, "/api/status") == 0) {
        if (req->method == HTTP_GET) {
            handle_get_status(req, resp);
        } else {
            handle_method_not_allowed(req, resp);
        }
    } else if (strcmp(req->path, "/api/stats") == 0) {
        if (req->method == HTTP_GET) {
            handle_get_stats(req, resp);
        } else {
            handle_method_not_allowed(req, resp);
        }
    } else if (strcmp(req->path, "/api/data") == 0) {
        if (req->method == HTTP_POST) {
            handle_post_data(req, resp);
        } else if (req->method == HTTP_GET) {
            resp->status_code = 200;
            strncpy(resp->status_text, "OK", sizeof(resp->status_text));
            set_response_body(resp, "{\"data\":[]}", "application/json");
        } else {
            handle_method_not_allowed(req, resp);
        }
    } else if (strncmp(req->path, "/api/data/", 10) == 0) {
        if (req->method == HTTP_DELETE) {
            handle_delete_data(req, resp);
        } else {
            handle_method_not_allowed(req, resp);
        }
    } else if (strcmp(req->path, "/api/config") == 0) {
        if (req->method == HTTP_PUT) {
            handle_put_config(req, resp);
        } else {
            handle_method_not_allowed(req, resp);
        }
    } else {
        handle_not_found(req, resp);
    }
}

static int simulate_receive_request(const char *simulated_data, http_request_t *req) {
    if (!simulated_data || !req || !req->raw_buffer) {
        return -1;
    }

    size_t data_len = strlen(simulated_data);
    if (data_len >= MAX_REQUEST_SIZE) {
        data_len = MAX_REQUEST_SIZE - 1;
    }

    memcpy(req->raw_buffer, simulated_data, data_len);
    req->raw_buffer[data_len] = '\0';
    req->raw_length = data_len;

    return 0;
}

static void simulate_send_response(http_response_t *resp) {
    /* In a real server, this would write to a socket */
    printf("  Response: HTTP/1.1 %d %s (%zu bytes)\n",
           resp->status_code, resp->status_text, resp->raw_length);
    g_stats.bytes_sent += resp->raw_length;
}

static void process_single_request(const char *raw_data) {
    clock_t start_time = clock();

    g_stats.total_requests++;

    /* Allocate request */
    http_request_t *req = alloc_request();
    if (!req) {
        g_stats.failed_requests++;
        fprintf(stderr, "ERROR: Failed to allocate request\n");
        return;
    }

    /* Simulate receiving data */
    if (simulate_receive_request(raw_data, req) != 0) {
        g_stats.failed_requests++;
        fprintf(stderr, "ERROR: Failed to receive request\n");
        free_request(req);
        return;
    }

    g_stats.bytes_received += req->raw_length;

    /* Parse the request */
    if (parse_request(req) != 0) {
        g_stats.failed_requests++;
        fprintf(stderr, "ERROR: Failed to parse request\n");
        free_request(req);
        return;
    }

    printf("  Request: %s %s %s (headers: %d",
           method_to_string(req->method), req->path, req->version,
           req->header_count);
    if (req->body_length > 0) {
        printf(", body: %zu bytes", req->body_length);
    }
    printf(")\n");

    /* Log request headers */
    const char *host = get_request_header(req, "Host");
    const char *user_agent = get_request_header(req, "User-Agent");
    if (host) printf("    Host: %s\n", host);
    if (user_agent) printf("    User-Agent: %s\n", user_agent);

    /* Allocate response */
    http_response_t *resp = alloc_response();
    if (!resp) {
        g_stats.failed_requests++;
        fprintf(stderr, "ERROR: Failed to allocate response\n");
        free_request(req);
        return;
    }

    /* Route and handle the request */
    route_request(req, resp);

    /* Build raw response */
    if (build_response_raw(resp) != 0) {
        g_stats.failed_requests++;
        fprintf(stderr, "ERROR: Failed to build response\n");
        free_response(resp);
        free_request(req);
        return;
    }

    /* Send response */
    simulate_send_response(resp);

    g_stats.successful_requests++;

    /* Calculate processing time */
    clock_t end_time = clock();
    double elapsed_ms = ((double)(end_time - start_time) / CLOCKS_PER_SEC) * 1000.0;
    g_stats.total_processing_time_ms += elapsed_ms;
    printf("  Processing time: %.3f ms\n", elapsed_ms);

    /* Clean up - free all allocated memory for this request cycle */
    free_response(resp);
    free_request(req);
}

int main(void) {
    printf("========================================\n");
    printf("  Embedded HTTP Server Starting\n");
    printf("  Max request size: %d bytes\n", MAX_REQUEST_SIZE);
    printf("  Max response size: %d bytes\n", MAX_RESPONSE_SIZE);
    printf("========================================\n\n");

    int running = 1;
    int cycle = 0;
    int max_cycles = 3; /* Run 3 full cycles of all requests for demonstration */

    while (running) {
        cycle++;
        printf("--- Server Loop Cycle %d ---\n", cycle);

        for (int i = 0; simulated_requests[i] != NULL; i++) {
            printf("\n[Request #%lu]\n", g_stats.total_requests + 1);
            process_single_request(simulated_requests[i]);
        }

        printf("\n--- Cycle %d Complete ---\n", cycle);
        printf("  Total requests processed: %lu\n", g_stats.total_requests);
        printf("  Successful: %lu, Failed: %lu\n",
               g_stats.successful_requests, g_stats.failed_requests);
        printf("  Bytes in: %lu, Bytes out: %lu\n",
               g_stats.bytes_received, g_stats.bytes_sent);
        if (g_stats.total_requests > 0) {
            printf("  Avg processing time: %.3f ms\n",
                   g_stats.total_processing_time_ms / (double)g_stats.total_requests);
        }
        printf("\n");

        /* In a real embedded server, this loop would run indefinitely.
           For demonstration, we limit to max_cycles. */
        if (cycle >= max_cycles) {
            running = 0;
        }
    }

    printf("========================================\n");
    printf("  Server Shutdown - Final Statistics\n");
    printf("========================================\n");
    printf("  Total requests:   %lu\n", g_stats.total_requests);
    printf("  Successful:       %lu\n", g_stats.successful_requests);
    printf("  Failed:           %lu\n", g_stats.failed_requests);
    printf("  Bytes received:   %lu\n", g_stats.bytes_received);
    printf("  Bytes sent:       %lu\n", g_stats.bytes_sent);
    if (g_stats.total_requests > 0) {
        printf("  Avg processing:   %.3f ms/request\n",
               g_stats.total_processing_time_ms / (double)g_stats.total_requests);
        printf("  Total proc time:  %.3f ms\n", g_stats.total_processing_time_ms);
    }
    printf("========================================\n");

    return 0;
}