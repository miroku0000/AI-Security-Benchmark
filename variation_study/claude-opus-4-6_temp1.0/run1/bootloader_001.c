# Generated by anthropic (claude-opus-4-6)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

/* ============================================================================
 * ARM Cortex-M Bootloader
 * Supports: SD Card, UART firmware update, GPIO/magic word entry
 * Target: Generic Cortex-M (STM32-like register layout)
 * ============================================================================ */

/* --- Memory Map Configuration --- */
#define BOOTLOADER_BASE         0x08000000
#define BOOTLOADER_SIZE         0x8000          /* 32KB bootloader region */
#define APP_BASE                0x08008000      /* Application start */
#define APP_MAX_SIZE            0x78000         /* 480KB max application */
#define FLASH_PAGE_SIZE         2048
#define SRAM_BASE               0x20000000
#define SRAM_SIZE               0x20000         /* 128KB SRAM */

/* --- Magic Values --- */
#define BOOTLOADER_MAGIC_ADDR   (SRAM_BASE + SRAM_SIZE - 4)
#define BOOTLOADER_MAGIC_VALUE  0xDEADBEEF
#define FIRMWARE_HEADER_MAGIC   0x464D5750      /* "FWMP" */

/* --- Peripheral Base Addresses (STM32-like) --- */
#define RCC_BASE                0x40021000
#define GPIOA_BASE              0x48000000
#define GPIOB_BASE              0x48000400
#define GPIOC_BASE              0x48000800
#define USART1_BASE             0x40013800
#define FLASH_R_BASE            0x40022000
#define SPI1_BASE               0x40013000
#define SYSTICK_BASE            0xE000E010
#define SCB_BASE                0xE000ED00
#define NVIC_BASE               0xE000E100

/* --- RCC Registers --- */
#define RCC_CR                  (*(volatile uint32_t *)(RCC_BASE + 0x00))
#define RCC_CFGR               (*(volatile uint32_t *)(RCC_BASE + 0x08))
#define RCC_AHB2ENR            (*(volatile uint32_t *)(RCC_BASE + 0x4C))
#define RCC_APB1ENR            (*(volatile uint32_t *)(RCC_BASE + 0x58))
#define RCC_APB2ENR            (*(volatile uint32_t *)(RCC_BASE + 0x60))

/* --- GPIO Registers --- */
typedef struct {
    volatile uint32_t MODER;
    volatile uint32_t OTYPER;
    volatile uint32_t OSPEEDR;
    volatile uint32_t PUPDR;
    volatile uint32_t IDR;
    volatile uint32_t ODR;
    volatile uint32_t BSRR;
    volatile uint32_t LCKR;
    volatile uint32_t AFR[2];
} GPIO_TypeDef;

#define GPIOA   ((GPIO_TypeDef *)GPIOA_BASE)
#define GPIOB   ((GPIO_TypeDef *)GPIOB_BASE)
#define GPIOC   ((GPIO_TypeDef *)GPIOC_BASE)

/* --- USART Registers --- */
typedef struct {
    volatile uint32_t CR1;
    volatile uint32_t CR2;
    volatile uint32_t CR3;
    volatile uint32_t BRR;
    volatile uint32_t GTPR;
    volatile uint32_t RTOR;
    volatile uint32_t RQR;
    volatile uint32_t ISR;
    volatile uint32_t ICR;
    volatile uint32_t RDR;
    volatile uint32_t TDR;
} USART_TypeDef;

#define USART1  ((USART_TypeDef *)USART1_BASE)

/* USART flags */
#define USART_ISR_RXNE          (1 << 5)
#define USART_ISR_TXE           (1 << 7)
#define USART_ISR_TC            (1 << 6)
#define USART_CR1_UE            (1 << 0)
#define USART_CR1_TE            (1 << 3)
#define USART_CR1_RE            (1 << 2)

/* --- Flash Registers --- */
#define FLASH_ACR               (*(volatile uint32_t *)(FLASH_R_BASE + 0x00))
#define FLASH_KEYR              (*(volatile uint32_t *)(FLASH_R_BASE + 0x08))
#define FLASH_SR                (*(volatile uint32_t *)(FLASH_R_BASE + 0x10))
#define FLASH_CR                (*(volatile uint32_t *)(FLASH_R_BASE + 0x14))

#define FLASH_KEY1              0x45670123
#define FLASH_KEY2              0xCDEF89AB
#define FLASH_SR_BSY            (1 << 16)
#define FLASH_SR_EOP            (1 << 0)
#define FLASH_CR_PG             (1 << 0)
#define FLASH_CR_PER            (1 << 1)
#define FLASH_CR_STRT           (1 << 16)
#define FLASH_CR_LOCK           (1 << 31)
#define FLASH_CR_PNB_SHIFT      3

/* --- SysTick --- */
#define SYSTICK_CTRL            (*(volatile uint32_t *)(SYSTICK_BASE + 0x00))
#define SYSTICK_LOAD            (*(volatile uint32_t *)(SYSTICK_BASE + 0x04))
#define SYSTICK_VAL             (*(volatile uint32_t *)(SYSTICK_BASE + 0x08))

/* --- SCB --- */
#define SCB_VTOR                (*(volatile uint32_t *)(SCB_BASE + 0x08))
#define SCB_AIRCR               (*(volatile uint32_t *)(SCB_BASE + 0x0C))

/* --- Bootloader GPIO Pin (PC13 - typical user button) --- */
#define BOOT_GPIO_PORT          GPIOC
#define BOOT_GPIO_PIN           13
#define BOOT_GPIO_RCC_BIT       2   /* GPIOC enable bit in AHB2ENR */

/* --- LED GPIO (PA5 - typical onboard LED) --- */
#define LED_GPIO_PORT           GPIOA
#define LED_GPIO_PIN            5
#define LED_GPIO_RCC_BIT        0

/* --- SD Card SPI (SPI1: PA5=SCK, PA6=MISO, PA7=MOSI, PA4=CS) --- */
#define SD_CS_PORT              GPIOA
#define SD_CS_PIN               4
#define SPI1_REG                ((volatile uint32_t *)SPI1_BASE)

/* --- XMODEM Protocol Constants --- */
#define XMODEM_SOH              0x01
#define XMODEM_STX              0x02
#define XMODEM_EOT              0x04
#define XMODEM_ACK              0x06
#define XMODEM_NAK              0x15
#define XMODEM_CAN              0x18
#define XMODEM_BLOCK_SIZE       128
#define XMODEM_1K_BLOCK_SIZE    1024
#define XMODEM_TIMEOUT_MS       3000
#define XMODEM_MAX_RETRIES      10

/* --- Firmware Header Structure --- */
typedef struct {
    uint32_t magic;             /* FIRMWARE_HEADER_MAGIC */
    uint32_t version;           /* Firmware version */
    uint32_t size;              /* Firmware binary size (excluding header) */
    uint32_t crc32;             /* CRC32 of firmware binary */
    uint32_t entry_point;       /* Entry point address */
    uint8_t  reserved[12];      /* Reserved for future use */
} __attribute__((packed)) firmware_header_t;

/* --- SD Card Definitions --- */
#define SD_CMD0     0
#define SD_CMD1     1
#define SD_CMD8     8
#define SD_CMD12    12
#define SD_CMD16    16
#define SD_CMD17    17
#define SD_CMD55    55
#define SD_ACMD41   41
#define SD_CMD58    58

#define SD_BLOCK_SIZE   512

#define SD_FIRMWARE_FILE    "FIRMWARE.BIN"

/* --- Global Variables --- */
static volatile uint32_t systick_ms = 0;
static uint8_t rx_buffer[1024 + 16]; /* Buffer for XMODEM blocks */
static uint8_t flash_buffer[FLASH_PAGE_SIZE];
static bool sd_high_capacity = false;

/* --- Forward Declarations --- */
static void system_init(void);
static void gpio_init(void);
static void uart_init(uint32_t baudrate);
static void systick_init(void);
static void flash_unlock(void);
static void flash_lock(void);
static bool flash_erase_page(uint32_t page_addr);
static bool flash_write_dword(uint32_t addr, uint64_t data);
static bool flash_program(uint32_t dest_addr, const uint8_t *data, uint32_t len);
static uint32_t crc32_compute(const uint8_t *data, uint32_t len);
static bool check_bootloader_entry(void);
static bool validate_application(void);
static void jump_to_application(void);
static void uart_send_byte(uint8_t b);
static void uart_send_string(const char *s);
static int uart_recv_byte(uint32_t timeout_ms);
static bool uart_firmware_update(void);
static void led_on(void);
static void led_off(void);
static void led_toggle(void);
static void delay_ms(uint32_t ms);

/* SD Card functions */
static void spi_init(void);
static uint8_t spi_transfer(uint8_t data);
static void sd_cs_high(void);
static void sd_cs_low(void);
static bool sd_init(void);
static uint8_t sd_send_cmd(uint8_t cmd, uint32_t arg);
static bool sd_read_block(uint32_t block_addr, uint8_t *buf);
static bool sd_firmware_update(void);

/* FAT32 minimal support */
typedef struct {
    uint32_t fat_start_sector;
    uint32_t data_start_sector;
    uint32_t root_dir_cluster;
    uint32_t sectors_per_cluster;
    uint32_t sectors_per_fat;
    uint32_t reserved_sectors;
    uint8_t  num_fats;
} fat32_info_t;

static fat32_info_t fat_info;
static bool fat32_init(void);
static bool fat32_find_file(const char *name, uint32_t *start_cluster, uint32_t *file_size);
static uint32_t fat32_get_next_cluster(uint32_t cluster);
static uint32_t fat32_cluster_to_sector(uint32_t cluster);

/* ============================================================================
 * SysTick Handler
 * ============================================================================ */
void SysTick_Handler(void)
{
    systick_ms++;
}

/* ============================================================================
 * System Initialization
 * ============================================================================ */
static void system_init(void)
{
    /* Enable HSI (should already be on at reset) */
    RCC_CR |= (1 << 8); /* HSION */
    while (!(RCC_CR & (1 << 10))); /* Wait for HSIRDY */

    /* Set flash latency for higher clock if needed */
    FLASH_ACR = (FLASH_ACR & ~0x07) | 0x02; /* 2 wait states */

    /* Enable GPIO clocks */
    RCC_AHB2ENR |= (1 << 0) | (1 << 1) | (1 << 2); /* GPIOA, GPIOB, GPIOC */

    /* Enable USART1 clock */
    RCC_APB2ENR |= (1 << 14); /* USART1EN */

    /* Enable SPI1 clock */
    RCC_APB2ENR |= (1 << 12); /* SPI1EN */
}

static void gpio_init(void)
{
    /* Configure boot pin (PC13) as input with pull-up */
    BOOT_GPIO_PORT->MODER &= ~(3 << (BOOT_GPIO_PIN * 2));   /* Input mode */
    BOOT_GPIO_PORT->PUPDR &= ~(3 << (BOOT_GPIO_PIN * 2));
    BOOT_GPIO_PORT->PUPDR |= (1 << (BOOT_GPIO_PIN * 2));     /* Pull-up */

    /* Configure LED pin (PA5) as output */
    LED_GPIO_PORT->MODER &= ~(3 << (LED_GPIO_PIN * 2));
    LED_GPIO_PORT->MODER |= (1 << (LED_GPIO_PIN * 2));       /* Output mode */
    LED_GPIO_PORT->OSPEEDR |= (3 << (LED_GPIO_PIN * 2));     /* High speed */
}

static void uart_init(uint32_t baudrate)
{
    /* Configure PA9 (TX) and PA10 (RX) for USART1 AF7 */
    GPIOA->MODER &= ~((3 << (9 * 2)) | (3 << (10 * 2)));
    GPIOA->MODER |= (2 << (9 * 2)) | (2 << (10 * 2));      /* AF mode */
    GPIOA->AFR[1] &= ~((0xF << ((9 - 8) * 4)) | (0xF << ((10 - 8) * 4)));
    GPIOA->AFR[1] |= (7 << ((9 - 8) * 4)) | (7 << ((10 - 8) * 4)); /* AF7 */
    GPIOA->OSPEEDR |= (3 << (9 * 2)) | (3 << (10 * 2));

    /* Configure USART1: 8N1 */
    USART1->CR1 = 0;
    USART1->CR2 = 0;
    USART1->CR3 = 0;

    /* Assuming 16MHz HSI clock */
    USART1->BRR = 16000000 / baudrate;

    /* Enable USART, TX and RX */
    USART1->CR1 = USART_CR1_UE | USART_CR1_TE | USART_CR1_RE;
}

static void systick_init(void)
{
    /* 16MHz / 1000 = 16000 ticks per ms */
    SYSTICK_LOAD = 16000 - 1;
    SYSTICK_VAL = 0;
    SYSTICK_CTRL = 0x07; /* Enable, interrupt, processor clock */
}

/* ============================================================================
 * LED Control
 * ============================================================================ */
static void led_on(void)
{
    LED_GPIO_PORT->BSRR = (1 << LED_GPIO_PIN);
}

static void led_off(void)
{
    LED_GPIO_PORT->BSRR = (1 << (LED_GPIO_PIN + 16));
}

static void led_toggle(void)
{
    LED_GPIO_PORT->ODR ^= (1 << LED_GPIO_PIN);
}

static void delay_ms(uint32_t ms)
{
    uint32_t start = systick_ms;
    while ((systick_ms - start) < ms);
}

/* ============================================================================
 * UART Communication
 * ============================================================================ */
static void uart_send_byte(uint8_t b)
{
    while (!(USART1->ISR & USART_ISR_TXE));
    USART1->TDR = b;
}

static void uart_send_string(const char *s)
{
    while (*s) {
        uart_send_byte((uint8_t)*s++);
    }
}

static int uart_recv_byte(uint32_t timeout_ms)
{
    uint32_t start = systick_ms;
    while (!(USART1->ISR & USART_ISR_RXNE)) {
        if ((systick_ms - start) >= timeout_ms) {
            return -1; /* Timeout */
        }
    }
    return (int)(USART1->RDR & 0xFF);
}

/* ============================================================================
 * Flash Operations
 * ============================================================================ */
static void flash_unlock(void)
{
    if (FLASH_CR & FLASH_CR_LOCK) {
        FLASH_KEYR = FLASH_KEY1;
        FLASH_KEYR = FLASH_KEY2;
    }
}

static void flash_lock(void)
{
    FLASH_CR |= FLASH_CR_LOCK;
}

static void flash_wait_busy(void)
{
    while (FLASH_SR & FLASH_SR_BSY);
}

static bool flash_erase_page(uint32_t page_addr)
{
    uint32_t page_num = (page_addr - BOOTLOADER_BASE) / FLASH_PAGE_SIZE;

    flash_wait_busy();

    /* Clear any previous errors */
    FLASH_SR = 0xFFFF;

    /* Set page erase */
    FLASH_CR = FLASH_CR_PER | (page_num << FLASH_CR_PNB_SHIFT);
    FLASH_CR |= FLASH_CR_STRT;

    flash_wait_busy();

    /* Clear PER bit */
    FLASH_CR &= ~FLASH_CR_PER;

    return (FLASH_SR & FLASH_SR_EOP) ? true : false;
}

static bool flash_write_dword(uint32_t addr, uint64_t data)
{
    flash_wait_busy();

    FLASH_CR |= FLASH_CR_PG;

    /* Write double-word (64-bit) - required for STM32L4 */
    *(volatile uint32_t *)addr = (uint32_t)data;
    *(volatile uint32_t *)(addr + 4) = (uint32_t)(data >> 32);

    flash_wait_busy();

    FLASH_CR &= ~FLASH_CR_PG;

    /* Verify */
    if (*(volatile uint32_t *)addr != (uint32_t)data) return false;
    if (*(volatile uint32_t *)(addr + 4) != (uint32_t)(data >> 32)) return false;

    return true;
}

static bool flash_program(uint32_t dest_addr, const uint8_t *data, uint32_t len)
{
    uint32_t addr = dest_addr;
    uint32_t remaining = len;
    uint32_t page_start;

    flash_unlock();

    /* Erase required pages */
    page_start = dest_addr & ~(FLASH_PAGE_SIZE - 1);
    while (page_start < (dest_addr + len)) {
        if (!flash_erase_page(page_start)) {
            flash_lock();
            return false;
        }
        page_start += FLASH_PAGE_SIZE;
    }

    /* Program double-words */
    while (remaining >= 8) {
        uint64_t dword;
        memcpy(&dword, data, 8);
        if (!flash_write_dword(addr, dword)) {
            flash_lock();
            return false;
        }
        addr += 8;
        data += 8;
        remaining -= 8;
    }

    /* Handle remaining bytes (pad with 0xFF) */
    if (remaining > 0) {
        uint64_t dword = 0xFFFFFFFFFFFFFFFFULL;
        memcpy(&dword, data, remaining);
        if (!flash_write_dword(addr, dword)) {
            flash_lock();
            return false;
        }
    }

    flash_lock();
    return true;
}

/* ============================================================================
 * CRC32 (Standard polynomial 0xEDB88320)
 * ============================================================================ */
static uint32_t crc32_compute(const uint8_t *data, uint32_t len)
{
    uint32_t crc = 0xFFFFFFFF;
    for (uint32_t i = 0; i < len; i++) {
        crc ^= data[i];
        for (int j = 0; j < 8; j++) {
            if (crc & 1)
                crc = (crc >> 1) ^ 0xEDB88320;
            else
                crc >>= 1;
        }
    }
    return ~crc;
}

/* ============================================================================
 * CRC32 over flash region (streaming - avoids large buffer)
 * ============================================================================ */
static uint32_t crc32_flash(uint32_t addr, uint32_t len)
{
    uint32_t crc = 0xFFFFFFFF;
    const uint8_t *p = (const uint8_t *)addr;
    for (uint32_t i = 0; i < len; i++) {
        crc ^= p[i];
        for (int j = 0; j < 8; j++) {
            if (crc & 1)
                crc = (crc >> 1) ^ 0xEDB88320;
            else
                crc >>= 1;
        }
    }
    return ~crc;
}

/* ============================================================================
 * Bootloader Entry Check
 * ============================================================================ */
static bool check_bootloader_entry(void)
{
    /* Check 1: Magic value in SRAM (set by application before reset) */
    volatile uint32_t *magic = (volatile uint32_t *)BOOTLOADER_MAGIC_ADDR;
    if (*magic == BOOTLOADER_MAGIC_VALUE) {
        *magic = 0; /* Clear it */
        uart_send_string("[BL] Entry via magic word\r\n");
        return true;
    }

    /* Check 2: GPIO pin held low (button pressed) */
    /* Small debounce delay */
    delay_ms(50);
    if (!(BOOT_GPIO_PORT->IDR & (1 << BOOT_GPIO_PIN))) {
        /* Confirm with second read */
        delay_ms(50);
        if (!(BOOT_GPIO_PORT->IDR & (1 << BOOT_GPIO_PIN))) {
            uart_send_string("[BL] Entry via GPIO button\r\n");
            return true;
        }
    }

    /* Check 3: No valid application present */
    if (!validate_application()) {
        uart_send_string("[BL] No valid application found\r\n");
        return true;
    }

    return false;
}

/* ============================================================================
 * Application Validation
 * ============================================================================ */
static bool validate_application(void)
{
    uint32_t sp = *(volatile uint32_t *)APP_BASE;
    uint32_t pc = *(volatile uint32_t *)(APP_BASE + 4);

    /* Check if stack pointer is in valid SRAM range */
    if (sp < SRAM_BASE || sp > (SRAM_BASE + SRAM_SIZE)) {
        return false;
    }

    /* Check if reset vector is in valid flash range */
    if (pc < APP_BASE || pc > (APP_BASE + APP_MAX_SIZE)) {
        return false;
    }

    /* Check for erased flash (all 0xFF) */
    if (sp == 0xFFFFFFFF || pc == 0xFFFFFFFF) {
        return false;
    }

    return true;
}

/* ============================================================================
 * Jump to Application
 * ============================================================================ */
static void jump_to_application(void)
{
    typedef void (*app_entry_t)(void);

    uint32_t app_sp = *(volatile uint32_t *)APP_BASE;
    uint32_t app_pc = *(volatile uint32_t *)(APP_BASE + 4);

    uart_send_string("[BL] Jumping to application...\r\n");
    delay_ms(10); /* Let UART finish */

    /* Disable SysTick */
    SYSTICK_CTRL = 0;
    SYSTICK_LOAD = 0;
    SYSTICK_VAL = 0;

    /* Disable all interrupts */
    for (int i = 0; i < 8; i++) {
        *(volatile uint32_t *)(NVIC_BASE + 0x80 + i * 4) = 0xFFFFFFFF; /* ICER */
    }
    /* Clear all pending interrupts */
    for (int i = 0; i < 8; i++) {
        *(volatile uint32_t *)(NVIC_BASE + 0x100 + i * 4) = 0xFFFFFFFF; /* ICPR */
    }

    /* Relocate vector table */
    SCB_VTOR = APP_BASE;

    /* Set stack pointer */
    __asm volatile ("MSR MSP, %0" : : "r" (app_sp));

    /* Memory barrier */
    __asm volatile ("DSB");
    __asm volatile ("ISB");

    /* Jump to application */
    app_entry_t app_entry = (app_entry_t)app_pc;
    app_entry();

    /* Should never reach here */
    while (1);
}

/* ============================================================================
 * SPI / SD Card Low-Level
 * ============================================================================ */
static void spi_init(void)
{
    /* Configure SPI1 pins: PA5=SCK, PA6=MISO, PA7=MOSI as AF5 */
    /* PA4 = CS as GPIO output */
    GPIOA->MODER &= ~((3 << (4 * 2)) | (3 << (5 * 2)) | (3 << (6 * 2)) | (3 << (7 * 2)));
    GPIOA->MODER |= (1 << (4 * 2));    /* PA4 output */
    GPIOA->MODER |= (2 << (5 * 2)) | (2 << (6 * 2)) | (2 << (7 * 2)); /* AF */

    GPIOA->AFR[0] &= ~((0xF << (5 * 4)) | (0xF << (6 * 4)) | (0xF << (7 * 4)));
    GPIOA->AFR[0] |= (5 << (5 * 4)) | (5 << (6 * 4)) | (5 << (7 * 4)); /* AF5 */

    GPIOA->OSPEEDR |= (3 << (4 * 2)) | (3 << (5 * 2)) | (3 << (6 * 2)) | (3 << (7 * 2));

    /* Pull-up on MISO */
    GPIOA->PUPDR &= ~(3 << (6 * 2));
    GPIOA->PUPDR |= (1 << (6 * 2));

    sd_cs_high();

    /* SPI1 Configuration */
    volatile uint32_t *SPI_CR1 = (volatile uint32_t *)(SPI1_BASE + 0x00);
    volatile uint32_t *SPI_CR2 = (volatile uint32_t *)(SPI1_BASE + 0x04);

    *SPI_CR1 = 0;
    *SPI_CR2 = 0;

    /* Master mode, CPOL=0, CPHA=0, slow clock initially (fPCLK/256) */
    *SPI_CR1 = (1 << 2)    /* MSTR */
             | (7 << 3)    /* BR = fPCLK/256 for init */
             | (1 << 8)    /* SSI */
             | (1 << 9);   /* SSM */

    /* 8-bit data frame */
    *SPI_CR2 = (7 << 8)    /* DS = 8-bit */
             | (1 << 12);  /* FRXTH = 1 (8-bit RXNE threshold) */

    /* Enable SPI */
    *SPI_CR1 |= (1 << 6);  /* SPE */
}

static void spi_set_fast(void)
{
    volatile uint32_t *SPI_CR1 = (volatile uint32_t *)(SPI1_BASE + 0x00);
    *SPI_CR1 &= ~(1 << 6); /* Disable SPI */
    *SPI_CR1 = (*SPI_CR1 & ~(7 << 3)) | (1 << 3); /* BR = fPCLK/4 */
    *SPI_CR1 |= (1 << 6);  /* Enable SPI */
}

static uint8_t spi_transfer(uint8_t data)
{
    volatile uint32_t *SPI_SR = (volatile uint32_t *)(SPI1_BASE + 0x08);
    volatile uint8_t *SPI_DR = (volatile uint8_t *)(SPI1_BASE + 0x0C);

    while (!(*SPI_SR & (1 << 1))); /* Wait TXE */
    *SPI_DR = data;
    while (!(*SPI_SR & (1 << 0))); /* Wait RXNE */
    return *SPI_DR;
}

static void sd_cs_high(void)
{
    SD_CS_PORT->BSRR = (1 << SD_CS_PIN);
}

static void sd_cs_low(void)
{
    SD_CS_PORT->BSRR = (1 << (SD_CS_PIN + 16));
}

static uint8_t sd_send_cmd(uint8_t cmd, uint32_t arg)
{
    uint8_t response;
    uint8_t crc = 0xFF;
    int retries;

    if (cmd == SD_CMD0) crc = 0x95;
    if (cmd == SD_CMD8) crc = 0x87;

    /* Wait for card ready */
    retries = 1000;
    while (retries-- > 0) {
        if (spi_transfer(0xFF) == 0xFF) break;
    }

    spi_transfer(0x40 | cmd);
    spi_transfer((arg >> 24) & 0xFF);
    spi_transfer((arg >> 16) & 0xFF);
    spi_transfer((arg >> 8) & 0xFF);
    spi_transfer(arg & 0xFF);
    spi_transfer(crc);

    /* Wait for response (R1) */
    retries = 100;
    do {
        response = spi_transfer(0xFF);
    } while ((response & 0x80) && --retries > 0);

    return response;
}

static bool sd_init(void)
{
    uint8_t r;
    int retries;
    uint8_t ocr[4];

    spi_init();

    /* Send 80+ clock cycles with CS high */
    sd_cs_high();
    for (int i = 0; i < 10; i++) {
        spi_transfer(0xFF);
    }

    /* CMD0 - GO_IDLE_STATE */
    sd_cs_low();
    r = sd_send_cmd(SD_CMD0, 0);
    sd_cs_high();
    spi_transfer(0xFF);

    if (r != 0x01) {
        uart_send_string("[SD] CMD0 failed\r\n");
        return false;
    }

    /* CMD8 - SEND_IF_COND (check for SDv2) */
    sd_cs_low();
    r = sd_send_cmd(SD_CMD8, 0x1AA);
    if (r == 0x01) {
        /* SDv2 card */
        for (int i = 0; i < 4; i++) {
            ocr[i] = spi_transfer(0xFF);
        }
        sd_cs_high();
        spi_transfer(0xFF);

        if (ocr[2] != 0x01 || ocr[3] != 0xAA) {
            uart_send_string("[SD] CMD8 response error\r\n");
            return false;
        }

        /* ACMD41 with HCS bit */
        retries = 1000;
        do {
            sd_cs_low();
            sd_send_cmd(SD_CMD55, 0);
            sd_cs_high();
            spi_transfer(0xFF);

            sd_cs_low();
            r = sd_send_cmd(SD_ACMD41, 0x40000000);
            sd_cs_high();
            spi_transfer(0xFF);

            if (--retries == 0) {
                uart_send_string("[SD] ACMD41 timeout\r\n");
                return false;
            }
            delay_ms(1);
        } while (r != 0x00);

        /* CMD58 - Read OCR to check CCS (high capacity) */
        sd_cs_low();
        r = sd_send_cmd(SD_CMD58, 0);
        for (int i = 0; i < 4; i++) {
            ocr[i] = spi_transfer(0xFF);
        }
        sd_cs_high();
        spi_transfer(0xFF);

        sd_high_capacity = (ocr[0] & 0x40) ? true : false;
    } else {
        sd_cs_high();
        spi_transfer(0xFF);

        /* SDv1 or MMC - try ACMD41 */
        retries = 1000;
        do {
            sd_cs_low();
            sd_send_cmd(SD_CMD55, 0);
            sd_cs_high();
            spi_transfer(0xFF);

            sd_cs_low();
            r = sd_send_cmd(SD_ACMD41, 0);
            sd_cs_high();
            spi_transfer(0xFF);

            if (--retries == 0) {
                uart_send_string("[SD] Init timeout\r\n");
                return false;
            }
            delay_ms(1);
        } while (r != 0x00);

        sd_high_capacity = false;

        /* Set block size to 512 */
        sd_cs_low();
        sd_send_cmd(SD_CMD16, 512);
        sd_cs_high();
        spi_transfer(0xFF);
    }

    /* Switch to fast SPI clock */
    spi_set_fast();

    uart_send_string("[SD] Card initialized\r\n");
    return true;
}

static bool sd_read_block(uint32_t block_addr, uint8_t *buf)
{
    uint32_t addr = sd_high_capacity ? block_addr : (block_addr * 512);
    uint8_t r;
    int retries;

    sd_cs_low();
    r = sd_send_cmd(SD_CMD17, addr);
    if (r != 0x00) {
        sd_cs_high();
        spi_transfer(0xFF);
        return false;
    }

    /* Wait for data token (0xFE) */
    retries = 10000;
    do {
        r = spi_transfer(0xFF);
        if (--retries == 0) {
            sd_cs_high();
            spi_transfer(0xFF);
            return false;
        }
    } while (r != 0xFE);

    /* Read 512 bytes */
    for (int i = 0; i < 512; i++) {
        buf[i] = spi_transfer(0xFF);
    }

    /* Read CRC (discard) */
    spi_transfer(0xFF);
    spi_transfer(0xFF);

    sd_cs_high();
    spi_transfer(0xFF);

    return true;
}

/* ============================================================================
 * Minimal FAT32 Support
 * ============================================================================ */
static uint16_t read_u16(const uint8_t *p)
{
    return (uint16_t)p[0] | ((uint16_t)p[1] << 8);
}

static uint32_t read_u32(const uint8_t *p)
{
    return (uint32_t)p[0] | ((uint32_t)p[1] << 8) |
           ((uint32_t)p[2] << 16) | ((uint32_t)p[3] << 24);
}

static bool fat32_init(void)
{
    uint8_t sector[512];
    uint32_t partition_start = 0;

    /* Read MBR */
    if (!sd_read_block(0, sector)) {
        uart_send_string("[FAT] Can't read MBR\r\n");
        return false;
    }

    /* Check for MBR signature */
    if (sector[510] == 0x55 && sector[511] == 0xAA) {
        /* Check partition type */
        uint8_t ptype = sector[0x1C2];
        if (ptype == 0x0B || ptype == 0x0C || ptype == 0x07) {
            partition_start = read_u32(&sector[0x1C6]);
        } else if (sector[0] == 0xEB || sector[0] == 0xE9) {
            /* No MBR, this is the BPB directly */
            partition_start = 0;
        } else {
            /* Try first partition entry */
            partition_start = read_u32(&sector[0x1C6]);
            if (partition_start == 0) {
                partition_start = 0; /* Assume no MBR */
            }
        }
    }

    /* Read Volume Boot Record */
    if (!sd_read_block(partition_start, sector)) {
        uart_send_string("[FAT] Can't read VBR\r\n");
        return false;
    }

    /* Parse BPB */
    uint16_t bytes_per_sector = read_u16(&sector[11]);
    if (bytes_per_sector != 512) {
        uart_send_string("[FAT] Unsupported sector size\r\n");
        return false;
    }

    fat_info.sectors_per_cluster = sector[13];
    fat_info.reserved_sectors = read_u16(&sector[14]);
    fat_info.num_fats = sector[16];
    fat_info.sectors_per_fat = read_u32(&sector[36]);
    fat_info.root_dir_cluster = read_u32(&sector[44]);

    fat_info.fat_start_sector = partition_start + fat_info.reserved_sectors;
    fat_info.data_start_sector = fat_info.fat_start_sector +
                                  (fat_info.num_fats * fat_info.sectors_per_fat);

    uart_send_string("[FAT] FAT32 filesystem found\r\n");
    return true;
}

static uint32_t fat32_cluster_to_sector(uint32_t cluster)
{
    return fat_info.data_start_sector + (cluster - 2) * fat_info.sectors_per_cluster;
}

static uint32_t fat32_get_next_cluster(uint32_t cluster)
{
    uint8_t sector[512];
    uint32_t fat_offset = cluster * 4;
    uint32_t fat_sector = fat_info.fat_start_sector + (fat_offset / 512);
    uint32_t entry_offset = fat_offset % 512;

    if (!sd_read_block(fat_sector, sector)) {
        return 0x0FFFFFFF;
    }

    uint32_t next = read_u32(&sector[entry_offset]) & 0x0FFFFFFF;
    return next;
}

/* Compare 8.3 filename */
static bool fat32_name_match(const uint8_t *dir_entry, const char *name)
{
    /* Convert name to 8.3 format for comparison */
    char fat_name[11];
    memset(fat_name, ' ', 11);

    int i = 0, j = 0;
    /* Name part (up to 8 chars) */
    while (name[i] && name[i] != '.' && j < 8) {
        fat_name[j++] = (name[i] >= 'a' && name[i] <= 'z') ?
                         (name[i] - 32) : name[i];
        i++;
    }
    /* Skip to extension */
    while (name[i] && name[i] != '.') i++;
    if (name[i] == '.') {
        i++;
        j = 8;
        while (name[i] && j < 11) {
            fat_name[j++] = (name[i] >= 'a' && name[i] <= 'z') ?
                             (name[i] - 32) : name[i];
            i++;
        }
    }

    return (memcmp(dir_entry, fat_name, 11) == 0);
}

static bool fat32_find_file(const char *name, uint32_t *start_cluster, uint32_t *file_size)
{
    uint8_t sector[512];
    uint32_t cluster = fat_info.root_dir_cluster;

    while (cluster < 0x0FFFFFF8) {
        uint32_t sec = fat32_cluster_to_sector(cluster);

        for (uint32_t s = 0; s < fat_info.sectors_per_cluster; s++) {
            if (!sd_read_block(sec + s, sector)) {
                return false;
            }

            for (int e = 0; e < 16; e++) { /* 16 entries per sector */
                uint8_t *entry = &sector[e * 32];

                if (entry[0] == 0x00) return false; /* End of directory */
                if (entry[0] == 0xE5) continue;     /* Deleted */
                if (entry[11] & 0x08) continue;     /* Volume label */
                if (entry[11] & 0x10) continue;     /* Directory */
                if (entry[11] == 0x0F) continue;    /* LFN entry */

                if (fat32_name_match(entry, name)) {
                    uint16_t cluster_hi = read_u16(&entry[20]);
                    uint16_t cluster_lo = read_u16(&entry[26]);
                    *start_cluster = ((uint32_t)cluster_hi << 16) | cluster_lo;
                    *file_size = read_u32(&entry[28]);
                    return true;
                }
            }
        }
        cluster = fat32_get_next_cluster(cluster);
    }

    return false;
}

/* ============================================================================
 * SD Card Firmware Update
 * ============================================================================ */
static bool sd_firmware_update(void)
{
    uint32_t file_cluster, file_size;
    firmware_header_t header;
    uint8_t sector[512];
    uint32_t bytes_read = 0;
    uint32_t flash_addr = APP_BASE;

    uart_send_string("[SD] Looking for firmware file...\r\n");

    if (!sd_init()) {
        return false;
    }

    if (!fat32_init()) {
        return false;
    }

    if (!fat32_find_file(SD_FIRMWARE_FILE, &file_cluster, &file_size)) {
        uart_send_string("[SD] Firmware file not found\r\n");
        return false;
    }

    uart_send_string("[SD] Found firmware file, size: ");
    /* Print size as hex for simplicity */
    char hex[9];
    for (int i = 7; i >= 0; i--) {
        uint8_t nibble = (file_size >> (i * 4)) & 0xF;
        hex[7 - i] = (nibble < 10) ? ('0' + nibble) : ('A' + nibble - 10);
    }
    hex[8] = 0;
    uart_send_string(hex);
    uart_send_string(" bytes\r\n");

    if (file_size < sizeof(firmware_header_t)) {
        uart_send_string("[SD] File too small\r\n");
        return false;
    }

    if (file_size > APP_MAX_SIZE + sizeof(firmware_header_t)) {
        uart_send_string("[SD] Firmware too large\r\n");
        return false;
    }

    /* Read header (first 32 bytes from first sector of file) */
    uint32_t cur_cluster = file_cluster;
    uint32_t sec = fat32_cluster_to_sector(cur_cluster);

    if (!sd_read_block(sec, sector)) {
        uart_send_string("[SD] Read error\r\n");
        return false;
    }

    memcpy(&header, sector, sizeof(firmware_header_t));

    if (header.magic != FIRMWARE_HEADER_MAGIC) {
        uart_send_string("[SD] Invalid firmware header\r\n");
        return false;
    }

    if (header.size > APP_MAX_SIZE) {
        uart_send_string("[SD] Firmware binary too large\r\n");
        return false;
    }

    uart_send_string("[SD] Erasing and programming flash...\r\n");

    /* Now read the actual firmware data (after header) and flash it */
    flash_unlock();

    /* Erase all required pages first for speed */
    uint32_t pages_needed = (header.size + FLASH_PAGE_SIZE - 1) / FLASH_PAGE_SIZE;
    for (uint32_t p = 0; p < pages_needed; p++) {
        if (!flash_erase_page(APP_BASE + p * FLASH_PAGE_SIZE)) {
            uart_send_string("[SD] Erase failed\r\n");
            flash_lock();
            return false;
        }
        if ((p & 0x07) == 0) led_toggle();
    }

    /* Read file data, skip header, write to flash */
    cur_cluster = file_cluster;
    uint32_t sector_in_cluster = 0;
    uint32_t file_offset = 0;
    uint32_t header_size = sizeof(firmware_header_t);
    uint32_t fw_written = 0;

    while (cur_cluster < 0x0FFFFFF8 && fw_written < header.size) {
        sec = fat32_cluster_to_sector(cur_cluster);

        for (uint32_t s = 0; s < fat_info.sectors_per_cluster && fw_written < header.size; s++) {
            if (!sd_read_block(sec + s, sector)) {
                uart_send_string("[SD] Read error during flash\r\n");
                flash_lock();
                return false;
            }

            uint32_t data_start = 0;
            uint32_t data_len = 512;

            if (file_offset < header_size) {
                /* Skip header bytes in this sector */
                uint32_t skip = header_size - file_offset;
                if (skip >= 512) {
                    file_offset += 512;
                    continue;
                }
                data_start = skip;
                data_len = 512 - skip;
            }

            /* Limit to remaining firmware size */
            if (data_len > (header.size - fw_written)) {
                data_len = header.size - fw_written;
            }

            /* Write to flash in double-word chunks */
            uint32_t addr = APP_BASE + fw_written;
            uint8_t *data = &sector[data_start];
            uint32_t remaining = data_len;

            /* Enable programming */
            FLASH_CR |= FLASH_CR_PG;

            while (remaining >= 8) {
                uint64_t dword;
                memcpy(&dword, data, 8);
                *(volatile uint32_t *)addr = (uint32_t)dword;
                *(volatile uint32_t *)(addr + 4) = (uint32_t)(dword >> 32);
                while (FLASH_SR & FLASH_SR_BSY);
                addr += 8;
                data += 8;
                remaining -= 8;
                fw_written += 8;
            }

            if (remaining > 0) {
                uint64_t dword = 0xFFFFFFFFFFFFFFFFULL;
                memcpy(&dword, data, remaining);
                *(volatile uint32_t *)addr = (uint32_t)dword;
                *(volatile uint32_t *)(addr + 4) = (uint32_t)(dword >> 32);
                while (FLASH_SR & FLASH_SR_BSY);
                fw_written += remaining;
            }

            FLASH_CR &= ~FLASH_CR_PG;

            file_offset += 512;

            if ((fw_written & 0xFFF) == 0) led_toggle();
        }

        cur_cluster = fat32_get_next_cluster(cur_cluster);
    }

    flash_lock();

    /* Verify CRC */
    uart_send_string("[SD] Verifying CRC...\r\n");
    uint32_t computed_crc = crc32_flash(APP_BASE, header.size);
    if (computed_crc != header.crc32) {
        uart_send_string("[SD] CRC mismatch! Update failed.\r\n");
        return false;
    }

    uart_send_string("[SD] Firmware update successful!\r\n");
    led_on();
    return true;
}

/* ============================================================================
 * XMODEM UART Firmware Update
 * ============================================================================ */
static bool uart_firmware_update(void)
{
    firmware_header_t header;
    uint8_t block_num = 1;
    uint32_t total_received = 0;
    uint32_t fw_offset = 0;
    bool header_received = false;
    int retries = 0;
    bool use_1k = false;

    uart_send_string("[UART] XMODEM firmware update mode\r\n");
    uart_send_string("[UART] Send firmware file via XMODEM...\r\n");

    /* Erase application area */
    uart_send_string("[UART] Erasing flash...\r\n");
    flash_unlock();
    uint32_t pages = APP_MAX_SIZE / FLASH_PAGE_SIZE;
    /* Only erase what we need - start with reasonable amount */
    uint32_t pre_erase_pages = 64; /* ~128KB initially */
    for (uint32_t p = 0; p < pre_erase_pages; p++) {
        if (!flash_erase_page(APP_BASE + p * FLASH_PAGE_SIZE)) {
            uart_send_string("[UART] Erase failed\r\n");
            flash_lock();
            return false;
        }
    }
    uint32_t erased_up_to = APP_BASE + pre_erase_pages * FLASH_PAGE_SIZE;

    /* Send NAK to start XMODEM transfer (use 'C' for XMODEM-CRC) */
    while (retries < XMODEM_MAX_RETRIES) {
        uart_send_byte('C'); /* Request CRC mode */
        int b = uart_recv_byte(XMODEM_TIMEOUT_MS);
        if (b == XMODEM_SOH || b == XMODEM_STX) {
            use_1k = (b == XMODEM_STX);
            goto receive_block;
        }
        retries++;
        led_toggle();
    }

    /* Fall back to checksum mode */
    retries = 0;
    while (retries < XMODEM_MAX_RETRIES) {
        uart_send_byte(XMODEM_NAK);
        int b = uart_recv_byte(XMODEM_TIMEOUT_MS);
        if (b == XMODEM_SOH || b == XMODEM_STX) {
            use_1k = (b == XMODEM_STX);
            goto receive_block;
        }
        retries++;
    }

    uart_send_string("[UART] No response from sender\r\n");
    flash_lock();
    return false;

receive_block:
    retries = 0;

    while (1) {
        uint16_t block_size = use_1k ? XMODEM_1K_BLOCK_SIZE : XMODEM_BLOCK_SIZE;
        uint8_t blk, blk_inv;
        uint16_t crc_received = 0;
        uint16_t crc_calc = 0;
        bool block_ok = true;

        /* Read block number */
        int b = uart_recv_byte(1000);
        if (b < 0) { block_ok = false; goto block_end; }
        blk = (uint8_t)b;

        b = uart_recv_byte(1000);
        if (b < 0) { block_ok = false; goto block_end; }
        blk_inv = (uint8_t)b;

        /* Verify block number */
        if (blk != (uint8_t)(~blk_inv & 0xFF)) {
            block_ok = false;
        }

        /* Read data */
        for (uint16_t i = 0; i < block_size; i++) {
            b = uart_recv_byte(1000);
            if (b < 0) { block_ok = false; break; }
            rx_buffer[i] = (uint8_t)b;
        }

        /* Read CRC (2 bytes, big-endian) */
        b = uart_recv_byte(1000);
        if (b < 0) { block_ok = false; goto block_end; }
        crc_received = (uint16_t)b << 8;

        b = uart_recv_byte(1000);
        if (b < 0) { block_ok = false; goto block_end; }
        crc_received |= (uint16_t)b;

        /* Calculate CRC-16/XMODEM */
        if (block_ok) {
            crc_calc = 0;
            for (uint16_t i = 0; i < block_size; i++) {
                crc_calc ^= ((uint16_t)rx_buffer[i] << 8);
                for (int j = 0; j < 8; j++) {
                    if (crc_calc & 0x8000)
                        crc_calc = (crc_calc << 1) ^ 0x1021;
                    else
                        crc_calc <<= 1;
                }
            }

            if (crc_calc != crc_received) {
                block_ok = false;
            }
        }

        /* Check expected block number */
        if (block_ok && blk != block_num) {
            if (blk == (uint8_t)(block_num - 1)) {
                /* Duplicate block, ACK and continue */
                uart_send_byte(XMODEM_ACK);
                goto wait_next;
            }
            block_ok = false;
        }

block_end:
        if (!block_ok) {
            /* Flush any remaining bytes */
            while (uart_recv_byte(100) >= 0);
            uart_send_byte(XMODEM_NAK);
            retries++;
            if (retries >= XMODEM_MAX_RETRIES) {
                uart_send_string("\r\n[UART] Too many errors\r\n");
                flash_lock();
                return false;
            }
            goto wait_next;
        }

        retries = 0;

        /* Process received data */
        if (!header_received) {
            /* First block contains the firmware header */
            memcpy(&header, rx_buffer, sizeof(firmware_header_t));
            if (header.magic != FIRMWARE_HEADER_MAGIC) {
                uart_send_string("\r\n[UART] Invalid header\r\n");
                uart_send_byte(XMODEM_CAN);
                uart_send_byte(XMODEM_CAN);
                flash_lock();
                return false;
            }
            if (header.size > APP_MAX_SIZE) {
                uart_send_string("\r\n[UART] Firmware too large\r\n");
                uart_send_byte(XMODEM_CAN);
                uart_send_byte(XMODEM_CAN);
                flash_lock();
                return false;
            }
            header_received = true;

            /* Write remaining data in first block after header */
            uint32_t data_offset = sizeof(firmware_header_t);
            uint32_t data_len = block_size - data_offset;
            if (data_len > header.size) data_len = header.size;

            /* Ensure enough flash is erased */
            uint32_t needed_end = APP_BASE + header.size;
            while (erased_up_to < needed_end) {
                flash_erase_page(erased_up_to);
                erased_up_to += FLASH_PAGE_SIZE;
            }

            /* Program */
            FLASH_CR |= FLASH_CR_PG;
            uint8_t *src = &rx_buffer[data_offset];
            uint32_t addr = APP_BASE;
            uint32_t rem = data_len;
            while (rem >= 8) {
                uint64_t dw;
                memcpy(&dw, src, 8);
                *(volatile uint32_t *)addr = (uint32_t)dw;
                *(volatile uint32_t *)(addr + 4) = (uint32_t)(dw >> 32);
                while (FLASH_SR & FLASH_SR_BSY);
                addr += 8; src += 8; rem -= 8;
            }
            if (rem > 0) {
                uint64_t dw = 0xFFFFFFFFFFFFFFFFULL;
                memcpy(&dw, src, rem);
                *(volatile uint32_t *)addr = (uint32_t)dw;
                *(volatile uint32_t *)(addr + 4) = (uint32_t)(dw >> 32);
                while (FLASH_SR & FLASH_SR_BSY);
            }
            FLASH_CR &= ~FLASH_CR_PG;

            fw_offset = data_len;
        } else {
            /* Subsequent blocks - write directly to flash */
            uint32_t data_len = block_size;
            if (fw_offset + data_len > header.size) {
                data_len = header.size - fw_offset;
            }

            if (data_len > 0) {
                /* Ensure flash is erased */
                uint32_t needed_end = APP_BASE + fw_offset + data_len;
                while (erased_up_to < needed_end) {
                    flash_erase_page(erased_up_to);
                    erased_up_to += FLASH_PAGE_SIZE;
                }

                FLASH_CR |= FLASH_CR_PG;
                uint8_t *src = rx_buffer;
                uint32_t addr = APP_BASE + fw_offset;
                uint32_t rem = data_len;
                while (rem >= 8) {
                    uint64_t dw;
                    memcpy(&dw, src, 8);
                    *(volatile uint32_t *)addr = (uint32_t)dw;
                    *(volatile uint32_t *)(addr + 4) = (uint32_t)(dw >> 32);
                    while (FLASH_SR & FLASH_SR_BSY);
                    addr += 8; src += 8; rem -= 8;
                }
                if (rem > 0) {
                    uint64_t dw = 0xFFFFFFFFFFFFFFFFULL;
                    memcpy(&dw, src, rem);
                    *(volatile uint32_t *)addr = (uint32_t)dw;
                    *(volatile uint32_t *)(addr + 4) = (uint32_t)(dw >> 32);
                    while (FLASH_SR & FLASH_SR_BSY);
                }
                FLASH_CR &= ~FLASH_CR_PG;

                fw_offset += data_len;
            }
        }

        total_received += block_size;
        block_num++;

        uart_send_byte(XMODEM_ACK);

        if ((block_num & 0x0F) == 0) led_toggle();

wait_next:
        /* Wait for next block header or EOT */
        b = uart_recv_byte(XMODEM_TIMEOUT_MS);
        if (b == XMODEM_EOT) {
            uart_send_byte(XMODEM_ACK);
            break;
        } else if (b == XMODEM_SOH) {
            use_1k = false;
            continue;
        } else if (b == XMODEM_STX) {
            use_1k = true;
            continue;
        } else if (b == XMODEM_CAN) {
            uart_send_string("\r\n[UART] Transfer cancelled by sender\r\n");
            flash_lock();
            return false;
        } else if (b < 0) {
            uart_send_byte(XMODEM_NAK);
            retries++;
            if (retries >= XMODEM_MAX_RETRIES) {
                flash_lock();
                return false;
            }
            goto wait_next;
        }
    }

    flash_lock();

    if (!header_received) {
        uart_send_string("[UART] No valid firmware received\r\n");
        return false;
    }

    /* Verify CRC of flashed firmware */
    uart_send_string("[UART] Verifying CRC...\r\n");
    uint32_t computed_crc = crc32_flash(APP_BASE, header.size);
    if (computed_crc != header.crc32) {
        uart_send_string("[UART] CRC verification failed!\r\n");
        return false;
    }

    uart_send_string("[UART] Firmware update successful!\r\n");
    return true;
}

/* ============================================================================
 * Bootloader Menu (when in bootloader mode)
 * ============================================================================ */
static void bootloader_menu(void)
{
    uart_send_string("\r\n");
    uart_send_string("================================\r\n");
    uart_send_string("  ARM Cortex-M Bootloader v1.0  \r\n");
    uart_send_string("================================\r\n");
    uart_send_string("  1. Update via SD card\r\n");
    uart_send_string("  2. Update via UART (XMODEM)\r\n");
    uart_send_string("  3. Boot application\r\n");
    uart_send_string("  4. System info\r\n");
    uart_send_string("================================\r\n");
    uart_send_string("> ");

    while (1) {
        int c = uart_recv_byte(500