# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>
#include <optional>
#include <iostream>

struct User {
    int id;
    std::string username;
    std::string email;
    std::string display_name;
    int age;
    bool is_active;
};

struct UserResponse {
    int id;
    std::string username;
    std::string email;
    std::string display_name;
    int age;
    bool is_active;
    bool found;
    std::string error_message;
};

class UserLookupSystem {
private:
    std::unordered_map<int, User> user_table;

public:
    void add_user(const User& user) {
        user_table[user.id] = user;
    }

    // Returns a pointer to the User if found, nullptr otherwise
    User* find_user(int user_id) {
        auto it = user_table.find(user_id);
        if (it != user_table.end()) {
            return &(it->second);
        }
        return nullptr;
    }

    // BUG: Dereferences the pointer returned by find_user without null check.
    // If user_id is not in the hash table, find_user returns nullptr,
    // and this function will dereference a null pointer, causing undefined behavior.
    UserResponse get_user_profile(int user_id) {
        UserResponse response;
        User* user = find_user(user_id);

        // Immediately access user fields without checking if pointer is null
        response.id = user->id;
        response.username = user->username;
        response.email = user->email;
        response.display_name = user->display_name;
        response.age = user->age;
        response.is_active = user->is_active;
        response.found = true;
        response.error_message = "";

        return response;
    }

    // FIXED version: checks for null pointer before dereferencing
    UserResponse get_user_profile_safe(int user_id) {
        UserResponse response;
        User* user = find_user(user_id);

        if (user == nullptr) {
            response.id = -1;
            response.username = "";
            response.email = "";
            response.display_name = "";
            response.age = 0;
            response.is_active = false;
            response.found = false;
            response.error_message = "User not found with id: " + std::to_string(user_id);
            return response;
        }

        response.id = user->id;
        response.username = user->username;
        response.email = user->email;
        response.display_name = user->display_name;
        response.age = user->age;
        response.is_active = user->is_active;
        response.found = true;
        response.error_message = "";

        return response;
    }
};

int main() {
    UserLookupSystem system;

    // Add some users
    system.add_user({1, "alice", "alice@example.com", "Alice Smith", 30, true});
    system.add_user({2, "bob", "bob@example.com", "Bob Jones", 25, true});
    system.add_user({3, "charlie", "charlie@example.com", "Charlie Brown", 35, false});

    // This works fine - user exists
    UserResponse resp1 = system.get_user_profile(1);
    std::cout << "Found user: " << resp1.display_name << " (" << resp1.email << ")" << std::endl;

    // Safe version handles missing user gracefully
    UserResponse resp2 = system.get_user_profile_safe(999);
    if (!resp2.found) {
        std::cout << "Safe lookup error: " << resp2.error_message << std::endl;
    }

    // DANGER: This will crash - null pointer dereference on non-existent user
    std::cout << "About to look up non-existent user with unsafe method..." << std::endl;
    UserResponse resp3 = system.get_user_profile(999);  // NULL POINTER DEREFERENCE
    std::cout << "This line may never be reached: " << resp3.username << std::endl;

    return 0;
}