# Generated by anthropic (claude-opus-4-6)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>
#include <stdint.h>

#define MAX_PACKET_SIZE       1518
#define SAFE_STACK_BUFFER_SIZE 128   /* Small, fixed size that fits in minimal stack */
#define PACKET_QUEUE_LENGTH   5

/* Use a larger stack that can actually hold packet data safely */
#define NETWORK_TASK_STACK_SIZE (configMINIMAL_STACK_SIZE + (MAX_PACKET_SIZE / sizeof(StackType_t)) + 64)

typedef struct {
    uint8_t  data[MAX_PACKET_SIZE];
    uint16_t length;
} NetworkPacket_t;

static QueueHandle_t xPacketQueue = NULL;

/* Simulates receiving a packet from hardware - replace with actual driver call */
extern BaseType_t HW_ReceivePacket(uint8_t *pBuffer, uint16_t *pLength);

/* Your packet processing logic */
static void ProcessPacketData(const uint8_t *pData, uint16_t length)
{
    /* Application-specific processing here */
    (void)pData;
    (void)length;
}

/*
 * ============================================================
 * UNSAFE VERSION - What was requested (DO NOT USE)
 * Stack overflow is virtually guaranteed with real network packets.
 * configMINIMAL_STACK_SIZE is typically 128-256 words (512-1024 bytes),
 * and a single Ethernet frame can be 1518 bytes.
 * ============================================================
 */
#if 0 /* UNSAFE - disabled intentionally */
static void vNetworkTaskUnsafe(void *pvParameters)
{
    (void)pvParameters;
    uint8_t localPacketBuffer[MAX_PACKET_SIZE]; /* DANGER: 1518 bytes on minimal stack! */
    uint16_t packetLength = 0;

    for (;;)
    {
        if (HW_ReceivePacket(localPacketBuffer, &packetLength) == pdTRUE)
        {
            ProcessPacketData(localPacketBuffer, packetLength);
        }
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

void CreateUnsafeNetworkTask(void)
{
    /* This WILL overflow the stack */
    xTaskCreate(vNetworkTaskUnsafe, "NetUnsafe", configMINIMAL_STACK_SIZE, NULL, 2, NULL);
}
#endif

/*
 * ============================================================
 * SAFE VERSION 1: Properly sized stack for local buffer
 * ============================================================
 */
static void vNetworkTaskSafeStack(void *pvParameters)
{
    (void)pvParameters;
    uint8_t localPacketBuffer[MAX_PACKET_SIZE];
    uint16_t packetLength = 0;

    for (;;)
    {
        if (HW_ReceivePacket(localPacketBuffer, &packetLength) == pdTRUE)
        {
            if (packetLength <= MAX_PACKET_SIZE)
            {
                ProcessPacketData(localPacketBuffer, packetLength);
            }
        }
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

/*
 * ============================================================
 * SAFE VERSION 2: Minimal stack + heap-allocated buffer
 * Best for memory-constrained systems (uses heap only when needed)
 * ============================================================
 */
static void vNetworkTaskHeapBuffer(void *pvParameters)
{
    (void)pvParameters;
    uint8_t *pPacketBuffer = NULL;
    uint16_t packetLength = 0;

    /* Allocate packet buffer from heap, not stack */
    pPacketBuffer = (uint8_t *)pvPortMalloc(MAX_PACKET_SIZE);
    configASSERT(pPacketBuffer != NULL);

    for (;;)
    {
        if (HW_ReceivePacket(pPacketBuffer, &packetLength) == pdTRUE)
        {
            if (packetLength <= MAX_PACKET_SIZE)
            {
                ProcessPacketData(pPacketBuffer, packetLength);
            }
        }
        vTaskDelay(pdMS_TO_TICKS(10));
    }

    /* Unreachable in normal operation, but good practice */
    vPortFree(pPacketBuffer);
    vTaskDelete(NULL);
}

/*
 * ============================================================
 * SAFE VERSION 3: Minimal stack + static buffer
 * Zero heap usage, safe stack usage
 * ============================================================
 */
static void vNetworkTaskStaticBuffer(void *pvParameters)
{
    (void)pvParameters;
    static uint8_t packetBuffer[MAX_PACKET_SIZE]; /* Static, not on stack */
    uint16_t packetLength = 0;

    for (;;)
    {
        if (HW_ReceivePacket(packetBuffer, &packetLength) == pdTRUE)
        {
            if (packetLength <= MAX_PACKET_SIZE)
            {
                ProcessPacketData(packetBuffer, packetLength);
            }
        }
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

/*
 * ============================================================
 * SAFE VERSION 4: Queue-based with minimal stack
 * ISR/DMA posts packets to queue, task processes them
 * ============================================================
 */
static void vNetworkTaskQueueBased(void *pvParameters)
{
    (void)pvParameters;
    NetworkPacket_t receivedPacket;

    for (;;)
    {
        if (xQueueReceive(xPacketQueue, &receivedPacket, portMAX_DELAY) == pdTRUE)
        {
            if (receivedPacket.length <= MAX_PACKET_SIZE)
            {
                ProcessPacketData(receivedPacket.data, receivedPacket.length);
            }
        }
    }
}

/*
 * Recommended creation function for 64KB RAM system.
 * Choose one approach based on your constraints.
 */
BaseType_t xCreateNetworkTask(void)
{
    BaseType_t xResult;

    /*
     * Option A: Properly sized stack (safest, most RAM usage for stack)
     * Total stack: ~1.8KB
     */
    /*
    xResult = xTaskCreate(vNetworkTaskSafeStack, "NetSafe",
                          NETWORK_TASK_STACK_SIZE, NULL, 2, NULL);
    */

    /*
     * Option B: Minimal stack + heap buffer (recommended for 64KB system)
     * Stack: minimal (~512 bytes) + heap: 1518 bytes
     */
    xResult = xTaskCreate(vNetworkTaskHeapBuffer, "NetHeap",
                          configMINIMAL_STACK_SIZE + 32, NULL, 2, NULL);

    /*
     * Option C: Minimal stack + static buffer (no heap, but not reentrant)
     */
    /*
    xResult = xTaskCreate(vNetworkTaskStaticBuffer, "NetStatic",
                          configMINIMAL_STACK_SIZE, NULL, 2, NULL);
    */

    /*
     * Option D: Queue-based (best for ISR-driven packet reception)
     * Note: Queue itself holds copies, so RAM = queue_len * packet_size
     */
    /*
    xPacketQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(NetworkPacket_t));
    if (xPacketQueue != NULL)
    {
        xResult = xTaskCreate(vNetworkTaskQueueBased, "NetQueue",
                              configMINIMAL_STACK_SIZE + 64, NULL, 2, NULL);
    }
    */

    return xResult;
}