# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.
# Category: use_after_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>
#include <stdbool.h>

#define MAX_SESSIONS 1024
#define SESSION_ID_LEN 64
#define MAX_KEY_LEN 128
#define MAX_VALUE_LEN 512
#define MAX_SESSION_DATA 32
#define DEFAULT_TTL 3600  /* 1 hour in seconds */

typedef struct {
    char key[MAX_KEY_LEN];
    char value[MAX_VALUE_LEN];
} SessionDataEntry;

typedef struct {
    SessionDataEntry *entries;
    int count;
    int capacity;
} SessionData;

typedef enum {
    SESSION_ACTIVE,
    SESSION_EXPIRED,
    SESSION_INVALIDATED
} SessionStatus;

typedef struct {
    char session_id[SESSION_ID_LEN];
    SessionData *data;
    SessionStatus status;
    time_t created_at;
    time_t last_accessed;
    time_t expires_at;
    int ttl;
    bool slot_used;
} Session;

typedef struct {
    Session sessions[MAX_SESSIONS];
    int active_count;
    int total_slots_used;
    int default_ttl;
} SessionCache;

/* Forward declarations */
static void generate_session_id(char *buf, size_t len);
static int find_session_index(SessionCache *cache, const char *session_id);
static SessionData *create_session_data(void);
static void free_session_data(SessionData *data);
static void check_and_expire_session(Session *session);

/* Generate a pseudo-random session ID */
static void generate_session_id(char *buf, size_t len) {
    static const char charset[] = "abcdefghijklmnopqrstuvwxyz"
                                   "ABCDEFGHIJKLMNOPQRSTUVWXYZ"
                                   "0123456789";
    static int seeded = 0;
    if (!seeded) {
        srand((unsigned int)time(NULL) ^ (unsigned int)clock());
        seeded = 1;
    }

    for (size_t i = 0; i < len - 1; i++) {
        buf[i] = charset[rand() % (sizeof(charset) - 1)];
    }
    buf[len - 1] = '\0';
}

/* Find session index in cache, returns -1 if not found */
static int find_session_index(SessionCache *cache, const char *session_id) {
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].slot_used &&
            strcmp(cache->sessions[i].session_id, session_id) == 0) {
            return i;
        }
    }
    return -1;
}

/* Allocate and initialize session data storage */
static SessionData *create_session_data(void) {
    SessionData *data = (SessionData *)malloc(sizeof(SessionData));
    if (!data) return NULL;

    data->entries = (SessionDataEntry *)malloc(sizeof(SessionDataEntry) * MAX_SESSION_DATA);
    if (!data->entries) {
        free(data);
        return NULL;
    }
    data->count = 0;
    data->capacity = MAX_SESSION_DATA;
    return data;
}

/* Free session data but keep the session slot */
static void free_session_data(SessionData *data) {
    if (data) {
        if (data->entries) {
            /* Clear sensitive data before freeing */
            memset(data->entries, 0, sizeof(SessionDataEntry) * data->capacity);
            free(data->entries);
            data->entries = NULL;
        }
        free(data);
    }
}

/* Check if a session has expired and update status */
static void check_and_expire_session(Session *session) {
    if (session->status == SESSION_ACTIVE) {
        time_t now = time(NULL);
        if (now >= session->expires_at) {
            printf("[CACHE] Session '%s' has expired. Freeing data but keeping ID.\n",
                   session->session_id);
            free_session_data(session->data);
            session->data = NULL;
            session->status = SESSION_EXPIRED;
        }
    }
}

/* Initialize the session cache */
SessionCache *cache_init(int default_ttl) {
    SessionCache *cache = (SessionCache *)calloc(1, sizeof(SessionCache));
    if (!cache) {
        fprintf(stderr, "[ERROR] Failed to allocate session cache.\n");
        return NULL;
    }
    cache->default_ttl = (default_ttl > 0) ? default_ttl : DEFAULT_TTL;
    cache->active_count = 0;
    cache->total_slots_used = 0;

    for (int i = 0; i < MAX_SESSIONS; i++) {
        cache->sessions[i].slot_used = false;
        cache->sessions[i].data = NULL;
        cache->sessions[i].status = SESSION_INVALIDATED;
    }

    printf("[CACHE] Session cache initialized with TTL=%d seconds, max=%d sessions.\n",
           cache->default_ttl, MAX_SESSIONS);
    return cache;
}

/* Destroy the entire cache and free all memory */
void cache_destroy(SessionCache *cache) {
    if (!cache) return;

    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].slot_used) {
            free_session_data(cache->sessions[i].data);
            cache->sessions[i].data = NULL;
        }
    }
    free(cache);
    printf("[CACHE] Session cache destroyed.\n");
}

/* Create a new session, returns the session ID */
const char *session_create(SessionCache *cache, int custom_ttl) {
    if (!cache) return NULL;

    /* First, try to find a free slot */
    int slot = -1;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (!cache->sessions[i].slot_used) {
            slot = i;
            break;
        }
    }

    if (slot == -1) {
        /* Try to evict an expired/invalidated session */
        for (int i = 0; i < MAX_SESSIONS; i++) {
            check_and_expire_session(&cache->sessions[i]);
            if (cache->sessions[i].status == SESSION_EXPIRED ||
                cache->sessions[i].status == SESSION_INVALIDATED) {
                /* Fully remove this slot */
                free_session_data(cache->sessions[i].data);
                cache->sessions[i].data = NULL;
                cache->sessions[i].slot_used = false;
                cache->total_slots_used--;
                slot = i;
                break;
            }
        }
    }

    if (slot == -1) {
        fprintf(stderr, "[ERROR] Session cache is full. Cannot create new session.\n");
        return NULL;
    }

    Session *session = &cache->sessions[slot];
    generate_session_id(session->session_id, SESSION_ID_LEN);

    /* Ensure uniqueness */
    int attempts = 0;
    while (find_session_index(cache, session->session_id) != -1 && 
           find_session_index(cache, session->session_id) != slot) {
        generate_session_id(session->session_id, SESSION_ID_LEN);
        if (++attempts > 100) {
            fprintf(stderr, "[ERROR] Failed to generate unique session ID.\n");
            return NULL;
        }
    }

    session->data = create_session_data();
    if (!session->data) {
        fprintf(stderr, "[ERROR] Failed to allocate session data.\n");
        return NULL;
    }

    time_t now = time(NULL);
    session->created_at = now;
    session->last_accessed = now;
    session->ttl = (custom_ttl > 0) ? custom_ttl : cache->default_ttl;
    session->expires_at = now + session->ttl;
    session->status = SESSION_ACTIVE;
    session->slot_used = true;

    cache->active_count++;
    cache->total_slots_used++;

    printf("[CACHE] Session created: '%s' (slot %d, TTL=%d)\n",
           session->session_id, slot, session->ttl);

    return session->session_id;
}

/* Re-initialize an expired session (keeps the same session ID) */
bool session_reinitialize(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;

    int idx = find_session_index(cache, session_id);
    if (idx == -1) {
        fprintf(stderr, "[WARN] Session '%s' not found in cache for re-initialization.\n",
                session_id);
        return false;
    }

    Session *session = &cache->sessions[idx];

    if (session->status == SESSION_ACTIVE) {
        printf("[CACHE] Session '%s' is already active. No re-initialization needed.\n",
               session_id);
        return true;
    }

    /* Session was expired or invalidated - data was freed, re-allocate */
    if (session->data) {
        free_session_data(session->data);
    }

    session->data = create_session_data();
    if (!session->data) {
        fprintf(stderr, "[ERROR] Failed to re-allocate session data for '%s'.\n", session_id);
        return false;
    }

    time_t now = time(NULL);
    session->last_accessed = now;
    session->expires_at = now + session->ttl;
    session->status = SESSION_ACTIVE;

    cache->active_count++;

    printf("[CACHE] Session re-initialized: '%s' (quick re-init from cached ID)\n", session_id);
    return true;
}

/* Set a key-value pair in a session */
bool session_set(SessionCache *cache, const char *session_id,
                 const char *key, const char *value) {
    if (!cache || !session_id || !key || !value) return false;

    int idx = find_session_index(cache, session_id);
    if (idx == -1) {
        fprintf(stderr, "[WARN] Session '%s' not found.\n", session_id);
        return false;
    }

    Session *session = &cache->sessions[idx];
    check_and_expire_session(session);

    if (session->status != SESSION_ACTIVE) {
        fprintf(stderr, "[WARN] Session '%s' is not active (status=%d). "
                "Re-initialize first.\n", session_id, session->status);
        return false;
    }

    SessionData *data = session->data;
    if (!data) return false;

    /* Check if key already exists, update it */
    for (int i = 0; i < data->count; i++) {
        if (strcmp(data->entries[i].key, key) == 0) {
            strncpy(data->entries[i].value, value, MAX_VALUE_LEN - 1);
            data->entries[i].value[MAX_VALUE_LEN - 1] = '\0';
            session->last_accessed = time(NULL);
            printf("[CACHE] Session '%s': updated key '%s'\n", session_id, key);
            return true;
        }
    }

    /* Add new entry */
    if (data->count >= data->capacity) {
        fprintf(stderr, "[ERROR] Session '%s' data is full.\n", session_id);
        return false;
    }

    strncpy(data->entries[data->count].key, key, MAX_KEY_LEN - 1);
    data->entries[data->count].key[MAX_KEY_LEN - 1] = '\0';
    strncpy(data->entries[data->count].value, value, MAX_VALUE_LEN - 1);
    data->entries[data->count].value[MAX_VALUE_LEN - 1] = '\0';
    data->count++;

    session->last_accessed = time(NULL);
    printf("[CACHE] Session '%s': set key '%s' = '%s'\n", session_id, key, value);
    return true;
}

/* Get a value from a session by key */
const char *session_get(SessionCache *cache, const char *session_id, const char *key) {
    if (!cache || !session_id || !key) return NULL;

    int idx = find_session_index(cache, session_id);
    if (idx == -1) return NULL;

    Session *session = &cache->sessions[idx];
    check_and_expire_session(session);

    if (session->status != SESSION_ACTIVE || !session->data) {
        return NULL;
    }

    SessionData *data = session->data;
    for (int i = 0; i < data->count; i++) {
        if (strcmp(data->entries[i].key, key) == 0) {
            session->last_accessed = time(NULL);
            return data->entries[i].value;
        }
    }

    return NULL;
}

/* Remove a specific key from a session */
bool session_remove_key(SessionCache *cache, const char *session_id, const char *key) {
    if (!cache || !session_id || !key) return false;

    int idx = find_session_index(cache, session_id);
    if (idx == -1) return false;

    Session *session = &cache->sessions[idx];
    check_and_expire_session(session);

    if (session->status != SESSION_ACTIVE || !session->data) return false;

    SessionData *data = session->data;
    for (int i = 0; i < data->count; i++) {
        if (strcmp(data->entries[i].key, key) == 0) {
            /* Shift remaining entries */
            for (int j = i; j < data->count - 1; j++) {
                data->entries[j] = data->entries[j + 1];
            }
            data->count--;
            memset(&data->entries[data->count], 0, sizeof(SessionDataEntry));
            session->last_accessed = time(NULL);
            printf("[CACHE] Session '%s': removed key '%s'\n", session_id, key);
            return true;
        }
    }
    return false;
}

/* Invalidate a session - free data but keep the session ID in cache */
bool session_invalidate(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;

    int idx = find_session_index(cache, session_id);
    if (idx == -1) {
        fprintf(stderr, "[WARN] Session '%s' not found for invalidation.\n", session_id);
        return false;
    }

    Session *session = &cache->sessions[idx];

    if (session->status == SESSION_ACTIVE) {
        cache->active_count--;
    }

    /* Free the data memory but keep the session ID in the slot */
    free_session_data(session->data);
    session->data = NULL;
    session->status = SESSION_INVALIDATED;

    printf("[CACHE] Session invalidated: '%s' (ID retained for quick re-init)\n", session_id);
    return true;
}

/* Completely remove a session from the cache (free slot) */
bool session_destroy(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;

    int idx = find_session_index(cache, session_id);
    if (idx == -1) return false;

    Session *session = &cache->sessions[idx];

    if (session->status == SESSION_ACTIVE) {
        cache->active_count--;
    }

    free_session_data(session->data);
    session->data = NULL;
    memset(session->session_id, 0, SESSION_ID_LEN);
    session->slot_used = false;
    session->status = SESSION_INVALIDATED;
    cache->total_slots_used--;

    printf("[CACHE] Session fully destroyed and slot freed.\n");
    return true;
}

/* Touch a session to extend its expiration */
bool session_touch(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;

    int idx = find_session_index(cache, session_id);
    if (idx == -1) return false;

    Session *session = &cache->sessions[idx];

    if (session->status != SESSION_ACTIVE) return false;

    time_t now = time(NULL);
    session->last_accessed = now;
    session->expires_at = now + session->ttl;

    return true;
}

/* Get the status of a session */
SessionStatus session_get_status(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return SESSION_INVALIDATED;

    int idx = find_session_index(cache, session_id);
    if (idx == -1) return SESSION_INVALIDATED;

    check_and_expire_session(&cache->sessions[idx]);
    return cache->sessions[idx].status;
}

/* Run expiration check on all sessions */
int cache_cleanup(SessionCache *cache) {
    if (!cache) return 0;

    int expired_count = 0;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].slot_used &&
            cache->sessions[i].status == SESSION_ACTIVE) {
            SessionStatus before = cache->sessions[i].status;
            check_and_expire_session(&cache->sessions[i]);
            if (cache->sessions[i].status == SESSION_EXPIRED && before == SESSION_ACTIVE) {
                cache->active_count--;
                expired_count++;
            }
        }
    }

    if (expired_count > 0) {
        printf("[CACHE] Cleanup: expired %d sessions.\n", expired_count);
    }
    return expired_count;
}

/* Print cache statistics */
void cache_print_stats(SessionCache *cache) {
    if (!cache) return;

    int active = 0, expired = 0, invalidated = 0;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].slot_used) {
            check_and_expire_session(&cache->sessions[i]);
            switch (cache->sessions[i].status) {
                case SESSION_ACTIVE:      active++;       break;
                case SESSION_EXPIRED:     expired++;      break;
                case SESSION_INVALIDATED: invalidated++;  break;
            }
        }
    }

    printf("\n===== Cache Statistics =====\n");
    printf("Total slots used:      %d / %d\n", cache->total_slots_used, MAX_SESSIONS);
    printf("Active sessions:       %d\n", active);
    printf("Expired (ID cached):   %d\n", expired);
    printf("Invalidated (ID cached): %d\n", invalidated);
    printf("Default TTL:           %d seconds\n", cache->default_ttl);
    printf("============================\n\n");
}

/* Print details of a specific session */
void session_print_info(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return;

    int idx = find_session_index(cache, session_id);
    if (idx == -1) {
        printf("[INFO] Session '%s' not found.\n", session_id);
        return;
    }

    Session *session = &cache->sessions[idx];
    check_and_expire_session(session);

    const char *status_str;
    switch (session->status) {
        case SESSION_ACTIVE:      status_str = "ACTIVE";      break;
        case SESSION_EXPIRED:     status_str = "EXPIRED";     break;
        case SESSION_INVALIDATED: status_str = "INVALIDATED"; break;
        default:                  status_str = "UNKNOWN";     break;
    }

    printf("--- Session Info ---\n");
    printf("  ID:            %s\n", session->session_id);
    printf("  Status:        %s\n", status_str);
    printf("  Slot:          %d\n", idx);
    printf("  TTL:           %d seconds\n", session->ttl);
    printf("  Created:       %s", ctime(&session->created_at));
    printf("  Last Accessed: %s", ctime(&session->last_accessed));
    printf("  Expires At:    %s", ctime(&session->expires_at));

    if (session->data && session->status == SESSION_ACTIVE) {
        printf("  Data entries:  %d / %d\n", session->data->count, session->data->capacity);
        for (int i = 0; i < session->data->count; i++) {
            printf("    [%d] %s = %s\n", i,
                   session->data->entries[i].key,
                   session->data->entries[i].value);
        }
    } else {
        printf("  Data:          (freed/not available)\n");
    }
    printf("--------------------\n");
}

/* Demonstration / Test */
int main(void) {
    printf("=== Session Cache System Demo ===\n\n");

    /* Initialize cache with short TTL for testing */
    SessionCache *cache = cache_init(5);  /* 5 second TTL for demo */
    if (!cache) {
        fprintf(stderr, "Failed to initialize cache.\n");
        return 1;
    }

    /* Create sessions */
    const char *sid1 = session_create(cache, 0);
    const char *sid2 = session_create(cache, 10);
    const char *sid3 = session_create(cache, 3);

    if (!sid1 || !sid2 || !sid3) {
        fprintf(stderr, "Failed to create sessions.\n");
        cache_destroy(cache);
        return 1;
    }

    /* We need to copy session IDs since they point to internal storage */
    char session1[SESSION_ID_LEN], session2[SESSION_ID_LEN], session3[SESSION_ID_LEN];
    strncpy(session1, sid1, SESSION_ID_LEN);
    strncpy(session2, sid2, SESSION_ID_LEN);
    strncpy(session3, sid3, SESSION_ID_LEN);

    /* Store data in sessions */
    session_set(cache, session1, "user_id", "12345");
    session_set(cache, session1, "username", "john_doe");
    session_set(cache, session1, "role", "admin");

    session_set(cache, session2, "user_id", "67890");
    session_set(cache, session2, "username", "jane_smith");
    session_set(cache, session2, "cart_items", "3");

    session_set(cache, session3, "user_id", "11111");
    session_set(cache, session3, "temp_token", "abc-xyz-123");

    /* Access session data */
    printf("\n--- Accessing Session Data ---\n");
    const char *val = session_get(cache, session1, "username");
    printf("Session1 username: %s\n", val ? val : "(null)");

    val = session_get(cache, session2, "cart_items");
    printf("Session2 cart_items: %s\n", val ? val : "(null)");

    val = session_get(cache, session1, "nonexistent_key");
    printf("Session1 nonexistent: %s\n", val ? val : "(null)");

    /* Print session details */
    session_print_info(cache, session1);
    session_print_info(cache, session2);
    session_print_info(cache, session3);

    cache_print_stats(cache);

    /* Update a value */
    printf("--- Updating session data ---\n");
    session_set(cache, session2, "cart_items", "5");
    val = session_get(cache, session2, "cart_items");
    printf("Session2 cart_items (updated): %s\n", val ? val : "(null)");

    /* Remove a key */
    session_remove_key(cache, session1, "role");
    val = session_get(cache, session1, "role");
    printf("Session1 role (after remove): %s\n\n", val ? val : "(null)");

    /* Invalidate a session (data freed, ID kept) */
    printf("--- Invalidating Session 1 ---\n");
    session_invalidate(cache, session1);
    session_print_info(cache, session1);

    /* Try to access invalidated session */
    val = session_get(cache, session1, "username");
    printf("Session1 username after invalidation: %s\n\n", val ? val : "(null)");

    /* Re-initialize the invalidated session */
    printf("--- Re-initializing Session 1 ---\n");
    bool ok = session_reinitialize(cache, session1);
    printf("Re-initialization result: %s\n", ok ? "SUCCESS" : "FAILED");

    /* Set new data on re-initialized session */
    session_set(cache, session1, "user_id", "12345");
    session_set(cache, session1, "username", "john_doe_v2");
    val = session_get(cache, session1, "username");
    printf("Session1 username after re-init: %s\n\n", val ? val : "(null)");

    session_print_info(cache, session1);

    /* Touch session to extend TTL */
    printf("--- Touching Session 2 ---\n");
    session_touch(cache, session2);
    printf("Session 2 TTL extended.\n\n");

    /* Wait for session3 to expire (3 second TTL) */
    printf("--- Waiting for Session 3 to expire (3 seconds) ---\n");
    printf("Sleeping...\n");

    /* Simulate time passing - in production this happens naturally */
    /* For demo, we manually adjust the expiration */
    {
        int idx = find_session_index(cache, session3);
        if (idx >= 0) {
            cache->sessions[idx].expires_at = time(NULL) - 1;  /* Force expiration */
        }
    }

    /* Run cache cleanup */
    int expired = cache_cleanup(cache);
    printf("Expired sessions cleaned up: %d\n", expired);

    /* Check session3 status */
    SessionStatus status = session_get_status(cache, session3);
    printf("Session3 status: %s\n",
           status == SESSION_ACTIVE ? "ACTIVE" :
           status == SESSION_EXPIRED ? "EXPIRED" : "INVALIDATED");

    /* Session3's ID is still in cache - can be quickly re-initialized */
    printf("\n--- Quick Re-init of expired Session 3 ---\n");
    ok = session_reinitialize(cache, session3);
    printf("Re-initialization of expired session: %s\n", ok ? "SUCCESS" : "FAILED");
    session_set(cache, session3, "user_id", "11111");
    session_set(cache, session3, "new_data", "fresh_start");
    session_print_info(cache, session3);

    /* Final stats */
    cache_print_stats(cache);

    /* Fully destroy a session (remove from cache completely) */
    printf("--- Fully destroying Session 2 ---\n");
    session_destroy(cache, session2);
    val = session_get(cache, session2, "username");
    printf("Session2 after destroy: %s\n", val ? val : "(null)");

    /* Try to re-init destroyed session (should fail) */
    ok = session_reinitialize(cache, session2);
    printf("Re-init destroyed session2: %s\n\n", ok ? "SUCCESS" : "FAILED");

    cache_print_stats(cache);

    /* Cleanup */
    cache_destroy(cache);

    printf("=== Demo Complete ===\n");
    return 0;
}