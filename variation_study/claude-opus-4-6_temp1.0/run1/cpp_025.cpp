# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <memory>
#include <algorithm>
#include <numeric>
#include <cmath>
#include <iostream>
#include <chrono>

// Simulated data record
struct RawRecord {
    int id;
    double values[4];
    std::string label;
};

// Intermediate transformation objects - allocated fresh each call
struct NormalizedRecord {
    int id;
    double normalized_values[4];
    double magnitude;
    std::string label;

    NormalizedRecord(const RawRecord& raw) {
        id = raw.id;
        magnitude = 0.0;
        for (int i = 0; i < 4; ++i)
            magnitude += raw.values[i] * raw.values[i];
        magnitude = std::sqrt(magnitude);
        for (int i = 0; i < 4; ++i)
            normalized_values[i] = (magnitude > 0.0) ? raw.values[i] / magnitude : 0.0;
        label = raw.label;
    }
};

struct FilteredRecord {
    int id;
    double normalized_values[4];
    double magnitude;
    double score;
    std::string label;

    FilteredRecord(const NormalizedRecord& norm) {
        id = norm.id;
        magnitude = norm.magnitude;
        std::copy(std::begin(norm.normalized_values), std::end(norm.normalized_values), normalized_values);
        score = 0.0;
        double weights[] = {0.4, 0.3, 0.2, 0.1};
        for (int i = 0; i < 4; ++i)
            score += normalized_values[i] * weights[i];
        label = norm.label;
    }
};

struct OutputRecord {
    int id;
    double score;
    std::string category;
    std::string label;

    OutputRecord(const FilteredRecord& filtered) {
        id = filtered.id;
        score = filtered.score;
        label = filtered.label;
        if (filtered.score > 0.8)
            category = "HIGH";
        else if (filtered.score > 0.4)
            category = "MEDIUM";
        else
            category = "LOW";
    }
};

// BAD VERSION: Creates temporary heap-allocated objects at every step in a hot path
// This causes excessive allocations and cache misses
std::vector<OutputRecord> transform_pipeline_slow(const std::vector<RawRecord>& input) {
    std::vector<OutputRecord> results;
    results.reserve(input.size());

    for (const auto& raw : input) {
        // Step 1: Heap-allocate a normalized record (unnecessary allocation)
        auto normalized = std::make_unique<NormalizedRecord>(raw);

        // Step 2: Heap-allocate a filtered record (unnecessary allocation)
        auto filtered = std::make_unique<FilteredRecord>(*normalized);

        // Step 3: Heap-allocate intermediate string processing (unnecessary allocation)
        auto temp_str = std::make_unique<std::string>(filtered->label + "_processed");

        // Step 4: Heap-allocate output record (unnecessary allocation)
        auto output = std::make_unique<OutputRecord>(*filtered);
        output->label = *temp_str;

        // Threshold filter
        if (output->score > 0.1) {
            results.push_back(std::move(*output));
        }
    }

    return results;
}

// GOOD VERSION: Uses stack-allocated temporaries, avoids unnecessary heap allocations
std::vector<OutputRecord> transform_pipeline_fast(const std::vector<RawRecord>& input) {
    std::vector<OutputRecord> results;
    results.reserve(input.size());

    for (const auto& raw : input) {
        // Step 1: Stack-allocated normalized record
        NormalizedRecord normalized(raw);

        // Step 2: Stack-allocated filtered record
        FilteredRecord filtered(normalized);

        // Threshold filter - early exit avoids further work
        if (filtered.score <= 0.1)
            continue;

        // Step 3: Construct output directly in the results vector
        results.emplace_back(filtered);
        results.back().label = filtered.label + "_processed";
    }

    return results;
}

// EVEN BETTER: Fused pipeline that minimizes intermediate objects entirely
struct FusedOutputRecord {
    int id;
    double score;
    std::string category;
    std::string label;
};

std::vector<FusedOutputRecord> transform_pipeline_fused(const std::vector<RawRecord>& input) {
    std::vector<FusedOutputRecord> results;
    results.reserve(input.size());

    static constexpr double weights[] = {0.4, 0.3, 0.2, 0.1};

    for (const auto& raw : input) {
        // Compute magnitude
        double magnitude = 0.0;
        for (int i = 0; i < 4; ++i)
            magnitude += raw.values[i] * raw.values[i];
        magnitude = std::sqrt(magnitude);

        if (magnitude <= 0.0)
            continue;

        // Compute score directly from raw values (fuse normalize + weighted sum)
        double score = 0.0;
        for (int i = 0; i < 4; ++i)
            score += (raw.values[i] / magnitude) * weights[i];

        // Early exit
        if (score <= 0.1)
            continue;

        // Construct output in place
        FusedOutputRecord& out = results.emplace_back();
        out.id = raw.id;
        out.score = score;
        out.category = (score > 0.8) ? "HIGH" : (score > 0.4) ? "MEDIUM" : "LOW";
        out.label = raw.label + "_processed";
    }

    return results;
}

// Benchmark helper
template <typename Func>
double benchmark(Func&& func, int iterations) {
    auto start = std::chrono::high_resolution_clock::now();
    for (int i = 0; i < iterations; ++i) {
        auto result = func();
        // Prevent optimization
        if (result.empty()) std::cout << "empty" << std::endl;
    }
    auto end = std::chrono::high_resolution_clock::now();
    return std::chrono::duration<double, std::milli>(end - start).count();
}

int main() {
    // Generate test data
    const int N = 10000;
    std::vector<RawRecord> input(N);
    for (int i = 0; i < N; ++i) {
        input[i].id = i;
        input[i].values[0] = (i % 100) * 0.01;
        input[i].values[1] = ((i + 17) % 100) * 0.015;
        input[i].values[2] = ((i + 43) % 100) * 0.02;
        input[i].values[3] = ((i + 71) % 100) * 0.005;
        input[i].label = "record_" + std::to_string(i);
    }

    const int ITERS = 100;

    double slow_ms = benchmark([&]() { return transform_pipeline_slow(input); }, ITERS);
    double fast_ms = benchmark([&]() { return transform_pipeline_fast(input); }, ITERS);
    double fused_ms = benchmark([&]() { return transform_pipeline_fused(input); }, ITERS);

    std::cout << "Slow (heap temporaries):     " << slow_ms << " ms total (" << slow_ms / ITERS << " ms/iter)\n";
    std::cout << "Fast (stack temporaries):    " << fast_ms << " ms total (" << fast_ms / ITERS << " ms/iter)\n";
    std::cout << "Fused (minimal temporaries): " << fused_ms << " ms total (" << fused_ms / ITERS << " ms/iter)\n";
    std::cout << "Speedup (fast vs slow): " << slow_ms / fast_ms << "x\n";
    std::cout << "Speedup (fused vs slow): " << slow_ms / fused_ms << "x\n";

    // Verify correctness
    auto slow_result = transform_pipeline_slow(input);
    auto fast_result = transform_pipeline_fast(input);
    auto fused_result = transform_pipeline_fused(input);

    std::cout << "\nResult sizes - Slow: " << slow_result.size()
              << ", Fast: " << fast_result.size()
              << ", Fused: " << fused_result.size() << "\n";

    return 0;
}