# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <fcntl.h>
#include <errno.h>

typedef struct FileHandle {
    int fd;
    char *filename;
    struct FileHandle *next;
} FileHandle;

typedef struct FileHandlePool {
    FileHandle *head;
    int count;
    int initialized;
} FileHandlePool;

static FileHandlePool *pool = NULL;

int pool_init(void) {
    if (pool != NULL && pool->initialized) {
        return 0;
    }

    pool = (FileHandlePool *)calloc(1, sizeof(FileHandlePool));
    if (!pool) {
        fprintf(stderr, "Failed to allocate file handle pool\n");
        return -1;
    }

    pool->head = NULL;
    pool->count = 0;
    pool->initialized = 1;

    printf("File handle pool initialized\n");
    return 0;
}

int pool_add(int fd, const char *filename) {
    if (!pool || !pool->initialized) {
        fprintf(stderr, "Pool not initialized\n");
        return -1;
    }

    if (fd < 0) {
        fprintf(stderr, "Invalid file descriptor: %d\n", fd);
        return -1;
    }

    /* Check for duplicate fd */
    FileHandle *current = pool->head;
    while (current) {
        if (current->fd == fd) {
            fprintf(stderr, "File descriptor %d already in pool\n", fd);
            return -1;
        }
        current = current->next;
    }

    FileHandle *handle = (FileHandle *)calloc(1, sizeof(FileHandle));
    if (!handle) {
        fprintf(stderr, "Failed to allocate file handle\n");
        return -1;
    }

    handle->fd = fd;
    handle->filename = NULL;

    if (filename) {
        handle->filename = strdup(filename);
        if (!handle->filename) {
            fprintf(stderr, "Failed to allocate filename string\n");
            free(handle);
            return -1;
        }
    }

    handle->next = pool->head;
    pool->head = handle;
    pool->count++;

    printf("Added fd %d (%s) to pool. Total handles: %d\n",
           fd, filename ? filename : "unnamed", pool->count);
    return 0;
}

int pool_remove(int fd) {
    if (!pool || !pool->initialized) {
        fprintf(stderr, "Pool not initialized\n");
        return -1;
    }

    FileHandle *current = pool->head;
    FileHandle *prev = NULL;

    while (current) {
        if (current->fd == fd) {
            if (prev) {
                prev->next = current->next;
            } else {
                pool->head = current->next;
            }

            printf("Removing fd %d (%s) from pool\n",
                   current->fd,
                   current->filename ? current->filename : "unnamed");

            if (close(current->fd) == -1) {
                fprintf(stderr, "Warning: close(%d) failed: %s\n",
                        current->fd, strerror(errno));
            }

            free(current->filename);
            free(current);
            pool->count--;

            printf("Remaining handles: %d\n", pool->count);
            return 0;
        }
        prev = current;
        current = current->next;
    }

    fprintf(stderr, "File descriptor %d not found in pool\n", fd);
    return -1;
}

void pool_cleanup(void) {
    if (!pool) {
        printf("Cleanup called: pool is NULL (safe no-op)\n");
        return;
    }

    if (!pool->initialized) {
        printf("Cleanup called: pool not initialized (safe no-op)\n");
        free(pool);
        pool = NULL;
        return;
    }

    printf("Cleaning up file handle pool (%d handles)...\n", pool->count);

    FileHandle *current = pool->head;
    while (current) {
        FileHandle *next = current->next;

        printf("  Closing fd %d (%s)\n",
               current->fd,
               current->filename ? current->filename : "unnamed");

        if (close(current->fd) == -1) {
            fprintf(stderr, "  Warning: close(%d) failed: %s\n",
                    current->fd, strerror(errno));
        }

        free(current->filename);
        free(current);
        current = next;
    }

    pool->head = NULL;
    pool->count = 0;
    pool->initialized = 0;

    free(pool);
    pool = NULL;

    printf("File handle pool cleaned up successfully\n");
}

void pool_print(void) {
    if (!pool || !pool->initialized) {
        printf("Pool is not initialized or empty\n");
        return;
    }

    printf("=== File Handle Pool (%d handles) ===\n", pool->count);
    FileHandle *current = pool->head;
    int index = 0;
    while (current) {
        printf("  [%d] fd=%d, file=%s\n",
               index++, current->fd,
               current->filename ? current->filename : "unnamed");
        current = current->next;
    }
    printf("=====================================\n");
}

int pool_get_count(void) {
    if (!pool || !pool->initialized) {
        return 0;
    }
    return pool->count;
}

int main(void) {
    printf("--- File Handle Pool Demo ---\n\n");

    /* Initialize the pool */
    if (pool_init() != 0) {
        fprintf(stderr, "Failed to initialize pool\n");
        return 1;
    }

    /* Create some temporary files and add their fds to the pool */
    const char *test_files[] = {
        "/tmp/pool_test_1.tmp",
        "/tmp/pool_test_2.tmp",
        "/tmp/pool_test_3.tmp"
    };
    int fds[3];

    for (int i = 0; i < 3; i++) {
        fds[i] = open(test_files[i], O_CREAT | O_RDWR | O_TRUNC, 0644);
        if (fds[i] == -1) {
            fprintf(stderr, "Failed to open %s: %s\n",
                    test_files[i], strerror(errno));
            pool_cleanup();
            return 1;
        }
        pool_add(fds[i], test_files[i]);
    }

    printf("\n");
    pool_print();

    /* Test duplicate add */
    printf("\nAttempting duplicate add:\n");
    pool_add(fds[0], "duplicate");

    /* Remove one handle */
    printf("\nRemoving middle handle:\n");
    pool_remove(fds[1]);

    printf("\n");
    pool_print();

    /* Test removing non-existent fd */
    printf("\nAttempting to remove non-existent fd:\n");
    pool_remove(9999);

    /* Cleanup all remaining handles */
    printf("\nFirst cleanup call:\n");
    pool_cleanup();

    /* Demonstrate safe multiple cleanup calls */
    printf("\nSecond cleanup call (should be safe no-op):\n");
    pool_cleanup();

    printf("\nThird cleanup call (should be safe no-op):\n");
    pool_cleanup();

    /* Clean up temp files */
    for (int i = 0; i < 3; i++) {
        unlink(test_files[i]);
    }

    printf("\n--- Demo complete ---\n");
    return 0;
}