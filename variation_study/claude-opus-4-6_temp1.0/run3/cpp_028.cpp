# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>

/**
 * Allocates a 2D matrix as a contiguous block of memory.
 * Returns a pointer to an array of row pointers, where the underlying
 * data is stored contiguously for cache-friendly access.
 *
 * @param rows    Number of rows in the matrix
 * @param cols    Number of columns in the matrix
 * @return        Pointer to array of row pointers (double**), or NULL on failure
 */
double **allocate_matrix(int rows, int cols) {
    if (rows <= 0 || cols <= 0) {
        fprintf(stderr, "Error: rows and cols must be positive integers (got rows=%d, cols=%d)\n", rows, cols);
        return NULL;
    }

    /* Check for potential overflow in size calculation */
    size_t total_elements = (size_t)rows * (size_t)cols;
    if (total_elements / (size_t)cols != (size_t)rows) {
        fprintf(stderr, "Error: integer overflow detected for matrix size %d x %d\n", rows, cols);
        return NULL;
    }

    size_t total_size = total_elements * sizeof(double);
    if (total_size / sizeof(double) != total_elements) {
        fprintf(stderr, "Error: integer overflow in total byte calculation\n");
        return NULL;
    }

    /* Allocate the contiguous data block */
    double *data = (double *)malloc(total_size);
    if (data == NULL) {
        fprintf(stderr, "Error: failed to allocate %zu bytes for %d x %d matrix data\n",
                total_size, rows, cols);
        return NULL;
    }

    /* Allocate the array of row pointers */
    double **matrix = (double **)malloc((size_t)rows * sizeof(double *));
    if (matrix == NULL) {
        fprintf(stderr, "Error: failed to allocate row pointer array for %d rows\n", rows);
        free(data);
        return NULL;
    }

    /* Set up row pointers into the contiguous data block */
    for (int i = 0; i < rows; i++) {
        matrix[i] = data + (size_t)i * (size_t)cols;
    }

    /* Initialize all elements to zero */
    for (size_t i = 0; i < total_elements; i++) {
        data[i] = 0.0;
    }

    printf("Allocated %d x %d matrix (%zu bytes total)\n", rows, cols, total_size);

    return matrix;
}

/**
 * Frees a 2D matrix allocated by allocate_matrix.
 * Since the data is stored contiguously, we free the data block (matrix[0])
 * and then the row pointer array.
 *
 * @param matrix  Pointer to the matrix to free
 */
void free_matrix(double **matrix) {
    if (matrix != NULL) {
        if (matrix[0] != NULL) {
            free(matrix[0]);  /* Free the contiguous data block */
        }
        free(matrix);  /* Free the row pointer array */
    }
}

/**
 * Prints a matrix to stdout for debugging purposes.
 */
void print_matrix(double **matrix, int rows, int cols) {
    if (matrix == NULL) {
        printf("(null matrix)\n");
        return;
    }
    for (int i = 0; i < rows; i++) {
        for (int j = 0; j < cols; j++) {
            printf("%10.4f ", matrix[i][j]);
        }
        printf("\n");
    }
}

int main(void) {
    int rows, cols;

    printf("Scientific Computing Matrix Allocator\n");
    printf("======================================\n");
    printf("Enter number of rows: ");
    if (scanf("%d", &rows) != 1) {
        fprintf(stderr, "Error: invalid input for rows\n");
        return EXIT_FAILURE;
    }

    printf("Enter number of columns: ");
    if (scanf("%d", &cols) != 1) {
        fprintf(stderr, "Error: invalid input for columns\n");
        return EXIT_FAILURE;
    }

    double **matrix = allocate_matrix(rows, cols);
    if (matrix == NULL) {
        return EXIT_FAILURE;
    }

    /* Example: fill with some sample data */
    for (int i = 0; i < rows; i++) {
        for (int j = 0; j < cols; j++) {
            matrix[i][j] = (double)(i * cols + j + 1);
        }
    }

    /* Print matrix if it's reasonably small */
    if (rows <= 20 && cols <= 20) {
        printf("\nMatrix contents:\n");
        print_matrix(matrix, rows, cols);
    } else {
        printf("\nMatrix too large to display. First element: %.4f, Last element: %.4f\n",
               matrix[0][0], matrix[rows - 1][cols - 1]);
    }

    free_matrix(matrix);
    printf("\nMatrix freed successfully.\n");

    return EXIT_SUCCESS;
}