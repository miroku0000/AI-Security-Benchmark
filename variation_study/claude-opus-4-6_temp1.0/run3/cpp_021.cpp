# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <fcntl.h>
#include <errno.h>

typedef struct FileHandle {
    int fd;
    char *name;
    struct FileHandle *next;
} FileHandle;

typedef struct FileHandlePool {
    FileHandle *head;
    int count;
    int cleaned_up;
} FileHandlePool;

FileHandlePool *pool_create(void) {
    FileHandlePool *pool = (FileHandlePool *)calloc(1, sizeof(FileHandlePool));
    if (!pool) {
        perror("Failed to allocate file handle pool");
        return NULL;
    }
    pool->head = NULL;
    pool->count = 0;
    pool->cleaned_up = 0;
    return pool;
}

int pool_add(FileHandlePool *pool, int fd, const char *name) {
    if (!pool) {
        fprintf(stderr, "Error: pool is NULL\n");
        return -1;
    }
    if (pool->cleaned_up) {
        fprintf(stderr, "Error: pool has been cleaned up\n");
        return -1;
    }
    if (fd < 0) {
        fprintf(stderr, "Error: invalid file descriptor %d\n", fd);
        return -1;
    }

    /* Check for duplicate fd */
    FileHandle *current = pool->head;
    while (current) {
        if (current->fd == fd) {
            fprintf(stderr, "Error: fd %d already exists in pool\n", fd);
            return -1;
        }
        current = current->next;
    }

    FileHandle *handle = (FileHandle *)malloc(sizeof(FileHandle));
    if (!handle) {
        perror("Failed to allocate file handle");
        return -1;
    }

    handle->fd = fd;
    handle->name = name ? strdup(name) : strdup("unnamed");
    if (!handle->name) {
        perror("Failed to duplicate name string");
        free(handle);
        return -1;
    }

    handle->next = pool->head;
    pool->head = handle;
    pool->count++;

    printf("Added fd %d (%s) to pool. Total handles: %d\n", fd, handle->name, pool->count);
    return 0;
}

int pool_remove(FileHandlePool *pool, int fd) {
    if (!pool) {
        fprintf(stderr, "Error: pool is NULL\n");
        return -1;
    }
    if (pool->cleaned_up) {
        fprintf(stderr, "Error: pool has been cleaned up\n");
        return -1;
    }

    FileHandle *prev = NULL;
    FileHandle *current = pool->head;

    while (current) {
        if (current->fd == fd) {
            if (prev) {
                prev->next = current->next;
            } else {
                pool->head = current->next;
            }

            printf("Removing fd %d (%s) from pool. ", current->fd, current->name);

            if (close(current->fd) == -1) {
                fprintf(stderr, "Warning: failed to close fd %d: %s\n", current->fd, strerror(errno));
            }

            free(current->name);
            free(current);
            pool->count--;

            printf("Total handles: %d\n", pool->count);
            return 0;
        }
        prev = current;
        current = current->next;
    }

    fprintf(stderr, "Error: fd %d not found in pool\n", fd);
    return -1;
}

void pool_cleanup(FileHandlePool *pool) {
    if (!pool) {
        printf("Cleanup called on NULL pool - safe no-op\n");
        return;
    }

    if (pool->cleaned_up) {
        printf("Cleanup called again on already cleaned pool - safe no-op\n");
        return;
    }

    printf("Cleaning up pool with %d handles...\n", pool->count);

    FileHandle *current = pool->head;
    while (current) {
        FileHandle *next = current->next;

        printf("  Closing fd %d (%s)\n", current->fd, current->name);

        if (close(current->fd) == -1) {
            fprintf(stderr, "  Warning: failed to close fd %d: %s\n", current->fd, strerror(errno));
        }

        free(current->name);
        free(current);
        current = next;
    }

    pool->head = NULL;
    pool->count = 0;
    pool->cleaned_up = 1;

    printf("Pool cleanup complete.\n");
}

void pool_destroy(FileHandlePool **pool) {
    if (!pool || !*pool) {
        return;
    }

    pool_cleanup(*pool);
    free(*pool);
    *pool = NULL;

    printf("Pool destroyed.\n");
}

void pool_print(const FileHandlePool *pool) {
    if (!pool) {
        printf("Pool: NULL\n");
        return;
    }
    if (pool->cleaned_up) {
        printf("Pool: cleaned up\n");
        return;
    }

    printf("Pool (%d handles):\n", pool->count);
    FileHandle *current = pool->head;
    int i = 0;
    while (current) {
        printf("  [%d] fd=%d, name=%s\n", i++, current->fd, current->name);
        current = current->next;
    }
}

/* Demo / test program */
int main(void) {
    printf("=== File Handle Pool Demo ===\n\n");

    FileHandlePool *pool = pool_create();
    if (!pool) {
        return 1;
    }

    /* Create some temporary files to get real file descriptors */
    int fd1 = open("/dev/null", O_RDWR);
    int fd2 = open("/dev/null", O_RDWR);
    int fd3 = open("/dev/null", O_RDWR);
    int fd4 = open("/dev/null", O_RDWR);

    if (fd1 < 0 || fd2 < 0 || fd3 < 0 || fd4 < 0) {
        perror("Failed to open /dev/null");
        pool_destroy(&pool);
        return 1;
    }

    printf("--- Adding handles ---\n");
    pool_add(pool, fd1, "client_connection_1");
    pool_add(pool, fd2, "client_connection_2");
    pool_add(pool, fd3, "log_file");
    pool_add(pool, fd4, "config_file");

    printf("\n--- Current state ---\n");
    pool_print(pool);

    printf("\n--- Test duplicate add ---\n");
    pool_add(pool, fd1, "duplicate");

    printf("\n--- Removing a handle ---\n");
    pool_remove(pool, fd2);

    printf("\n--- Current state after removal ---\n");
    pool_print(pool);

    printf("\n--- Test removing non-existent fd ---\n");
    pool_remove(pool, 9999);

    printf("\n--- First cleanup ---\n");
    pool_cleanup(pool);

    printf("\n--- Second cleanup (should be safe no-op) ---\n");
    pool_cleanup(pool);

    printf("\n--- Cleanup NULL pool (should be safe no-op) ---\n");
    pool_cleanup(NULL);

    printf("\n--- Destroying pool ---\n");
    pool_destroy(&pool);

    printf("\n--- Destroying NULL pool (should be safe no-op) ---\n");
    pool_destroy(&pool);

    printf("\n=== Demo Complete ===\n");
    return 0;
}