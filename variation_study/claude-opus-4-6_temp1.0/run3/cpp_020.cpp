# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <utility>
#include <functional>

template <typename T>
class ResourceManager {
public:
    using DeleterType = std::function<void(T*)>;

    // Default constructor - no resource
    ResourceManager() noexcept
        : m_resource(nullptr)
        , m_deleter(default_deleter)
    {}

    // Constructor with raw pointer and optional custom deleter
    explicit ResourceManager(T* resource, DeleterType deleter = default_deleter)
        : m_resource(resource)
        , m_deleter(std::move(deleter))
    {}

    // Destructor - RAII cleanup
    ~ResourceManager() {
        cleanup();
    }

    // Delete copy constructor and copy assignment (unique ownership)
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource)
        , m_deleter(std::move(other.m_deleter))
    {
        other.m_resource = nullptr;
    }

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            m_resource = other.m_resource;
            m_deleter = std::move(other.m_deleter);
            other.m_resource = nullptr;
        }
        return *this;
    }

    // Reset with no argument - releases current resource
    void reset() noexcept {
        cleanup();
    }

    // Reset with new resource and optional deleter
    void reset(T* resource, DeleterType deleter = default_deleter) {
        cleanup();
        m_resource = resource;
        m_deleter = std::move(deleter);
    }

    // Release ownership without deleting
    T* release() noexcept {
        T* temp = m_resource;
        m_resource = nullptr;
        return temp;
    }

    // Access the managed resource
    T* get() const noexcept {
        return m_resource;
    }

    // Dereference operators
    T& operator*() const {
        return *m_resource;
    }

    T* operator->() const noexcept {
        return m_resource;
    }

    // Boolean conversion - check if resource is held
    explicit operator bool() const noexcept {
        return m_resource != nullptr;
    }

    // Swap
    void swap(ResourceManager& other) noexcept {
        using std::swap;
        swap(m_resource, other.m_resource);
        swap(m_deleter, other.m_deleter);
    }

private:
    T* m_resource;
    DeleterType m_deleter;

    static void default_deleter(T* ptr) {
        delete ptr;
    }

    void cleanup() noexcept {
        if (m_resource) {
            try {
                if (m_deleter) {
                    m_deleter(m_resource);
                }
            } catch (...) {
                // Suppress exceptions in cleanup
            }
            m_resource = nullptr;
        }
    }
};

// Free swap function
template <typename T>
void swap(ResourceManager<T>& a, ResourceManager<T>& b) noexcept {
    a.swap(b);
}

// Helper factory function (similar to std::make_unique)
template <typename T, typename... Args>
ResourceManager<T> make_resource(Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...));
}


// --- Demo / Usage ---

struct DatabaseConnection {
    std::string connection_string;

    DatabaseConnection(const std::string& conn) : connection_string(conn) {
        std::cout << "  [DB] Opened connection: " << connection_string << std::endl;
    }

    ~DatabaseConnection() {
        std::cout << "  [DB] Closed connection: " << connection_string << std::endl;
    }

    void query(const std::string& sql) const {
        std::cout << "  [DB] Executing on " << connection_string << ": " << sql << std::endl;
    }
};

struct FileHandle {
    std::string filename;

    FileHandle(const std::string& name) : filename(name) {
        std::cout << "  [File] Opened: " << filename << std::endl;
    }

    void write(const std::string& data) const {
        std::cout << "  [File] Writing to " << filename << ": " << data << std::endl;
    }
};

void close_file(FileHandle* fh) {
    std::cout << "  [File] Custom close for: " << fh->filename << std::endl;
    delete fh;
}

int main() {
    std::cout << "=== Basic RAII with default deleter ===" << std::endl;
    {
        auto db = make_resource<DatabaseConnection>("localhost:5432/mydb");
        db->query("SELECT * FROM users");
        std::cout << "  Resource valid: " << (db ? "yes" : "no") << std::endl;
    }
    std::cout << "  (scope ended, resource auto-cleaned)\n" << std::endl;

    std::cout << "=== Custom deleter ===" << std::endl;
    {
        ResourceManager<FileHandle> file(new FileHandle("output.txt"), close_file);
        file->write("Hello, RAII!");
    }
    std::cout << "  (scope ended, custom deleter called)\n" << std::endl;

    std::cout << "=== Move semantics ===" << std::endl;
    {
        auto db1 = make_resource<DatabaseConnection>("server-A");
        std::cout << "  db1 valid: " << (db1 ? "yes" : "no") << std::endl;

        ResourceManager<DatabaseConnection> db2 = std::move(db1);
        std::cout << "  After move:" << std::endl;
        std::cout << "  db1 valid: " << (db1 ? "yes" : "no") << std::endl;
        std::cout << "  db2 valid: " << (db2 ? "yes" : "no") << std::endl;
        db2->query("SELECT 1");
    }
    std::cout << "  (scope ended)\n" << std::endl;

    std::cout << "=== Early cleanup with reset() ===" << std::endl;
    {
        auto db = make_resource<DatabaseConnection>("server-B");
        db->query("BEGIN TRANSACTION");
        std::cout << "  Calling reset() for early cleanup..." << std::endl;
        db.reset();
        std::cout << "  Resource valid after reset: " << (db ? "yes" : "no") << std::endl;
        std::cout << "  Resetting with new resource..." << std::endl;
        db.reset(new DatabaseConnection("server-C"));
        db->query("SELECT version()");
    }
    std::cout << "  (scope ended)\n" << std::endl;

    std::cout << "=== Release ownership ===" << std::endl;
    {
        auto db = make_resource<DatabaseConnection>("server-D");
        DatabaseConnection* raw = db.release();
        std::cout << "  Resource valid after release: " << (db ? "yes" : "no") << std::endl;
        std::cout << "  Manual cleanup of released resource..." << std::endl;
        delete raw;
    }
    std::cout << "  (scope ended)\n" << std::endl;

    std::cout << "=== Swap ===" << std::endl;
    {
        auto r1 = make_resource<DatabaseConnection>("alpha");
        auto r2 = make_resource<DatabaseConnection>("beta");
        std::cout << "  Before swap: r1=" << r1->connection_string
                  << ", r2=" << r2->connection_string << std::endl;
        swap(r1, r2);
        std::cout << "  After swap:  r1=" << r1->connection_string
                  << ", r2=" << r2->connection_string << std::endl;
    }
    std::cout << "  (scope ended)\n" << std::endl;

    return 0;
}