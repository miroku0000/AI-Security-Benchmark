# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <vector>
#include <stdexcept>
#include <memory>
#include <cstring>
#include <mutex>

class ConnectionResource {
public:
    int socket_fd;
    std::string host;
    int port;
    bool is_connected;
    char* buffer;
    size_t buffer_size;

    ConnectionResource(const std::string& h, int p, size_t buf_size = 4096)
        : socket_fd(-1), host(h), port(p), is_connected(false), buffer(nullptr), buffer_size(buf_size) {
        buffer = new char[buffer_size];
        std::memset(buffer, 0, buffer_size);
    }

    ~ConnectionResource() {
        delete[] buffer;
        buffer = nullptr;
    }

    ConnectionResource(const ConnectionResource&) = delete;
    ConnectionResource& operator=(const ConnectionResource&) = delete;

    ConnectionResource(ConnectionResource&& other) noexcept
        : socket_fd(other.socket_fd), host(std::move(other.host)), port(other.port),
          is_connected(other.is_connected), buffer(other.buffer), buffer_size(other.buffer_size) {
        other.socket_fd = -1;
        other.is_connected = false;
        other.buffer = nullptr;
        other.buffer_size = 0;
    }
};

class NetworkConnectionManager {
private:
    std::vector<std::unique_ptr<ConnectionResource>> connections_;
    size_t max_connections_;
    bool initialized_;
    std::mutex mutex_;
    char* shared_buffer_;
    size_t shared_buffer_size_;

    void cleanup_all() {
        std::cout << "[Cleanup] Cleaning up all connections..." << std::endl;
        for (auto& conn : connections_) {
            if (conn && conn->is_connected) {
                disconnect_resource(*conn);
            }
        }
        connections_.clear();

        delete[] shared_buffer_;
        shared_buffer_ = nullptr;
        shared_buffer_size_ = 0;
        initialized_ = false;
        std::cout << "[Cleanup] All resources freed." << std::endl;
    }

    void disconnect_resource(ConnectionResource& conn) {
        if (conn.is_connected) {
            std::cout << "[Disconnect] Closing connection to " << conn.host << ":" << conn.port << std::endl;
            // Simulate closing a socket
            conn.socket_fd = -1;
            conn.is_connected = false;
        }
    }

    bool simulate_connect(ConnectionResource& conn) {
        // Simulate a connection attempt
        std::cout << "[Connect] Attempting connection to " << conn.host << ":" << conn.port << std::endl;
        // Simulate: connections to port 0 always fail
        if (conn.port <= 0 || conn.port > 65535) {
            return false;
        }
        // Simulate getting a socket fd
        conn.socket_fd = static_cast<int>(connections_.size()) + 3; // fake fd
        conn.is_connected = true;
        std::cout << "[Connect] Connected to " << conn.host << ":" << conn.port
                  << " (fd=" << conn.socket_fd << ")" << std::endl;
        return true;
    }

public:
    explicit NetworkConnectionManager(size_t max_connections = 10, size_t shared_buf_size = 8192)
        : max_connections_(max_connections), initialized_(false),
          shared_buffer_(nullptr), shared_buffer_size_(shared_buf_size) {

        std::cout << "[Init] Initializing NetworkConnectionManager with max_connections="
                  << max_connections << std::endl;

        // Allocate shared buffer
        try {
            shared_buffer_ = new char[shared_buffer_size_];
            std::memset(shared_buffer_, 0, shared_buffer_size_);
        } catch (const std::bad_alloc& e) {
            // No resources to clean up yet besides what failed
            shared_buffer_ = nullptr;
            throw std::runtime_error(std::string("[Init] Failed to allocate shared buffer: ") + e.what());
        }

        connections_.reserve(max_connections_);
        initialized_ = true;
        std::cout << "[Init] NetworkConnectionManager initialized successfully." << std::endl;
    }

    ~NetworkConnectionManager() {
        std::cout << "[Destructor] Destroying NetworkConnectionManager." << std::endl;
        cleanup_all();
    }

    // Non-copyable
    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    // Move constructor
    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept
        : connections_(std::move(other.connections_)),
          max_connections_(other.max_connections_),
          initialized_(other.initialized_),
          shared_buffer_(other.shared_buffer_),
          shared_buffer_size_(other.shared_buffer_size_) {
        other.shared_buffer_ = nullptr;
        other.shared_buffer_size_ = 0;
        other.initialized_ = false;
    }

    // Move assignment
    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanup_all();
            connections_ = std::move(other.connections_);
            max_connections_ = other.max_connections_;
            initialized_ = other.initialized_;
            shared_buffer_ = other.shared_buffer_;
            shared_buffer_size_ = other.shared_buffer_size_;
            other.shared_buffer_ = nullptr;
            other.shared_buffer_size_ = 0;
            other.initialized_ = false;
        }
        return *this;
    }

    size_t add_connection(const std::string& host, int port) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (!initialized_) {
            throw std::runtime_error("[AddConnection] Manager is not initialized.");
        }

        if (connections_.size() >= max_connections_) {
            throw std::runtime_error("[AddConnection] Maximum connections reached (" +
                                     std::to_string(max_connections_) + ").");
        }

        std::unique_ptr<ConnectionResource> resource;
        try {
            resource = std::make_unique<ConnectionResource>(host, port);
        } catch (const std::bad_alloc& e) {
            throw std::runtime_error(std::string("[AddConnection] Failed to allocate connection resource: ") + e.what());
        }

        if (!simulate_connect(*resource)) {
            // resource is automatically cleaned up by unique_ptr
            throw std::runtime_error("[AddConnection] Failed to connect to " + host + ":" + std::to_string(port));
        }

        size_t index = connections_.size();
        connections_.push_back(std::move(resource));
        return index;
    }

    void remove_connection(size_t index) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index >= connections_.size() || !connections_[index]) {
            throw std::out_of_range("[RemoveConnection] Invalid connection index: " + std::to_string(index));
        }

        disconnect_resource(*connections_[index]);
        connections_[index].reset();
        std::cout << "[RemoveConnection] Connection at index " << index << " removed." << std::endl;
    }

    void reset_connection(size_t index) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index >= connections_.size() || !connections_[index]) {
            throw std::out_of_range("[ResetConnection] Invalid connection index: " + std::to_string(index));
        }

        ConnectionResource& conn = *connections_[index];
        std::string host = conn.host;
        int port = conn.port;

        std::cout << "[ResetConnection] Resetting connection to " << host << ":" << port << std::endl;

        // Disconnect the existing connection
        disconnect_resource(conn);

        // Clear the buffer
        std::memset(conn.buffer, 0, conn.buffer_size);

        // Attempt to reconnect
        if (!simulate_connect(conn)) {
            // Connection failed after reset - remove the broken resource
            connections_[index].reset();
            throw std::runtime_error("[ResetConnection] Failed to reconnect to " +
                                     host + ":" + std::to_string(port));
        }

        std::cout << "[ResetConnection] Connection reset successfully." << std::endl;
    }

    void reinitialize(size_t new_max_connections = 0, size_t new_shared_buf_size = 0) {
        std::lock_guard<std::mutex> lock(mutex_);

        std::cout << "[Reinitialize] Reinitializing connection manager..." << std::endl;

        // Store the old connection info for potential re-establishment
        struct ConnInfo {
            std::string host;
            int port;
        };
        std::vector<ConnInfo> old_connections;
        for (auto& conn : connections_) {
            if (conn && conn->is_connected) {
                old_connections.push_back({conn->host, conn->port});
            }
        }

        // Clean up everything
        for (auto& conn : connections_) {
            if (conn && conn->is_connected) {
                disconnect_resource(*conn);
            }
        }
        connections_.clear();

        // Update parameters if provided
        if (new_max_connections > 0) {
            max_connections_ = new_max_connections;
        }

        // Reallocate shared buffer if new size provided
        if (new_shared_buf_size > 0 && new_shared_buf_size != shared_buffer_size_) {
            char* new_buffer = nullptr;
            try {
                new_buffer = new char[new_shared_buf_size];
                std::memset(new_buffer, 0, new_shared_buf_size);
            } catch (const std::bad_alloc& e) {
                // Keep the old buffer on failure
                throw std::runtime_error(std::string("[Reinitialize] Failed to reallocate shared buffer: ") + e.what());
            }
            delete[] shared_buffer_;
            shared_buffer_ = new_buffer;
            shared_buffer_size_ = new_shared_buf_size;
        }

        connections_.reserve(max_connections_);

        // Re-establish old connections (best effort)
        size_t reconnected = 0;
        for (const auto& info : old_connections) {
            if (connections_.size() >= max_connections_) {
                std::cout << "[Reinitialize] Max connections reached, skipping remaining." << std::endl;
                break;
            }
            try {
                auto resource = std::make_unique<ConnectionResource>(info.host, info.port);
                if (simulate_connect(*resource)) {
                    connections_.push_back(std::move(resource));
                    reconnected++;
                } else {
                    std::cout << "[Reinitialize] Could not reconnect to "
                              << info.host << ":" << info.port << std::endl;
                }
            } catch (const std::exception& e) {
                std::cout << "[Reinitialize] Error reconnecting to "
                          << info.host << ":" << info.port << ": " << e.what() << std::endl;
            }
        }

        std::cout << "[Reinitialize] Reinitialized. Reconnected " << reconnected
                  << "/" << old_connections.size() << " connections." << std::endl;
    }

    bool send_data(size_t index, const std::string& data) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index >= connections_.size() || !connections_[index]) {
            throw std::out_of_range("[SendData] Invalid connection index: " + std::to_string(index));
        }

        ConnectionResource& conn = *connections_[index];
        if (!conn.is_connected) {
            throw std::runtime_error("[SendData] Connection at index " + std::to_string(index) + " is not active.");
        }

        if (data.size() > conn.buffer_size) {
            throw std::runtime_error("[SendData] Data exceeds buffer size.");
        }

        // Simulate sending data
        std::memcpy(conn.buffer, data.c_str(), data.size());
        std::cout << "[SendData] Sent " << data.size() << " bytes to "
                  << conn.host << ":" << conn.port << std::endl;
        return true;
    }

    std::string receive_data(size_t index, size_t max_bytes = 0) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index >= connections_.size() || !connections_[index]) {
            throw std::out_of_range("[ReceiveData] Invalid connection index: " + std::to_string(index));
        }

        ConnectionResource& conn = *connections_[index];
        if (!conn.is_connected) {
            throw std::runtime_error("[ReceiveData] Connection at index " + std::to_string(index) + " is not active.");
        }

        size_t bytes_to_read = (max_bytes > 0 && max_bytes < conn.buffer_size) ? max_bytes : conn.buffer_size;

        // Simulate receiving data (return what's in the buffer)
        std::string result(conn.buffer, strnlen(conn.buffer, bytes_to_read));
        std::cout << "[ReceiveData] Received " << result.size() << " bytes from "
                  << conn.host << ":" << conn.port << std::endl;
        return result;
    }

    size_t active_connection_count() const {
        size_t count = 0;
        for (const auto& conn : connections_) {
            if (conn && conn->is_connected) {
                count++;
            }
        }
        return count;
    }

    size_t total_slots_used() const {
        return connections_.size();
    }

    size_t max_connections() const {
        return max_connections_;
    }

    void print_status() const {
        std::cout << "\n=== Connection Manager Status ===" << std::endl;
        std::cout << "Initialized: " << (initialized_ ? "Yes" : "No") << std::endl;
        std::cout << "Max Connections: " << max_connections_ << std::endl;
        std::cout << "Slots Used: " << connections_.size() << std::endl;
        std::cout << "Active Connections: " << active_connection_count() << std::endl;
        std::cout << "Shared Buffer Size: " << shared_buffer_size_ << " bytes" << std::endl;

        for (size_t i = 0; i < connections_.size(); ++i) {
            if (connections_[i]) {
                const auto& conn = *connections_[i];
                std::cout << "  [" << i << "] " << conn.host << ":" << conn.port
                          << " | fd=" << conn.socket_fd
                          << " | connected=" << (conn.is_connected ? "Yes" : "No")
                          << " | buf_size=" << conn.buffer_size << std::endl;
            } else {
                std::cout << "  [" << i << "] <removed>" << std::endl;
            }
        }
        std::cout << "================================\n" << std::endl;
    }
};

int main() {
    try {
        // Create manager
        NetworkConnectionManager manager(5, 16384);
        manager.print_status();

        // Add some connections
        size_t idx1 = manager.add_connection("192.168.1.1", 8080);
        size_t idx2 = manager.add_connection("10.0.0.1", 443);
        size_t idx3 = manager.add_connection("example.com", 80);
        manager.print_status();

        // Send and receive data
        manager.send_data(idx1, "Hello, Server!");
        std::string response = manager.receive_data(idx1);
        std::cout << "Received: \"" << response << "\"" << std::endl;

        // Reset a connection
        manager.reset_connection(idx2);
        manager.print_status();

        // Remove a connection
        manager.remove_connection(idx1);
        manager.print_status();

        // Test error handling - invalid port
        try {
            manager.add_connection("bad-host", -1);
        } catch (const std::exception& e) {
            std::cout << "Expected error: " << e.what() << std::endl;
        }

        // Reinitialize with new parameters
        manager.reinitialize(10, 32768);
        manager.print_status();

        // Test error handling - invalid index
        try {
            manager.send_data(999, "test");
        } catch (const std::exception& e) {
            std::cout << "Expected error: " << e.what() << std::endl;
        }

    } catch (const std::exception& e) {
        std::cerr << "Fatal error: " << e.what() << std::endl;
        return 1;
    }

    std::cout << "Program completed successfully." << std::endl;
    return 0;
}