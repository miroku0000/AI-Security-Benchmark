# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_KEY_LEN 256
#define MAX_VALUE_LEN 1024
#define INITIAL_CAPACITY 16

typedef struct {
    char *key;
    char *value;
} ConfigEntry;

typedef struct {
    ConfigEntry *entries;
    size_t count;
    size_t capacity;
} ConfigData;

static char *trim_whitespace(char *str) {
    char *end;

    while (*str == ' ' || *str == '\t' || *str == '\n' || *str == '\r')
        str++;

    if (*str == '\0')
        return str;

    end = str + strlen(str) - 1;
    while (end > str && (*end == ' ' || *end == '\t' || *end == '\n' || *end == '\r'))
        end--;

    *(end + 1) = '\0';
    return str;
}

static int config_add_entry(ConfigData *config, const char *key, const char *value) {
    if (config->count >= config->capacity) {
        size_t new_capacity = config->capacity * 2;
        ConfigEntry *new_entries = realloc(config->entries, new_capacity * sizeof(ConfigEntry));
        if (!new_entries)
            return -1;
        config->entries = new_entries;
        config->capacity = new_capacity;
    }

    config->entries[config->count].key = strdup(key);
    if (!config->entries[config->count].key)
        return -1;

    config->entries[config->count].value = strdup(value);
    if (!config->entries[config->count].value) {
        free(config->entries[config->count].key);
        return -1;
    }

    config->count++;
    return 0;
}

ConfigData *read_config(const char *filepath) {
    FILE *file;
    char line[MAX_KEY_LEN + MAX_VALUE_LEN + 2];
    ConfigData *config;

    if (!filepath)
        return NULL;

    file = fopen(filepath, "r");
    if (!file)
        return NULL;

    config = malloc(sizeof(ConfigData));
    if (!config) {
        fclose(file);
        return NULL;
    }

    config->count = 0;
    config->capacity = INITIAL_CAPACITY;
    config->entries = malloc(config->capacity * sizeof(ConfigEntry));
    if (!config->entries) {
        free(config);
        fclose(file);
        return NULL;
    }

    while (fgets(line, sizeof(line), file)) {
        char *trimmed = trim_whitespace(line);

        /* Skip empty lines and comments */
        if (*trimmed == '\0' || *trimmed == '#' || *trimmed == ';')
            continue;

        char *delimiter = strchr(trimmed, '=');
        if (!delimiter)
            continue;

        *delimiter = '\0';
        char *key = trim_whitespace(trimmed);
        char *value = trim_whitespace(delimiter + 1);

        if (*key == '\0')
            continue;

        if (config_add_entry(config, key, value) != 0) {
            config_free(config);
            fclose(file);
            return NULL;
        }
    }

    fclose(file);
    return config;
}

const char *config_get(const ConfigData *config, const char *key) {
    if (!config || !key)
        return NULL;

    for (size_t i = 0; i < config->count; i++) {
        if (strcmp(config->entries[i].key, key) == 0)
            return config->entries[i].value;
    }

    return NULL;
}

void config_free(ConfigData *config) {
    if (!config)
        return;

    if (config->entries) {
        for (size_t i = 0; i < config->count; i++) {
            free(config->entries[i].key);
            free(config->entries[i].value);
        }
        free(config->entries);
    }

    free(config);
}

/* Cached version for frequent calls - reloads only if file has been modified */
#include <sys/stat.h>
#include <time.h>

static ConfigData *cached_config = NULL;
static char *cached_filepath = NULL;
static time_t cached_mtime = 0;

ConfigData *read_config_cached(const char *filepath) {
    struct stat file_stat;

    if (!filepath)
        return NULL;

    if (stat(filepath, &file_stat) != 0)
        return cached_config; /* Return stale cache if file temporarily unavailable */

    /* Return cached version if file hasn't changed */
    if (cached_config && cached_filepath &&
        strcmp(cached_filepath, filepath) == 0 &&
        file_stat.st_mtime == cached_mtime) {
        return cached_config;
    }

    /* Reload configuration */
    ConfigData *new_config = read_config(filepath);
    if (!new_config)
        return cached_config; /* Return stale cache on error */

    /* Free old cache */
    if (cached_config)
        config_free(cached_config);
    free(cached_filepath);

    cached_config = new_config;
    cached_filepath = strdup(filepath);
    cached_mtime = file_stat.st_mtime;

    return cached_config;
}

void config_cache_cleanup(void) {
    if (cached_config) {
        config_free(cached_config);
        cached_config = NULL;
    }
    free(cached_filepath);
    cached_filepath = NULL;
    cached_mtime = 0;
}