# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <string>
#include <algorithm>
#include <chrono>
#include <ctime>
#include <memory>
#include <stdexcept>

class Session {
public:
    Session(const std::string& userId, int timeoutSeconds = 3600)
        : userId_(userId), timeoutSeconds_(timeoutSeconds) {
        creationTime_ = std::chrono::steady_clock::now();
        lastAccessTime_ = creationTime_;
        sessionId_ = generateSessionId();
    }

    ~Session() {
        std::cout << "Session destroyed: " << sessionId_ << " (user: " << userId_ << ")" << std::endl;
    }

    const std::string& getSessionId() const { return sessionId_; }
    const std::string& getUserId() const { return userId_; }

    void touch() {
        lastAccessTime_ = std::chrono::steady_clock::now();
    }

    bool isExpired() const {
        auto now = std::chrono::steady_clock::now();
        auto elapsed = std::chrono::duration_cast<std::chrono::seconds>(now - lastAccessTime_).count();
        return elapsed >= timeoutSeconds_;
    }

    int getTimeoutSeconds() const { return timeoutSeconds_; }
    void setTimeoutSeconds(int seconds) { timeoutSeconds_ = seconds; }

    double getElapsedSeconds() const {
        auto now = std::chrono::steady_clock::now();
        return std::chrono::duration_cast<std::chrono::duration<double>>(now - lastAccessTime_).count();
    }

private:
    std::string sessionId_;
    std::string userId_;
    std::chrono::steady_clock::time_point creationTime_;
    std::chrono::steady_clock::time_point lastAccessTime_;
    int timeoutSeconds_;

    static std::string generateSessionId() {
        static int counter = 0;
        auto now = std::chrono::system_clock::now();
        auto epoch = now.time_since_epoch();
        auto millis = std::chrono::duration_cast<std::chrono::milliseconds>(epoch).count();
        return "sess_" + std::to_string(millis) + "_" + std::to_string(++counter);
    }
};

class SessionManager {
public:
    SessionManager() = default;

    ~SessionManager() {
        removeAllSessions();
    }

    // Disable copy to prevent double-free
    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    // Enable move
    SessionManager(SessionManager&& other) noexcept
        : sessions_(std::move(other.sessions_)) {}

    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this != &other) {
            removeAllSessions();
            sessions_ = std::move(other.sessions_);
        }
        return *this;
    }

    Session* addSession(const std::string& userId, int timeoutSeconds = 3600) {
        Session* session = new Session(userId, timeoutSeconds);
        sessions_.push_back(session);
        std::cout << "Session added: " << session->getSessionId()
                  << " for user: " << userId << std::endl;
        return session;
    }

    bool removeSession(const std::string& sessionId) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [&sessionId](const Session* s) {
                return s->getSessionId() == sessionId;
            });

        if (it != sessions_.end()) {
            delete *it;
            sessions_.erase(it);
            return true;
        }
        return false;
    }

    bool removeSessionsByUser(const std::string& userId) {
        bool removed = false;
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if ((*it)->getUserId() == userId) {
                delete *it;
                it = sessions_.erase(it);
                removed = true;
            } else {
                ++it;
            }
        }
        return removed;
    }

    Session* getSession(const std::string& sessionId) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [&sessionId](const Session* s) {
                return s->getSessionId() == sessionId;
            });

        if (it != sessions_.end()) {
            (*it)->touch();
            return *it;
        }
        return nullptr;
    }

    Session* getSessionByUser(const std::string& userId) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [&userId](const Session* s) {
                return s->getUserId() == userId;
            });

        if (it != sessions_.end()) {
            (*it)->touch();
            return *it;
        }
        return nullptr;
    }

    Session* getSessionAt(size_t index) {
        if (index >= sessions_.size()) {
            throw std::out_of_range("Session index out of range");
        }
        return sessions_[index];
    }

    size_t cleanupExpiredSessions() {
        size_t count = 0;
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if ((*it)->isExpired()) {
                std::cout << "Cleaning up expired session: " << (*it)->getSessionId() << std::endl;
                delete *it;
                it = sessions_.erase(it);
                ++count;
            } else {
                ++it;
            }
        }
        return count;
    }

    void removeAllSessions() {
        for (Session* session : sessions_) {
            delete session;
        }
        sessions_.clear();
    }

    size_t getSessionCount() const {
        return sessions_.size();
    }

    size_t getActiveSessionCount() const {
        return std::count_if(sessions_.begin(), sessions_.end(),
            [](const Session* s) { return !s->isExpired(); });
    }

    bool hasSession(const std::string& sessionId) const {
        return std::any_of(sessions_.begin(), sessions_.end(),
            [&sessionId](const Session* s) {
                return s->getSessionId() == sessionId;
            });
    }

    void printSessions() const {
        std::cout << "=== Session Manager Status ===" << std::endl;
        std::cout << "Total sessions: " << sessions_.size() << std::endl;
        for (const Session* session : sessions_) {
            std::cout << "  [" << session->getSessionId() << "] "
                      << "User: " << session->getUserId()
                      << ", Expired: " << (session->isExpired() ? "Yes" : "No")
                      << ", Idle: " << session->getElapsedSeconds() << "s"
                      << std::endl;
        }
        std::cout << "==============================" << std::endl;
    }

private:
    std::vector<Session*> sessions_;
};

int main() {
    SessionManager manager;

    Session* s1 = manager.addSession("alice", 2);
    Session* s2 = manager.addSession("bob", 3600);
    Session* s3 = manager.addSession("charlie", 1);

    manager.printSessions();

    // Access a session (refreshes its timer)
    std::string s2Id = s2->getSessionId();
    Session* found = manager.getSession(s2Id);
    if (found) {
        std::cout << "Found session for user: " << found->getUserId() << std::endl;
    }

    // Simulate waiting for expiration
    std::cout << "\nWaiting for some sessions to expire..." << std::endl;
    // In a real scenario, you'd wait; here we use short timeouts for demonstration
    // For testing, we can manually check
    // std::this_thread::sleep_for(std::chrono::seconds(2));

    // Remove a specific session
    std::string s1Id = s1->getSessionId();
    if (manager.removeSession(s1Id)) {
        std::cout << "Successfully removed session: " << s1Id << std::endl;
    }

    // Cleanup expired sessions
    size_t cleaned = manager.cleanupExpiredSessions();
    std::cout << "Cleaned up " << cleaned << " expired sessions." << std::endl;

    manager.printSessions();

    std::cout << "Active sessions: " << manager.getActiveSessionCount() << std::endl;
    std::cout << "Total sessions: " << manager.getSessionCount() << std::endl;

    // Manager destructor will clean up remaining sessions
    return 0;
}