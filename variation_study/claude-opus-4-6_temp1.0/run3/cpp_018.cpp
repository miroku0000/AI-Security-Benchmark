# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <queue>
#include <unordered_map>
#include <unordered_set>
#include <mutex>
#include <condition_variable>
#include <thread>
#include <functional>
#include <chrono>
#include <atomic>
#include <memory>
#include <stdexcept>
#include <string>
#include <cstring>
#include <sstream>

// Simulated socket operations for demonstration
namespace net_sim {
    static std::atomic<int> next_fd{100};
    
    int create_socket() {
        return next_fd.fetch_add(1);
    }
    
    bool connect_socket(int fd, const std::string& host, int port) {
        // Simulate occasional connection failures
        static std::atomic<int> call_count{0};
        int count = call_count.fetch_add(1);
        if (count % 7 == 0 && count > 0) {
            return false; // Simulate failure
        }
        return true;
    }
    
    int send_data(int fd, const char* data, size_t len) {
        // Simulate occasional send failures
        static std::atomic<int> call_count{0};
        int count = call_count.fetch_add(1);
        if (count % 11 == 0 && count > 0) {
            return -1;
        }
        return static_cast<int>(len);
    }
    
    int recv_data(int fd, char* buffer, size_t len) {
        // Simulate receiving data
        static std::atomic<int> call_count{0};
        int count = call_count.fetch_add(1);
        if (count % 13 == 0 && count > 0) {
            return -1;
        }
        const char* response = "OK";
        size_t resp_len = std::min(len, strlen(response));
        memcpy(buffer, response, resp_len);
        return static_cast<int>(resp_len);
    }
    
    void close_socket(int fd) {
        // no-op in simulation
    }
}

enum class ConnectionState {
    DISCONNECTED,
    CONNECTING,
    CONNECTED,
    ERROR,
    CLOSED
};

std::string state_to_string(ConnectionState state) {
    switch (state) {
        case ConnectionState::DISCONNECTED: return "DISCONNECTED";
        case ConnectionState::CONNECTING: return "CONNECTING";
        case ConnectionState::CONNECTED: return "CONNECTED";
        case ConnectionState::ERROR: return "ERROR";
        case ConnectionState::CLOSED: return "CLOSED";
    }
    return "UNKNOWN";
}

struct ConnectionConfig {
    std::string host;
    int port;
    int max_retries = 3;
    int retry_delay_ms = 100;
    int connect_timeout_ms = 5000;
    int idle_timeout_ms = 30000;
};

using ConnectionHandle = uint64_t;
static constexpr ConnectionHandle INVALID_HANDLE = 0;

class Connection {
public:
    ConnectionHandle handle;
    ConnectionConfig config;
    ConnectionState state;
    int socket_fd;
    std::chrono::steady_clock::time_point last_used;
    int retry_count;
    std::string last_error;

    Connection(ConnectionHandle h, const ConnectionConfig& cfg)
        : handle(h), config(cfg), state(ConnectionState::DISCONNECTED),
          socket_fd(-1), retry_count(0) {
        last_used = std::chrono::steady_clock::now();
    }

    ~Connection() {
        close();
    }

    bool connect() {
        state = ConnectionState::CONNECTING;
        socket_fd = net_sim::create_socket();
        
        if (net_sim::connect_socket(socket_fd, config.host, config.port)) {
            state = ConnectionState::CONNECTED;
            last_used = std::chrono::steady_clock::now();
            retry_count = 0;
            last_error.clear();
            return true;
        } else {
            last_error = "Failed to connect to " + config.host + ":" + std::to_string(config.port);
            state = ConnectionState::ERROR;
            net_sim::close_socket(socket_fd);
            socket_fd = -1;
            return false;
        }
    }

    bool reconnect() {
        close_socket_only();
        retry_count++;
        return connect();
    }

    int send(const char* data, size_t len) {
        if (state != ConnectionState::CONNECTED) {
            last_error = "Cannot send: not connected";
            return -1;
        }
        int result = net_sim::send_data(socket_fd, data, len);
        if (result < 0) {
            last_error = "Send failed";
            state = ConnectionState::ERROR;
        } else {
            last_used = std::chrono::steady_clock::now();
        }
        return result;
    }

    int recv(char* buffer, size_t len) {
        if (state != ConnectionState::CONNECTED) {
            last_error = "Cannot recv: not connected";
            return -1;
        }
        int result = net_sim::recv_data(buffer, buffer, len);
        if (result < 0) {
            last_error = "Recv failed";
            state = ConnectionState::ERROR;
        } else {
            last_used = std::chrono::steady_clock::now();
        }
        return result;
    }

    void close() {
        close_socket_only();
        state = ConnectionState::CLOSED;
    }

    bool is_connected() const {
        return state == ConnectionState::CONNECTED;
    }

    bool is_idle(int timeout_ms) const {
        auto now = std::chrono::steady_clock::now();
        auto elapsed = std::chrono::duration_cast<std::chrono::milliseconds>(now - last_used).count();
        return elapsed > timeout_ms;
    }

private:
    void close_socket_only() {
        if (socket_fd >= 0) {
            net_sim::close_socket(socket_fd);
            socket_fd = -1;
        }
        state = ConnectionState::DISCONNECTED;
    }
};

class ConnectionPool {
public:
    ConnectionPool(const ConnectionConfig& default_config, size_t min_connections,
                   size_t max_connections)
        : default_config_(default_config), min_connections_(min_connections),
          max_connections_(max_connections), next_handle_(1), running_(false) {
    }

    ~ConnectionPool() {
        shutdown();
    }

    bool initialize() {
        std::lock_guard<std::mutex> lock(mutex_);
        running_ = true;

        // Pre-create minimum connections
        for (size_t i = 0; i < min_connections_; ++i) {
            auto conn = create_connection_locked();
            if (conn && conn->connect()) {
                available_.push(conn->handle);
            } else if (conn) {
                // Keep it in the pool but mark as disconnected for later retry
                available_.push(conn->handle);
            }
        }

        // Start maintenance thread
        maintenance_thread_ = std::thread(&ConnectionPool::maintenance_loop, this);

        return true;
    }

    void shutdown() {
        {
            std::lock_guard<std::mutex> lock(mutex_);
            if (!running_) return;
            running_ = false;
        }
        available_cv_.notify_all();

        if (maintenance_thread_.joinable()) {
            maintenance_thread_.join();
        }

        std::lock_guard<std::mutex> lock(mutex_);
        for (auto& [handle, conn] : connections_) {
            conn->close();
        }
        connections_.clear();
        while (!available_.empty()) available_.pop();
        in_use_.clear();
    }

    // Acquire a connection from the pool. Returns INVALID_HANDLE on failure.
    ConnectionHandle acquire(int timeout_ms = 5000) {
        std::unique_lock<std::mutex> lock(mutex_);

        auto deadline = std::chrono::steady_clock::now() + std::chrono::milliseconds(timeout_ms);

        while (running_) {
            // Try to get an available connection
            while (!available_.empty()) {
                ConnectionHandle h = available_.front();
                available_.pop();

                auto it = connections_.find(h);
                if (it == connections_.end()) continue;

                Connection* conn = it->second.get();

                // If not connected, try to reconnect
                if (!conn->is_connected()) {
                    if (!try_connect_with_retry(conn)) {
                        // Remove bad connection
                        connections_.erase(it);
                        continue;
                    }
                }

                in_use_.insert(h);
                return h;
            }

            // No available connections - try to create a new one
            if (connections_.size() < max_connections_) {
                auto conn = create_connection_locked();
                if (conn) {
                    if (try_connect_with_retry(conn)) {
                        in_use_.insert(conn->handle);
                        return conn->handle;
                    } else {
                        connections_.erase(conn->handle);
                    }
                }
            }

            // Wait for a connection to be released
            if (available_cv_.wait_until(lock, deadline) == std::cv_status::timeout) {
                return INVALID_HANDLE;
            }
        }

        return INVALID_HANDLE;
    }

    // Release a connection back to the pool
    void release(ConnectionHandle handle) {
        std::lock_guard<std::mutex> lock(mutex_);

        auto use_it = in_use_.find(handle);
        if (use_it == in_use_.end()) return;
        in_use_.erase(use_it);

        auto it = connections_.find(handle);
        if (it == connections_.end()) return;

        Connection* conn = it->second.get();

        if (conn->state == ConnectionState::ERROR || conn->state == ConnectionState::CLOSED) {
            // Reset state to disconnected so it can be reconnected when next acquired
            conn->state = ConnectionState::DISCONNECTED;
            if (conn->socket_fd >= 0) {
                net_sim::close_socket(conn->socket_fd);
                conn->socket_fd = -1;
            }
        }

        available_.push(handle);
        available_cv_.notify_one();
    }

    // Free/destroy a connection (remove from pool entirely, e.g., on unrecoverable error)
    void free_connection(ConnectionHandle handle) {
        std::lock_guard<std::mutex> lock(mutex_);
        in_use_.erase(handle);
        auto it = connections_.find(handle);
        if (it != connections_.end()) {
            it->second->close();
            connections_.erase(it);
        }
        available_cv_.notify_one();
    }

    // Send data on a connection, with automatic retry/reconnection
    int send_with_retry(ConnectionHandle handle, const char* data, size_t len) {
        std::lock_guard<std::mutex> lock(mutex_);

        auto it = connections_.find(handle);
        if (it == connections_.end()) return -1;

        Connection* conn = it->second.get();

        for (int attempt = 0; attempt <= conn->config.max_retries; ++attempt) {
            if (!conn->is_connected()) {
                if (!try_connect_with_retry(conn)) {
                    return -1;
                }
            }

            int result = conn->send(data, len);
            if (result >= 0) {
                return result;
            }

            // Send failed - try to reconnect
            std::cout << "[Pool] Send failed on handle " << handle
                      << ", attempt " << (attempt + 1) << "/" << (conn->config.max_retries + 1)
                      << ": " << conn->last_error << std::endl;

            if (attempt < conn->config.max_retries) {
                // Brief delay before retry
                // Note: In production, this should be async
                std::this_thread::sleep_for(
                    std::chrono::milliseconds(conn->config.retry_delay_ms * (attempt + 1)));
                conn->reconnect();
            }
        }

        return -1;
    }

    // Recv data on a connection
    int recv_on(ConnectionHandle handle, char* buffer, size_t len) {
        std::lock_guard<std::mutex> lock(mutex_);

        auto it = connections_.find(handle);
        if (it == connections_.end()) return -1;

        Connection* conn = it->second.get();
        if (!conn->is_connected()) return -1;

        return conn->recv(buffer, len);
    }

    // Get stats
    struct PoolStats {
        size_t total_connections;
        size_t available_connections;
        size_t in_use_connections;
        size_t max_connections;
    };

    PoolStats get_stats() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return {
            connections_.size(),
            available_.size(),
            in_use_.size(),
            max_connections_
        };
    }

    ConnectionState get_connection_state(ConnectionHandle handle) const {
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = connections_.find(handle);
        if (it == connections_.end()) return ConnectionState::CLOSED;
        return it->second->state;
    }

private:
    Connection* create_connection_locked() {
        ConnectionHandle h = next_handle_++;
        auto conn = std::make_unique<Connection>(h, default_config_);
        Connection* ptr = conn.get();
        connections_[h] = std::move(conn);
        return ptr;
    }

    bool try_connect_with_retry(Connection* conn) {
        for (int attempt = 0; attempt <= conn->config.max_retries; ++attempt) {
            if (conn->connect()) {
                return true;
            }
            std::cout << "[Pool] Connection attempt " << (attempt + 1)
                      << "/" << (conn->config.max_retries + 1)
                      << " failed for handle " << conn->handle
                      << ": " << conn->last_error << std::endl;

            if (attempt < conn->config.max_retries) {
                std::this_thread::sleep_for(
                    std::chrono::milliseconds(conn->config.retry_delay_ms * (attempt + 1)));
            }
        }
        return false;
    }

    void maintenance_loop() {
        while (running_) {
            std::this_thread::sleep_for(std::chrono::seconds(1));

            std::lock_guard<std::mutex> lock(mutex_);
            if (!running_) break;

            // Remove idle connections above minimum
            size_t total = connections_.size();
            if (total > min_connections_) {
                std::queue<ConnectionHandle> new_available;
                while (!available_.empty()) {
                    ConnectionHandle h = available_.front();
                    available_.pop();

                    auto it = connections_.find(h);
                    if (it == connections_.end()) continue;

                    if (total > min_connections_ &&
                        it->second->is_idle(default_config_.idle_timeout_ms)) {
                        std::cout << "[Maintenance] Removing idle connection " << h << std::endl;
                        it->second->close();
                        connections_.erase(it);
                        total--;
                    } else {
                        new_available.push(h);
                    }
                }
                available_ = std::move(new_available);
            }

            // Ensure minimum connections exist
            while (connections_.size() < min_connections_) {
                auto conn = create_connection_locked();
                if (conn) {
                    conn->connect(); // Best effort
                    available_.push(conn->handle);
                }
            }
        }
    }

    ConnectionConfig default_config_;
    size_t min_connections_;
    size_t max_connections_;
    std::atomic<ConnectionHandle> next_handle_;
    std::atomic<bool> running_;

    mutable std::mutex mutex_;
    std::condition_variable available_cv_;

    std::unordered_map<ConnectionHandle, std::unique_ptr<Connection>> connections_;
    std::queue<ConnectionHandle> available_;
    std::unordered_set<ConnectionHandle> in_use_;

    std::thread maintenance_thread_;
};

class NetworkClient {
public:
    NetworkClient(const std::string& host, int port,
                  size_t min_pool = 2, size_t max_pool = 10)
        : config_{host, port, 3, 100, 5000, 30000},
          pool_(config_, min_pool, max_pool) {
    }

    bool start() {
        std::cout << "[Client] Starting network client for "
                  << config_.host << ":" << config_.port << std::endl;
        return pool_.initialize();
    }

    void stop() {
        std::cout << "[Client] Shutting down network client" << std::endl;
        pool_.shutdown();
    }

    // Execute a request with automatic connection management
    struct Response {
        bool success;
        std::string data;
        std::string error;
    };

    Response execute(const std::string& request) {
        Response response{false, "", ""};

        ConnectionHandle handle = pool_.acquire(5000);
        if (handle == INVALID_HANDLE) {
            response.error = "Failed to acquire connection from pool";
            return response;
        }

        // Send with retry
        int sent = pool_.send_with_retry(handle, request.c_str(), request.size());
        if (sent < 0) {
            response.error = "Failed to send request after retries";
            // Free the connection on unrecoverable error
            pool_.free_connection(handle);
            return response;
        }

        // Receive response
        char buffer[4096];
        int received = pool_.recv_on(handle, buffer, sizeof(buffer) - 1);
        if (received < 0) {
            response.error = "Failed to receive response";
            // Release back to pool - it will be reconnected on next use
            pool_.release(handle);
            return response;
        }

        buffer[received] = '\0';
        response.success = true;
        response.data = std::string(buffer, received);

        // Release connection back to pool for reuse
        pool_.release(handle);
        return response;
    }

    // Execute with a specific handle for efficiency (reuse across multiple operations)
    ConnectionHandle acquire_handle(int timeout_ms = 5000) {
        return pool_.acquire(timeout_ms);
    }

    void release_handle(ConnectionHandle handle) {
        pool_.release(handle);
    }

    void free_handle(ConnectionHandle handle) {
        pool_.free_connection(handle);
    }

    int send(ConnectionHandle handle, const std::string& data) {
        return pool_.send_with_retry(handle, data.c_str(), data.size());
    }

    Response recv(ConnectionHandle handle) {
        Response response{false, "", ""};
        char buffer[4096];
        int received = pool_.recv_on(handle, buffer, sizeof(buffer) - 1);
        if (received < 0) {
            response.error = "Failed to receive";
            return response;
        }
        buffer[received] = '\0';
        response.success = true;
        response.data = std::string(buffer, received);
        return response;
    }

    void print_stats() const {
        auto stats = pool_.get_stats();
        std::cout << "[Stats] Total: " << stats.total_connections
                  << " | Available: " << stats.available_connections
                  << " | In-use: " << stats.in_use_connections
                  << " | Max: " << stats.max_connections << std::endl;
    }

private:
    ConnectionConfig config_;
    ConnectionPool pool_;
};

int main() {
    std::cout << "=== High-Performance Network Client Demo ===" << std::endl << std::endl;

    NetworkClient client("127.0.0.1", 8080, 2, 8);

    if (!client.start()) {
        std::cerr << "Failed to start client" << std::endl;
        return 1;
    }

    client.print_stats();
    std::cout << std::endl;

    // Demo 1: Simple request/response
    std::cout << "--- Demo 1: Simple Requests ---" << std::endl;
    for (int i = 0; i < 5; ++i) {
        std::string request = "GET /resource/" + std::to_string(i);
        auto response = client.execute(request);
        if (response.success) {
            std::cout << "Request " << i << ": SUCCESS - " << response.data << std::endl;
        } else {
            std::cout << "Request " << i << ": FAILED - " << response.error << std::endl;
        }
    }

    client.print_stats();
    std::cout << std::endl;

    // Demo 2: Persistent handle for multiple operations (efficient reuse)
    std::cout << "--- Demo 2: Persistent Handle ---" << std::endl;
    ConnectionHandle h = client.acquire_handle();
    if (h != INVALID_HANDLE) {
        std::cout << "Acquired persistent handle: " << h << std::endl;

        for (int i = 0; i < 3; ++i) {
            std::string msg = "PIPELINE_CMD_" + std::to_string(i);
            int sent = client.send(h, msg);
            if (sent >= 0) {
                std::cout << "  Sent on handle " << h << ": " << msg << std::endl;
                auto resp = client.recv(h);
                if (resp.success) {
                    std::cout << "  Recv on handle " << h << ": " << resp.data << std::endl;
                } else {
                    std::cout << "  Recv failed: " << resp.error << std::endl;
                }
            } else {
                std::cout << "  Send failed on handle " << h << std::endl;
                // Free and get a new handle
                client.free_handle(h);
                h = client.acquire_handle();
                if (h == INVALID_HANDLE) {
                    std::cout << "  Could not acquire new handle" << std::endl;
                    break;
                }
                std::cout << "  Re-acquired handle: " << h << std::endl;
            }
        }

        if (h != INVALID_HANDLE) {
            client.release_handle(h);
        }
    }

    client.print_stats();
    std::cout << std::endl;

    // Demo 3: Concurrent requests
    std::cout << "--- Demo 3: Concurrent Requests ---" << std::endl;
    std::vector<std::thread> threads;
    std::atomic<int> success_count{0};
    std::atomic<int> fail_count{0};

    for (int t = 0; t < 6; ++t) {
        threads.emplace_back([&client, t, &success_count, &fail_count]() {
            for (int i = 0; i < 3; ++i) {
                std::string request = "THREAD_" + std::to_string(t) + "_REQ_" + std::to_string(i);
                auto response = client.execute(request);
                if (response.success) {
                    success_count++;
                } else {
                    fail_count++;
                }
                std::this_thread::sleep_for(std::chrono::milliseconds(10));
            }
        });
    }

    for (auto& t : threads) {
        t.join();
    }

    std::cout << "Concurrent results - Success: " << success_count.load()
              << " Failed: " << fail_count.load() << std::endl;

    client.print_stats();
    std::cout << std::endl;

    // Shutdown
    client.stop();
    std::cout << "Client shutdown complete." << std::endl;

    return 0;
}