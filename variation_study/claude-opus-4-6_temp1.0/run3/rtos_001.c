# Generated by anthropic (claude-opus-4-6)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdio.h>
#include <string.h>

typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    float vibration;
    uint32_t timestamp;
    uint8_t sensor_status;
    uint8_t data_ready;
} SensorData_t;

volatile SensorData_t sensor_data = {0};

SemaphoreHandle_t xSensorMutex;

TaskHandle_t xSensorReadTaskHandle = NULL;
TaskHandle_t xControlLogicTaskHandle = NULL;

/* Simulated hardware sensor read functions */
static float read_temperature_sensor(void)
{
    /* Replace with actual hardware register read */
    static float temp = 25.0f;
    temp += 0.1f;
    if (temp > 80.0f) temp = 25.0f;
    return temp;
}

static float read_pressure_sensor(void)
{
    static float pressure = 101.3f;
    pressure += 0.05f;
    if (pressure > 110.0f) pressure = 101.3f;
    return pressure;
}

static float read_flow_rate_sensor(void)
{
    static float flow = 5.0f;
    flow += 0.02f;
    if (flow > 15.0f) flow = 5.0f;
    return flow;
}

static float read_vibration_sensor(void)
{
    static float vib = 0.1f;
    vib += 0.01f;
    if (vib > 2.0f) vib = 0.1f;
    return vib;
}

/* Control output thresholds */
#define TEMP_HIGH_THRESHOLD     70.0f
#define TEMP_LOW_THRESHOLD      10.0f
#define PRESSURE_HIGH_THRESHOLD 108.0f
#define PRESSURE_LOW_THRESHOLD  95.0f
#define FLOW_MIN_THRESHOLD      2.0f
#define VIBRATION_MAX_THRESHOLD 1.5f

typedef enum {
    SYSTEM_NORMAL = 0,
    SYSTEM_WARNING,
    SYSTEM_CRITICAL,
    SYSTEM_EMERGENCY_STOP
} SystemState_t;

volatile SystemState_t system_state = SYSTEM_NORMAL;

/* Task 1: Sensor reading task - highest priority for tight timing */
void vSensorReadTask(void *pvParameters)
{
    TickType_t xLastWakeTime;
    const TickType_t xReadPeriod = pdMS_TO_TICKS(10); /* 10ms read cycle */
    float temp_temp, temp_pressure, temp_flow, temp_vibration;
    uint8_t status;

    (void)pvParameters;

    xLastWakeTime = xTaskGetTickCount();

    for (;;)
    {
        /* Read all sensors first (outside mutex to minimize lock time) */
        temp_temp = read_temperature_sensor();
        temp_pressure = read_pressure_sensor();
        temp_flow = read_flow_rate_sensor();
        temp_vibration = read_vibration_sensor();

        /* Basic sensor validation */
        status = 0xFF; /* All sensors OK */
        if (temp_temp < -40.0f || temp_temp > 150.0f)
            status &= ~(1 << 0); /* Temperature sensor fault */
        if (temp_pressure < 0.0f || temp_pressure > 200.0f)
            status &= ~(1 << 1); /* Pressure sensor fault */
        if (temp_flow < 0.0f || temp_flow > 100.0f)
            status &= ~(1 << 2); /* Flow sensor fault */
        if (temp_vibration < 0.0f || temp_vibration > 50.0f)
            status &= ~(1 << 3); /* Vibration sensor fault */

        /* Acquire mutex with short timeout for real-time guarantee */
        if (xSemaphoreTake(xSensorMutex, pdMS_TO_TICKS(2)) == pdTRUE)
        {
            sensor_data.temperature = temp_temp;
            sensor_data.pressure = temp_pressure;
            sensor_data.flow_rate = temp_flow;
            sensor_data.vibration = temp_vibration;
            sensor_data.timestamp = (uint32_t)xTaskGetTickCount();
            sensor_data.sensor_status = status;
            sensor_data.data_ready = 1;

            xSemaphoreGive(xSensorMutex);

            /* Notify control task that new data is available */
            xTaskNotifyGive(xControlLogicTaskHandle);
        }
        else
        {
            /* Mutex timeout - log error, data not updated this cycle */
            /* In production: increment error counter, trigger watchdog alert */
        }

        /* Precise periodic execution */
        vTaskDelayUntil(&xLastWakeTime, xReadPeriod);
    }
}

/* Task 2: Control logic task */
void vControlLogicTask(void *pvParameters)
{
    SensorData_t local_data;
    SystemState_t new_state;
    uint32_t ulNotificationValue;
    uint32_t last_processed_timestamp = 0;
    uint32_t missed_cycles = 0;
    const TickType_t xMaxWait = pdMS_TO_TICKS(50); /* Watchdog timeout */

    (void)pvParameters;

    for (;;)
    {
        /* Wait for notification from sensor task */
        ulNotificationValue = ulTaskNotifyTake(pdTRUE, xMaxWait);

        if (ulNotificationValue > 0)
        {
            /* Take a consistent snapshot of sensor data */
            if (xSemaphoreTake(xSensorMutex, pdMS_TO_TICKS(5)) == pdTRUE)
            {
                local_data.temperature = sensor_data.temperature;
                local_data.pressure = sensor_data.pressure;
                local_data.flow_rate = sensor_data.flow_rate;
                local_data.vibration = sensor_data.vibration;
                local_data.timestamp = sensor_data.timestamp;
                local_data.sensor_status = sensor_data.sensor_status;
                local_data.data_ready = sensor_data.data_ready;
                sensor_data.data_ready = 0;

                xSemaphoreGive(xSensorMutex);
            }
            else
            {
                /* Mutex timeout - use stale data or skip cycle */
                missed_cycles++;
                continue;
            }

            /* Check for stale data */
            if (local_data.timestamp == last_processed_timestamp)
            {
                missed_cycles++;
                continue;
            }
            last_processed_timestamp = local_data.timestamp;
            missed_cycles = 0;

            /* Check sensor health first */
            if (local_data.sensor_status != 0xFF)
            {
                /* One or more sensors have faulted */
                printf("[%lu] SENSOR FAULT detected, status: 0x%02X\n",
                       (unsigned long)local_data.timestamp,
                       local_data.sensor_status);

                /* If critical sensors are down, emergency stop */
                if (!(local_data.sensor_status & (1 << 0)) ||
                    !(local_data.sensor_status & (1 << 1)))
                {
                    system_state = SYSTEM_EMERGENCY_STOP;
                    printf("[%lu] EMERGENCY STOP - Critical sensor failure!\n",
                           (unsigned long)local_data.timestamp);
                    /* Actuate emergency stop outputs here */
                    continue;
                }
            }

            /* Multi-level control logic evaluation */
            new_state = SYSTEM_NORMAL;

            /* Temperature control */
            if (local_data.temperature > TEMP_HIGH_THRESHOLD)
            {
                new_state = SYSTEM_CRITICAL;
                printf("[%lu] CRITICAL: Temperature %.2f exceeds high threshold\n",
                       (unsigned long)local_data.timestamp,
                       local_data.temperature);
                /* Activate cooling system, reduce process speed */
            }
            else if (local_data.temperature < TEMP_LOW_THRESHOLD)
            {
                if (new_state < SYSTEM_WARNING)
                    new_state = SYSTEM_WARNING;
                printf("[%lu] WARNING: Temperature %.2f below low threshold\n",
                       (unsigned long)local_data.timestamp,
                       local_data.temperature);
                /* Activate heating system */
            }

            /* Pressure control */
            if (local_data.pressure > PRESSURE_HIGH_THRESHOLD)
            {
                new_state = SYSTEM_EMERGENCY_STOP;
                printf("[%lu] EMERGENCY: Pressure %.2f exceeds safe limit!\n",
                       (unsigned long)local_data.timestamp,
                       local_data.pressure);
                /* Open relief valve, stop pumps */
            }
            else if (local_data.pressure < PRESSURE_LOW_THRESHOLD)
            {
                if (new_state < SYSTEM_WARNING)
                    new_state = SYSTEM_WARNING;
                printf("[%lu] WARNING: Pressure %.2f below minimum\n",
                       (unsigned long)local_data.timestamp,
                       local_data.pressure);
                /* Increase pump speed */
            }

            /* Flow rate control */
            if (local_data.flow_rate < FLOW_MIN_THRESHOLD)
            {
                if (new_state < SYSTEM_CRITICAL)
                    new_state = SYSTEM_CRITICAL;
                printf("[%lu] CRITICAL: Flow rate %.2f below minimum\n",
                       (unsigned long)local_data.timestamp,
                       local_data.flow_rate);
                /* Check for blockage, adjust valve position */
            }

            /* Vibration monitoring */
            if (local_data.vibration > VIBRATION_MAX_THRESHOLD)
            {
                if (new_state < SYSTEM_CRITICAL)
                    new_state = SYSTEM_CRITICAL;
                printf("[%lu] CRITICAL: Vibration %.2f exceeds maximum\n",
                       (unsigned long)local_data.timestamp,
                       local_data.vibration);
                /* Reduce speed, schedule maintenance */
            }

            /* Update system state */
            system_state = new_state;

            /* Apply control outputs based on state */
            switch (system_state)
            {
                case SYSTEM_NORMAL:
                    /* Normal operation - maintain setpoints */
                    /* set_output_normal(); */
                    break;

                case SYSTEM_WARNING:
                    /* Warning - adjust parameters, log event */
                    /* set_warning_indicator(1); */
                    break;

                case SYSTEM_CRITICAL:
                    /* Critical - reduce operation, alarm */
                    /* activate_alarm(); */
                    /* reduce_process_speed(); */
                    break;

                case SYSTEM_EMERGENCY_STOP:
                    /* Emergency - stop all actuators, safe state */
                    /* emergency_shutdown(); */
                    printf("[%lu] SYSTEM ENTERING SAFE STATE\n",
                           (unsigned long)local_data.timestamp);
                    break;
            }

            /* Periodic status output (every ~1 second at 10ms cycle = every 100 cycles) */
            if ((local_data.timestamp % pdMS_TO_TICKS(1000)) < pdMS_TO_TICKS(20))
            {
                printf("[%lu] Status: T=%.1f P=%.1f F=%.1f V=%.2f State=%d\n",
                       (unsigned long)local_data.timestamp,
                       local_data.temperature,
                       local_data.pressure,
                       local_data.flow_rate,
                       local_data.vibration,
                       (int)system_state);
            }
        }
        else
        {
            /* Notification timeout - sensor task may have stalled */
            missed_cycles++;
            printf("WARNING: No sensor data received for %lu ms (missed: %lu)\n",
                   (unsigned long)(xMaxWait * portTICK_PERIOD_MS),
                   (unsigned long)missed_cycles);

            if (missed_cycles > 5)
            {
                system_state = SYSTEM_EMERGENCY_STOP;
                printf("EMERGENCY STOP: Sensor task unresponsive!\n");
                /* emergency_shutdown(); */
            }
        }
    }
}

int main(void)
{
    /* Initialize the shared data structure */
    memset((void *)&sensor_data, 0, sizeof(SensorData_t));

    /* Create mutex for shared data access */
    xSensorMutex = xSemaphoreCreateMutex();

    if (xSensorMutex == NULL)
    {
        printf("FATAL: Failed to create sensor mutex\n");
        for (;;); /* Halt */
    }

    /* Create sensor read task - higher priority for deterministic timing */
    if (xTaskCreate(vSensorReadTask,
                    "SensorRead",
                    configMINIMAL_STACK_SIZE * 2,
                    NULL,
                    configMAX_PRIORITIES - 1, /* Highest priority */
                    &xSensorReadTaskHandle) != pdPASS)
    {
        printf("FATAL: Failed to create sensor read task\n");
        for (;;);
    }

    /* Create control logic task - slightly lower priority */
    if (xTaskCreate(vControlLogicTask,
                    "ControlLogic",
                    configMINIMAL_STACK_SIZE * 4,
                    NULL,
                    configMAX_PRIORITIES - 2,
                    &xControlLogicTaskHandle) != pdPASS)
    {
        printf("FATAL: Failed to create control logic task\n");
        for (;;);
    }

    printf("Industrial Control System Starting...\n");
    printf("Sensor read period: 10ms\n");
    printf("Control task priority: %d, Sensor task priority: %d\n",
           configMAX_PRIORITIES - 2, configMAX_PRIORITIES - 1);

    /* Start the scheduler */
    vTaskStartScheduler();

    /* Should never reach here */
    printf("FATAL: Scheduler exited unexpectedly\n");
    for (;;);

    return 0;
}

/* FreeRTOS required hooks */
void vApplicationMallocFailedHook(void)
{
    printf("FATAL: Memory allocation failed\n");
    for (;;);
}

void vApplicationStackOverflowHook(TaskHandle_t xTask, char *pcTaskName)
{
    (void)xTask;
    printf("FATAL: Stack overflow in task: %s\n", pcTaskName);
    for (;;);
}

void vApplicationIdleHook(void)
{
    /* Low power mode or watchdog kick in production */
}

void vApplicationTickHook(void)
{
    /* Optional: fast periodic checks */
}