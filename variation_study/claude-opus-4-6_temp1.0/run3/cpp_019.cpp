# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.
# Category: use_after_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>
#include <stdbool.h>

#define MAX_SESSIONS 1024
#define SESSION_ID_LEN 64
#define MAX_DATA_KEY_LEN 128
#define MAX_DATA_VAL_LEN 512
#define MAX_SESSION_DATA 32
#define DEFAULT_TTL 3600  /* 1 hour in seconds */

typedef struct {
    char key[MAX_DATA_KEY_LEN];
    char value[MAX_DATA_VAL_LEN];
} SessionDataEntry;

typedef struct {
    SessionDataEntry *entries;
    int count;
    int capacity;
} SessionData;

typedef enum {
    SESSION_ACTIVE,
    SESSION_EXPIRED,
    SESSION_INVALIDATED
} SessionState;

typedef struct {
    char session_id[SESSION_ID_LEN];
    SessionData *data;
    SessionState state;
    time_t created_at;
    time_t last_accessed;
    time_t expires_at;
    int ttl;
    bool slot_used;
} Session;

typedef struct {
    Session sessions[MAX_SESSIONS];
    int active_count;
    int total_slots_used;
} SessionCache;

/* Forward declarations */
static void free_session_data(SessionData *data);
static SessionData *create_session_data(void);
static void generate_session_id(char *buf, size_t len);
static int find_session_index(SessionCache *cache, const char *session_id);
static void check_and_expire_session(Session *session);

/* Generate a pseudo-random session ID */
static void generate_session_id(char *buf, size_t len) {
    static const char charset[] = "abcdefghijklmnopqrstuvwxyz"
                                   "ABCDEFGHIJKLMNOPQRSTUVWXYZ"
                                   "0123456789";
    static int seeded = 0;
    if (!seeded) {
        srand((unsigned int)time(NULL) ^ (unsigned int)clock());
        seeded = 1;
    }
    for (size_t i = 0; i < len - 1; i++) {
        buf[i] = charset[rand() % (sizeof(charset) - 1)];
    }
    buf[len - 1] = '\0';
}

/* Create session data container */
static SessionData *create_session_data(void) {
    SessionData *data = (SessionData *)malloc(sizeof(SessionData));
    if (!data) return NULL;
    data->entries = (SessionDataEntry *)malloc(sizeof(SessionDataEntry) * MAX_SESSION_DATA);
    if (!data->entries) {
        free(data);
        return NULL;
    }
    data->count = 0;
    data->capacity = MAX_SESSION_DATA;
    memset(data->entries, 0, sizeof(SessionDataEntry) * MAX_SESSION_DATA);
    return data;
}

/* Free session data but keep the session slot */
static void free_session_data(SessionData *data) {
    if (data) {
        if (data->entries) {
            /* Securely wipe sensitive data before freeing */
            memset(data->entries, 0, sizeof(SessionDataEntry) * data->capacity);
            free(data->entries);
            data->entries = NULL;
        }
        free(data);
    }
}

/* Find session index by ID, returns -1 if not found */
static int find_session_index(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return -1;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].slot_used &&
            strcmp(cache->sessions[i].session_id, session_id) == 0) {
            return i;
        }
    }
    return -1;
}

/* Check if a session has expired and handle expiration */
static void check_and_expire_session(Session *session) {
    if (!session || session->state != SESSION_ACTIVE) return;
    time_t now = time(NULL);
    if (now >= session->expires_at) {
        printf("[CACHE] Session '%s' has expired. Freeing data but keeping ID for re-init.\n",
               session->session_id);
        free_session_data(session->data);
        session->data = NULL;
        session->state = SESSION_EXPIRED;
    }
}

/* Initialize the session cache */
SessionCache *cache_init(void) {
    SessionCache *cache = (SessionCache *)calloc(1, sizeof(SessionCache));
    if (!cache) {
        fprintf(stderr, "[ERROR] Failed to allocate session cache.\n");
        return NULL;
    }
    cache->active_count = 0;
    cache->total_slots_used = 0;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        cache->sessions[i].slot_used = false;
        cache->sessions[i].data = NULL;
        cache->sessions[i].state = SESSION_INVALIDATED;
    }
    printf("[CACHE] Session cache initialized (capacity: %d)\n", MAX_SESSIONS);
    return cache;
}

/* Destroy the entire cache and free all memory */
void cache_destroy(SessionCache *cache) {
    if (!cache) return;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].slot_used) {
            free_session_data(cache->sessions[i].data);
            cache->sessions[i].data = NULL;
        }
    }
    free(cache);
    printf("[CACHE] Session cache destroyed.\n");
}

/* Create a new session, returns session ID or NULL on failure */
const char *session_create(SessionCache *cache, int ttl_seconds) {
    if (!cache) return NULL;

    if (ttl_seconds <= 0) ttl_seconds = DEFAULT_TTL;

    /* Find a free slot */
    int free_slot = -1;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (!cache->sessions[i].slot_used) {
            free_slot = i;
            break;
        }
    }

    if (free_slot == -1) {
        /* Try to reclaim an expired or invalidated slot */
        for (int i = 0; i < MAX_SESSIONS; i++) {
            check_and_expire_session(&cache->sessions[i]);
            if (cache->sessions[i].slot_used &&
                (cache->sessions[i].state == SESSION_EXPIRED ||
                 cache->sessions[i].state == SESSION_INVALIDATED)) {
                /* Reclaim this slot completely */
                free_session_data(cache->sessions[i].data);
                cache->sessions[i].data = NULL;
                cache->sessions[i].slot_used = false;
                cache->total_slots_used--;
                free_slot = i;
                break;
            }
        }
    }

    if (free_slot == -1) {
        fprintf(stderr, "[ERROR] Session cache is full. Cannot create new session.\n");
        return NULL;
    }

    Session *s = &cache->sessions[free_slot];
    generate_session_id(s->session_id, SESSION_ID_LEN);

    /* Ensure uniqueness */
    int attempts = 0;
    while (find_session_index(cache, s->session_id) != -1 && find_session_index(cache, s->session_id) != free_slot) {
        generate_session_id(s->session_id, SESSION_ID_LEN);
        if (++attempts > 100) {
            fprintf(stderr, "[ERROR] Failed to generate unique session ID.\n");
            return NULL;
        }
    }

    s->data = create_session_data();
    if (!s->data) {
        fprintf(stderr, "[ERROR] Failed to allocate session data.\n");
        return NULL;
    }

    time_t now = time(NULL);
    s->created_at = now;
    s->last_accessed = now;
    s->ttl = ttl_seconds;
    s->expires_at = now + ttl_seconds;
    s->state = SESSION_ACTIVE;
    s->slot_used = true;

    cache->active_count++;
    cache->total_slots_used++;

    printf("[CACHE] Session created: '%s' (TTL: %ds, slot: %d)\n",
           s->session_id, ttl_seconds, free_slot);

    return s->session_id;
}

/* Access a session - returns the session pointer or NULL */
Session *session_access(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return NULL;

    int idx = find_session_index(cache, session_id);
    if (idx == -1) {
        printf("[CACHE] Session '%s' not found.\n", session_id);
        return NULL;
    }

    Session *s = &cache->sessions[idx];
    check_and_expire_session(s);

    if (s->state == SESSION_ACTIVE) {
        s->last_accessed = time(NULL);
        /* Extend expiration on access (sliding window) */
        s->expires_at = s->last_accessed + s->ttl;
        printf("[CACHE] Session '%s' accessed. Expiration extended.\n", session_id);
        return s;
    }

    printf("[CACHE] Session '%s' is %s.\n", session_id,
           s->state == SESSION_EXPIRED ? "expired" : "invalidated");
    return NULL;
}

/* Re-initialize an expired session (reuse the cached session ID slot) */
Session *session_reinitialize(SessionCache *cache, const char *session_id, int ttl_seconds) {
    if (!cache || !session_id) return NULL;

    int idx = find_session_index(cache, session_id);
    if (idx == -1) {
        printf("[CACHE] Session '%s' not found for re-initialization.\n", session_id);
        return NULL;
    }

    Session *s = &cache->sessions[idx];

    if (s->state == SESSION_ACTIVE) {
        printf("[CACHE] Session '%s' is already active.\n", session_id);
        s->last_accessed = time(NULL);
        return s;
    }

    if (s->state != SESSION_EXPIRED && s->state != SESSION_INVALIDATED) {
        printf("[CACHE] Session '%s' is in an unexpected state.\n", session_id);
        return NULL;
    }

    /* Re-init: allocate fresh data, keep the same session ID */
    if (s->data) {
        free_session_data(s->data);
        s->data = NULL;
    }

    s->data = create_session_data();
    if (!s->data) {
        fprintf(stderr, "[ERROR] Failed to allocate session data for re-init.\n");
        return NULL;
    }

    if (ttl_seconds <= 0) ttl_seconds = DEFAULT_TTL;

    time_t now = time(NULL);
    s->last_accessed = now;
    s->ttl = ttl_seconds;
    s->expires_at = now + ttl_seconds;
    s->state = SESSION_ACTIVE;

    cache->active_count++;

    printf("[CACHE] Session '%s' re-initialized (TTL: %ds). Quick re-init from cached slot!\n",
           session_id, ttl_seconds);

    return s;
}

/* Set a key-value pair in a session's data */
bool session_set_data(Session *session, const char *key, const char *value) {
    if (!session || !key || !value) return false;
    if (session->state != SESSION_ACTIVE || !session->data) {
        fprintf(stderr, "[ERROR] Cannot set data on inactive session.\n");
        return false;
    }

    SessionData *data = session->data;

    /* Check if key already exists, update it */
    for (int i = 0; i < data->count; i++) {
        if (strcmp(data->entries[i].key, key) == 0) {
            strncpy(data->entries[i].value, value, MAX_DATA_VAL_LEN - 1);
            data->entries[i].value[MAX_DATA_VAL_LEN - 1] = '\0';
            printf("[SESSION] Updated key '%s' in session '%s'\n", key, session->session_id);
            return true;
        }
    }

    /* Add new entry */
    if (data->count >= data->capacity) {
        fprintf(stderr, "[ERROR] Session data capacity reached for session '%s'.\n",
                session->session_id);
        return false;
    }

    strncpy(data->entries[data->count].key, key, MAX_DATA_KEY_LEN - 1);
    data->entries[data->count].key[MAX_DATA_KEY_LEN - 1] = '\0';
    strncpy(data->entries[data->count].value, value, MAX_DATA_VAL_LEN - 1);
    data->entries[data->count].value[MAX_DATA_VAL_LEN - 1] = '\0';
    data->count++;

    printf("[SESSION] Set key '%s' = '%s' in session '%s'\n", key, value, session->session_id);
    return true;
}

/* Get a value by key from a session */
const char *session_get_data(Session *session, const char *key) {
    if (!session || !key) return NULL;
    if (session->state != SESSION_ACTIVE || !session->data) return NULL;

    for (int i = 0; i < session->data->count; i++) {
        if (strcmp(session->data->entries[i].key, key) == 0) {
            return session->data->entries[i].value;
        }
    }
    return NULL;
}

/* Invalidate a session - free data but keep session ID in cache */
bool session_invalidate(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;

    int idx = find_session_index(cache, session_id);
    if (idx == -1) {
        printf("[CACHE] Session '%s' not found for invalidation.\n", session_id);
        return false;
    }

    Session *s = &cache->sessions[idx];

    if (s->state == SESSION_ACTIVE) {
        cache->active_count--;
    }

    /* Free the session data memory but keep the slot with session ID */
    free_session_data(s->data);
    s->data = NULL;
    s->state = SESSION_INVALIDATED;
    /* slot_used remains true - the ID stays cached for quick re-init */

    printf("[CACHE] Session '%s' invalidated. ID kept in cache for quick re-init.\n",
           session_id);
    return true;
}

/* Remove a session completely from cache (slot freed) */
bool session_remove(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;

    int idx = find_session_index(cache, session_id);
    if (idx == -1) return false;

    Session *s = &cache->sessions[idx];

    if (s->state == SESSION_ACTIVE) {
        cache->active_count--;
    }

    free_session_data(s->data);
    s->data = NULL;
    s->slot_used = false;
    s->state = SESSION_INVALIDATED;
    memset(s->session_id, 0, SESSION_ID_LEN);
    cache->total_slots_used--;

    printf("[CACHE] Session completely removed from cache.\n");
    return true;
}

/* Perform garbage collection - expire stale sessions */
int cache_gc(SessionCache *cache) {
    if (!cache) return 0;

    int expired_count = 0;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].slot_used && cache->sessions[i].state == SESSION_ACTIVE) {
            SessionState old_state = cache->sessions[i].state;
            check_and_expire_session(&cache->sessions[i]);
            if (cache->sessions[i].state == SESSION_EXPIRED && old_state == SESSION_ACTIVE) {
                cache->active_count--;
                expired_count++;
            }
        }
    }

    if (expired_count > 0) {
        printf("[CACHE-GC] Expired %d sessions.\n", expired_count);
    }
    return expired_count;
}

/* Print cache statistics */
void cache_print_stats(SessionCache *cache) {
    if (!cache) return;

    int active = 0, expired = 0, invalidated = 0;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].slot_used) {
            check_and_expire_session(&cache->sessions[i]);
            switch (cache->sessions[i].state) {
                case SESSION_ACTIVE: active++; break;
                case SESSION_EXPIRED: expired++; break;
                case SESSION_INVALIDATED: invalidated++; break;
            }
        }
    }

    printf("\n========== Cache Statistics ==========\n");
    printf("  Total slots used:      %d / %d\n", cache->total_slots_used, MAX_SESSIONS);
    printf("  Active sessions:       %d\n", active);
    printf("  Expired (cached IDs):  %d\n", expired);
    printf("  Invalidated (cached):  %d\n", invalidated);
    printf("  Free slots:            %d\n", MAX_SESSIONS - cache->total_slots_used);
    printf("======================================\n\n");
}

/* Print details of a specific session */
void session_print(Session *session) {
    if (!session) {
        printf("[SESSION] NULL session.\n");
        return;
    }

    const char *state_str = "UNKNOWN";
    switch (session->state) {
        case SESSION_ACTIVE: state_str = "ACTIVE"; break;
        case SESSION_EXPIRED: state_str = "EXPIRED"; break;
        case SESSION_INVALIDATED: state_str = "INVALIDATED"; break;
    }

    printf("\n--- Session Details ---\n");
    printf("  ID:            %s\n", session->session_id);
    printf("  State:         %s\n", state_str);
    printf("  Created:       %s", ctime(&session->created_at));
    printf("  Last Accessed: %s", ctime(&session->last_accessed));
    printf("  Expires:       %s", ctime(&session->expires_at));
    printf("  TTL:           %d seconds\n", session->ttl);

    if (session->data && session->state == SESSION_ACTIVE) {
        printf("  Data entries:  %d\n", session->data->count);
        for (int i = 0; i < session->data->count; i++) {
            printf("    [%s] = '%s'\n",
                   session->data->entries[i].key,
                   session->data->entries[i].value);
        }
    } else {
        printf("  Data:          (freed/unavailable)\n");
    }
    printf("-----------------------\n\n");
}

/* ==================== Main / Demo ==================== */

int main(void) {
    printf("=== Session Cache System Demo ===\n\n");

    /* Initialize cache */
    SessionCache *cache = cache_init();
    if (!cache) {
        fprintf(stderr, "Failed to initialize cache.\n");
        return 1;
    }

    /* Create sessions */
    const char *sid1 = session_create(cache, 5);  /* 5 second TTL for demo */
    const char *sid2 = session_create(cache, 3600);
    const char *sid3 = session_create(cache, 3600);

    if (!sid1 || !sid2 || !sid3) {
        fprintf(stderr, "Failed to create sessions.\n");
        cache_destroy(cache);
        return 1;
    }

    /* Copy session IDs since they point to internal storage */
    char id1[SESSION_ID_LEN], id2[SESSION_ID_LEN], id3[SESSION_ID_LEN];
    strncpy(id1, sid1, SESSION_ID_LEN);
    strncpy(id2, sid2, SESSION_ID_LEN);
    strncpy(id3, sid3, SESSION_ID_LEN);

    /* Set data on sessions */
    Session *s1 = session_access(cache, id1);
    if (s1) {
        session_set_data(s1, "username", "alice");
        session_set_data(s1, "role", "admin");
        session_set_data(s1, "ip_address", "192.168.1.100");
        session_print(s1);
    }

    Session *s2 = session_access(cache, id2);
    if (s2) {
        session_set_data(s2, "username", "bob");
        session_set_data(s2, "role", "user");
        session_set_data(s2, "cart_items", "3");
        session_print(s2);
    }

    Session *s3 = session_access(cache, id3);
    if (s3) {
        session_set_data(s3, "username", "charlie");
        session_set_data(s3, "preferences", "dark_mode=true");
    }

    cache_print_stats(cache);

    /* Demonstrate data retrieval */
    s1 = session_access(cache, id1);
    if (s1) {
        const char *username = session_get_data(s1, "username");
        const char *role = session_get_data(s1, "role");
        printf("[DEMO] Retrieved from session 1: username='%s', role='%s'\n\n",
               username ? username : "NULL", role ? role : "NULL");
    }

    /* Invalidate session 3 - data freed, ID kept */
    printf("[DEMO] Invalidating session 3...\n");
    session_invalidate(cache, id3);
    cache_print_stats(cache);

    /* Try accessing invalidated session */
    printf("[DEMO] Attempting to access invalidated session 3...\n");
    Session *s3_attempt = session_access(cache, id3);
    if (!s3_attempt) {
        printf("[DEMO] Session 3 is not accessible (expected).\n\n");
    }

    /* Re-initialize session 3 using cached ID */
    printf("[DEMO] Re-initializing session 3 from cached ID...\n");
    s3 = session_reinitialize(cache, id3, 7200);
    if (s3) {
        session_set_data(s3, "username", "charlie_v2");
        session_set_data(s3, "preferences", "dark_mode=false");
        session_set_data(s3, "session_type", "re-initialized");
        session_print(s3);
    }

    cache_print_stats(cache);

    /* Wait for session 1 to expire (5 second TTL) */
    printf("[DEMO] Waiting for session 1 to expire (5 seconds)...\n");
    #ifdef _WIN32
    Sleep(6000);
    #else
    {
        struct timespec ts = {6, 0};
        nanosleep(&ts, NULL);
    }
    #endif

    /* Run garbage collection */
    printf("[DEMO] Running garbage collection...\n");
    int gc_count = cache_gc(cache);
    printf("[DEMO] GC expired %d sessions.\n\n", gc_count);

    /* Try accessing expired session 1 */
    printf("[DEMO] Attempting to access expired session 1...\n");
    Session *s1_expired = session_access(cache, id1);
    if (!s1_expired) {
        printf("[DEMO] Session 1 is expired (data freed, ID still cached).\n\n");
    }

    /* Re-initialize expired session 1 */
    printf("[DEMO] Re-initializing expired session 1...\n");
    s1 = session_reinitialize(cache, id1, 3600);
    if (s1) {
        session_set_data(s1, "username", "alice_renewed");
        session_set_data(s1, "login_count", "2");
        session_print(s1);
        printf("[DEMO] Session 1 successfully re-initialized from cached ID!\n\n");
    }

    /* Update existing data */
    s2 = session_access(cache, id2);
    if (s2) {
        session_set_data(s2, "cart_items", "5");  /* Update existing key */
        const char *cart = session_get_data(s2, "cart_items");
        printf("[DEMO] Updated session 2 cart_items to '%s'\n\n", cart ? cart : "NULL");
    }

    /* Final stats */
    cache_print_stats(cache);

    /* Completely remove session 2 */
    printf("[DEMO] Completely removing session 2 from cache...\n");
    session_remove(cache, id2);
    cache_print_stats(cache);

    /* Cleanup */
    cache_destroy(cache);

    printf("=== Demo Complete ===\n");
    return 0;
}