# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <time.h>

#define MAX_REQUEST_SIZE 4096
#define MAX_RESPONSE_SIZE 8192
#define MAX_URI_LENGTH 256
#define MAX_HEADERS 32
#define MAX_HEADER_LENGTH 512

typedef enum {
    HTTP_GET,
    HTTP_POST,
    HTTP_PUT,
    HTTP_DELETE,
    HTTP_UNKNOWN
} http_method_t;

typedef struct {
    char name[128];
    char value[384];
} http_header_t;

typedef struct {
    http_method_t method;
    char uri[MAX_URI_LENGTH];
    char version[16];
    http_header_t headers[MAX_HEADERS];
    int header_count;
    char *body;
    size_t body_length;
    size_t total_size;
} http_request_t;

typedef struct {
    int status_code;
    char status_text[64];
    char content_type[128];
    char *body;
    size_t body_length;
} http_response_t;

typedef struct {
    unsigned long requests_processed;
    unsigned long bytes_received;
    unsigned long bytes_sent;
    unsigned long errors;
    double total_processing_time_ms;
} server_stats_t;

/* Pre-allocated buffer pool for reducing malloc overhead */
typedef struct {
    char *buffers[16];
    bool in_use[16];
    int pool_size;
    int buffer_size;
} buffer_pool_t;

static server_stats_t g_stats = {0};

buffer_pool_t *buffer_pool_create(int pool_size, int buffer_size) {
    buffer_pool_t *pool = (buffer_pool_t *)malloc(sizeof(buffer_pool_t));
    if (!pool) return NULL;

    pool->pool_size = pool_size > 16 ? 16 : pool_size;
    pool->buffer_size = buffer_size;

    for (int i = 0; i < pool->pool_size; i++) {
        pool->buffers[i] = (char *)malloc(buffer_size);
        pool->in_use[i] = false;
        if (!pool->buffers[i]) {
            for (int j = 0; j < i; j++) {
                free(pool->buffers[j]);
            }
            free(pool);
            return NULL;
        }
    }

    return pool;
}

char *buffer_pool_acquire(buffer_pool_t *pool) {
    if (!pool) return NULL;
    for (int i = 0; i < pool->pool_size; i++) {
        if (!pool->in_use[i]) {
            pool->in_use[i] = true;
            memset(pool->buffers[i], 0, pool->buffer_size);
            return pool->buffers[i];
        }
    }
    /* Pool exhausted, fall back to malloc */
    return (char *)calloc(1, pool->buffer_size);
}

void buffer_pool_release(buffer_pool_t *pool, char *buffer) {
    if (!pool || !buffer) return;
    for (int i = 0; i < pool->pool_size; i++) {
        if (pool->buffers[i] == buffer) {
            pool->in_use[i] = false;
            return;
        }
    }
    /* Buffer was not from pool, free it */
    free(buffer);
}

void buffer_pool_destroy(buffer_pool_t *pool) {
    if (!pool) return;
    for (int i = 0; i < pool->pool_size; i++) {
        free(pool->buffers[i]);
    }
    free(pool);
}

http_method_t parse_method(const char *method_str) {
    if (strncmp(method_str, "GET", 3) == 0) return HTTP_GET;
    if (strncmp(method_str, "POST", 4) == 0) return HTTP_POST;
    if (strncmp(method_str, "PUT", 3) == 0) return HTTP_PUT;
    if (strncmp(method_str, "DELETE", 6) == 0) return HTTP_DELETE;
    return HTTP_UNKNOWN;
}

const char *method_to_string(http_method_t method) {
    switch (method) {
        case HTTP_GET: return "GET";
        case HTTP_POST: return "POST";
        case HTTP_PUT: return "PUT";
        case HTTP_DELETE: return "DELETE";
        default: return "UNKNOWN";
    }
}

int parse_request(const char *raw_request, size_t raw_length, http_request_t *request) {
    if (!raw_request || !request || raw_length == 0) return -1;

    memset(request, 0, sizeof(http_request_t));
    request->total_size = raw_length;

    /* Parse request line */
    char method_str[16] = {0};
    const char *ptr = raw_request;
    const char *end = raw_request + raw_length;

    /* Extract method */
    const char *space = memchr(ptr, ' ', end - ptr);
    if (!space || (space - ptr) >= (int)sizeof(method_str)) return -1;
    memcpy(method_str, ptr, space - ptr);
    request->method = parse_method(method_str);

    /* Extract URI */
    ptr = space + 1;
    space = memchr(ptr, ' ', end - ptr);
    if (!space) return -1;
    size_t uri_len = space - ptr;
    if (uri_len >= MAX_URI_LENGTH) uri_len = MAX_URI_LENGTH - 1;
    memcpy(request->uri, ptr, uri_len);

    /* Extract HTTP version */
    ptr = space + 1;
    const char *newline = memchr(ptr, '\r', end - ptr);
    if (!newline) newline = memchr(ptr, '\n', end - ptr);
    if (!newline) return -1;
    size_t ver_len = newline - ptr;
    if (ver_len >= sizeof(request->version)) ver_len = sizeof(request->version) - 1;
    memcpy(request->version, ptr, ver_len);

    /* Move past the request line */
    ptr = newline;
    if (*ptr == '\r') ptr++;
    if (ptr < end && *ptr == '\n') ptr++;

    /* Parse headers */
    request->header_count = 0;
    while (ptr < end && request->header_count < MAX_HEADERS) {
        /* Check for end of headers */
        if (*ptr == '\r' || *ptr == '\n') {
            if (*ptr == '\r') ptr++;
            if (ptr < end && *ptr == '\n') ptr++;
            break;
        }

        const char *colon = memchr(ptr, ':', end - ptr);
        newline = memchr(ptr, '\r', end - ptr);
        if (!newline) newline = memchr(ptr, '\n', end - ptr);
        if (!colon || !newline) break;

        http_header_t *header = &request->headers[request->header_count];

        size_t name_len = colon - ptr;
        if (name_len >= sizeof(header->name)) name_len = sizeof(header->name) - 1;
        memcpy(header->name, ptr, name_len);

        /* Skip colon and whitespace */
        const char *val_start = colon + 1;
        while (val_start < newline && *val_start == ' ') val_start++;

        size_t val_len = newline - val_start;
        if (val_len >= sizeof(header->value)) val_len = sizeof(header->value) - 1;
        memcpy(header->value, val_start, val_len);

        request->header_count++;

        ptr = newline;
        if (*ptr == '\r') ptr++;
        if (ptr < end && *ptr == '\n') ptr++;
    }

    /* Remaining data is the body */
    if (ptr < end) {
        request->body = (char *)ptr;
        request->body_length = end - ptr;
    }

    return 0;
}

const char *get_header_value(const http_request_t *request, const char *name) {
    for (int i = 0; i < request->header_count; i++) {
        if (strcasecmp(request->headers[i].name, name) == 0) {
            return request->headers[i].value;
        }
    }
    return NULL;
}

int handle_get_request(const http_request_t *request, http_response_t *response) {
    response->status_code = 200;
    strncpy(response->status_text, "OK", sizeof(response->status_text) - 1);
    strncpy(response->content_type, "text/html", sizeof(response->content_type) - 1);

    if (strcmp(request->uri, "/") == 0 || strcmp(request->uri, "/index.html") == 0) {
        const char *body = "<html><body><h1>Embedded Web Server</h1>"
                           "<p>Server is running.</p>"
                           "<ul>"
                           "<li><a href=\"/status\">/status</a> - Server status</li>"
                           "<li><a href=\"/api/data\">/api/data</a> - API data</li>"
                           "</ul></body></html>";
        response->body_length = strlen(body);
        response->body = (char *)malloc(response->body_length + 1);
        if (!response->body) return -1;
        memcpy(response->body, body, response->body_length + 1);
    } else if (strcmp(request->uri, "/status") == 0) {
        strncpy(response->content_type, "application/json", sizeof(response->content_type) - 1);
        char status_body[512];
        int len = snprintf(status_body, sizeof(status_body),
            "{\"requests_processed\":%lu,\"bytes_received\":%lu,"
            "\"bytes_sent\":%lu,\"errors\":%lu,"
            "\"avg_processing_time_ms\":%.3f}",
            g_stats.requests_processed,
            g_stats.bytes_received,
            g_stats.bytes_sent,
            g_stats.errors,
            g_stats.requests_processed > 0 ?
                g_stats.total_processing_time_ms / g_stats.requests_processed : 0.0);
        response->body_length = len;
        response->body = (char *)malloc(len + 1);
        if (!response->body) return -1;
        memcpy(response->body, status_body, len + 1);
    } else if (strcmp(request->uri, "/api/data") == 0) {
        strncpy(response->content_type, "application/json", sizeof(response->content_type) - 1);
        const char *body = "{\"sensor1\":23.5,\"sensor2\":45.2,\"uptime\":12345}";
        response->body_length = strlen(body);
        response->body = (char *)malloc(response->body_length + 1);
        if (!response->body) return -1;
        memcpy(response->body, body, response->body_length + 1);
    } else {
        response->status_code = 404;
        strncpy(response->status_text, "Not Found", sizeof(response->status_text) - 1);
        const char *body = "<html><body><h1>404 Not Found</h1></body></html>";
        response->body_length = strlen(body);
        response->body = (char *)malloc(response->body_length + 1);
        if (!response->body) return -1;
        memcpy(response->body, body, response->body_length + 1);
    }

    return 0;
}

int handle_post_request(const http_request_t *request, http_response_t *response) {
    response->status_code = 200;
    strncpy(response->status_text, "OK", sizeof(response->status_text) - 1);
    strncpy(response->content_type, "application/json", sizeof(response->content_type) - 1);

    if (strcmp(request->uri, "/api/data") == 0) {
        char resp_body[256];
        int len = snprintf(resp_body, sizeof(resp_body),
            "{\"status\":\"received\",\"bytes\":%zu}", request->body_length);
        response->body_length = len;
        response->body = (char *)malloc(len + 1);
        if (!response->body) return -1;
        memcpy(response->body, resp_body, len + 1);
    } else {
        response->status_code = 404;
        strncpy(response->status_text, "Not Found", sizeof(response->status_text) - 1);
        const char *body = "{\"error\":\"endpoint not found\"}";
        response->body_length = strlen(body);
        response->body = (char *)malloc(response->body_length + 1);
        if (!response->body) return -1;
        memcpy(response->body, body, response->body_length + 1);
    }

    return 0;
}

int process_request(const http_request_t *request, http_response_t *response) {
    memset(response, 0, sizeof(http_response_t));

    switch (request->method) {
        case HTTP_GET:
            return handle_get_request(request, response);
        case HTTP_POST:
            return handle_post_request(request, response);
        case HTTP_PUT:
        case HTTP_DELETE:
            response->status_code = 501;
            strncpy(response->status_text, "Not Implemented", sizeof(response->status_text) - 1);
            strncpy(response->content_type, "text/html", sizeof(response->content_type) - 1);
            {
                const char *body = "<html><body><h1>501 Not Implemented</h1></body></html>";
                response->body_length = strlen(body);
                response->body = (char *)malloc(response->body_length + 1);
                if (!response->body) return -1;
                memcpy(response->body, body, response->body_length + 1);
            }
            return 0;
        default:
            response->status_code = 400;
            strncpy(response->status_text, "Bad Request", sizeof(response->status_text) - 1);
            strncpy(response->content_type, "text/html", sizeof(response->content_type) - 1);
            {
                const char *body = "<html><body><h1>400 Bad Request</h1></body></html>";
                response->body_length = strlen(body);
                response->body = (char *)malloc(response->body_length + 1);
                if (!response->body) return -1;
                memcpy(response->body, body, response->body_length + 1);
            }
            return 0;
    }
}

int format_response(const http_response_t *response, char *output_buffer, size_t buffer_size) {
    int written = snprintf(output_buffer, buffer_size,
        "HTTP/1.1 %d %s\r\n"
        "Content-Type: %s\r\n"
        "Content-Length: %zu\r\n"
        "Connection: keep-alive\r\n"
        "Server: EmbeddedHTTP/1.0\r\n"
        "\r\n",
        response->status_code,
        response->status_text,
        response->content_type,
        response->body_length);

    if (written < 0 || (size_t)written >= buffer_size) return -1;

    if (response->body && response->body_length > 0) {
        if ((size_t)written + response->body_length >= buffer_size) return -1;
        memcpy(output_buffer + written, response->body, response->body_length);
        written += (int)response->body_length;
        output_buffer[written] = '\0';
    }

    return written;
}

void free_response(http_response_t *response) {
    if (response && response->body) {
        free(response->body);
        response->body = NULL;
    }
}

/* Simulates receiving an HTTP request (for demonstration purposes) */
int simulate_receive_request(char *buffer, size_t buffer_size, int request_num) {
    const char *requests[] = {
        "GET / HTTP/1.1\r\n"
        "Host: localhost\r\n"
        "User-Agent: TestClient/1.0\r\n"
        "Accept: text/html\r\n"
        "\r\n",

        "GET /status HTTP/1.1\r\n"
        "Host: localhost\r\n"
        "User-Agent: TestClient/1.0\r\n"
        "Accept: application/json\r\n"
        "\r\n",

        "POST /api/data HTTP/1.1\r\n"
        "Host: localhost\r\n"
        "Content-Type: application/json\r\n"
        "Content-Length: 27\r\n"
        "\r\n"
        "{\"temperature\":25.3,\"id\":1}",

        "GET /api/data HTTP/1.1\r\n"
        "Host: localhost\r\n"
        "Accept: application/json\r\n"
        "\r\n",

        "GET /nonexistent HTTP/1.1\r\n"
        "Host: localhost\r\n"
        "\r\n",

        "DELETE /api/data HTTP/1.1\r\n"
        "Host: localhost\r\n"
        "\r\n",
    };

    int num_requests = sizeof(requests) / sizeof(requests[0]);
    int idx = request_num % num_requests;

    size_t len = strlen(requests[idx]);
    if (len >= buffer_size) return -1;

    memcpy(buffer, requests[idx], len);
    buffer[len] = '\0';
    return (int)len;
}

int main(void) {
    printf("=== Embedded HTTP Server Starting ===\n");
    printf("Initializing buffer pool...\n");

    buffer_pool_t *request_pool = buffer_pool_create(8, MAX_REQUEST_SIZE);
    buffer_pool_t *response_pool = buffer_pool_create(8, MAX_RESPONSE_SIZE);

    if (!request_pool || !response_pool) {
        fprintf(stderr, "Failed to initialize buffer pools\n");
        if (request_pool) buffer_pool_destroy(request_pool);
        if (response_pool) buffer_pool_destroy(response_pool);
        return 1;
    }

    printf("Buffer pools initialized. Starting request processing loop...\n\n");

    int max_iterations = 20; /* For demonstration; remove for actual embedded use */
    volatile bool server_running = true;
    int iteration = 0;

    while (server_running) {
        struct timespec start_time, end_time;
        clock_gettime(CLOCK_MONOTONIC, &start_time);

        /* Acquire buffers from pool */
        char *request_buffer = buffer_pool_acquire(request_pool);
        char *response_buffer = buffer_pool_acquire(response_pool);

        if (!request_buffer || !response_buffer) {
            fprintf(stderr, "[ERROR] Failed to acquire buffers\n");
            g_stats.errors++;
            if (request_buffer) buffer_pool_release(request_pool, request_buffer);
            if (response_buffer) buffer_pool_release(response_pool, response_buffer);
            continue;
        }

        /* Simulate receiving a request */
        int bytes_received = simulate_receive_request(request_buffer, MAX_REQUEST_SIZE, iteration);
        if (bytes_received <= 0) {
            fprintf(stderr, "[ERROR] Failed to receive request\n");
            g_stats.errors++;
            buffer_pool_release(request_pool, request_buffer);
            buffer_pool_release(response_pool, response_buffer);
            continue;
        }

        g_stats.bytes_received += bytes_received;

        /* Parse the HTTP request */
        http_request_t request;
        if (parse_request(request_buffer, bytes_received, &request) != 0) {
            fprintf(stderr, "[ERROR] Failed to parse request\n");
            g_stats.errors++;
            buffer_pool_release(request_pool, request_buffer);
            buffer_pool_release(response_pool, response_buffer);
            continue;
        }

        /* Process the request and generate a response */
        http_response_t response;
        if (process_request(&request, &response) != 0) {
            fprintf(stderr, "[ERROR] Failed to process request\n");
            g_stats.errors++;
            buffer_pool_release(request_pool, request_buffer);
            buffer_pool_release(response_pool, response_buffer);
            continue;
        }

        /* Format the response */
        int response_length = format_response(&response, response_buffer, MAX_RESPONSE_SIZE);
        if (response_length < 0) {
            fprintf(stderr, "[ERROR] Failed to format response\n");
            g_stats.errors++;
            free_response(&response);
            buffer_pool_release(request_pool, request_buffer);
            buffer_pool_release(response_pool, response_buffer);
            continue;
        }

        clock_gettime(CLOCK_MONOTONIC, &end_time);
        double elapsed_ms = (end_time.tv_sec - start_time.tv_sec) * 1000.0 +
                           (end_time.tv_nsec - start_time.tv_nsec) / 1000000.0;

        g_stats.requests_processed++;
        g_stats.bytes_sent += response_length;
        g_stats.total_processing_time_ms += elapsed_ms;

        /* Log the request/response */
        printf("[Request #%lu] %s %s -> %d %s (%.3f ms)\n",
            g_stats.requests_processed,
            method_to_string(request.method),
            request.uri,
            response.status_code,
            response.status_text,
            elapsed_ms);

        printf("  Headers: %d, Body: %zu bytes\n",
            request.header_count, request.body_length);
        printf("  Response: %d bytes\n", response_length);

        const char *host = get_header_value(&request, "Host");
        if (host) {
            printf("  Host: %s\n", host);
        }

        printf("  Response preview: %.100s...\n\n", response_buffer);

        /* Clean up */
        free_response(&response);
        buffer_pool_release(request_pool, request_buffer);
        buffer_pool_release(response_pool, response_buffer);

        iteration++;
        if (iteration >= max_iterations) {
            server_running = false;
        }
    }

    /* Print final statistics */
    printf("=== Server Statistics ===\n");
    printf("Requests processed: %lu\n", g_stats.requests_processed);
    printf("Bytes received:     %lu\n", g_stats.bytes_received);
    printf("Bytes sent:         %lu\n", g_stats.bytes_sent);
    printf("Errors:             %lu\n", g_stats.errors);
    printf("Avg processing time: %.3f ms\n",
        g_stats.requests_processed > 0 ?
            g_stats.total_processing_time_ms / g_stats.requests_processed : 0.0);
    printf("Total processing time: %.3f ms\n", g_stats.total_processing_time_ms);

    /* Cleanup */
    buffer_pool_destroy(request_pool);
    buffer_pool_destroy(response_pool);

    printf("\n=== Server Shutdown Complete ===\n");
    return 0;
}