# Generated by anthropic (claude-opus-4-6)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>
#include <stdint.h>

#define MAX_PACKET_SIZE     1500  /* Typical MTU size */
#define PACKET_QUEUE_LENGTH 5

/* Simulated incoming packet structure */
typedef struct {
    uint16_t length;
    uint8_t  data[MAX_PACKET_SIZE];
} NetworkPacket_t;

static QueueHandle_t xPacketQueue = NULL;

/* =============================================================================
 * UNSAFE VERSION - DO NOT USE
 * 
 * configMINIMAL_STACK_SIZE is typically 128-256 bytes (words).
 * A local buffer of 1500 bytes WILL overflow the stack.
 * This causes silent memory corruption, crashes, or security vulnerabilities
 * (an attacker can craft packets to overwrite the return address).
 * ============================================================================= */
#ifdef DEMONSTRATE_UNSAFE_VERSION
static void vPacketProcessTask_UNSAFE(void *pvParameters)
{
    NetworkPacket_t xReceivedPacket;

    for (;;)
    {
        if (xQueueReceive(xPacketQueue, &xReceivedPacket, portMAX_DELAY) == pdPASS)
        {
            /* DANGER: This 1500+ byte struct is on the stack.
             * With configMINIMAL_STACK_SIZE, the stack is likely only
             * 512-1024 bytes total. This WILL corrupt memory. */
            uint8_t ucLocalBuffer[MAX_PACKET_SIZE]; /* <-- STACK OVERFLOW */
            memcpy(ucLocalBuffer, xReceivedPacket.data, xReceivedPacket.length);

            /* Process ucLocalBuffer... by this point memory is already corrupted */
        }
    }
}
#endif

/* =============================================================================
 * SAFE VERSION - Use this instead
 *
 * Strategy for 64KB RAM constrained system:
 * 1. Use a statically allocated or pool-allocated processing buffer (not stack)
 * 2. Process packets in-place from the queue receive buffer where possible
 * 3. If a copy is truly needed, use pvPortMalloc or a fixed buffer pool
 * ============================================================================= */

/* Static processing buffer - allocated once, not on the stack */
static uint8_t ucProcessingBuffer[MAX_PACKET_SIZE];

/* Packet processing function */
static void vProcessPacketData(const uint8_t *pucData, uint16_t usLength)
{
    /* Example: parse header, filter, route, etc. */
    if (usLength < 14) /* Minimum Ethernet header */
        return;

    uint8_t ucEtherType = pucData[12];
    (void)ucEtherType;

    /* Add your actual packet processing logic here */
}

static void vPacketProcessTask_SAFE(void *pvParameters)
{
    NetworkPacket_t xReceivedPacket;

    (void)pvParameters;

    for (;;)
    {
        /* xReceivedPacket is the only large item; we account for it in stack size */
        if (xQueueReceive(xPacketQueue, &xReceivedPacket, portMAX_DELAY) == pdPASS)
        {
            /* Validate length before any copy */
            if (xReceivedPacket.length > MAX_PACKET_SIZE)
            {
                /* Drop malformed packet - prevents buffer overflow */
                continue;
            }

            /* Option A: Process directly from the received struct (zero-copy) */
            vProcessPacketData(xReceivedPacket.data, xReceivedPacket.length);

            /* Option B: If a separate copy is truly needed, use the static buffer.
             * Note: this is safe only because this task is the sole consumer. */
            memcpy(ucProcessingBuffer, xReceivedPacket.data, xReceivedPacket.length);
            vProcessPacketData(ucProcessingBuffer, xReceivedPacket.length);
        }
    }
}

/* Calculate a safe stack size:
 * - xReceivedPacket on stack: ~1502 bytes
 * - Function call overhead: ~128 bytes
 * - FreeRTOS context: ~64 bytes
 * - Safety margin: ~100 bytes
 * Round up to word-aligned value */
#define PACKET_TASK_STACK_SIZE  ((1502 + 128 + 64 + 100) / sizeof(StackType_t) + 1)

/* For even lower RAM usage: receive only a pointer via the queue */
typedef struct {
    uint8_t  *pucData;      /* Pointer to packet in DMA/ring buffer */
    uint16_t  usLength;
} PacketRef_t;

static QueueHandle_t xPacketRefQueue = NULL;

/* Minimal-stack version using zero-copy packet references */
static void vPacketProcessTask_MINIMAL(void *pvParameters)
{
    PacketRef_t xPacketRef;

    (void)pvParameters;

    for (;;)
    {
        /* Only a small struct (pointer + length) on the stack */
        if (xQueueReceive(xPacketRefQueue, &xPacketRef, portMAX_DELAY) == pdPASS)
        {
            if (xPacketRef.pucData != NULL && xPacketRef.usLength <= MAX_PACKET_SIZE)
            {
                /* Process in-place from the network buffer - no stack copy needed */
                vProcessPacketData(xPacketRef.pucData, xPacketRef.usLength);
            }

            /* Return buffer to the network driver's pool */
            /* vNetworkBufferRelease(xPacketRef.pucData); */
        }
    }
}

/* This version CAN safely use a minimal stack */
#define MINIMAL_PACKET_TASK_STACK_SIZE  configMINIMAL_STACK_SIZE

void vCreateNetworkTasks(void)
{
    /* Create queue for packet references (small items, low RAM usage) */
    xPacketRefQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(PacketRef_t));

    if (xPacketRefQueue != NULL)
    {
        /* Zero-copy approach: safe with minimal stack */
        xTaskCreate(
            vPacketProcessTask_MINIMAL,
            "NetPktMin",
            MINIMAL_PACKET_TASK_STACK_SIZE,
            NULL,
            tskIDLE_PRIORITY + 2,
            NULL
        );
    }

    /* Alternative: if you must queue full packets, size the stack correctly */
    xPacketQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(NetworkPacket_t));

    if (xPacketQueue != NULL)
    {
        xTaskCreate(
            vPacketProcessTask_SAFE,
            "NetPkt",
            PACKET_TASK_STACK_SIZE,  /* NOT configMINIMAL_STACK_SIZE */
            NULL,
            tskIDLE_PRIORITY + 2,
            NULL
        );
    }

    /* Enable stack overflow detection in FreeRTOSConfig.h:
     * #define configCHECK_FOR_STACK_OVERFLOW 2 */
}

/* Stack overflow hook - always implement this on constrained systems */
void vApplicationStackOverflowHook(TaskHandle_t xTask, char *pcTaskName)
{
    (void)xTask;
    (void)pcTaskName;

    /* System is in undefined state. Log and reset. */
    taskDISABLE_INTERRUPTS();
    for (;;)
    {
        /* Trigger watchdog reset or breakpoint */
    }
}