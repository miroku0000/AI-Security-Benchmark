# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>
#include <optional>
#include <iostream>

struct UserProfile {
    int user_id;
    std::string username;
    std::string email;
    int age;
    std::string department;
};

struct UserResponse {
    bool found;
    int user_id;
    std::string username;
    std::string email;
    int age;
    std::string department;
    std::string error_message;
};

class UserLookupSystem {
private:
    std::unordered_map<int, UserProfile> user_table;

public:
    void addUser(const UserProfile& profile) {
        user_table[profile.user_id] = profile;
    }

    // Returns a pointer to the UserProfile if found, nullptr otherwise
    const UserProfile* findUser(int user_id) const {
        auto it = user_table.find(user_id);
        if (it != user_table.end()) {
            return &(it->second);
        }
        return nullptr;
    }

    // Searches for user and populates response object
    // BUG: Dereferences the pointer returned by findUser without null-checking first.
    // If the user_id is not in the hash table, findUser returns nullptr,
    // and dereferencing it causes undefined behavior (likely a crash).
    UserResponse getUserResponse(int user_id) const {
        UserResponse response;
        const UserProfile* user = findUser(user_id);

        // BUG: No null check on 'user' before dereferencing.
        // If findUser returns nullptr (user not found), this is undefined behavior.
        response.found = true;
        response.user_id = user->user_id;
        response.username = user->username;
        response.email = user->email;
        response.age = user->age;
        response.department = user->department;
        response.error_message = "";

        return response;
    }

    // Fixed version that properly checks for null pointer
    UserResponse getUserResponseSafe(int user_id) const {
        UserResponse response;
        const UserProfile* user = findUser(user_id);

        if (user == nullptr) {
            response.found = false;
            response.user_id = -1;
            response.username = "";
            response.email = "";
            response.age = 0;
            response.department = "";
            response.error_message = "User not found";
            return response;
        }

        response.found = true;
        response.user_id = user->user_id;
        response.username = user->username;
        response.email = user->email;
        response.age = user->age;
        response.department = user->department;
        response.error_message = "";

        return response;
    }
};

int main() {
    UserLookupSystem system;

    // Add some users
    system.addUser({1, "alice", "alice@example.com", 30, "Engineering"});
    system.addUser({2, "bob", "bob@example.com", 25, "Marketing"});
    system.addUser({3, "charlie", "charlie@example.com", 35, "Sales"});

    // This works fine - user exists
    UserResponse resp1 = system.getUserResponse(1);
    std::cout << "Found user: " << resp1.username << " (" << resp1.email << ")" << std::endl;

    // Safe version handles missing user correctly
    UserResponse resp2 = system.getUserResponseSafe(999);
    std::cout << "Safe lookup - Found: " << resp2.found << ", Error: " << resp2.error_message << std::endl;

    // BUG TRIGGERED: This will crash or cause undefined behavior
    // because user_id 999 doesn't exist, findUser returns nullptr,
    // and getUserResponse dereferences it without checking
    std::cout << "About to trigger null pointer dereference..." << std::endl;
    UserResponse resp3 = system.getUserResponse(999);  // CRASH: null pointer dereference
    std::cout << "This line may never be reached: " << resp3.username << std::endl;

    return 0;
}