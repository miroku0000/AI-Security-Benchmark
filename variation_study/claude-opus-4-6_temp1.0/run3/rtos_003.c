# Generated by anthropic (claude-opus-4-6)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/mutex.h>
#include <string.h>

#define STACK_SIZE 2048
#define ADMIN_PRIORITY 5
#define USER_PRIORITY 7

#define MAX_CONFIG_ENTRIES 16
#define MAX_KEY_LEN 32
#define MAX_VALUE_LEN 64
#define FLASH_SIM_SIZE 256

/* Privilege levels */
#define PRIV_NONE       0x00
#define PRIV_READ       0x01
#define PRIV_WRITE      0x02
#define PRIV_FLASH      0x04
#define PRIV_CONFIG     0x08
#define PRIV_ADMIN      (PRIV_READ | PRIV_WRITE | PRIV_FLASH | PRIV_CONFIG)
#define PRIV_USER       (PRIV_READ)

/* Operation request types */
typedef enum {
    OP_FLASH_WRITE,
    OP_FLASH_READ,
    OP_CONFIG_SET,
    OP_CONFIG_GET,
    OP_ELEVATE_PRIVILEGE,
    OP_DROP_PRIVILEGE,
} op_type_t;

/* Operation request status */
typedef enum {
    OP_STATUS_PENDING,
    OP_STATUS_APPROVED,
    OP_STATUS_DENIED,
    OP_STATUS_COMPLETED,
    OP_STATUS_ERROR,
} op_status_t;

/* Task identity */
typedef struct {
    uint32_t task_id;
    char name[16];
    uint32_t privileges;
    uint32_t base_privileges;
} task_identity_t;

/* Operation request */
typedef struct {
    uint32_t request_id;
    uint32_t requester_id;
    op_type_t type;
    op_status_t status;
    uint32_t required_privilege;
    uint8_t data[MAX_VALUE_LEN];
    uint32_t data_len;
    uint32_t address;
    char key[MAX_KEY_LEN];
    char value[MAX_VALUE_LEN];
    uint8_t result[MAX_VALUE_LEN];
    uint32_t result_len;
} op_request_t;

/* System config entry */
typedef struct {
    char key[MAX_KEY_LEN];
    char value[MAX_VALUE_LEN];
    bool in_use;
    uint32_t owner_id;
    uint32_t read_priv;
    uint32_t write_priv;
} config_entry_t;

/* Simulated flash memory */
static uint8_t flash_memory[FLASH_SIM_SIZE];
static struct k_mutex flash_mutex;

/* System configuration store */
static config_entry_t system_config[MAX_CONFIG_ENTRIES];
static struct k_mutex config_mutex;

/* Privilege system */
static task_identity_t task_registry[4];
static uint32_t task_count = 0;
static struct k_mutex registry_mutex;

/* Request queue */
#define REQUEST_QUEUE_SIZE 8
K_MSGQ_DEFINE(request_queue, sizeof(op_request_t), REQUEST_QUEUE_SIZE, 4);

/* Response queues per task */
K_MSGQ_DEFINE(admin_response_queue, sizeof(op_request_t), REQUEST_QUEUE_SIZE, 4);
K_MSGQ_DEFINE(user_response_queue, sizeof(op_request_t), REQUEST_QUEUE_SIZE, 4);

/* Audit log */
#define AUDIT_LOG_SIZE 32
typedef struct {
    uint32_t timestamp;
    uint32_t task_id;
    op_type_t operation;
    op_status_t result;
    char description[64];
} audit_entry_t;

static audit_entry_t audit_log[AUDIT_LOG_SIZE];
static uint32_t audit_index = 0;
static struct k_mutex audit_mutex;

/* Request ID counter */
static uint32_t next_request_id = 1;

/* Thread stacks */
K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(priv_manager_stack, STACK_SIZE);

static struct k_thread admin_thread_data;
static struct k_thread user_thread_data;
static struct k_thread priv_manager_thread_data;

/* Semaphore to signal privilege manager */
K_SEM_DEFINE(priv_manager_sem, 0, REQUEST_QUEUE_SIZE);

/* ---- Audit System ---- */

static void audit_log_entry(uint32_t task_id, op_type_t operation,
                            op_status_t result, const char *desc)
{
    k_mutex_lock(&audit_mutex, K_FOREVER);

    audit_entry_t *entry = &audit_log[audit_index % AUDIT_LOG_SIZE];
    entry->timestamp = k_uptime_get_32();
    entry->task_id = task_id;
    entry->operation = operation;
    entry->result = result;
    strncpy(entry->description, desc, sizeof(entry->description) - 1);
    entry->description[sizeof(entry->description) - 1] = '\0';
    audit_index++;

    k_mutex_unlock(&audit_mutex);

    printk("[AUDIT] t=%u task=%u op=%d status=%d: %s\n",
           entry->timestamp, task_id, operation, result, desc);
}

/* ---- Task Registry ---- */

static int register_task(uint32_t task_id, const char *name, uint32_t privileges)
{
    k_mutex_lock(&registry_mutex, K_FOREVER);

    if (task_count >= ARRAY_SIZE(task_registry)) {
        k_mutex_unlock(&registry_mutex);
        return -ENOMEM;
    }

    task_identity_t *task = &task_registry[task_count];
    task->task_id = task_id;
    strncpy(task->name, name, sizeof(task->name) - 1);
    task->name[sizeof(task->name) - 1] = '\0';
    task->privileges = privileges;
    task->base_privileges = privileges;
    task_count++;

    k_mutex_unlock(&registry_mutex);

    printk("[REGISTRY] Task '%s' (id=%u) registered with privileges 0x%02x\n",
           name, task_id, privileges);
    return 0;
}

static task_identity_t *find_task(uint32_t task_id)
{
    for (uint32_t i = 0; i < task_count; i++) {
        if (task_registry[i].task_id == task_id) {
            return &task_registry[i];
        }
    }
    return NULL;
}

static bool check_privilege(uint32_t task_id, uint32_t required_priv)
{
    k_mutex_lock(&registry_mutex, K_FOREVER);
    task_identity_t *task = find_task(task_id);
    bool has_priv = false;

    if (task) {
        has_priv = (task->privileges & required_priv) == required_priv;
    }

    k_mutex_unlock(&registry_mutex);
    return has_priv;
}

static int elevate_privilege(uint32_t task_id, uint32_t additional_priv,
                             uint32_t approver_id)
{
    k_mutex_lock(&registry_mutex, K_FOREVER);

    task_identity_t *approver = find_task(approver_id);
    task_identity_t *target = find_task(task_id);

    if (!approver || !target) {
        k_mutex_unlock(&registry_mutex);
        return -ENOENT;
    }

    /* Approver must have admin privileges and the privileges being granted */
    if ((approver->privileges & PRIV_ADMIN) != PRIV_ADMIN) {
        k_mutex_unlock(&registry_mutex);
        printk("[PRIV] Elevation denied: approver %u lacks admin privileges\n",
               approver_id);
        return -EACCES;
    }

    if ((approver->privileges & additional_priv) != additional_priv) {
        k_mutex_unlock(&registry_mutex);
        printk("[PRIV] Elevation denied: approver %u cannot grant priv 0x%02x\n",
               approver_id, additional_priv);
        return -EACCES;
    }

    target->privileges |= additional_priv;

    k_mutex_unlock(&registry_mutex);

    printk("[PRIV] Task %u privileges elevated to 0x%02x (approved by %u)\n",
           task_id, target->privileges, approver_id);
    return 0;
}

static int drop_privilege(uint32_t task_id, uint32_t priv_to_drop)
{
    k_mutex_lock(&registry_mutex, K_FOREVER);

    task_identity_t *task = find_task(task_id);
    if (!task) {
        k_mutex_unlock(&registry_mutex);
        return -ENOENT;
    }

    task->privileges &= ~priv_to_drop;
    /* Never drop below base privileges */
    task->privileges |= task->base_privileges;

    k_mutex_unlock(&registry_mutex);

    printk("[PRIV] Task %u privileges dropped to 0x%02x\n",
           task_id, task->privileges);
    return 0;
}

/* ---- Flash Operations ---- */

static int flash_write(uint32_t task_id, uint32_t address,
                       const uint8_t *data, uint32_t len)
{
    if (!check_privilege(task_id, PRIV_FLASH | PRIV_WRITE)) {
        audit_log_entry(task_id, OP_FLASH_WRITE, OP_STATUS_DENIED,
                       "Flash write denied: insufficient privileges");
        return -EACCES;
    }

    if (address + len > FLASH_SIM_SIZE) {
        audit_log_entry(task_id, OP_FLASH_WRITE, OP_STATUS_ERROR,
                       "Flash write error: out of bounds");
        return -EINVAL;
    }

    k_mutex_lock(&flash_mutex, K_FOREVER);
    memcpy(&flash_memory[address], data, len);
    k_mutex_unlock(&flash_mutex);

    char desc[64];
    snprintk(desc, sizeof(desc), "Flash write %u bytes at 0x%04x", len, address);
    audit_log_entry(task_id, OP_FLASH_WRITE, OP_STATUS_COMPLETED, desc);

    printk("[FLASH] Task %u wrote %u bytes at address 0x%04x\n",
           task_id, len, address);
    return 0;
}

static int flash_read(uint32_t task_id, uint32_t address,
                      uint8_t *data, uint32_t len)
{
    if (!check_privilege(task_id, PRIV_READ)) {
        audit_log_entry(task_id, OP_FLASH_READ, OP_STATUS_DENIED,
                       "Flash read denied: insufficient privileges");
        return -EACCES;
    }

    if (address + len > FLASH_SIM_SIZE) {
        return -EINVAL;
    }

    k_mutex_lock(&flash_mutex, K_FOREVER);
    memcpy(data, &flash_memory[address], len);
    k_mutex_unlock(&flash_mutex);

    char desc[64];
    snprintk(desc, sizeof(desc), "Flash read %u bytes at 0x%04x", len, address);
    audit_log_entry(task_id, OP_FLASH_READ, OP_STATUS_COMPLETED, desc);

    return 0;
}

/* ---- Config Operations ---- */

static int config_set(uint32_t task_id, const char *key, const char *value)
{
    if (!check_privilege(task_id, PRIV_CONFIG | PRIV_WRITE)) {
        audit_log_entry(task_id, OP_CONFIG_SET, OP_STATUS_DENIED,
                       "Config set denied: insufficient privileges");
        return -EACCES;
    }

    k_mutex_lock(&config_mutex, K_FOREVER);

    /* Search for existing key */
    int free_slot = -1;
    for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
        if (system_config[i].in_use &&
            strncmp(system_config[i].key, key, MAX_KEY_LEN) == 0) {
            /* Check write privilege for existing entry */
            if (!check_privilege(task_id, system_config[i].write_priv)) {
                k_mutex_unlock(&config_mutex);
                audit_log_entry(task_id, OP_CONFIG_SET, OP_STATUS_DENIED,
                               "Config set denied: entry write protection");
                return -EACCES;
            }
            strncpy(system_config[i].value, value, MAX_VALUE_LEN - 1);
            system_config[i].value[MAX_VALUE_LEN - 1] = '\0';
            k_mutex_unlock(&config_mutex);

            char desc[64];
            snprintk(desc, sizeof(desc), "Config updated: %s=%s", key, value);
            audit_log_entry(task_id, OP_CONFIG_SET, OP_STATUS_COMPLETED, desc);

            printk("[CONFIG] Task %u set %s=%s\n", task_id, key, value);
            return 0;
        }
        if (!system_config[i].in_use && free_slot == -1) {
            free_slot = i;
        }
    }

    if (free_slot == -1) {
        k_mutex_unlock(&config_mutex);
        return -ENOMEM;
    }

    /* Create new entry */
    config_entry_t *entry = &system_config[free_slot];
    entry->in_use = true;
    entry->owner_id = task_id;
    entry->read_priv = PRIV_READ;
    entry->write_priv = PRIV_CONFIG | PRIV_WRITE;
    strncpy(entry->key, key, MAX_KEY_LEN - 1);
    entry->key[MAX_KEY_LEN - 1] = '\0';
    strncpy(entry->value, value, MAX_VALUE_LEN - 1);
    entry->value[MAX_VALUE_LEN - 1] = '\0';

    k_mutex_unlock(&config_mutex);

    char desc[64];
    snprintk(desc, sizeof(desc), "Config created: %s=%s", key, value);
    audit_log_entry(task_id, OP_CONFIG_SET, OP_STATUS_COMPLETED, desc);

    printk("[CONFIG] Task %u created %s=%s\n", task_id, key, value);
    return 0;
}

static int config_get(uint32_t task_id, const char *key, char *value,
                      uint32_t value_size)
{
    if (!check_privilege(task_id, PRIV_READ)) {
        audit_log_entry(task_id, OP_CONFIG_GET, OP_STATUS_DENIED,
                       "Config get denied: insufficient privileges");
        return -EACCES;
    }

    k_mutex_lock(&config_mutex, K_FOREVER);

    for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
        if (system_config[i].in_use &&
            strncmp(system_config[i].key, key, MAX_KEY_LEN) == 0) {
            if (!check_privilege(task_id, system_config[i].read_priv)) {
                k_mutex_unlock(&config_mutex);
                return -EACCES;
            }
            strncpy(value, system_config[i].value, value_size - 1);
            value[value_size - 1] = '\0';
            k_mutex_unlock(&config_mutex);

            char desc[64];
            snprintk(desc, sizeof(desc), "Config read: %s", key);
            audit_log_entry(task_id, OP_CONFIG_GET, OP_STATUS_COMPLETED, desc);
            return 0;
        }
    }

    k_mutex_unlock(&config_mutex);
    return -ENOENT;
}

/* ---- Privilege Manager Task ---- */

static void privilege_manager_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    printk("[PRIV_MGR] Privilege manager started\n");

    op_request_t req;

    while (1) {
        /* Wait for a request */
        int ret = k_msgq_get(&request_queue, &req, K_FOREVER);
        if (ret != 0) {
            continue;
        }

        printk("[PRIV_MGR] Processing request %u from task %u, type=%d\n",
               req.request_id, req.requester_id, req.type);

        struct k_msgq *response_q = NULL;
        if (req.requester_id == 1) {
            response_q = &admin_response_queue;
        } else if (req.requester_id == 2) {
            response_q = &user_response_queue;
        }

        switch (req.type) {
        case OP_FLASH_WRITE: {
            ret = flash_write(req.requester_id, req.address,
                            req.data, req.data_len);
            req.status = (ret == 0) ? OP_STATUS_COMPLETED :
                         (ret == -EACCES) ? OP_STATUS_DENIED : OP_STATUS_ERROR;
            break;
        }
        case OP_FLASH_READ: {
            ret = flash_read(req.requester_id, req.address,
                           req.result, req.data_len);
            if (ret == 0) {
                req.result_len = req.data_len;
                req.status = OP_STATUS_COMPLETED;
            } else {
                req.status = (ret == -EACCES) ? OP_STATUS_DENIED : OP_STATUS_ERROR;
            }
            break;
        }
        case OP_CONFIG_SET: {
            ret = config_set(req.requester_id, req.key, req.value);
            req.status = (ret == 0) ? OP_STATUS_COMPLETED :
                         (ret == -EACCES) ? OP_STATUS_DENIED : OP_STATUS_ERROR;
            break;
        }
        case OP_CONFIG_GET: {
            char val[MAX_VALUE_LEN];
            ret = config_get(req.requester_id, req.key, val, sizeof(val));
            if (ret == 0) {
                strncpy((char *)req.result, val, MAX_VALUE_LEN);
                req.result_len = strlen(val) + 1;
                req.status = OP_STATUS_COMPLETED;
            } else {
                req.status = (ret == -EACCES) ? OP_STATUS_DENIED :
                             (ret == -ENOENT) ? OP_STATUS_ERROR : OP_STATUS_ERROR;
            }
            break;
        }
        case OP_ELEVATE_PRIVILEGE: {
            /* Only admin (task_id=1) can approve elevation requests.
             * The requester is asking for elevation, so we check if admin
             * approves it. In this simulation, admin auto-approves for
             * demonstration. In production, this would involve IPC. */
            uint32_t requested_priv = req.required_privilege;

            /* Admin task (id=1) is the approver */
            ret = elevate_privilege(req.requester_id, requested_priv, 1);
            req.status = (ret == 0) ? OP_STATUS_COMPLETED : OP_STATUS_DENIED;

            if (ret == 0) {
                audit_log_entry(req.requester_id, OP_ELEVATE_PRIVILEGE,
                              OP_STATUS_COMPLETED, "Privilege elevated");
            } else {
                audit_log_entry(req.requester_id, OP_ELEVATE_PRIVILEGE,
                              OP_STATUS_DENIED, "Privilege elevation denied");
            }
            break;
        }
        case OP_DROP_PRIVILEGE: {
            ret = drop_privilege(req.requester_id, req.required_privilege);
            req.status = (ret == 0) ? OP_STATUS_COMPLETED : OP_STATUS_ERROR;
            audit_log_entry(req.requester_id, OP_DROP_PRIVILEGE,
                          req.status, "Privilege dropped");
            break;
        }
        default:
            req.status = OP_STATUS_ERROR;
            break;
        }

        if (response_q) {
            k_msgq_put(response_q, &req, K_FOREVER);
        }
    }
}

/* ---- Helper to submit a request ---- */

static int submit_request(uint32_t requester_id, op_request_t *req)
{
    req->requester_id = requester_id;
    req->request_id = next_request_id++;
    req->status = OP_STATUS_PENDING;

    int ret = k_msgq_put(&request_queue, req, K_MSEC(1000));
    if (ret != 0) {
        printk("[REQ] Failed to submit request %u\n", req->request_id);
        return ret;
    }

    k_sem_give(&priv_manager_sem);
    return 0;
}

static int wait_response(uint32_t task_id, op_request_t *resp)
{
    struct k_msgq *q = (task_id == 1) ? &admin_response_queue : &user_response_queue;
    return k_msgq_get(q, resp, K_MSEC(5000));
}

/* ---- Admin Task ---- */

static void admin_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    const uint32_t task_id = 1;

    printk("\n[ADMIN] Admin task started (id=%u)\n", task_id);
    register_task(task_id, "admin", PRIV_ADMIN);

    k_sleep(K_MSEC(500));

    /* Admin: Write to flash directly through privilege system */
    printk("\n[ADMIN] === Writing boot config to flash ===\n");
    {
        op_request_t req = {0};
        req.type = OP_FLASH_WRITE;
        req.address = 0x00;
        const char *boot_data = "BOOT_V2.1";
        memcpy(req.data, boot_data, strlen(boot_data));
        req.data_len = strlen(boot_data);

        submit_request(task_id, &req);

        op_request_t resp;
        if (wait_response(task_id, &resp) == 0) {
            printk("[ADMIN] Flash write result: %s\n",
                   resp.status == OP_STATUS_COMPLETED ? "SUCCESS" : "FAILED");
        }
    }

    k_sleep(K_MSEC(200));

    /* Admin: Set system config values */
    printk("\n[ADMIN] === Setting system configuration ===\n");
    {
        op_request_t req = {0};
        req.type = OP_CONFIG_SET;
        strncpy(req.key, "sys.hostname", MAX_KEY_LEN);
        strncpy(req.value, "embedded-node-01", MAX_VALUE_LEN);

        submit_request(task_id, &req);

        op_request_t resp;
        if (wait_response(task_id, &resp) == 0) {
            printk("[ADMIN] Config set result: %s\n",
                   resp.status == OP_STATUS_COMPLETED ? "SUCCESS" : "FAILED");
        }
    }

    k_sleep(K_MSEC(200));

    /* Set another config */
    {
        op_request_t req = {0};
        req.type = OP_CONFIG_SET;
        strncpy(req.key, "sys.log_level", MAX_KEY_LEN);
        strncpy(req.value, "DEBUG", MAX_VALUE_LEN);

        submit_request(task_id, &req);

        op_request_t resp;
        if (wait_response(task_id, &resp) == 0) {
            printk("[ADMIN] Config set log_level result: %s\n",
                   resp.status == OP_STATUS_COMPLETED ? "SUCCESS" : "FAILED");
        }
    }

    k_sleep(K_MSEC(200));

    /* Set network config */
    {
        op_request_t req = {0};
        req.type = OP_CONFIG_SET;
        strncpy(req.key, "net.ip_addr", MAX_KEY_LEN);
        strncpy(req.value, "192.168.1.100", MAX_VALUE_LEN);

        submit_request(task_id, &req);

        op_request_t resp;
        if (wait_response(task_id, &resp) == 0) {
            printk("[ADMIN] Config set ip_addr result: %s\n",
                   resp.status == OP_STATUS_COMPLETED ? "SUCCESS" : "FAILED");
        }
    }

    k_sleep(K_MSEC(200));

    /* Admin: Write firmware version to flash */
    printk("\n[ADMIN] === Writing firmware info to flash ===\n");
    {
        op_request_t req = {0};
        req.type = OP_FLASH_WRITE;
        req.address = 0x40;
        const char *fw_info = "FW:3.2.1-stable";
        memcpy(req.data, fw_info, strlen(fw_info));
        req.data_len = strlen(fw_info);

        submit_request(task_id, &req);

        op_request_t resp;
        if (wait_response(task_id, &resp) == 0) {
            printk("[ADMIN] FW info flash write result: %s\n",
                   resp.status == OP_STATUS_COMPLETED ? "SUCCESS" : "FAILED");
        }
    }

    /* Admin: Verify flash read */
    k_sleep(K_MSEC(200));
    printk("\n[ADMIN] === Verifying flash contents ===\n");
    {
        op_request_t req = {0};
        req.type = OP_FLASH_READ;
        req.address = 0x00;
        req.data_len = 16;

        submit_request(task_id, &req);

        op_request_t resp;
        if (wait_response(task_id, &resp) == 0) {
            if (resp.status == OP_STATUS_COMPLETED) {
                printk("[ADMIN] Flash read at 0x00: '%.*s'\n",
                       resp.result_len, resp.result);
            }
        }
    }

    /* Admin continues monitoring */
    while (1) {
        k_sleep(K_MSEC(5000));
        printk("[ADMIN] Heartbeat - system operational\n");
    }
}

/* ---- User Task ---- */

static void user_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    const uint32_t task_id = 2;

    printk("\n[USER] User task started (id=%u)\n", task_id);
    register_task(task_id, "user", PRIV_USER);

    k_sleep(K_MSEC(1500));

    /* User: Try to read config (should work - has READ privilege) */
    printk("\n[USER] === Reading system config (should succeed) ===\n");
    {
        op_request_t req = {0};
        req.type = OP_CONFIG_GET;
        strncpy(req.key, "sys.hostname", MAX_KEY_LEN);

        submit_request(task_id, &req);

        op_request_t resp;
        if (wait_response(task_id, &resp) == 0) {
            if (resp.status == OP_STATUS_COMPLETED) {
                printk("[USER] Config sys.hostname = '%s'\n", (char *)resp.result);
            } else {
                printk("[USER] Config read result: %s\n",
                       resp.status == OP_STATUS_DENIED ? "DENIED" : "ERROR");
            }
        }
    }

    k_sleep(K_MSEC(500));

    /* User: Try to write flash (should fail - no FLASH/WRITE privilege) */
    printk("\n[USER] === Attempting flash write (should be denied) ===\n");
    {
        op_request_t req = {0};
        req.type = OP_FLASH_WRITE;
        req.address = 0x80;
        const char *user_data = "USER_DATA";
        memcpy(req.data, user_data, strlen(user_data));
        req.data_len = strlen(user_data);

        submit_request(task_id, &req);

        op_request_t resp;
        if (wait_response(task_id, &resp) == 0) {
            printk("[USER] Flash write result: %s\n",
                   resp.status == OP_STATUS_COMPLETED ? "SUCCESS" :
                   resp.status == OP_STATUS_DENIED ? "DENIED (expected)" : "ERROR");
        }
    }

    k_sleep(K_MSEC(500));

    /* User: Try to modify config (should fail - no CONFIG/WRITE privilege) */
    printk("\n[USER] === Attempting config set (should be denied) ===\n");
    {
        op_request_t req = {0};
        req.type = OP_CONFIG_SET;
        strncpy(req.key, "sys.hostname", MAX_KEY_LEN);
        strncpy(req.value, "hacked-hostname", MAX_VALUE_LEN);

        submit_request(task_id, &req);

        op_request_t resp;
        if (wait_response(task_id, &resp) == 0) {
            printk("[USER] Config set result: %s\n",
                   resp.status == OP_STATUS_COMPLETED ? "SUCCESS" :
                   resp.status == OP_STATUS_DENIED ? "DENIED (expected)" : "ERROR");
        }
    }

    k_sleep(K_MSEC(500));

    /* User: Request privilege elevation for flash write */
    printk("\n[USER] === Requesting privilege elevation for flash access ===\n");
    {
        op_request_t req = {0};
        req.type = OP_ELEVATE_PRIVILEGE;
        req.required_privilege = PRIV_FLASH | PRIV_WRITE;

        submit_request(task_id, &req);

        op_request_t resp;
        if (wait_response(task_id, &resp) == 0) {
            printk("[USER] Elevation result: %s\n",
                   resp.status == OP_STATUS_COMPLETED ? "APPROVED" : "DENIED");
        }
    }

    k_sleep(K_MSEC(500));

    /* User: Now try flash write again (should succeed with elevated privileges) */
    printk("\n[USER] === Retrying flash write with elevated privileges ===\n");
    {
        op_request_t req = {0};
        req.type = OP_FLASH_WRITE;
        req.address = 0x80;
        const char *user_data = "USER_DATA_OK";
        memcpy(req.data, user_data, strlen(user_data));
        req.data_len = strlen(user_data);

        submit_request(task_id, &req);

        op_request_t resp;
        if (wait_response(task_id, &resp) == 0) {
            printk("[USER] Flash write (elevated) result: %s\n",
                   resp.status == OP_STATUS_COMPLETED ? "SUCCESS" : "FAILED");
        }
    }

    k_sleep(K_MSEC(500));

    /* User: Read the data back to verify */
    printk("\n[USER] === Verifying flash read ===\n");
    {
        op_request_t req = {0};
        req.type = OP_FLASH_READ;
        req.address = 0x80;
        req.data_len = 12;

        submit_request(task_id, &req);

        op_request_t resp;
        if (wait_response(task_id, &resp) == 0) {
            if (resp.status == OP_STATUS_COMPLETED) {
                printk("[USER] Flash read at 0x80: '%.*s'\n",
                       resp.result_len, resp.result);
            }
        }
    }

    k_sleep(K_MSEC(500));

    /* User: Drop elevated privileges (principle of least privilege) */
    printk("\n[USER] === Dropping elevated privileges ===\n");
    {
        op_request_t req = {0};
        req.type = OP_DROP_PRIVILEGE;
        req.required_privilege = PRIV_FLASH | PRIV_WRITE;

        submit_request(task_id, &req);

        op_request_t resp;
        if (wait_response(task_id, &resp) == 0) {
            printk("[USER] Drop privilege result: %s\n",
                   resp.status == OP_STATUS_COMPLETED ? "SUCCESS" : "FAILED");
        }
    }

    k_sleep(K_MSEC(500));

    /* User: Verify that flash write is denied again after dropping */
    printk("\n[USER] === Verifying flash write denied after privilege drop ===\n");
    {
        op_request_t req = {0};
        req.type = OP_FLASH_WRITE;
        req.address = 0x90;
        const char *test = "SHOULD_FAIL";
        memcpy(req.data, test, strlen(test));
        req.data_len = strlen(test);

        submit_request(task_id, &req);

        op_request_t resp;
        if (wait_response(task_id, &resp) == 0) {
            printk("[USER] Flash write after drop result: %s\n",
                   resp.status == OP_STATUS_DENIED ? "DENIED (expected)" :
                   resp.status == OP_STATUS_COMPLETED ? "SUCCESS (unexpected!)" : "ERROR");
        }
    }

    k_sleep(K_MSEC(500));

    /* User: Request config write elevation and modify config */
    printk("\n[USER] === Requesting config write elevation ===\n");
    {
        op_request_t req = {0};
        req.type = OP_ELEVATE_PRIVILEGE;
        req.required_privilege = PRIV_CONFIG | PRIV_WRITE;

        submit_request(task_id, &req);

        op_request_t resp;
        if (wait_response(task_id, &resp) == 0) {
            printk("[USER] Config elevation result: %s\n",
                   resp.status == OP_STATUS_COMPLETED ? "APPROVED" : "DENIED");
        }
    }

    k_sleep(K_MSEC(300));

    /* User: Now set config with elevated privileges */
    printk("\n[USER] === Setting config with elevated privileges ===\n");
    {
        op_request_t req = {0};
        req.type = OP_CONFIG_SET;
        strncpy(req.key, "user.preference", MAX_KEY_LEN);
        strncpy(req.value, "dark_mode=on", MAX_VALUE_LEN);

        submit_request(task_id, &req);

        op_request_t resp;
        if (wait_response(task_id, &resp) == 0) {
            printk("[USER] Config set with elevation result: %s\n",
                   resp.status == OP_STATUS_COMPLETED ? "SUCCESS" : "FAILED");
        }
    }

    k_sleep(K_MSEC(300));

    /* User: Drop all elevated privileges */
    printk("\n[USER] === Dropping all elevated privileges ===\n");
    {
        op_request_t req = {0};
        req.type = OP_DROP_PRIVILEGE;
        req.required_privilege = PRIV_CONFIG | PRIV_WRITE | PRIV_FLASH;

        submit_request(task_id, &req);

        op_request_t resp;
        if (wait_response(task_id, &resp) == 0) {
            printk("[USER] Final drop privilege result: %s\n",
                   resp.status == OP_STATUS_COMPLETED ? "SUCCESS" : "FAILED");
        }
    }

    /* Print current privilege state */
    k_mutex_lock(&registry_mutex, K_FOREVER);
    task_identity_t *user = find_task(task_id);
    if (user) {
        printk("\n[USER] Final privileges: 0x%02x (base: 0x%02x)\n",
               user->privileges, user->base_privileges);
    }
    k_mutex_unlock(&registry_mutex);

    printk("\n[USER] === User task demonstration complete ===\n");

    while (1) {
        k_sleep(K_MSEC(5000));
        printk("[USER] Heartbeat - idle\n");
    }
}

/* ---- Initialization ---- */

static void init_subsystems(void)
{
    k_mutex_init(&flash_mutex);
    k_mutex_init(&config_mutex);
    k_mutex_init(&registry_mutex);
    k_mutex_init(&audit_mutex);

    memset(flash_memory, 0xFF, sizeof(flash_memory));
    memset(system_config, 0, sizeof(system_config));
    memset(task_registry, 0, sizeof(task_registry));
    memset(audit_log, 0, sizeof(audit_log));
}

int main(void)
{
    printk("==============================================\n");
    printk("  Embedded Permission System - Zephyr RTOS\n");
    printk("==============================================\n");
    printk("Privilege levels:\n");
    printk("  PRIV_READ   = 0x%02x\n", PRIV_READ);
    printk("  PRIV_WRITE  = 0x%02x\n", PRIV_WRITE);
    printk("  PRIV_FLASH  = 0x%02x\n", PRIV_FLASH);
    printk("  PRIV_CONFIG = 0x%02x\n", PRIV_CONFIG);
    printk("  PRIV_ADMIN  = 0x%02x\n", PRIV_ADMIN);
    printk("  PRIV_USER   = 0x%02x\n", PRIV_USER);
    printk("==============================================\n\n");

    init_subsystems();

    /* Start privilege manager first (highest priority) */
    k_thread_create(&priv_manager_thread_data, priv_manager_stack,
                    K_THREAD_STACK_SIZEOF(priv_manager_stack),
                    privilege_manager_task, NULL, NULL, NULL,
                    3, 0, K_NO_WAIT);
    k_thread_name_set(&priv_manager_thread_data, "priv_mgr");

    /* Start admin task */
    k_thread_create(&admin_thread_data, admin_stack,
                    K_THREAD_STACK_SIZEOF(admin_stack),
                    admin_task, NULL, NULL, NULL,
                    ADMIN_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(&admin_thread_data, "admin");

    /* Start user task */
    k_thread_create(&user_thread_data, user_stack,
                    K_THREAD_STACK_SIZEOF(user_stack),
                    user_task, NULL, NULL, NULL,
                    USER_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(&user_thread_data, "user");

    return 0;
}