# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

typedef struct {
    char *input_file;
    char *output_file;
    int verbose;
    int max_threads;
    bool dry_run;
    char *log_level;
} Config;

void config_free(Config *config) {
    if (config) {
        free(config->input_file);
        free(config->output_file);
        free(config->log_level);
        free(config);
    }
}

void config_print(const Config *config) {
    if (!config) {
        printf("Config is NULL\n");
        return;
    }
    printf("=== Application Configuration ===\n");
    printf("  Input file:   %s\n", config->input_file ? config->input_file : "(none)");
    printf("  Output file:  %s\n", config->output_file ? config->output_file : "(none)");
    printf("  Verbose:      %d\n", config->verbose);
    printf("  Max threads:  %d\n", config->max_threads);
    printf("  Dry run:      %s\n", config->dry_run ? "yes" : "no");
    printf("  Log level:    %s\n", config->log_level ? config->log_level : "info");
    printf("=================================\n");
}

static char *safe_strdup(const char *s) {
    if (!s) return NULL;
    char *dup = (char *)malloc(strlen(s) + 1);
    if (dup) {
        strcpy(dup, s);
    }
    return dup;
}

Config *parse_arguments(int argc, char *argv[]) {
    if (argc < 1 || !argv) {
        fprintf(stderr, "Error: Invalid arguments\n");
        return NULL;
    }

    Config *config = (Config *)calloc(1, sizeof(Config));
    if (!config) {
        fprintf(stderr, "Error: Failed to allocate memory for config\n");
        return NULL;
    }

    /* Set defaults */
    config->input_file = NULL;
    config->output_file = NULL;
    config->verbose = 0;
    config->max_threads = 1;
    config->dry_run = false;
    config->log_level = safe_strdup("info");

    int i = 1;
    while (i < argc) {
        if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: --input requires a value\n");
                config_free(config);
                return NULL;
            }
            free(config->input_file);
            config->input_file = safe_strdup(argv[++i]);
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: --output requires a value\n");
                config_free(config);
                return NULL;
            }
            free(config->output_file);
            config->output_file = safe_strdup(argv[++i]);
        } else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbose = 1;
        } else if (strcmp(argv[i], "-t") == 0 || strcmp(argv[i], "--threads") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: --threads requires a value\n");
                config_free(config);
                return NULL;
            }
            config->max_threads = atoi(argv[++i]);
            if (config->max_threads <= 0) {
                fprintf(stderr, "Error: --threads must be a positive integer\n");
                config_free(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-n") == 0 || strcmp(argv[i], "--dry-run") == 0) {
            config->dry_run = true;
        } else if (strcmp(argv[i], "-l") == 0 || strcmp(argv[i], "--log-level") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: --log-level requires a value\n");
                config_free(config);
                return NULL;
            }
            free(config->log_level);
            config->log_level = safe_strdup(argv[++i]);
        } else if (strcmp(argv[i], "-h") == 0 || strcmp(argv[i], "--help") == 0) {
            printf("Usage: %s [OPTIONS]\n", argv[0]);
            printf("Options:\n");
            printf("  -i, --input FILE       Input file path\n");
            printf("  -o, --output FILE      Output file path\n");
            printf("  -v, --verbose          Enable verbose output\n");
            printf("  -t, --threads N        Max number of threads (default: 1)\n");
            printf("  -n, --dry-run          Perform a dry run\n");
            printf("  -l, --log-level LEVEL  Log level (debug|info|warn|error)\n");
            printf("  -h, --help             Show this help message\n");
            config_free(config);
            return NULL;
        } else {
            fprintf(stderr, "Error: Unknown option '%s'\n", argv[i]);
            fprintf(stderr, "Use --help for usage information\n");
            config_free(config);
            return NULL;
        }
        i++;
    }

    /* Validate required fields */
    if (!config->input_file) {
        fprintf(stderr, "Error: --input is required\n");
        config_free(config);
        return NULL;
    }

    return config;
}

typedef struct {
    const Config *config;
    bool initialized;
    char status_message[256];
} Application;

bool application_init(Application *app, const Config *config) {
    if (!app || !config) {
        return false;
    }

    app->config = config;
    app->initialized = true;

    snprintf(app->status_message, sizeof(app->status_message),
             "App initialized: processing '%s' with %d thread(s)",
             config->input_file, config->max_threads);

    if (config->verbose) {
        printf("[VERBOSE] %s\n", app->status_message);
    }

    return true;
}

bool application_run(Application *app) {
    if (!app || !app->initialized) {
        fprintf(stderr, "Error: Application not initialized\n");
        return false;
    }

    const Config *cfg = app->config;

    printf("Running application...\n");
    printf("  Reading from: %s\n", cfg->input_file);

    if (cfg->output_file) {
        printf("  Writing to:   %s\n", cfg->output_file);
    } else {
        printf("  Writing to:   stdout\n");
    }

    if (cfg->dry_run) {
        printf("  [DRY RUN] No actual processing performed.\n");
        return true;
    }

    /* Simulate actual work */
    printf("  Processing with %d thread(s)...\n", cfg->max_threads);
    printf("  Done.\n");

    return true;
}

int main(int argc, char *argv[]) {
    /* Parse arguments and immediately use the returned pointer */
    Config *config = parse_arguments(argc, argv);
    if (!config) {
        return EXIT_FAILURE;
    }

    config_print(config);

    /* Initialize the application immediately using the config pointer */
    Application app = {0};
    if (!application_init(&app, config)) {
        fprintf(stderr, "Error: Failed to initialize application\n");
        config_free(config);
        return EXIT_FAILURE;
    }

    /* Run the application */
    bool success = application_run(&app);

    /* Cleanup */
    config_free(config);

    return success ? EXIT_SUCCESS : EXIT_FAILURE;
}