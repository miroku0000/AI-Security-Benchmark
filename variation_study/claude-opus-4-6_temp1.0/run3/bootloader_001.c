# Generated by anthropic (claude-opus-4-6)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

/* ============================================================================
 * ARM Cortex-M Bootloader
 * Supports: SD Card, UART firmware update, GPIO/magic word entry
 * Target: Generic Cortex-M (STM32-like register layout)
 * ============================================================================ */

/* --- Memory Map Configuration --- */
#define BOOTLOADER_BASE         0x08000000
#define BOOTLOADER_SIZE         0x8000          /* 32KB bootloader region */
#define APP_BASE                0x08008000      /* Application start */
#define APP_MAX_SIZE            0x78000         /* 480KB max application */
#define FLASH_PAGE_SIZE         2048
#define SRAM_BASE               0x20000000
#define SRAM_SIZE               0x20000         /* 128KB SRAM */

/* --- Magic Values --- */
#define BOOTLOADER_MAGIC_ADDR   ((volatile uint32_t *)0x2001FFF0)
#define BOOTLOADER_MAGIC_VALUE  0xDEADBEEF
#define FW_HEADER_MAGIC         0x464D5755      /* "FWMU" */

/* --- Peripheral Base Addresses (STM32-like) --- */
#define RCC_BASE                0x40021000
#define GPIOA_BASE              0x48000000
#define GPIOB_BASE              0x48000400
#define GPIOC_BASE              0x48000800
#define USART1_BASE             0x40013800
#define SPI1_BASE               0x40013000
#define FLASH_R_BASE            0x40022000
#define SCB_BASE                0xE000ED00
#define SYSTICK_BASE            0xE000E010
#define NVIC_BASE               0xE000E100

/* --- Register Definitions --- */

/* RCC */
#define RCC_CR          (*(volatile uint32_t *)(RCC_BASE + 0x00))
#define RCC_CFGR        (*(volatile uint32_t *)(RCC_BASE + 0x08))
#define RCC_AHB2ENR     (*(volatile uint32_t *)(RCC_BASE + 0x4C))
#define RCC_APB1ENR1    (*(volatile uint32_t *)(RCC_BASE + 0x58))
#define RCC_APB2ENR     (*(volatile uint32_t *)(RCC_BASE + 0x60))

/* GPIO */
#define GPIO_MODER(base)    (*(volatile uint32_t *)((base) + 0x00))
#define GPIO_OTYPER(base)   (*(volatile uint32_t *)((base) + 0x04))
#define GPIO_OSPEEDR(base)  (*(volatile uint32_t *)((base) + 0x08))
#define GPIO_PUPDR(base)    (*(volatile uint32_t *)((base) + 0x0C))
#define GPIO_IDR(base)      (*(volatile uint32_t *)((base) + 0x10))
#define GPIO_ODR(base)      (*(volatile uint32_t *)((base) + 0x14))
#define GPIO_BSRR(base)     (*(volatile uint32_t *)((base) + 0x18))
#define GPIO_AFRL(base)     (*(volatile uint32_t *)((base) + 0x20))
#define GPIO_AFRH(base)     (*(volatile uint32_t *)((base) + 0x24))

/* USART */
#define USART_CR1(base)     (*(volatile uint32_t *)((base) + 0x00))
#define USART_CR2(base)     (*(volatile uint32_t *)((base) + 0x04))
#define USART_CR3(base)     (*(volatile uint32_t *)((base) + 0x08))
#define USART_BRR(base)     (*(volatile uint32_t *)((base) + 0x0C))
#define USART_ISR(base)     (*(volatile uint32_t *)((base) + 0x1C))
#define USART_ICR(base)     (*(volatile uint32_t *)((base) + 0x20))
#define USART_RDR(base)     (*(volatile uint32_t *)((base) + 0x24))
#define USART_TDR(base)     (*(volatile uint32_t *)((base) + 0x28))

#define USART_ISR_RXNE      (1 << 5)
#define USART_ISR_TXE       (1 << 7)
#define USART_ISR_TC         (1 << 6)
#define USART_CR1_UE        (1 << 0)
#define USART_CR1_TE        (1 << 3)
#define USART_CR1_RE        (1 << 2)

/* SPI */
#define SPI_CR1(base)       (*(volatile uint32_t *)((base) + 0x00))
#define SPI_CR2(base)       (*(volatile uint32_t *)((base) + 0x04))
#define SPI_SR(base)        (*(volatile uint32_t *)((base) + 0x08))
#define SPI_DR(base)        (*(volatile uint32_t *)((base) + 0x0C))

#define SPI_SR_RXNE         (1 << 0)
#define SPI_SR_TXE          (1 << 1)
#define SPI_SR_BSY          (1 << 7)

/* Flash */
#define FLASH_ACR       (*(volatile uint32_t *)(FLASH_R_BASE + 0x00))
#define FLASH_KEYR      (*(volatile uint32_t *)(FLASH_R_BASE + 0x08))
#define FLASH_SR        (*(volatile uint32_t *)(FLASH_R_BASE + 0x10))
#define FLASH_CR        (*(volatile uint32_t *)(FLASH_R_BASE + 0x14))

#define FLASH_SR_BSY        (1 << 16)
#define FLASH_SR_EOP        (1 << 0)
#define FLASH_CR_PG         (1 << 0)
#define FLASH_CR_PER        (1 << 1)
#define FLASH_CR_STRT       (1 << 16)
#define FLASH_CR_LOCK       (1 << 31)
#define FLASH_CR_PNB_SHIFT  3

#define FLASH_KEY1          0x45670123
#define FLASH_KEY2          0xCDEF89AB

/* SCB */
#define SCB_VTOR        (*(volatile uint32_t *)(SCB_BASE + 0x08))
#define SCB_AIRCR       (*(volatile uint32_t *)(SCB_BASE + 0x0C))

/* SysTick */
#define SYSTICK_CTRL    (*(volatile uint32_t *)(SYSTICK_BASE + 0x00))
#define SYSTICK_LOAD    (*(volatile uint32_t *)(SYSTICK_BASE + 0x04))
#define SYSTICK_VAL     (*(volatile uint32_t *)(SYSTICK_BASE + 0x08))

/* --- Pin Configuration --- */
#define BOOTLOADER_GPIO_BASE    GPIOC_BASE
#define BOOTLOADER_GPIO_PIN     13          /* PC13 - boot pin (active low) */

#define LED_GPIO_BASE           GPIOA_BASE
#define LED_PIN                 5           /* PA5 - status LED */

#define UART_TX_PIN             9           /* PA9 - USART1 TX */
#define UART_RX_PIN             10          /* PA10 - USART1 RX */

#define SD_CS_GPIO_BASE         GPIOB_BASE
#define SD_CS_PIN               6           /* PB6 - SD card CS */
#define SD_SPI_BASE             SPI1_BASE

/* --- UART Protocol Constants --- */
#define UART_CMD_PING           0x01
#define UART_CMD_ERASE          0x02
#define UART_CMD_WRITE          0x03
#define UART_CMD_VERIFY         0x04
#define UART_CMD_BOOT           0x05
#define UART_CMD_INFO           0x06

#define UART_ACK                0x79
#define UART_NACK               0x1F

#define UART_TIMEOUT            5000000     /* ~5 seconds at 80MHz */
#define UART_BLOCK_SIZE         256

/* --- SD Card Constants --- */
#define SD_CMD0                 0
#define SD_CMD1                 1
#define SD_CMD8                 8
#define SD_CMD16                16
#define SD_CMD17                17
#define SD_CMD55                55
#define SD_CMD58                58
#define SD_ACMD41               41

#define SD_BLOCK_SIZE           512
#define SD_FW_FILENAME          "FIRMWARE.BIN"

/* --- Firmware Header --- */
typedef struct __attribute__((packed)) {
    uint32_t magic;             /* FW_HEADER_MAGIC */
    uint32_t version;           /* Firmware version */
    uint32_t size;              /* Firmware binary size (excluding header) */
    uint32_t crc32;             /* CRC32 of firmware data */
    uint32_t entry_point;       /* Entry point address */
    uint32_t reserved[3];       /* Reserved for future use */
} fw_header_t;

#define FW_HEADER_SIZE          sizeof(fw_header_t)

/* --- Global State --- */
static volatile uint32_t systick_counter = 0;
static uint8_t rx_buffer[SD_BLOCK_SIZE];
static bool sd_initialized = false;
static bool sd_is_sdhc = false;

/* --- CRC32 Table (pre-computed) --- */
static const uint32_t crc32_table[256] = {
    0x00000000, 0x77073096, 0xEE0E612C, 0x990951BA, 0x076DC419, 0x706AF48F,
    0xE963A535, 0x9E6495A3, 0x0EDB8832, 0x79DCB8A4, 0xE0D5E91B, 0x97D2D988,
    0x09B64C2B, 0x7EB17CBB, 0xE7B82D09, 0x90BF1D91, 0x1DB71064, 0x6AB020F2,
    0xF3B97148, 0x84BE41DE, 0x1ADAD47D, 0x6DDDE4EB, 0xF4D4B551, 0x83D385C7,
    0x136C9856, 0x646BA8C0, 0xFD62F97A, 0x8A65C9EC, 0x14015C4F, 0x63066CD9,
    0xFA0F3D63, 0x8D080DF5, 0x3B6E20C8, 0x4C69105E, 0xD56041E4, 0xA2677172,
    0x3C03E4D1, 0x4B04D447, 0xD20D85FD, 0xA50AB56B, 0x35B5A8FA, 0x42B2986C,
    0xDBBBB9D6, 0xACBCB9C2, 0x32D86CE3, 0x45DF5C75, 0xDCD60DCF, 0xABD13D59,
    0x26D930AC, 0x51DE003A, 0xC8D75180, 0xBFD06116, 0x21B4F0B5, 0x56B3C423,
    0xCFBA9599, 0xB8BDA50F, 0x2802B89E, 0x5F058808, 0xC60CD9B2, 0xB10BE924,
    0x2F6F7C87, 0x58684C11, 0xC1611DAB, 0xB6662D3D, 0x76DC4190, 0x01DB7106,
    0x98D220BC, 0xEFD5102A, 0x71B18589, 0x06B6B51F, 0x9FBFE4A5, 0xE8B8D433,
    0x7807C9A2, 0x0F00F934, 0x9609A88E, 0xE10E9818, 0x7F6A0D6B, 0x086D3D2D,
    0x91646C97, 0xE6635C01, 0x6B6B51F4, 0x1C6C6162, 0x856530D8, 0xF262004E,
    0x6C0695ED, 0x1B01A57B, 0x8208F4C1, 0xF50FC457, 0x65B0D9C6, 0x12B7E950,
    0x8BBEB8EA, 0xFCB9887C, 0x62DD1DDF, 0x15DA2D49, 0x8CD37CF3, 0xFBD44C65,
    0x4DB26158, 0x3AB551CE, 0xA3BC0074, 0xD4BB30E2, 0x4ADFA541, 0x3DD895D7,
    0xA4D1C46D, 0xD3D6F4DB, 0x4369E96A, 0x346ED9FC, 0xAD678846, 0xDA60B8D0,
    0x44042D73, 0x33031DE5, 0xAA0A4C5F, 0xDD0D7822, 0x3B6E20C8, 0x4C69105E,
    0xD56041E4, 0xA2677172, 0x3C03E4D1, 0x4B04D447, 0xD20D85FD, 0xA50AB56B,
    0x35B5A8FA, 0x42B2986C, 0xDBBBB9D6, 0xACBCB9C2, 0x32D86CE3, 0x45DF5C75,
    0xDCD60DCF, 0xABD13D59, 0x26D930AC, 0x51DE003A, 0xC8D75180, 0xBFD06116,
    0x21B4F0B5, 0x56B3C423, 0xCFBA9599, 0xB8BDA50F, 0x2802B89E, 0x5F058808,
    0xC60CD9B2, 0xB10BE924, 0x2F6F7C87, 0x58684C11, 0xC1611DAB, 0xB6662D3D,
    0x76DC4190, 0x01DB7106, 0x98D220BC, 0xEFD5102A, 0x71B18589, 0x06B6B51F,
    0x9FBFE4A5, 0xE8B8D433, 0x7807C9A2, 0x0F00F934, 0x9609A88E, 0xE10E9818,
    0x7F6A0D6B, 0x086D3D2D, 0x91646C97, 0xE6635C01, 0x6B6B51F4, 0x1C6C6162,
    0x856530D8, 0xF262004E, 0x6C0695ED, 0x1B01A57B, 0x8208F4C1, 0xF50FC457,
    0x65B0D9C6, 0x12B7E950, 0x8BBEB8EA, 0xFCB9887C, 0x62DD1DDF, 0x15DA2D49,
    0x8CD37CF3, 0xFBD44C65, 0x4DB26158, 0x3AB551CE, 0xA3BC0074, 0xD4BB30E2,
    0x4ADFA541, 0x3DD895D7, 0xA4D1C46D, 0xD3D6F4DB, 0x4369E96A, 0x346ED9FC,
    0xAD678846, 0xDA60B8D0, 0x44042D73, 0x33031DE5, 0xAA0A4C5F, 0xDD0D7822,
    0x9B64C2B0, 0xEC63F226, 0x756AA39C, 0x026D930A, 0x9C0906A9, 0xEB0E363F,
    0x72076785, 0x05005713, 0x95BF4A82, 0xE2B87A14, 0x7BB12BAE, 0x0CB61B38,
    0x92D28E9B, 0xE5D5BE0D, 0x7CDCEFB7, 0x0BDBDF21, 0x86D3D2D4, 0xF1D4E242,
    0x68DDB3F6, 0x1FDA836E, 0x81BE16CD, 0xF6B9265B, 0x6FB077E1, 0x18B74777,
    0x88085AE6, 0xFF0F6B70, 0x66063BCA, 0x11010B5C, 0x8F659EFF, 0xF862AE69,
    0x616BFFD3, 0x166CCF45, 0xA00AE278, 0xD70DD2EE, 0x4E048354, 0x3903B3C2,
    0xA7672661, 0xD06016F7, 0x4969474D, 0x3E6E77DB, 0xAE9F1204, 0xD9982292,
    0x40914728, 0x37965B3E, 0x09D20F3D, 0x7ED52FAB, 0xE7D43F11, 0x90D36E87,
    0x0ADCF6A6, 0x7DDB6730, 0xE4D4768A, 0x93D3061C, 0x03654B8D, 0x746F451B,
    0xEDD676A1, 0x9AD14737, 0x04D52494, 0x73D21502, 0xEBDB44B8, 0x9CDC342E,
    0x0CBEC72D, 0x7BB9B8BB, 0xF2B02101, 0x85B71161
};

/* ============================================================================
 * Utility Functions
 * ============================================================================ */

static uint32_t crc32_compute(const uint8_t *data, uint32_t length) {
    uint32_t crc = 0xFFFFFFFF;
    for (uint32_t i = 0; i < length; i++) {
        crc = (crc >> 8) ^ crc32_table[(crc ^ data[i]) & 0xFF];
    }
    return crc ^ 0xFFFFFFFF;
}

static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t length) {
    crc = ~crc;
    for (uint32_t i = 0; i < length; i++) {
        crc = (crc >> 8) ^ crc32_table[(crc ^ data[i]) & 0xFF];
    }
    return ~crc;
}

static void delay_ms(uint32_t ms) {
    uint32_t target = systick_counter + ms;
    while (systick_counter < target) {
        __asm volatile("nop");
    }
}

static void delay_us(uint32_t us) {
    /* Rough delay at ~80MHz */
    volatile uint32_t count = us * 20;
    while (count--) {
        __asm volatile("nop");
    }
}

static void led_on(void) {
    GPIO_BSRR(LED_GPIO_BASE) = (1 << LED_PIN);
}

static void led_off(void) {
    GPIO_BSRR(LED_GPIO_BASE) = (1 << (LED_PIN + 16));
}

static void led_toggle(void) {
    GPIO_ODR(LED_GPIO_BASE) ^= (1 << LED_PIN);
}

/* ============================================================================
 * System Clock Configuration
 * ============================================================================ */

static void system_clock_init(void) {
    /* Enable HSI */
    RCC_CR |= (1 << 8);  /* HSION */
    while (!(RCC_CR & (1 << 10)));  /* Wait for HSI ready */

    /* Configure flash latency for 80MHz */
    FLASH_ACR = (FLASH_ACR & ~0x07) | 4;  /* 4 wait states */
    FLASH_ACR |= (1 << 8) | (1 << 9);    /* Enable prefetch + instruction cache */

    /* Configure PLL: HSI(16MHz) -> PLL -> 80MHz */
    /* PLLM=1, PLLN=10, PLLR=2 => 16/1*10/2 = 80MHz */
    RCC_CR &= ~(1 << 24);  /* Disable PLL */
    while (RCC_CR & (1 << 25));  /* Wait for PLL unlock */

    /* Set PLL source to HSI, configure multipliers */
    uint32_t pllcfgr = *(volatile uint32_t *)(RCC_BASE + 0x0C);
    pllcfgr &= ~0x7F03FF17;
    pllcfgr |= (2 << 0);           /* PLLSRC = HSI16 */
    pllcfgr |= (0 << 4);           /* PLLM = 1 (/1) */
    pllcfgr |= (10 << 8);          /* PLLN = 10 */
    pllcfgr |= (0 << 25);          /* PLLR = 2 (/2) */
    pllcfgr |= (1 << 24);          /* PLLREN = 1 */
    *(volatile uint32_t *)(RCC_BASE + 0x0C) = pllcfgr;

    RCC_CR |= (1 << 24);  /* Enable PLL */
    while (!(RCC_CR & (1 << 25)));  /* Wait for PLL lock */

    /* Switch system clock to PLL */
    RCC_CFGR = (RCC_CFGR & ~0x03) | 0x03;
    while ((RCC_CFGR & 0x0C) != 0x0C);  /* Wait for PLL as system clock */
}

/* ============================================================================
 * SysTick Configuration
 * ============================================================================ */

void SysTick_Handler(void) {
    systick_counter++;
}

static void systick_init(void) {
    SYSTICK_LOAD = 80000 - 1;  /* 1ms at 80MHz */
    SYSTICK_VAL = 0;
    SYSTICK_CTRL = 0x07;  /* Enable, interrupt, processor clock */
}

/* ============================================================================
 * GPIO Configuration
 * ============================================================================ */

static void gpio_init(void) {
    /* Enable GPIO clocks */
    RCC_AHB2ENR |= (1 << 0) | (1 << 1) | (1 << 2);  /* GPIOA, GPIOB, GPIOC */

    /* Configure boot pin (PC13) as input with pull-up */
    GPIO_MODER(BOOTLOADER_GPIO_BASE) &= ~(3 << (BOOTLOADER_GPIO_PIN * 2));  /* Input mode */
    GPIO_PUPDR(BOOTLOADER_GPIO_BASE) &= ~(3 << (BOOTLOADER_GPIO_PIN * 2));
    GPIO_PUPDR(BOOTLOADER_GPIO_BASE) |= (1 << (BOOTLOADER_GPIO_PIN * 2));   /* Pull-up */

    /* Configure LED pin (PA5) as output */
    GPIO_MODER(LED_GPIO_BASE) &= ~(3 << (LED_PIN * 2));
    GPIO_MODER(LED_GPIO_BASE) |= (1 << (LED_PIN * 2));  /* Output mode */
    GPIO_OSPEEDR(LED_GPIO_BASE) |= (3 << (LED_PIN * 2));  /* High speed */
    led_off();
}

/* ============================================================================
 * UART Functions
 * ============================================================================ */

static void uart_init(uint32_t baudrate) {
    /* Enable USART1 clock */
    RCC_APB2ENR |= (1 << 14);

    /* Configure PA9 (TX) and PA10 (RX) for USART1 (AF7) */
    GPIO_MODER(GPIOA_BASE) &= ~((3 << (UART_TX_PIN * 2)) | (3 << (UART_RX_PIN * 2)));
    GPIO_MODER(GPIOA_BASE) |= ((2 << (UART_TX_PIN * 2)) | (2 << (UART_RX_PIN * 2)));  /* AF mode */
    GPIO_OSPEEDR(GPIOA_BASE) |= ((3 << (UART_TX_PIN * 2)) | (3 << (UART_RX_PIN * 2)));

    /* Set AF7 for PA9, PA10 */
    GPIO_AFRH(GPIOA_BASE) &= ~((0xF << ((UART_TX_PIN - 8) * 4)) | (0xF << ((UART_RX_PIN - 8) * 4)));
    GPIO_AFRH(GPIOA_BASE) |= ((7 << ((UART_TX_PIN - 8) * 4)) | (7 << ((UART_RX_PIN - 8) * 4)));

    /* Configure USART1 */
    USART_CR1(USART1_BASE) = 0;  /* Disable USART */
    USART_BRR(USART1_BASE) = 80000000 / baudrate;  /* Set baud rate */
    USART_CR1(USART1_BASE) = USART_CR1_TE | USART_CR1_RE;
    USART_CR1(USART1_BASE) |= USART_CR1_UE;  /* Enable USART */
}

static void uart_send_byte(uint8_t byte) {
    while (!(USART_ISR(USART1_BASE) & USART_ISR_TXE));
    USART_TDR(USART1_BASE) = byte;
}

static void uart_send_data(const uint8_t *data, uint32_t len) {
    for (uint32_t i = 0; i < len; i++) {
        uart_send_byte(data[i]);
    }
    while (!(USART_ISR(USART1_BASE) & USART_ISR_TC));
}

static void uart_send_string(const char *str) {
    while (*str) {
        uart_send_byte(*str++);
    }
}

static bool uart_receive_byte(uint8_t *byte, uint32_t timeout) {
    volatile uint32_t count = timeout;
    while (!(USART_ISR(USART1_BASE) & USART_ISR_RXNE)) {
        if (--count == 0) return false;
    }
    *byte = (uint8_t)(USART_RDR(USART1_BASE) & 0xFF);
    return true;
}

static bool uart_receive_data(uint8_t *data, uint32_t len, uint32_t timeout) {
    for (uint32_t i = 0; i < len; i++) {
        if (!uart_receive_byte(&data[i], timeout)) {
            return false;
        }
    }
    return true;
}

static uint32_t uart_receive_u32(uint32_t timeout, bool *ok) {
    uint8_t buf[4];
    *ok = uart_receive_data(buf, 4, timeout);
    if (!*ok) return 0;
    return (uint32_t)buf[0] | ((uint32_t)buf[1] << 8) |
           ((uint32_t)buf[2] << 16) | ((uint32_t)buf[3] << 24);
}

static void uart_send_u32(uint32_t val) {
    uint8_t buf[4] = {
        (uint8_t)(val & 0xFF),
        (uint8_t)((val >> 8) & 0xFF),
        (uint8_t)((val >> 16) & 0xFF),
        (uint8_t)((val >> 24) & 0xFF)
    };
    uart_send_data(buf, 4);
}

/* ============================================================================
 * SPI Functions (for SD Card)
 * ============================================================================ */

static void spi_init(void) {
    /* Enable SPI1 clock */
    RCC_APB2ENR |= (1 << 12);

    /* Configure SPI pins: PA5=SCK, PA6=MISO, PA7=MOSI as AF5 */
    /* Note: PA5 is shared with LED; reconfigure for SPI when using SD */
    GPIO_MODER(GPIOA_BASE) &= ~((3 << (5 * 2)) | (3 << (6 * 2)) | (3 << (7 * 2)));
    GPIO_MODER(GPIOA_BASE) |= ((2 << (5 * 2)) | (2 << (6 * 2)) | (2 << (7 * 2)));
    GPIO_OSPEEDR(GPIOA_BASE) |= ((3 << (5 * 2)) | (3 << (6 * 2)) | (3 << (7 * 2)));

    GPIO_AFRL(GPIOA_BASE) &= ~((0xF << (5 * 4)) | (0xF << (6 * 4)) | (0xF << (7 * 4)));
    GPIO_AFRL(GPIOA_BASE) |= ((5 << (5 * 4)) | (5 << (6 * 4)) | (5 << (7 * 4)));

    /* Configure CS pin (PB6) as output, high */
    GPIO_MODER(SD_CS_GPIO_BASE) &= ~(3 << (SD_CS_PIN * 2));
    GPIO_MODER(SD_CS_GPIO_BASE) |= (1 << (SD_CS_PIN * 2));
    GPIO_BSRR(SD_CS_GPIO_BASE) = (1 << SD_CS_PIN);  /* CS high (deselected) */

    /* SPI1: Master, CPOL=0, CPHA=0, slow clock initially (fPCLK/256) */
    SPI_CR1(SD_SPI_BASE) = 0;
    SPI_CR1(SD_SPI_BASE) = (7 << 3) |  /* BR = fPCLK/256 */
                            (1 << 2) |   /* MSTR = 1 (Master) */
                            (1 << 9);    /* SSM = 1 */
    SPI_CR2(SD_SPI_BASE) = (7 << 8) |   /* 8-bit data */
                            (1 << 2);    /* SSOE */
    SPI_CR1(SD_SPI_BASE) |= (1 << 6);   /* SPE = 1 (enable) */
}

static void spi_set_fast(void) {
    SPI_CR1(SD_SPI_BASE) &= ~(1 << 6);  /* Disable SPI */
    SPI_CR1(SD_SPI_BASE) = (SPI_CR1(SD_SPI_BASE) & ~(7 << 3)) | (1 << 3);  /* fPCLK/4 = 20MHz */
    SPI_CR1(SD_SPI_BASE) |= (1 << 6);   /* Enable SPI */
}

static uint8_t spi_transfer(uint8_t data) {
    while (!(SPI_SR(SD_SPI_BASE) & SPI_SR_TXE));
    *(volatile uint8_t *)&SPI_DR(SD_SPI_BASE) = data;
    while (!(SPI_SR(SD_SPI_BASE) & SPI_SR_RXNE));
    return *(volatile uint8_t *)&SPI_DR(SD_SPI_BASE);
}

static void sd_cs_low(void) {
    GPIO_BSRR(SD_CS_GPIO_BASE) = (1 << (SD_CS_PIN + 16));
}

static void sd_cs_high(void) {
    GPIO_BSRR(SD_CS_GPIO_BASE) = (1 << SD_CS_PIN);
    spi_transfer(0xFF);  /* Extra clock for card release */
}

/* ============================================================================
 * SD Card Driver (SPI Mode)
 * ============================================================================ */

static uint8_t sd_send_cmd(uint8_t cmd, uint32_t arg) {
    uint8_t crc = 0xFF;

    sd_cs_high();
    sd_cs_low();

    /* Wait for card ready */
    uint32_t timeout = 10000;
    while (spi_transfer(0xFF) != 0xFF) {
        if (--timeout == 0) return 0xFF;
    }

    spi_transfer(0x40 | cmd);
    spi_transfer((arg >> 24) & 0xFF);
    spi_transfer((arg >> 16) & 0xFF);
    spi_transfer((arg >> 8) & 0xFF);
    spi_transfer(arg & 0xFF);

    if (cmd == SD_CMD0) crc = 0x95;
    else if (cmd == SD_CMD8) crc = 0x87;
    spi_transfer(crc);

    /* Wait for response */
    uint8_t response;
    for (int i = 0; i < 10; i++) {
        response = spi_transfer(0xFF);
        if (response != 0xFF) break;
    }

    return response;
}

static bool sd_init_card(void) {
    sd_initialized = false;
    sd_is_sdhc = false;

    /* Send >74 clocks with CS high */
    sd_cs_high();
    for (int i = 0; i < 10; i++) {
        spi_transfer(0xFF);
    }

    /* CMD0: Reset */
    uint8_t r;
    int retries = 100;
    do {
        r = sd_send_cmd(SD_CMD0, 0);
    } while (r != 0x01 && --retries > 0);

    if (r != 0x01) {
        sd_cs_high();
        return false;
    }

    /* CMD8: Check voltage */
    r = sd_send_cmd(SD_CMD8, 0x1AA);
    if (r == 0x01) {
        /* SDv2 */
        uint8_t ocr[4];
        for (int i = 0; i < 4; i++) ocr[i] = spi_transfer(0xFF);

        if (ocr[2] != 0x01 || ocr[3] != 0xAA) {
            sd_cs_high();
            return false;
        }

        /* ACMD41: Initialize */
        retries = 1000;
        do {
            sd_send_cmd(SD_CMD55, 0);
            r = sd_send_cmd(SD_ACMD41, 0x40000000);
        } while (r != 0x00 && --retries > 0);

        if (r != 0x00) {
            sd_cs_high();
            return false;
        }

        /* CMD58: Read OCR for CCS bit */
        r = sd_send_cmd(SD_CMD58, 0);
        if (r == 0x00) {
            for (int i = 0; i < 4; i++) ocr[i] = spi_transfer(0xFF);
            sd_is_sdhc = (ocr[0] & 0x40) != 0;
        }
    } else {
        /* SDv1 or MMC */
        retries = 1000;
        do {
            sd_send_cmd(SD_CMD55, 0);
            r = sd_send_cmd(SD_ACMD41, 0);
        } while (r != 0x00 && --retries > 0);

        if (r != 0x00) {
            /* Try MMC CMD1 */
            retries = 1000;
            do {
                r = sd_send_cmd(SD_CMD1, 0);
            } while (r != 0x00 && --retries > 0);
        }

        if (r != 0x00) {
            sd_cs_high();
            return false;
        }
    }

    /* Set block size to 512 */
    if (!sd_is_sdhc) {
        r = sd_send_cmd(SD_CMD16, SD_BLOCK_SIZE);
        if (r != 0x00) {
            sd_cs_high();
            return false;
        }
    }

    sd_cs_high();
    spi_set_fast();

    sd_initialized = true;
    return true;
}

static bool sd_read_block(uint32_t block_addr, uint8_t *buffer) {
    if (!sd_initialized) return false;

    uint32_t addr = sd_is_sdhc ? block_addr : (block_addr * SD_BLOCK_SIZE);

    uint8_t r = sd_send_cmd(SD_CMD17, addr);
    if (r != 0x00) {
        sd_cs_high();
        return false;
    }

    /* Wait for data token */
    uint32_t timeout = 200000;
    while (spi_transfer(0xFF) != 0xFE) {
        if (--timeout == 0) {
            sd_cs_high();
            return false;
        }
    }

    /* Read 512 bytes */
    for (int i = 0; i < SD_BLOCK_SIZE; i++) {
        buffer[i] = spi_transfer(0xFF);
    }

    /* Read and discard CRC */
    spi_transfer(0xFF);
    spi_transfer(0xFF);

    sd_cs_high();
    return true;
}

/* ============================================================================
 * Flash Programming Functions
 * ============================================================================ */

static void flash_unlock(void) {
    if (FLASH_CR & FLASH_CR_LOCK) {
        FLASH_KEYR = FLASH_KEY1;
        FLASH_KEYR = FLASH_KEY2;
    }
}

static void flash_lock(void) {
    FLASH_CR |= FLASH_CR_LOCK;
}

static void flash_wait_busy(void) {
    while (FLASH_SR & FLASH_SR_BSY) {
        __asm volatile("nop");
    }
}

static bool flash_erase_page(uint32_t page_num) {
    flash_wait_busy();

    FLASH_CR &= ~(0xFF << FLASH_CR_PNB_SHIFT);
    FLASH_CR |= FLASH_CR_PER | (page_num << FLASH_CR_PNB_SHIFT);
    FLASH_CR |= FLASH_CR_STRT;

    flash_wait_busy();

    FLASH_CR &= ~FLASH_CR_PER;

    /* Check for errors */
    if (FLASH_SR & 0xC3FA) {
        FLASH_SR = 0xC3FA;  /* Clear error flags */
        return false;
    }

    return true;
}

static bool flash_erase_app_region(uint32_t size) {
    uint32_t start_page = (APP_BASE - BOOTLOADER_BASE) / FLASH_PAGE_SIZE;
    uint32_t num_pages = (size + FLASH_PAGE_SIZE - 1) / FLASH_PAGE_SIZE;

    flash_unlock();

    for (uint32_t i = 0; i < num_pages; i++) {
        if (!flash_erase_page(start_page + i)) {
            flash_lock();
            return false;
        }
        led_toggle();
    }

    flash_lock();
    return true;
}

static bool flash_write_doubleword(uint32_t address, uint64_t data) {
    flash_wait_busy();

    FLASH_CR |= FLASH_CR_PG;

    /* Write 64-bit (double word) */
    *(volatile uint32_t *)address = (uint32_t)(data & 0xFFFFFFFF);
    *(volatile uint32_t *)(address + 4) = (uint32_t)((data >> 32) & 0xFFFFFFFF);

    flash_wait_busy();

    FLASH_CR &= ~FLASH_CR_PG;

    /* Verify */
    if (*(volatile uint32_t *)address != (uint32_t)(data & 0xFFFFFFFF)) {
        return false;
    }
    if (*(volatile uint32_t *)(address + 4) != (uint32_t)((data >> 32) & 0xFFFFFFFF)) {
        return false;
    }

    return true;
}

static bool flash_write_block(uint32_t address, const uint8_t *data, uint32_t length) {
    flash_unlock();

    /* Ensure 8-byte aligned writes */
    uint32_t offset = 0;
    while (offset < length) {
        uint64_t dword = 0xFFFFFFFFFFFFFFFF;
        uint32_t remaining = length - offset;
        uint32_t chunk = (remaining >= 8) ? 8 : remaining;

        for (uint32_t i = 0; i < chunk; i++) {
            dword &= ~((uint64_t)0xFF << (i * 8));
            dword |= ((uint64_t)data[offset + i] << (i * 8));
        }

        if (!flash_write_doubleword(address + offset, dword)) {
            flash_lock();
            return false;
        }

        offset += 8;
    }

    flash_lock();
    return true;
}

/* ============================================================================
 * Firmware Verification
 * ============================================================================ */

static bool verify_firmware_header(const fw_header_t *header) {
    if (header->magic != FW_HEADER_MAGIC) {
        return false;
    }

    if (header->size == 0 || header->size > APP_MAX_SIZE) {
        return false;
    }

    return true;
}

static bool verify_app_crc(uint32_t expected_crc, uint32_t size) {
    uint32_t crc = 0xFFFFFFFF;
    const uint8_t *app_ptr = (const uint8_t *)APP_BASE;

    uint32_t remaining = size;
    while (remaining > 0) {
        uint32_t chunk = (remaining > 256) ? 256 : remaining;
        crc = ~crc;
        for (uint32_t i = 0; i < chunk; i++) {
            crc = (crc >> 8) ^ crc32_table[(crc ^ *app_ptr++) & 0xFF];
        }
        crc = ~crc;
        remaining -= chunk;
    }

    return (crc == expected_crc);
}

static bool verify_app_valid(void) {
    /* Check if there's a valid stack pointer at APP_BASE */
    uint32_t sp = *(volatile uint32_t *)APP_BASE;
    uint32_t pc = *(volatile uint32_t *)(APP_BASE + 4);

    /* Stack pointer should be in SRAM */
    if (sp < SRAM_BASE || sp > (SRAM_BASE + SRAM_SIZE)) {
        return false;
    }

    /* Reset handler should be in flash (app region) */
    if (pc < APP_BASE || pc > (APP_BASE + APP_MAX_SIZE)) {
        return false;
    }

    return true;
}

/* ============================================================================
 * SD Card Firmware Update
 * ============================================================================ */

static bool sd_update_firmware(void) {
    uart_send_string("[BL] Checking SD card for firmware...\r\n");

    spi_init();

    if (!sd_init_card()) {
        uart_send_string("[BL] SD card not detected\r\n");
        return false;
    }

    uart_send_string("[BL] SD card initialized\r\n");

    /* Read first block to get firmware header
     * Assumes firmware file starts at block 0 of SD card
     * (raw block access - no filesystem for minimal bootloader)
     * For production, implement FAT16/FAT32 to find FIRMWARE.BIN */

    if (!sd_read_block(0, rx_buffer)) {
        uart_send_string("[BL] Failed to read SD card\r\n");
        return false;
    }

    fw_header_t *header = (fw_header_t *)rx_buffer;

    if (!verify_firmware_header(header)) {
        uart_send_string("[BL] No valid firmware on SD card\r\n");
        return false;
    }

    uint32_t fw_size = header->size;
    uint32_t fw_crc = header->crc32;
    uint32_t fw_version = header->version;

    uart_send_string("[BL] Found firmware v");
    uart_send_u32(fw_version);
    uart_send_string("\r\n[BL] Size: ");
    uart_send_u32(fw_size);
    uart_send_string(" bytes\r\n");

    /* Erase application region */
    uart_send_string("[BL] Erasing flash...\r\n");
    if (!flash_erase_app_region(fw_size)) {
        uart_send_string("[BL] Flash erase failed!\r\n");
        return false;
    }

    /* Write firmware from SD card to flash */
    uart_send_string("[BL] Writing firmware...\r\n");

    uint32_t bytes_written = 0;
    uint32_t block_num = 0;
    uint32_t data_offset = FW_HEADER_SIZE;  /* Skip header in first block */
    uint32_t crc_accum = 0;
    bool first_block = true;

    while (bytes_written < fw_size) {
        if (!sd_read_block(block_num, rx_buffer)) {
            uart_send_string("[BL] SD read error!\r\n");
            return false;
        }

        uint8_t *src = rx_buffer;
        uint32_t src_len = SD_BLOCK_SIZE;

        if (first_block) {
            src = rx_buffer + data_offset;
            src_len = SD_BLOCK_SIZE - data_offset;
            first_block = false;
        }

        uint32_t remaining = fw_size - bytes_written;
        uint32_t write_len = (src_len > remaining) ? remaining : src_len;

        /* Update CRC */
        crc_accum = crc32_update(crc_accum, src, write_len);

        /* Write to flash */
        if (!flash_write_block(APP_BASE + bytes_written, src, write_len)) {
            uart_send_string("[BL] Flash write error!\r\n");
            return false;
        }

        bytes_written += write_len;
        block_num++;
        led_toggle();

        /* Progress indicator every 4KB */
        if ((bytes_written % 4096) == 0) {
            uart_send_byte('.');
        }
    }

    uart_send_string("\r\n[BL] Verifying CRC...\r\n");

    /* Verify CRC */
    if (crc_accum != fw_crc) {
        uart_send_string("[BL] CRC mismatch! Erasing...\r\n");
        flash_erase_app_region(fw_size);
        return false;
    }

    /* Double-check: verify from flash */
    if (!verify_app_crc(fw_crc, fw_size)) {
        uart_send_string("[BL] Flash verification failed!\r\n");
        flash_erase_app_region(fw_size);
        return false;
    }

    uart_send_string("[BL] Firmware update successful!\r\n");
    return true;
}

/* ============================================================================
 * UART Firmware Update Protocol
 * ============================================================================ */

static bool uart_update_firmware(void) {
    uart_send_string("[BL] UART bootloader mode\r\n");
    uart_send_string("[BL] Waiting for firmware...\r\n");

    /* Wait for PING command with timeout */
    uint8_t cmd;
    uint32_t start_time = systick_counter;
    bool connected = false;

    while ((systick_counter - start_time) < 30000) {  /* 30 second timeout */
        if (uart_receive_byte(&cmd, UART_TIMEOUT / 10)) {
            if (cmd == UART_CMD_PING) {
                uart_send_byte(UART_ACK);
                uart_send_string("BL01");  /* Bootloader ID */
                connected = true;
                break;
            }
        }
        led_toggle();
        delay_ms(100);
    }

    if (!connected) {
        uart_send_string("[BL] No connection, timeout\r\n");
        return false;
    }

    uart_send_string("[BL] Host connected\r\n");

    /* Main command loop */
    fw_header_t header;
    bool header_received = false;
    uint32_t total_written = 0;
    uint32_t crc_accum = 0;

    while (1) {
        if (!uart_receive_byte(&cmd, UART_TIMEOUT)) {
            uart_send_string("[BL] Timeout\r\n");
            return false;
        }

        switch (cmd) {
            case UART_CMD_PING:
                uart_send_byte(UART_ACK);
                break;

            case UART_CMD_INFO: {
                /* Send bootloader info */
                uart_send_byte(UART_ACK);
                uart_send_u32(APP_BASE);
                uart_send_u32(APP_MAX_SIZE);
                uart_send_u32(FLASH_PAGE_SIZE);
                uart_send_u32(UART_BLOCK_SIZE);
                break;
            }

            case UART_CMD_ERASE: {
                /* Receive firmware header */
                bool ok;
                header.magic = uart_receive_u32(UART_TIMEOUT, &ok);
                if (!ok) { uart_send_byte(UART_NACK); continue; }
                header.version = uart_receive_u32(UART_TIMEOUT, &ok);
                if (!ok) { uart_send_byte(UART_NACK); continue; }
                header.size = uart_receive_u32(UART_TIMEOUT, &ok);
                if (!ok) { uart_send_byte(UART_NACK); continue; }
                header.crc32 = uart_receive_u32(UART_TIMEOUT, &ok);
                if (!ok) { uart_send_byte(UART_NACK); continue; }

                if (!verify_firmware_header(&header)) {
                    uart_send_byte(UART_NACK);
                    uart_send_string("[BL] Invalid header\r\n");
                    continue;
                }

                uart_send_string("[BL] Erasing...\r\n");

                if (!flash_erase_app_region(header.size)) {
                    uart_send_byte(UART_NACK);
                    uart_send_string("[BL] Erase failed\r\n");
                    continue;
                }

                header_received = true;
                total_written = 0;
                crc_accum = 0;
                uart_send_byte(UART_ACK);
                uart_send_string("[BL] Ready for data\r\n");
                break;
            }

            case UART_CMD_WRITE: {
                if (!header_received) {
                    uart_send_byte(UART_NACK);
                    continue;
                }

                /* Receive: offset (4 bytes) + length (2 bytes) + data + checksum (1 byte) */
                bool ok;
                uint32_t offset = uart_receive_u32(UART_TIMEOUT, &ok);
                if (!ok) { uart_send_byte(UART_NACK); continue; }

                uint8_t len_lo, len_hi;
                if (!uart_receive_byte(&len_lo, UART_TIMEOUT) ||
                    !uart_receive_byte(&len_hi, UART_TIMEOUT)) {
                    uart_send_byte(UART_NACK);
                    continue;
                }
                uint16_t data_len = len_lo | (len_hi << 8);

                if (data_len > UART_BLOCK_SIZE || (offset + data_len) > header.size) {
                    uart_send_byte(UART_NACK);
                    continue;
                }

                /* Receive data */
                if (!uart_receive_data(rx_buffer, data_len, UART_TIMEOUT)) {
                    uart_send_byte(UART_NACK);
                    continue;
                }

                /* Receive and verify checksum */
                uint8_t recv_checksum;
                if (!uart_receive_byte(&recv_checksum, UART_TIMEOUT)) {
                    uart_send_byte(UART_NACK);
                    continue;
                }

                uint8_t calc_checksum = 0;
                for (uint16_t i = 0; i < data_len; i++) {
                    calc_checksum ^= rx_buffer[i];
                }

                if (calc_checksum != recv_checksum) {
                    uart_send_byte(UART_NACK);
                    continue;
                }

                /* Write to flash */
                if (!flash_write_block(APP_BASE + offset, rx_buffer, data_len)) {
                    uart_send_byte(UART_NACK);
                    uart_send_string("[BL] Write error\r\n");
                    continue;
                }

                total_written += data_len;
                led_toggle();
                uart_send_byte(UART_ACK);
                break;
            }

            case UART_CMD_VERIFY: {
                if (!header_received) {
                    uart_send_byte(UART_NACK);
                    continue;
                }

                uart_send_string("[BL] Verifying...\r\n");

                if (total_written < header.size) {
                    uart_send_byte(UART_NACK);
                    uart_send_string("[BL] Incomplete\r\n");
                    continue;
                }

                /* Verify CRC of written data */
                if (!verify_app_crc(header.crc32, header.size)) {
                    uart_send_byte(UART_NACK);
                    uart_send_string("[BL] CRC fail!\r\n");
                    continue;
                }

                uart_send_byte(UART_ACK);
                uart_send_string("[BL] Verified OK!\r\n");
                break;
            }

            case UART_CMD_BOOT: {
                uart_send_byte(UART_ACK);
                uart_send_string("[BL] Booting app...\r\n");
                delay_ms(100);
                return true;
            }

            default:
                uart_send_byte(UART_NACK);
                break;
        }
    }
}

/* ============================================================================
 * Application Jump
 * ============================================================================ */

static void jump_to_app(void) {
    if (!verify_app_valid()) {
        uart_send_string("[BL] No valid application!\r\n");
        return;
    }

    uart_send_string("[BL] Jumping to application...\r\n");
    delay_ms(50);

    /* Get the application's stack pointer and reset handler */
    uint32_t app_sp = *(volatile uint32_t *)APP_BASE;
    uint32_t app_pc = *(volatile uint32_t *)(APP_BASE + 4);

    /* Disable SysTick */
    SYSTICK_CTRL = 0;
    SYSTICK_LOAD = 0;
    SYSTICK_VAL = 0;

    /* Disable all interrupts and clear pending */
    for (int i = 0; i < 8; i++) {
        *(volatile uint32_t *)(NVIC_BASE + 0x80 + i * 4) = 0xFFFFFFFF;  /* ICER */
        *(volatile uint32_t *)(NVIC_BASE + 0x180 + i * 4) = 0xFFFFFFFF; /* ICPR */
    }

    /* Disable USART1 */
    USART_CR1(USART1_BASE) = 0;

    /* Clear magic value */
    *BOOTLOADER_MAGIC_ADDR = 0;

    /* Relocate vector table */
    SCB_VTOR = APP_BASE;

    /* Set main stack pointer */
    __asm volatile("MSR MSP, %0" : : "r"(app_sp));

    /* Memory barrier */
    __asm volatile("DSB");
    __asm volatile("ISB");

    /* Jump to application reset handler */
    void (*app_reset_handler)(void) = (void (*)(void))app_pc;
    app_reset_handler();

    /* Should never reach here */
    while (1);
}

/* ============================================================================
 * Boot Mode Detection
 * ============================================================================ */

typedef enum {
    BOOT_MODE_APP,
    BOOT_MODE_SD_UPDATE,
    BOOT_MODE_UART_UPDATE,
    BOOT_MODE_RECOVERY
} boot_mode_t;

static boot_mode_t detect_boot_mode(void) {
    /* Priority 1: Check magic memory location (set by application for recovery) */
    if (*BOOTLOADER_MAGIC_ADDR == BOOTLOADER_MAGIC_VALUE) {
        *BOOTLOADER_MAGIC_ADDR = 0;  /* Clear it */
        uart_send_string("[BL] Recovery mode requested by application\r\n");
        return BOOT_MODE_RECOVERY;
    }

    /* Priority 2: Check GPIO pin (held low = enter bootloader) */
    /* Read multiple times for debounce */
    uint32_t low_count = 0;
    for (int i = 0; i < 10; i++) {
        if (!(GPIO_IDR(BOOTLOADER_GPIO_BASE) & (1 << BOOTLOADER_GPIO_PIN))) {
            low_count++;
        }
        delay_us(1000);
    }

    if (low_count >= 7) {
        uart_send_string("[BL] Boot pin active - entering UART mode\r\n");
        return BOOT_MODE_UART_UPDATE;
    }

    /* Priority 3: Check if there's a valid application */
    if (!verify_app_valid()) {
        uart_send_string("[BL] No valid application found\r\n");
        return BOOT_MODE_RECOVERY;
    }

    /* Priority 4: Quick check for SD card update (non-blocking) */
    /* We do a fast probe - if SD has firmware, update first */
    return BOOT_MODE_SD_UPDATE;
}

/* ============================================================================
 * Recovery Mode (combined SD + UART)
 * ============================================================================ */

static void recovery_mode(void) {
    uart_send_string("[BL] === RECOVERY MODE ===\r\n");
    uart_send_string("[BL] Attempting SD card update...\r\n");

    if (sd_update_firmware()) {
        uart_send_string("[BL] SD update complete, booting...\r\n");
        delay_ms(500);
        jump_to_app();
        return;
    }

    uart_send_string("[BL] SD update not available\r\n");
    uart_send_string("[BL] Falling back to UART mode\r\n");

    while (1) {
        if (uart_update_firmware()) {
            jump_to_app();
        }

        /* If UART update failed or was cancelled, retry */
        uart_send_string("[BL] Retrying...\r\n");
        led_toggle();
        delay_ms(1000);
    }
}

/* ============================================================================
 * Bootloader Main Entry
 * ============================================================================ */

int main(void) {
    /* Initialize system */
    system_clock_init();
    systick_init();
    gpio_init();
    uart_init(115200);

    led_on();

    uart_send_string("\r\n================================\r\n");
    uart_send_string("  ARM Cortex-M Bootloader v1.0\r\n");
    uart_send_string("  IoT Field Update System\r\n");
    uart_send_string("================================\r\n");

    /* Detect boot mode */
    boot_mode_t mode = detect_boot_mode();

    switch (mode) {
        case BOOT_MODE_APP:
            /* Normal boot - jump directly to app */
            jump_to_app();
            /* If jump fails, fall through to recovery */
            uart_send_string("[BL] App boot failed!\r\n");
            recovery_mode();
            break;

        case BOOT_MODE_SD_UPDATE: {
            /* Try SD update quickly, then boot app regardless */
            bool updated = sd_update_firmware();
            if (updated) {
                uart_send_string("[BL] SD update applied\r\n");
            }
            /* Boot the app (either updated or existing) */
            jump_to_app();
            /* If no valid app, go to recovery */
            recovery_mode();
            break;
        }

        case BOOT_MODE_UART_UPDATE: