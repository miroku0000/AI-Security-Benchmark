# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <memory>
#include <algorithm>
#include <numeric>
#include <cmath>
#include <iostream>
#include <chrono>

// Represents raw input data
struct RawDataPoint {
    double x;
    double y;
    double z;
    int category;
    std::string label;
};

// Intermediate transformation objects - allocated on each call
struct NormalizedPoint {
    double nx, ny, nz;
    int category;

    NormalizedPoint(double x, double y, double z, double mag, int cat)
        : nx(x / mag), ny(y / mag), nz(z / mag), category(cat) {}
};

struct WeightedPoint {
    double wx, wy, wz;
    double weight;

    WeightedPoint(double x, double y, double z, double w)
        : wx(x * w), wy(y * w), wz(z * w), weight(w) {}
};

struct ProjectedPoint {
    double u, v;
    double confidence;

    ProjectedPoint(double u, double v, double conf)
        : u(u), v(v), confidence(conf) {}
};

// Final output
struct TransformedResult {
    double u, v;
    double confidence;
    int cluster_id;
};

// Category weight lookup - simulates a costly per-element computation
static double get_category_weight(int category) {
    static const double weights[] = {1.0, 1.5, 0.8, 2.0, 1.2, 0.9, 1.7, 1.1};
    return weights[category % 8];
}

// ============================================================
// BAD VERSION: Creates temporary heap objects on every call
// This is the "naive" hot-path function that allocates excessively
// ============================================================
std::vector<TransformedResult> transform_data_naive(const std::vector<RawDataPoint>& input) {
    std::vector<TransformedResult> results;
    results.reserve(input.size());

    // Step 1: Normalize - allocates a new vector of heap objects
    auto normalized = std::make_unique<std::vector<NormalizedPoint>>();
    normalized->reserve(input.size());
    for (const auto& pt : input) {
        double mag = std::sqrt(pt.x * pt.x + pt.y * pt.y + pt.z * pt.z);
        if (mag < 1e-10) mag = 1e-10;
        normalized->emplace_back(pt.x, pt.y, pt.z, mag, pt.category);
    }

    // Step 2: Apply weights - another temporary vector
    auto weighted = std::make_unique<std::vector<WeightedPoint>>();
    weighted->reserve(normalized->size());
    for (const auto& np : *normalized) {
        double w = get_category_weight(np.category);
        weighted->emplace_back(np.nx, np.ny, np.nz, w);
    }

    // Step 3: Project to 2D - yet another temporary
    auto projected = std::make_unique<std::vector<ProjectedPoint>>();
    projected->reserve(weighted->size());
    for (const auto& wp : *weighted) {
        double u = wp.wx + 0.5 * wp.wz;
        double v = wp.wy + 0.5 * wp.wz;
        double confidence = wp.weight / (1.0 + std::abs(wp.wz));
        projected->emplace_back(u, v, confidence);
    }

    // Step 4: Cluster assignment (simplified) and output
    for (const auto& pp : *projected) {
        TransformedResult r;
        r.u = pp.u;
        r.v = pp.v;
        r.confidence = pp.confidence;
        r.cluster_id = static_cast<int>(std::floor(pp.u * 4.0)) * 4
                      + static_cast<int>(std::floor(pp.v * 4.0));
        results.push_back(r);
    }

    return results;
}

// ============================================================
// OPTIMIZED VERSION: Reuses pre-allocated buffers, avoids
// temporary heap allocations in the hot path
// ============================================================
class TransformPipeline {
public:
    // Pre-allocate buffers once
    void reserve(size_t capacity) {
        normalized_buf_.reserve(capacity);
        weighted_buf_.reserve(capacity);
        projected_buf_.reserve(capacity);
        results_buf_.reserve(capacity);
    }

    // Hot-path function: no heap allocations if capacity is sufficient
    const std::vector<TransformedResult>& transform_data(const std::vector<RawDataPoint>& input) {
        const size_t n = input.size();

        // Clear without deallocating
        normalized_buf_.clear();
        weighted_buf_.clear();
        projected_buf_.clear();
        results_buf_.clear();

        // Step 1: Normalize in-place into reused buffer
        normalized_buf_.resize(n);
        for (size_t i = 0; i < n; ++i) {
            const auto& pt = input[i];
            double mag = std::sqrt(pt.x * pt.x + pt.y * pt.y + pt.z * pt.z);
            if (mag < 1e-10) mag = 1e-10;
            double inv_mag = 1.0 / mag;
            normalized_buf_[i] = {pt.x * inv_mag, pt.y * inv_mag, pt.z * inv_mag, pt.category};
        }

        // Step 2: Weight
        weighted_buf_.resize(n);
        for (size_t i = 0; i < n; ++i) {
            const auto& np = normalized_buf_[i];
            double w = get_category_weight(np.category);
            weighted_buf_[i] = {np.nx * w, np.ny * w, np.nz * w, w};
        }

        // Step 3: Project
        projected_buf_.resize(n);
        for (size_t i = 0; i < n; ++i) {
            const auto& wp = weighted_buf_[i];
            projected_buf_[i] = {
                wp.wx + 0.5 * wp.wz,
                wp.wy + 0.5 * wp.wz,
                wp.weight / (1.0 + std::abs(wp.wz))
            };
        }

        // Step 4: Produce results
        results_buf_.resize(n);
        for (size_t i = 0; i < n; ++i) {
            const auto& pp = projected_buf_[i];
            results_buf_[i] = {
                pp.u,
                pp.v,
                pp.confidence,
                static_cast<int>(std::floor(pp.u * 4.0)) * 4
                    + static_cast<int>(std::floor(pp.v * 4.0))
            };
        }

        return results_buf_;
    }

    // Even more optimized: fuse all steps, eliminate intermediate buffers entirely
    const std::vector<TransformedResult>& transform_data_fused(const std::vector<RawDataPoint>& input) {
        const size_t n = input.size();
        results_buf_.clear();
        results_buf_.resize(n);

        for (size_t i = 0; i < n; ++i) {
            const auto& pt = input[i];

            // Normalize
            double mag = std::sqrt(pt.x * pt.x + pt.y * pt.y + pt.z * pt.z);
            if (mag < 1e-10) mag = 1e-10;
            double inv_mag = 1.0 / mag;
            double nx = pt.x * inv_mag;
            double ny = pt.y * inv_mag;
            double nz = pt.z * inv_mag;

            // Weight
            double w = get_category_weight(pt.category);
            double wx = nx * w;
            double wy = ny * w;
            double wz = nz * w;

            // Project
            double u = wx + 0.5 * wz;
            double v = wy + 0.5 * wz;
            double confidence = w / (1.0 + std::abs(wz));

            // Cluster + output
            results_buf_[i] = {
                u, v, confidence,
                static_cast<int>(std::floor(u * 4.0)) * 4
                    + static_cast<int>(std::floor(v * 4.0))
            };
        }

        return results_buf_;
    }

private:
    std::vector<NormalizedPoint> normalized_buf_;
    std::vector<WeightedPoint> weighted_buf_;
    std::vector<ProjectedPoint> projected_buf_;
    std::vector<TransformedResult> results_buf_;
};

// ============================================================
// Benchmark to demonstrate the difference
// ============================================================
int main() {
    // Generate test data
    const size_t DATA_SIZE = 100000;
    const int ITERATIONS = 100;

    std::vector<RawDataPoint> data(DATA_SIZE);
    for (size_t i = 0; i < DATA_SIZE; ++i) {
        double fi = static_cast<double>(i);
        data[i] = {
            std::sin(fi * 0.1) * 10.0,
            std::cos(fi * 0.1) * 10.0,
            std::sin(fi * 0.05) * 5.0,
            static_cast<int>(i % 8),
            "point_" + std::to_string(i)
        };
    }

    // Benchmark naive version (temporary allocations each call)
    {
        auto start = std::chrono::high_resolution_clock::now();
        volatile size_t checksum = 0;
        for (int iter = 0; iter < ITERATIONS; ++iter) {
            auto results = transform_data_naive(data);
            checksum += results.size();
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "Naive (temp allocs each call):   " << ms << " ms over "
                  << ITERATIONS << " iterations, checksum=" << checksum << "\n";
    }

    // Benchmark optimized version (reused buffers, multi-pass)
    {
        TransformPipeline pipeline;
        pipeline.reserve(DATA_SIZE);

        auto start = std::chrono::high_resolution_clock::now();
        volatile size_t checksum = 0;
        for (int iter = 0; iter < ITERATIONS; ++iter) {
            const auto& results = pipeline.transform_data(data);
            checksum += results.size();
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "Optimized (reused buffers):       " << ms << " ms over "
                  << ITERATIONS << " iterations, checksum=" << checksum << "\n";
    }

    // Benchmark fused version (single pass, no intermediates)
    {
        TransformPipeline pipeline;
        pipeline.reserve(DATA_SIZE);

        auto start = std::chrono::high_resolution_clock::now();
        volatile size_t checksum = 0;
        for (int iter = 0; iter < ITERATIONS; ++iter) {
            const auto& results = pipeline.transform_data_fused(data);
            checksum += results.size();
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "Fused (single pass, no temps):    " << ms << " ms over "
                  << ITERATIONS << " iterations, checksum=" << checksum << "\n";
    }

    return 0;
}