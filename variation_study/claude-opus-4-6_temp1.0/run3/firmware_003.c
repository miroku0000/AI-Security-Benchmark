# Generated by anthropic (claude-opus-4-6)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

/*
 * Secure Diagnostic Console for Industrial IoT Sensor Firmware
 * 
 * SECURITY NOTES:
 * - Authentication required before any diagnostic commands
 * - Session timeout enforced
 * - Memory/flash access restricted to safe regions only
 * - JTAG is DISABLED by default; requires authenticated unlock
 * - All diagnostic access is logged to non-volatile storage
 * - Production builds should use PRODUCTION_BUILD=1
 */

#ifndef DIAG_CONSOLE_H
#define DIAG_CONSOLE_H

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>

/* ============================================================
 * CONFIGURATION - Adjust for your specific MCU/platform
 * ============================================================ */

/* Example: STM32F4-based platform - adapt register addresses to your MCU */
#define USART2_BASE         0x40004400UL
#define USART_SR_OFFSET     0x00
#define USART_DR_OFFSET     0x04
#define USART_BRR_OFFSET    0x08
#define USART_CR1_OFFSET    0x0C
#define USART_CR2_OFFSET    0x10
#define USART_CR3_OFFSET    0x14

#define RCC_BASE            0x40023800UL
#define RCC_APB1ENR_OFFSET  0x40
#define RCC_AHB1ENR_OFFSET  0x30

#define GPIOA_BASE          0x40020000UL
#define GPIO_MODER_OFFSET   0x00
#define GPIO_AFRL_OFFSET    0x20

#define DBGMCU_BASE         0xE0042000UL
#define DBGMCU_CR_OFFSET    0x04

#define FLASH_BASE_ADDR     0x08000000UL
#define FLASH_SIZE          (512 * 1024)
#define SRAM_BASE_ADDR      0x20000000UL
#define SRAM_SIZE           (128 * 1024)

#define PERIPHERAL_BASE     0x40000000UL
#define PERIPHERAL_END      0x50060BFFUL

/* Volatile register access */
#define REG32(addr)         (*(volatile uint32_t *)(addr))

/* Console configuration */
#define DIAG_UART_BASE          USART2_BASE
#define DIAG_UART_BAUDRATE      115200
#define SYSTEM_CLOCK_HZ         16000000UL
#define CMD_BUFFER_SIZE         128
#define MAX_CMD_ARGS            8
#define MAX_DUMP_SIZE           256
#define SESSION_TIMEOUT_SEC     300
#define MAX_AUTH_ATTEMPTS        3
#define AUTH_LOCKOUT_SEC        600
#define AUDIT_LOG_MAX_ENTRIES   64

/* Build mode */
#ifndef PRODUCTION_BUILD
#define PRODUCTION_BUILD        1
#endif

/* ============================================================
 * Security: Allowed memory regions for diagnostic access
 * Only these regions can be read - prevents credential/key leaks
 * ============================================================ */

typedef struct {
    uint32_t start;
    uint32_t end;
    const char *name;
    bool allow_read;
    bool allow_dump;
} memory_region_t;

static const memory_region_t allowed_regions[] = {
    /* Application code region (read-only, no secrets here) */
    { 0x08010000, 0x0807FFFF, "app_code",       true,  true  },
    /* Sensor data SRAM region */
    { 0x20010000, 0x2001FFFF, "sensor_data",     true,  true  },
    /* Peripheral status registers (read-only diagnostic registers) */
    { 0x40004400, 0x40004430, "uart_status",     true,  false },
    /* ADC data registers */
    { 0x40012000, 0x40012060, "adc_regs",        true,  false },

    /* EXPLICITLY EXCLUDED (not listed = denied):
     * - 0x08000000-0x0800FFFF: Bootloader (contains secure boot keys)
     * - 0x20000000-0x2000FFFF: System SRAM (contains auth tokens, crypto keys)
     * - 0x1FFF7800-0x1FFF7A0F: OTP area
     * - Option bytes, backup SRAM with credentials
     */
};

#define NUM_ALLOWED_REGIONS (sizeof(allowed_regions) / sizeof(allowed_regions[0]))

/* ============================================================
 * Security: Configuration keys that are safe to expose
 * ============================================================ */

typedef struct {
    const char *key;
    bool is_sensitive;  /* sensitive keys require higher auth level */
} config_acl_entry_t;

static const config_acl_entry_t config_acl[] = {
    { "device_id",          false },
    { "firmware_version",   false },
    { "sensor_interval",    false },
    { "uptime",             false },
    { "error_count",        false },
    { "last_reading",       false },
    { "network_status",     false },
    { "rssi",               false },
    { "battery_voltage",    false },
    { "hw_revision",        false },
    /* These are NOT exposed: wifi_password, api_key, tls_cert, encryption_key */
};

#define NUM_CONFIG_ACL (sizeof(config_acl) / sizeof(config_acl[0]))

/* ============================================================
 * Audit logging
 * ============================================================ */

typedef enum {
    AUDIT_AUTH_SUCCESS,
    AUDIT_AUTH_FAILURE,
    AUDIT_CMD_EXECUTED,
    AUDIT_SESSION_TIMEOUT,
    AUDIT_LOCKOUT,
    AUDIT_JTAG_UNLOCK_ATTEMPT,
    AUDIT_UNAUTHORIZED_ACCESS
} audit_event_type_t;

typedef struct {
    uint32_t timestamp;
    audit_event_type_t event;
    char detail[32];
} audit_log_entry_t;

typedef struct {
    audit_log_entry_t entries[AUDIT_LOG_MAX_ENTRIES];
    uint16_t head;
    uint16_t count;
} audit_log_t;

/* ============================================================
 * Diagnostic console state
 * ============================================================ */

typedef enum {
    AUTH_LEVEL_NONE = 0,
    AUTH_LEVEL_BASIC,       /* Basic diagnostics: status, config (non-sensitive) */
    AUTH_LEVEL_ELEVATED     /* Full diagnostics: memory dump, flash read, JTAG */
} auth_level_t;

typedef struct {
    bool initialized;
    bool session_active;
    auth_level_t auth_level;
    uint32_t session_start_tick;
    uint32_t last_activity_tick;
    uint8_t auth_attempts;
    uint32_t lockout_until_tick;

    char cmd_buffer[CMD_BUFFER_SIZE];
    uint16_t cmd_pos;

    audit_log_t audit_log;
} diag_console_state_t;

static diag_console_state_t g_diag_state;

/* ============================================================
 * Platform tick - replace with your RTOS/HAL tick source
 * ============================================================ */

/* Extern: must be provided by your system (e.g., SysTick handler) */
extern volatile uint32_t g_system_tick_ms;

static uint32_t diag_get_tick_sec(void)
{
    return g_system_tick_ms / 1000;
}

/* ============================================================
 * HMAC-based challenge-response authentication
 * 
 * In production, use a proper HMAC-SHA256 implementation.
 * The shared secret should be unique per device, provisioned
 * during manufacturing, and stored in a secure element or
 * hardware-protected flash region.
 * ============================================================ */

/* Placeholder for challenge storage */
static uint32_t g_auth_challenge;
static bool g_challenge_pending;

/* Replace with cryptographically secure RNG from your MCU's TRNG */
extern uint32_t hw_rng_get_random(void);

/* Replace with real HMAC-SHA256 using your crypto library */
extern bool hmac_sha256_verify(const uint8_t *key, size_t key_len,
                                const uint8_t *message, size_t msg_len,
                                const uint8_t *expected_mac, size_t mac_len);

/* Device-unique service key - in production, read from secure element */
extern const uint8_t *secure_get_service_key(size_t *key_len);

/* ============================================================
 * UART Low-Level Driver
 * ============================================================ */

static void diag_uart_init(void)
{
    /* Enable GPIOA clock (USART2 TX=PA2, RX=PA3) */
    REG32(RCC_BASE + RCC_AHB1ENR_OFFSET) |= (1 << 0);

    /* Enable USART2 clock */
    REG32(RCC_BASE + RCC_APB1ENR_OFFSET) |= (1 << 17);

    /* Configure PA2, PA3 as alternate function (AF7 for USART2) */
    uint32_t moder = REG32(GPIOA_BASE + GPIO_MODER_OFFSET);
    moder &= ~((3 << (2 * 2)) | (3 << (3 * 2)));
    moder |= ((2 << (2 * 2)) | (2 << (3 * 2)));  /* AF mode */
    REG32(GPIOA_BASE + GPIO_MODER_OFFSET) = moder;

    uint32_t afrl = REG32(GPIOA_BASE + GPIO_AFRL_OFFSET);
    afrl &= ~((0xF << (2 * 4)) | (0xF << (3 * 4)));
    afrl |= ((7 << (2 * 4)) | (7 << (3 * 4)));    /* AF7 */
    REG32(GPIOA_BASE + GPIO_AFRL_OFFSET) = afrl;

    /* Configure USART2 */
    REG32(DIAG_UART_BASE + USART_CR1_OFFSET) = 0; /* Disable USART */

    /* Set baud rate */
    uint32_t brr = (SYSTEM_CLOCK_HZ + (DIAG_UART_BAUDRATE / 2)) / DIAG_UART_BAUDRATE;
    REG32(DIAG_UART_BASE + USART_BRR_OFFSET) = brr;

    /* 8N1, enable TX, RX, and USART */
    REG32(DIAG_UART_BASE + USART_CR1_OFFSET) = (1 << 13) | (1 << 3) | (1 << 2);
}

static void diag_uart_putchar(char c)
{
    while (!(REG32(DIAG_UART_BASE + USART_SR_OFFSET) & (1 << 7)))
        ;  /* Wait for TXE */
    REG32(DIAG_UART_BASE + USART_DR_OFFSET) = (uint32_t)c;
}

static bool diag_uart_rx_ready(void)
{
    return (REG32(DIAG_UART_BASE + USART_SR_OFFSET) & (1 << 5)) != 0;
}

static char diag_uart_getchar(void)
{
    return (char)(REG32(DIAG_UART_BASE + USART_DR_OFFSET) & 0xFF);
}

static void diag_print(const char *str)
{
    while (*str) {
        if (*str == '\n')
            diag_uart_putchar('\r');
        diag_uart_putchar(*str++);
    }
}

static void diag_print_hex32(uint32_t val)
{
    char buf[12];
    const char hex[] = "0123456789ABCDEF";
    buf[0] = '0';
    buf[1] = 'x';
    for (int i = 7; i >= 0; i--) {
        buf[2 + (7 - i)] = hex[(val >> (i * 4)) & 0xF];
    }
    buf[10] = '\0';
    diag_print(buf);
}

static void diag_print_hex8(uint8_t val)
{
    char buf[5];
    const char hex[] = "0123456789ABCDEF";
    buf[0] = '0';
    buf[1] = 'x';
    buf[2] = hex[(val >> 4) & 0xF];
    buf[3] = hex[val & 0xF];
    buf[4] = '\0';
    diag_print(buf);
}

static void diag_print_dec(uint32_t val)
{
    char buf[12];
    int pos = 0;
    if (val == 0) {
        diag_print("0");
        return;
    }
    while (val > 0) {
        buf[pos++] = '0' + (val % 10);
        val /= 10;
    }
    /* Reverse */
    for (int i = 0; i < pos / 2; i++) {
        char tmp = buf[i];
        buf[i] = buf[pos - 1 - i];
        buf[pos - 1 - i] = tmp;
    }
    buf[pos] = '\0';
    diag_print(buf);
}

/* ============================================================
 * Audit Log Implementation
 * ============================================================ */

static void audit_log_event(audit_event_type_t event, const char *detail)
{
    audit_log_t *log = &g_diag_state.audit_log;
    audit_log_entry_t *entry = &log->entries[log->head];

    entry->timestamp = diag_get_tick_sec();
    entry->event = event;
    if (detail) {
        strncpy(entry->detail, detail, sizeof(entry->detail) - 1);
        entry->detail[sizeof(entry->detail) - 1] = '\0';
    } else {
        entry->detail[0] = '\0';
    }

    log->head = (log->head + 1) % AUDIT_LOG_MAX_ENTRIES;
    if (log->count < AUDIT_LOG_MAX_ENTRIES)
        log->count++;
}

/* ============================================================
 * Memory region access validation
 * ============================================================ */

static bool is_address_in_allowed_region(uint32_t addr, uint32_t size, bool need_dump)
{
    uint32_t end_addr = addr + size - 1;

    /* Overflow check */
    if (end_addr < addr)
        return false;

    for (size_t i = 0; i < NUM_ALLOWED_REGIONS; i++) {
        const memory_region_t *region = &allowed_regions[i];
        if (addr >= region->start && end_addr <= region->end) {
            if (need_dump)
                return region->allow_dump;
            return region->allow_read;
        }
    }
    return false;
}

/* ============================================================
 * JTAG Configuration - SECURE
 * 
 * JTAG is DISABLED in production by default.
 * Can only be temporarily enabled with elevated authentication
 * and automatically re-disables after timeout.
 * ============================================================ */

typedef struct {
    bool enabled;
    uint32_t enable_tick;
    uint32_t timeout_sec;
} jtag_state_t;

static jtag_state_t g_jtag_state = { .enabled = false, .timeout_sec = 300 };

static void jtag_disable(void)
{
    /* Disable JTAG pins - release as GPIO */
    /* On STM32: disable debug port in sleep/standby modes */
    REG32(DBGMCU_BASE + DBGMCU_CR_OFFSET) &= ~(0x7);

    /* Optionally: configure JTAG pins (PA13-PA15, PB3-PB4) as GPIO
     * to prevent JTAG attachment */
    /* In a real product, consider using RDP level 1 or option byte
     * protection to hardware-disable JTAG permanently for
     * highest security. */

    g_jtag_state.enabled = false;
    diag_print("[JTAG] Debug port DISABLED\n");
}

static bool jtag_enable_temporary(uint32_t timeout_sec)
{
    if (g_diag_state.auth_level < AUTH_LEVEL_ELEVATED) {
        diag_print("[JTAG] ERROR: Elevated authentication required\n");
        audit_log_event(AUDIT_JTAG_UNLOCK_ATTEMPT, "denied:auth");
        return false;
    }

#if PRODUCTION_BUILD
    /* In production, require additional confirmation */
    diag_print("[JTAG] WARNING: Enabling JTAG on production device\n");
    diag_print("[JTAG] This will be logged and auto-disable after ");
    diag_print_dec(timeout_sec);
    diag_print(" seconds\n");
#endif

    /* Enable JTAG-DP and SW-DP */
    REG32(DBGMCU_BASE + DBGMCU_CR_OFFSET) |= (1 << 5) | (1 << 6) | (1 << 7);

    /* Reconfigure PA13 (SWDIO), PA14 (SWCLK) as alternate function */
    uint32_t moder = REG32(GPIOA_BASE + GPIO_MODER_OFFSET);
    moder &= ~((3 << (13 * 2)) | (3 << (14 * 2)));
    moder |= ((2 << (13 * 2)) | (2 << (14 * 2)));
    REG32(GPIOA_BASE + GPIO_MODER_OFFSET) = moder;

    g_jtag_state.enabled = true;
    g_jtag_state.enable_tick = diag_get_tick_sec();
    g_jtag_state.timeout_sec = (timeout_sec > 0 && timeout_sec <= 3600) ? timeout_sec : 300;

    audit_log_event(AUDIT_JTAG_UNLOCK_ATTEMPT, "granted");
    diag_print("[JTAG] Debug port ENABLED (temporary)\n");
    return true;
}

static void jtag_check_timeout(void)
{
    if (g_jtag_state.enabled) {
        uint32_t elapsed = diag_get_tick_sec() - g_jtag_state.enable_tick;
        if (elapsed >= g_jtag_state.timeout_sec) {
            jtag_disable();
            diag_print("[JTAG] Auto-disabled after timeout\n");
            audit_log_event(AUDIT_JTAG_UNLOCK_ATTEMPT, "timeout_disable");
        }
    }
}

/* ============================================================
 * Simple hex string parser
 * ============================================================ */

static bool parse_hex32(const char *str, uint32_t *out)
{
    uint32_t val = 0;
    if (str[0] == '0' && (str[1] == 'x' || str[1] == 'X'))
        str += 2;

    int digits = 0;
    while (*str && digits < 8) {
        char c = *str++;
        uint8_t nibble;
        if (c >= '0' && c <= '9')
            nibble = c - '0';
        else if (c >= 'a' && c <= 'f')
            nibble = 10 + (c - 'a');
        else if (c >= 'A' && c <= 'F')
            nibble = 10 + (c - 'A');
        else
            return false;
        val = (val << 4) | nibble;
        digits++;
    }
    if (digits == 0)
        return false;
    *out = val;
    return true;
}

static bool parse_dec32(const char *str, uint32_t *out)
{
    uint32_t val = 0;
    if (!*str) return false;
    while (*str) {
        if (*str < '0' || *str > '9') return false;
        uint32_t new_val = val * 10 + (*str - '0');
        if (new_val < val) return false; /* overflow */
        val = new_val;
        str++;
    }
    *out = val;
    return true;
}

/* ============================================================
 * Authentication: Challenge-Response Protocol
 * 
 * Flow:
 * 1. User sends "auth basic" or "auth elevated"
 * 2. Device responds with a random challenge (nonce)
 * 3. User computes HMAC-SHA256(service_key, challenge) off-device
 *    using a secure service tool
 * 4. User sends "auth_response <hex-encoded-hmac>"
 * 5. Device verifies and grants session
 * ============================================================ */

static void cmd_auth_start(const char *level_str)
{
    uint32_t now = diag_get_tick_sec();

    /* Check lockout */
    if (g_diag_state.auth_attempts >= MAX_AUTH_ATTEMPTS) {
        if (now < g_diag_state.lockout_until_tick) {
            diag_print("ERROR: Account locked. Try again in ");
            diag_print_dec(g_diag_state.lockout_until_tick - now);
            diag_print(" seconds\n");
            return;
        }
        /* Lockout expired */
        g_diag_state.auth_attempts = 0;
    }

    auth_level_t requested;
    if (strcmp(level_str, "basic") == 0) {
        requested = AUTH_LEVEL_BASIC;
    } else if (strcmp(level_str, "elevated") == 0) {
        requested = AUTH_LEVEL_ELEVATED;
    } else {
        diag_print("Usage: auth <basic|elevated>\n");
        return;
    }

    /* Generate challenge */
    g_auth_challenge = hw_rng_get_random();
    g_challenge_pending = true;

    diag_print("CHALLENGE: ");
    diag_print_hex32(g_auth_challenge);
    diag_print("\nCompute HMAC-SHA256(service_key, challenge) and send:\n");
    diag_print("  auth_response <hex_hmac>\n");

    (void)requested; /* Will be checked when response arrives */
}

static void cmd_auth_response(const char *hmac_hex, const char *level_str)
{
    if (!g_challenge_pending) {
        diag_print("ERROR: No challenge pending. Start with 'auth <level>'\n");
        return;
    }

    g_challenge_pending = false;

    /* Parse the HMAC from hex string */
    uint8_t received_mac[32];
    size_t mac_len = 0;
    const char *p = hmac_hex;
    if (p[0] == '0' && (p[1] == 'x' || p[1] == 'X'))
        p += 2;

    while (*p && mac_len < 32) {
        uint8_t hi, lo;
        char c1 = *p++;
        if (!*p) break;
        char c2 = *p++;

        if (c1 >= '0' && c1 <= '9') hi = c1 - '0';
        else if (c1 >= 'a' && c1 <= 'f') hi = 10 + c1 - 'a';
        else if (c1 >= 'A' && c1 <= 'F') hi = 10 + c1 - 'A';
        else { diag_print("ERROR: Invalid hex\n"); return; }

        if (c2 >= '0' && c2 <= '9') lo = c2 - '0';
        else if (c2 >= 'a' && c2 <= 'f') lo = 10 + c2 - 'a';
        else if (c2 >= 'A' && c2 <= 'F') lo = 10 + c2 - 'A';
        else { diag_print("ERROR: Invalid hex\n"); return; }

        received_mac[mac_len++] = (hi << 4) | lo;
    }

    if (mac_len != 32) {
        diag_print("ERROR: Expected 32-byte HMAC-SHA256\n");
        g_diag_state.auth_attempts++;
        audit_log_event(AUDIT_AUTH_FAILURE, "bad_mac_len");
        return;
    }

    /* Verify HMAC */
    size_t key_len;
    const uint8_t *service_key = secure_get_service_key(&key_len);
    uint8_t challenge_bytes[4];
    challenge_bytes[0] = (g_auth_challenge >> 24) & 0xFF;
    challenge_bytes[1] = (g_auth_challenge >> 16) & 0xFF;
    challenge_bytes[2] = (g_auth_challenge >> 8) & 0xFF;
    challenge_bytes[3] = g_auth_challenge & 0xFF;

    if (!hmac_sha256_verify(service_key, key_len,
                            challenge_bytes, 4,
                            received_mac, 32)) {
        g_diag_state.auth_attempts++;
        diag_print("ERROR: Authentication failed (");
        diag_print_dec(MAX_AUTH_ATTEMPTS - g_diag_state.auth_attempts);
        diag_print(" attempts remaining)\n");
        audit_log_event(AUDIT_AUTH_FAILURE, "hmac_mismatch");

        if (g_diag_state.auth_attempts >= MAX_AUTH_ATTEMPTS) {
            g_diag_state.lockout_until_tick = diag_get_tick_sec() + AUTH_LOCKOUT_SEC;
            diag_print("LOCKED OUT for ");
            diag_print_dec(AUTH_LOCKOUT_SEC);
            diag_print(" seconds\n");
            audit_log_event(AUDIT_LOCKOUT, "max_attempts");
        }
        return;
    }

    /* Authentication successful */
    auth_level_t requested = AUTH_LEVEL_BASIC;
    if (level_str && strcmp(level_str, "elevated") == 0)
        requested = AUTH_LEVEL_ELEVATED;

    g_diag_state.auth_level = requested;
    g_diag_state.session_active = true;
    g_diag_state.session_start_tick = diag_get_tick_sec();
    g_diag_state.last_activity_tick = diag_get_tick_sec();
    g_diag_state.auth_attempts = 0;

    diag_print("OK: Authenticated at level ");
    diag_print(requested == AUTH_LEVEL_ELEVATED ? "ELEVATED" : "BASIC");
    diag_print("\nSession timeout: ");
    diag_print_dec(SESSION_TIMEOUT_SEC);
    diag_print(" seconds\n");

    audit_log_event(AUDIT_AUTH_SUCCESS,
                    requested == AUTH_LEVEL_ELEVATED ? "elevated" : "basic");
}

static bool check_auth(auth_level_t required)
{
    if (!g_diag_state.session_active || g_diag_state.auth_level < required) {
        diag_print("ERROR: Insufficient privileges. Required: ");
        diag_print(required == AUTH_LEVEL_ELEVATED ? "ELEVATED" : "BASIC");
        diag_print("\nUse 'auth <basic|elevated>' to authenticate\n");
        audit_log_event(AUDIT_UNAUTHORIZED_ACCESS, "insufficient_auth");
        return false;
    }
    /* Check session timeout */
    uint32_t elapsed = diag_get_tick_sec() - g_diag_state.last_activity_tick;
    if (elapsed > SESSION_TIMEOUT_SEC) {
        diag_print("ERROR: Session expired. Re-authenticate.\n");
        g_diag_state.session_active = false;
        g_diag_state.auth_level = AUTH_LEVEL_NONE;
        audit_log_event(AUDIT_SESSION_TIMEOUT, NULL);
        return false;
    }
    g_diag_state.last_activity_tick = diag_get_tick_sec();
    return true;
}

/* ============================================================
 * Device Configuration Store (placeholder - adapt to your system)
 * ============================================================ */

typedef struct {
    char device_id[32];
    char firmware_version[16];
    uint32_t sensor_interval_ms;
    uint32_t uptime_sec;
    uint32_t error_count;
    float last_reading;
    char network_status[16];
    int8_t rssi_dbm;
    float battery_voltage;
    char hw_revision[8];
    /* Sensitive fields - never exposed via diagnostic console */
    char wifi_password[64];
    char api_key[64];
    uint8_t encryption_key[32];
} device_config_t;

/* Extern: provided by your application */
extern const device_config_t *app_get_config(void);
extern uint32_t app_get_uptime_sec(void);

static void print_config_value(const char *key)
{
    const device_config_t *cfg = app_get_config();
    if (!cfg) {
        diag_print("ERROR: Config unavailable\n");
        return;
    }

    /* Check ACL */
    bool found = false;
    for (size_t i = 0; i < NUM_CONFIG_ACL; i++) {
        if (strcmp(config_acl[i].key, key) == 0) {
            found = true;
            if (config_acl[i].is_sensitive &&
                g_diag_state.auth_level < AUTH_LEVEL_ELEVATED) {
                diag_print("ERROR: Elevated auth required for '");
                diag_print(key);
                diag_print("'\n");
                return;
            }
            break;
        }
    }

    if (!found) {
        diag_print("ERROR: Config key '");
        diag_print(key);
        diag_print("' not accessible\n");
        return;
    }

    diag_print(key);
    diag_print(" = ");

    if (strcmp(key, "device_id") == 0) {
        diag_print(cfg->device_id);
    } else if (strcmp(key, "firmware_version") == 0) {
        diag_print(cfg->firmware_version);
    } else if (strcmp(key, "sensor_interval") == 0) {
        diag_print_dec(cfg->sensor_interval_ms);
        diag_print(" ms");
    } else if (strcmp(key, "uptime") == 0) {
        diag_print_dec(app_get_uptime_sec());
        diag_print(" sec");
    } else if (strcmp(key, "error_count") == 0) {
        diag_print_dec(cfg->error_count);
    } else if (strcmp(key, "network_status") == 0) {
        diag_print(cfg->network_status);
    } else if (strcmp(key, "hw_revision") == 0) {
        diag_print(cfg->hw_revision);
    } else if (strcmp(key, "rssi") == 0) {
        diag_print_dec((uint32_t)(int32_t)cfg->rssi_dbm);
        diag_print(" dBm");
    } else {
        diag_print("<no formatter>");
    }
    diag_print("\n");
}

/* ============================================================
 * Command Handlers
 * ============================================================ */

static void cmd_help(void)
{
    diag_print("\n=== IoT Sensor Diagnostic Console ===\n");
    diag_print("Authentication:\n");
    diag_print("  auth <basic|elevated>    - Start authentication\n");
    diag_print("  auth_response <hmac>     - Complete authentication\n");
    diag_print("  logout                   - End session\n\n");
    diag_print("Basic commands (require AUTH_LEVEL_BASIC):\n");
    diag_print("  help                     - Show this help\n");
    diag_print("  status                   - Device status summary\n");
    diag_print("  get_config <key>         - Read config value\n");
    diag_print("  get_config list          - List available config keys\n");
    diag_print("  audit_log                - View recent audit events\n\n");
    diag_print("Elevated commands (require AUTH_LEVEL_ELEVATED):\n");
    diag_print("  dump_memory <addr> <len> - Hex dump (allowed regions only)\n");
    diag_print("  read_flash <addr> <len>  - Read flash (allowed regions only)\n");
    diag_print("  read_reg <addr>          - Read 32-bit register\n");
    diag_print("  regions                  - List allowed memory regions\n");
    diag_print("  jtag_enable [timeout_s]  - Temporarily enable JTAG\n");
    diag_print("  jtag_disable             - Disable JTAG immediately\n");
    diag_print("  jtag_status              - Show JTAG state\n\n");
}

static void cmd_status(void)
{
    if (!check_auth(AUTH_LEVEL_BASIC)) return;

    const device_config_t *cfg = app_get_config();

    diag_print("\n--- Device Status ---\n");
    diag_print("Device ID:    ");
    diag_print(cfg ? cfg->device_id : "N/A");
    diag_print("\nFW Version:   ");
    diag_print(cfg ? cfg->firmware_version : "N/A");
    diag_print("\nUptime:       ");
    diag_print_dec(app_get_uptime_sec());
    diag_print(" sec\nError Count:  ");
    diag_print_dec(cfg ? cfg->error_count : 0);
    diag_print("\nAuth Level:   ");
    diag_print_dec((uint32_t)g_diag_state.auth_level);
    diag_print("\nJTAG:         ");
    diag_print(g_jtag_state.enabled ? "ENABLED" : "DISABLED");
    diag_print("\n");

    audit_log_event(AUDIT_CMD_EXECUTED, "status");
}

static void cmd_get_config(int argc, char **argv)
{
    if (!check_auth(AUTH_LEVEL_BASIC)) return;

    if (argc < 2) {
        diag_print("Usage: get_config <key|list|all>\n");
        return;
    }

    if (strcmp(argv[1], "list") == 0) {
        diag_print("Available config keys:\n");
        for (size_t i = 0; i < NUM_CONFIG_ACL; i++) {
            diag_print("  ");
            diag_print(config_acl[i].key);
            if (config_acl[i].is_sensitive)
                diag_print(" [elevated]");
            diag_print("\n");
        }
        return;
    }

    if (strcmp(argv[1], "all") == 0) {
        for (size_t i = 0; i < NUM_CONFIG_ACL; i++) {
            if (!config_acl[i].is_sensitive ||
                g_diag_state.auth_level >= AUTH_LEVEL_ELEVATED) {
                print_config_value(config_acl[i].key);
            }
        }
        return;
    }

    print_config_value(argv[1]);
    audit_log_event(AUDIT_CMD_EXECUTED, "get_config");
}

static void cmd_dump_memory(int argc, char **argv)
{
    if (!check_auth(AUTH_LEVEL_ELEVATED)) return;

    if (argc < 3) {
        diag_print("Usage: dump_memory <hex_addr> <length>\n");
        diag_print("  Max length: ");
        diag_print_dec(MAX_DUMP_SIZE);
        diag_print(" bytes\n");
        return;
    }

    uint32_t addr, length;
    if (!parse_hex32(argv[1], &addr)) {
        diag_print("ERROR: Invalid address\n");
        return;
    }
    if (!parse_dec32(argv[2], &length) && !parse_hex32(argv[2], &length)) {
        diag_print("ERROR: Invalid length\n");
        return;
    }
    if (length == 0 || length > MAX_DUMP_SIZE) {
        diag_print("ERROR: Length must be 1-");
        diag_print_dec(MAX_DUMP_SIZE);
        diag_print("\n");
        return;
    }

    /* Enforce alignment */
    addr &= ~0x3UL;

    /* Validate against allowed regions */
    if (!is_address_in_allowed_region(addr, length, true)) {
        diag_print("ERROR: Address range not in allowed dump regions\n");
        diag_print("Use 'regions' to see allowed addresses\n");
        audit_log_event(AUDIT_UNAUTHORIZED_ACCESS, "dump_denied");
        return;
    }

    diag_print("\nMemory dump at ");
    diag_print_hex32(addr);
    diag_print(", ");
    diag_print_dec(length);
    diag_print(" bytes:\n");

    const uint8_t *ptr = (const uint8_t *)addr;
    for (uint32_t i = 0; i < length; i += 16) {
        diag_print_hex32(addr + i);
        diag_print(": ");
        for (uint32_t j = 0; j < 16 && (i + j) < length; j++) {
            diag_print_hex8(ptr[i + j]);
            diag_uart_putchar(' ');
        }
        /* ASCII representation */
        diag_print(" |");
        for (uint32_t j = 0; j < 16 && (i + j) < length; j++) {
            char c = (char)ptr[i + j];
            diag_uart_putchar((c >= 0x20 && c < 0x7F) ? c : '.');
        }
        diag_print("|\n");
    }

    audit_log_event(AUDIT_CMD_EXECUTED, "dump_memory");
}

static void cmd_read_flash(int argc, char **argv)
{
    if (!check_auth(AUTH_LEVEL_ELEVATED)) return;

    if (argc < 3) {
        diag_print("Usage: read_flash <hex_addr> <length>\n");
        return;
    }

    uint32_t addr, length;
    if (!parse_hex32(argv[1], &addr) || !parse_dec32(argv[2], &length)) {
        diag_print("ERROR: Invalid parameters\n");
        return;
    }

    if (length == 0 || length > MAX_DUMP_SIZE) {
        diag_print("ERROR: Length must be 1-");
        diag_print_dec(MAX_DUMP_SIZE);
        diag_print("\n");
        return;
    }

    /* Validate flash address is in allowed region */
    if (!is_address_in_allowed_region(addr, length, true)) {
        diag_print("ERROR: Flash address not in allowed read regions\n");
        diag_print("Note: Bootloader and key storage areas are protected\n");
        audit_log_event(AUDIT_UNAUTHORIZED_ACCESS, "flash_denied");
        return;
    }

    diag_print("\nFlash read at ");
    diag_print_hex32(addr);
    diag_print(":\n");

    const uint8_t *ptr = (const uint8_t *)addr;
    for (uint32_t i = 0; i < length; i += 16) {
        diag_print_hex32(addr + i);
        diag_print(": ");
        for (uint32_t j = 0; j < 16 && (i + j) < length; j++) {
            diag_print_hex8(ptr[i + j]);
            diag_uart_putchar(' ');
        }
        diag_print("\n");
    }

    audit_log_event(AUDIT_CMD_EXECUTED, "read_flash");
}

static void cmd_read_reg(int argc, char **argv)
{
    if (!check_auth(AUTH_LEVEL_ELEVATED)) return;

    if (argc < 2) {
        diag_print("Usage: read_reg <hex_addr>\n");
        return;
    }

    uint32_t addr;
    if (!parse_hex32(argv[1], &addr)) {
        diag_print("ERROR: Invalid address\n");
        return;
    }

    /* Must be aligned */
    addr &= ~0x3UL;

    if (!is_address_in_allowed_region(addr, 4, false)) {
        diag_print("ERROR: Register address not in allowed regions\n");
        audit_log_event(AUDIT_UNAUTHORIZED_ACCESS, "reg_denied");
        return;
    }

    uint32_t val = REG32(addr);
    diag_print("[");
    diag_print_hex32(addr);
    diag_print("] = ");
    diag_print_hex32(val);
    diag_print("\n");

    audit_log_event(AUDIT_CMD_EXECUTED, "read_reg");
}

static void cmd_regions(void)
{
    if (!check_auth(AUTH_LEVEL_BASIC)) return;

    diag_print("\nAllowed memory regions:\n");
    diag_print("  %-16s %-12s %-12s Read  Dump\n");
    for (size_t i = 0; i < NUM_ALLOWED_REGIONS; i++) {
        const memory_region_t *r = &allowed_regions[i];
        diag_print("  ");
        diag_print(r->name);
        diag_print("\t");
        diag_print_hex32(r->start);
        diag_print(" - ");
        diag_print_hex32(r->end);
        diag_print("  ");
        diag_print(r->allow_read ? "YES" : "NO ");
        diag_print("   ");
        diag_print(r->allow_dump ? "YES" : "NO ");
        diag_print("\n");
    }
}

static void cmd_jtag_enable(int argc, char **argv)
{
    if (!check_auth(AUTH_LEVEL_ELEVATED)) return;

    uint32_t timeout = 300; /* default 5 minutes */
    if (argc >= 2) {
        if (!parse_dec32(argv[1], &timeout) || timeout == 0 || timeout > 3600) {
            diag_print("ERROR: Timeout must be 1-3600 seconds\n");
            return;
        }
    }

    jtag_enable_temporary(timeout);
}

static void cmd_jtag_disable_handler(void)
{
    if (!check_auth(AUTH_LEVEL_BASIC)) return;
    jtag_disable();
}

static void cmd_jtag_status(void)
{
    if (!check_auth(AUTH_LEVEL_BASIC)) return;

    diag_print("JTAG Status: ");
    diag_print(g_jtag_state.enabled ? "ENABLED" : "DISABLED");
    if (g_jtag_state.enabled) {
        uint32_t remaining = g_jtag_state.timeout_sec -
                             (diag_get_tick_sec() - g_jtag_state.enable_tick);
        diag_print(" (auto-disable in ");
        diag_print_dec(remaining);
        diag_print(" sec)");
    }
    diag_print("\n");
}

static void cmd_audit_log(void)
{
    if (!check_auth(AUTH_LEVEL_BASIC)) return;

    audit_log_t *log = &g_diag_state.audit_log;
    if (log->count == 0) {
        diag_print("Audit log is empty\n");
        return;
    }

    diag_print("\n--- Audit Log (");
    diag_print_dec(log->count);
    diag_print(" entries) ---\n");

    const char *event_names[] = {
        "AUTH_OK", "AUTH_FAIL", "CMD_EXEC", "TIMEOUT",
        "LOCKOUT", "JTAG_ATTEMPT", "UNAUTH_ACCESS"
    };

    uint16_t start;
    if (log->count >= AUDIT_LOG_MAX_ENTRIES) {
        start = log->head; /* Oldest entry */
    } else {
        start = 0;
    }

    for (uint16_t i = 0; i < log->count; i++) {
        uint16_t idx = (start + i) % AUDIT_LOG_MAX_ENTRIES;
        audit_log_entry_t *e = &log->entries[idx];

        diag_print("[T+");
        diag_print_dec(e->timestamp);
        diag_print("s] ");
        if (e->event < sizeof(event_names) / sizeof(event_names[0]))
            diag_print(event_names[e->event]);
        else
            diag_print("UNKNOWN");
        if (e->detail[0]) {
            diag_print(": ");
            diag_print(e->detail);
        }
        diag_print("\n");
    }
}

static void cmd_logout(void)
{
    if (g_diag_state.session_active) {
        g_diag_state.session_active = false;
        g_diag_state.auth_level = AUTH_LEVEL_NONE;
        diag_print("Session ended.\n");
        audit_log_event(AUDIT_CMD_EXECUTED, "logout");
    } else {
        diag_print("No active session.\n");
    }
}

/* ============================================================
 * Command Parser and Dispatcher
 * ============================================================ */

static void parse_and_execute(char *cmd_line)
{
    char *argv[MAX_CMD_ARGS];
    int argc = 0;

    /* Tokenize */
    char *p = cmd_line;
    while (*p && argc < MAX_CMD_ARGS) {
        /* Skip whitespace */
        while (*p == ' ' || *p == '\t') p++;
        if (*p == '\0') break;
        argv[argc++] = p;
        while (*p && *p != ' ' && *p != '\t') p++;
        if (*p) *p++ = '\0';
    }

    if (argc == 0) return;

    /* Command dispatch */
    const char *cmd = argv[0];

    /* Unauthenticated commands */
    if (strcmp(cmd, "help") == 0 || strcmp(cmd, "?") == 0) {
        cmd_help();
    }
    else if (strcmp(cmd, "auth") == 0) {
        if (argc >= 2)
            cmd_auth_start(argv[1]);
        else
            diag_print("Usage: auth <basic|elevated>\n");
    }
    else if (strcmp(cmd, "auth_response") == 0) {
        if (argc >= 2)
            cmd_auth_response(argv[1], argc >= 3 ? argv[2] : "basic");
        else
            diag_print("Usage: auth_response <hmac_hex> [level]\n");
    }
    else if (strcmp(cmd, "logout") == 0) {
        cmd_logout();
    }
    /* Authenticated commands */
    else if (strcmp(cmd, "status") == 0) {
        cmd_status();
    }
    else if (strcmp(cmd, "get_config") == 0) {
        cmd_get_config(argc, argv);
    }
    else if (strcmp(cmd, "dump_memory") == 0) {
        cmd_dump_memory(argc, argv);
    }
    else if (strcmp(cmd, "read_flash") == 0) {
        cmd_read_flash(argc, argv);
    }
    else if (strcmp(cmd, "read_reg") == 0) {
        cmd_read_reg(argc, argv);
    }
    else if (strcmp(cmd, "regions") == 0) {
        cmd_regions();
    }
    else if (strcmp(cmd, "jtag_enable") == 0) {
        cmd_jtag_enable(argc, argv);
    }
    else if (strcmp(cmd, "jtag_disable") == 0) {
        cmd_jtag_disable_handler();
    }
    else if (strcmp(cmd, "jtag_status") == 0) {
        cmd_jtag_status();
    }
    else if (strcmp(cmd, "audit_log") == 0) {
        cmd_audit_log();
    }
    else {
        diag_print("Unknown command: '");
        diag_print(cmd);
        diag_print("'. Type 'help' for commands.\n");
    }
}

/* ============================================================
 * Public API
 * ============================================================ */

/**
 * Initialize the diagnostic console.
 * Call once during system startup.
 */
void diag_console_init(void)
{
    memset(&g_diag_state, 0, sizeof(g_diag_state));
    g_diag_state.auth_level = AUTH_LEVEL_NONE;
    g_diag_state.session_active = false;
    g_challenge_pending = false;

    diag_uart_init();

    /* JTAG disabled by default on production builds */
#if PRODUCTION_BUILD
    jtag_disable();
#endif

    g_diag_state.initialized = true;

    diag_print("\n\n");
    diag_print("========================================\n");
    diag_print("  Industrial IoT Sensor - Diag Console\n");
    diag_print("  PRODUCTION BUILD - Auth Required\n");
    diag_print("========================================\n");
    diag_print("Type 'help' for commands.\n");
    diag_print("Authenticate with 'auth <basic|elevated>'\n\n");
    diag_print("diag> ");

    audit_log_event(AUDIT_CMD_EXECUTED, "console_init");
}

/**
 * Process incoming characters from the diagnostic UART.
 * Call this from your main loop or UART interrupt handler.
 * Non-blocking: processes available characters and returns.
 */
void diag_console_process(void)
{
    if (!g_diag_state.initialized)
        return;

    /* Check JTAG auto-disable timeout */
    jtag_check_timeout();

    /* Check session timeout */
    if (g_diag_state.session_active) {
        uint32_t elapsed = diag_get_tick_sec() - g_diag_state.last_activity_tick;
        if (elapsed > SESSION_TIMEOUT_SEC) {
            diag_print("\n[Session expired]\n");
            g_diag_state.session_active = false;
            g_diag_state.auth_level = AUTH_LEVEL_NONE;
            audit_log_event(AUDIT_SESSION_TIMEOUT, NULL);
            diag_print("diag> ");
        }
    }

    /* Process received characters */
    while (diag_uart_rx_ready()) {
        char c = diag_uart_getchar();

        if (c == '\r' || c == '\n') {
            diag_uart_putchar('\r');
            diag_uart_putchar('\n');

            if (g_diag_state.cmd_pos > 0) {
                g_diag_state.cmd_buffer[g_diag_state.cmd_pos] = '\0';
                parse_and_execute(g_diag_state.cmd_buffer);
                g_diag_state.cmd_pos = 0;
            }
            diag_print("diag> ");
        }
        else if (c == '\b' || c == 0x7F) {  /* Backspace / DEL */
            if (g_diag_state.cmd_pos > 0) {
                g_diag_state.cmd_pos--;
                diag_print("\b \b");
            }
        }
        else if (c == 0x03) {  /* Ctrl+C */
            diag_print("^C\n");
            g_diag_state.cmd_pos = 0;
            diag_print("diag> ");
        }
        else if (c >= 0x20 && c < 0x7F) {
            if (g_diag_state.cmd_pos < CMD_BUFFER_SIZE - 1) {
                g_diag_state.cmd_buffer[g_diag_state.cmd_pos++] = c;
                diag_uart_putchar(c);
            }
        }
        /* Ignore other control characters */
    }
}

/**
 * Check if the diagnostic console is currently authenticated.
 * Useful for other system components to gate behavior.
 */
bool diag_console_is_authenticated(void)
{
    return g_diag_state.session_active;
}

/**
 * Force-terminate diagnostic session (e.g., on tamper detection).
 */
void diag_console_force_logout(void)
{
    g_diag_state.session_active = false;
    g_diag_state.auth_level = AUTH_LEVEL_NONE;
    g_challenge_pending = false;
    if (g_jtag_state.enabled)
        jtag_disable();
    audit_log_event(AUDIT_CMD_EXECUTED, "force_logout");
}

#endif /* DIAG_CONSOLE_H */

/*
 * ============================================================
 * Example main() showing integration
 * ============================================================
 */

/*
#include "diag_console.h"

volatile uint32_t g_system_tick_ms = 0;

void SysTick_Handler(void) {
    g_system_tick_ms++;
}

int main(void) {
    // System init, clocks, peripherals...
    
    diag_console_init();
    
    while (1) {
        // Your main application tasks
        app_sensor_task();
        app_network_task();
        
        // Process diagnostic console (non-blocking)
        diag_console_process();
    }
}
*/