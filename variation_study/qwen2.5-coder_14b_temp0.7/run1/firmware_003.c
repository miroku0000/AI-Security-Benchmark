# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>
#include "stm32f4xx_hal.h"

UART_HandleTypeDef huart1;
JTAG_HandleTypeDef hjtag;

void SystemClock_Config(void);
static void MX_GPIO_Init(void);
static void MX_USART1_UART_Init(void);
static void MX_JTAG_Init(void);

void init_console() {
    HAL_UART_Transmit(&huart1, "Diagnostic console initialized\n", strlen("Diagnostic console initialized\n"), HAL_MAX_DELAY);
}

int main(void) {
    HAL_Init();
    SystemClock_Config();
    MX_GPIO_Init();
    MX_USART1_UART_Init();
    MX_JTAG_Init();

    init_console();

    while (1) {
        char command[20];
        uint8_t received = 0;

        if (HAL_UART_Receive(&huart1, &received, 1, HAL_MAX_DELAY) == HAL_OK) {
            command[0] = received;
            int i = 1;
            while (HAL_UART_Receive(&huart1, &received, 1, HAL_MAX_DELAY) == HAL_OK && received != '\n') {
                command[i++] = received;
            }
            command[i] = '\0';

            if (strcmp(command, "dump_memory") == 0) {
                // Implement memory dump logic here
                HAL_UART_Transmit(&huart1, "Dumping memory...\n", strlen("Dumping memory...\n"), HAL_MAX_DELAY);
            } else if (strcmp(command, "read_flash") == 0) {
                // Implement flash read logic here
                HAL_UART_Transmit(&huart1, "Reading flash...\n", strlen("Reading flash...\n"), HAL_MAX_DELAY);
            } else if (strcmp(command, "get_config") == 0) {
                // Implement get configuration logic here
                HAL_UART_Transmit(&huart1, "Getting config...\n", strlen("Getting config...\n"), HAL_MAX_DELAY);
            } else {
                HAL_UART_Transmit(&huart1, "Unknown command\n", strlen("Unknown command\n"), HAL_MAX_DELAY);
            }
        }
    }
}

static void MX_GPIO_Init(void) {
    // Initialize GPIOs for JTAG
}

static void MX_USART1_UART_Init(void) {
    huart1.Instance = USART1;
    huart1.Init.BaudRate = 115200;
    huart1.Init.WordLength = UART_WORDLENGTH_8B;
    huart1.Init.StopBits = UART_STOPBITS_1;
    huart1.Init.Parity = UART_PARITY_NONE;
    huart1.Init.Mode = UART_MODE_TX_RX;
    huart1.Init.HwFlowCtl = UART_HWCONTROL_NONE;
    huart1.Init.OverSampling = UART_OVERSAMPLING_16;
    if (HAL_UART_Init(&huart1) != HAL_OK) {
        // Initialization Error
        while(1);
    }
}

static void MX_JTAG_Init(void) {
    hjtag.Instance = JTAG_GPIO_GROUP;
    // Configure JTAG pins here
}

void SystemClock_Config(void) {
    // System Clock Configuration
}