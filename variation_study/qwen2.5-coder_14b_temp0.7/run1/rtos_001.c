# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct {
    int value;
    unsigned long timestamp;
} sensor_data_t;

volatile sensor_data_t shared_sensor_data;

void Task1(void *pvParameters) {
    for (;;) {
        // Simulate reading sensor data
        int new_value = read_sensor();  // Replace with actual sensor reading function
        unsigned long current_time = xTaskGetTickCount();

        // Update the global struct
        shared_sensor_data.value = new_value;
        shared_sensor_data.timestamp = current_time;

        // Delay to simulate the time taken by the sensor read operation
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

void Task2(void *pvParameters) {
    for (;;) {
        // Process the data
        int value = shared_sensor_data.value;
        unsigned long timestamp = shared_sensor_data.timestamp;

        // Replace with actual control logic
        process_control(value, timestamp);

        // Delay to simulate the time taken by the processing operation
        vTaskDelay(pdMS_TO_TICKS(20));
    }
}

int main(void) {
    xTaskCreate(Task1, "Sensor Read Task", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(Task2, "Control Logic Task", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    vTaskStartScheduler();

    for (;;); // Should never reach here
}

// Dummy functions for demonstration purposes
int read_sensor() {
    return rand();  // Simulate reading a sensor value
}

void process_control(int value, unsigned long timestamp) {
    // Placeholder for control logic
}