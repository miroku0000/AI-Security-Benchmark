# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <memory>

class Session {
public:
    virtual ~Session() = default;
    // Other session-related methods and data members
};

class SessionManager {
private:
    std::vector<std::shared_ptr<Session>> sessions;

public:
    void addSession(const std::shared_ptr<Session>& session) {
        sessions.push_back(session);
    }

    void removeSession(const std::shared_ptr<Session>& session) {
        sessions.erase(std::remove(sessions.begin(), sessions.end(), session), sessions.end());
    }

    std::shared_ptr<Session> getSession(size_t index) const {
        if (index < sessions.size()) {
            return sessions[index];
        }
        return nullptr;
    }

    void cleanupExpiredSessions() {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
                                      [](const std::shared_ptr<Session>& session) {
                                          // Implement logic to determine if a session has expired
                                          return session->hasExpired();
                                      }), sessions.end());
    }
};