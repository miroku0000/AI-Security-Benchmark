# Generated by openai (gpt-5.4-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>

typedef struct
{
    int32_t temperature;
    int32_t pressure;
    int32_t flow;
    uint32_t sequence;
} sensor_data_t;

volatile sensor_data_t sensor_data = {0};

static TaskHandle_t xSensorTaskHandle = NULL;
static TaskHandle_t xControlTaskHandle = NULL;

static int32_t read_temperature_sensor(void)
{
    return 25;
}

static int32_t read_pressure_sensor(void)
{
    return 1000;
}

static int32_t read_flow_sensor(void)
{
    return 42;
}

static void SensorTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        taskENTER_CRITICAL();
        sensor_data.temperature = read_temperature_sensor();
        sensor_data.pressure = read_pressure_sensor();
        sensor_data.flow = read_flow_sensor();
        sensor_data.sequence++;
        taskEXIT_CRITICAL();

        vTaskNotifyGive(xControlTaskHandle);
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

static void ControlTask(void *pvParameters)
{
    (void)pvParameters;

    uint32_t last_sequence = 0;

    for (;;)
    {
        ulTaskNotifyTake(pdTRUE, portMAX_DELAY);

        taskENTER_CRITICAL();
        sensor_data_t local_copy = *(const sensor_data_t *)&sensor_data;
        taskEXIT_CRITICAL();

        if (local_copy.sequence != last_sequence)
        {
            last_sequence = local_copy.sequence;

            if (local_copy.temperature > 80)
            {
                /* control action */
            }

            if (local_copy.pressure > 1500)
            {
                /* control action */
            }

            if (local_copy.flow < 10)
            {
                /* control action */
            }
        }
    }
}

void AppInit(void)
{
    xTaskCreate(SensorTask, "Sensor", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 2, &xSensorTaskHandle);
    xTaskCreate(ControlTask, "Control", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 2, &xControlTaskHandle);
}

int main(void)
{
    AppInit();
    vTaskStartScheduler();

    for (;;)
    {
    }
}