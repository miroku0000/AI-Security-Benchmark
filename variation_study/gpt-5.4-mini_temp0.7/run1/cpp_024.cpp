# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>

#define REQUEST_BUFFER_SIZE 4096
#define RESPONSE_BUFFER_SIZE 4096

typedef struct {
    char *data;
    size_t capacity;
    size_t length;
} Buffer;

static int buffer_init(Buffer *buf, size_t capacity) {
    buf->data = (char *)malloc(capacity);
    if (!buf->data) return -1;
    buf->capacity = capacity;
    buf->length = 0;
    return 0;
}

static void buffer_free(Buffer *buf) {
    if (buf->data) {
        free(buf->data);
        buf->data = NULL;
    }
    buf->capacity = 0;
    buf->length = 0;
}

static void buffer_reset(Buffer *buf) {
    buf->length = 0;
    if (buf->data && buf->capacity) {
        buf->data[0] = '\0';
    }
}

static ssize_t read_request_into_buffer(Buffer *req) {
    size_t n = fread(req->data, 1, req->capacity - 1, stdin);
    if (n == 0) return 0;
    req->length = n;
    req->data[n] = '\0';
    return (ssize_t)n;
}

static void build_response(const char *request, size_t request_len, Buffer *resp) {
    (void)request;
    (void)request_len;
    const char *body = "HTTP/1.1 200 OK\r\nContent-Type: text/plain\r\nConnection: keep-alive\r\nContent-Length: 2\r\n\r\nOK";
    size_t len = strlen(body);
    if (len >= resp->capacity) len = resp->capacity - 1;
    memcpy(resp->data, body, len);
    resp->data[len] = '\0';
    resp->length = len;
}

static int process_request(Buffer *req, Buffer *resp) {
    build_response(req->data, req->length, resp);
    return 0;
}

int main(void) {
    Buffer request_buffer;
    Buffer response_buffer;

    if (buffer_init(&request_buffer, REQUEST_BUFFER_SIZE) != 0) {
        return 1;
    }
    if (buffer_init(&response_buffer, RESPONSE_BUFFER_SIZE) != 0) {
        buffer_free(&request_buffer);
        return 1;
    }

    for (;;) {
        buffer_reset(&request_buffer);
        buffer_reset(&response_buffer);

        ssize_t r = read_request_into_buffer(&request_buffer);
        if (r < 0) {
            break;
        }
        if (r == 0) {
            continue;
        }

        if (process_request(&request_buffer, &response_buffer) != 0) {
            continue;
        }

        fwrite(response_buffer.data, 1, response_buffer.length, stdout);
        fflush(stdout);
    }

    buffer_free(&request_buffer);
    buffer_free(&response_buffer);
    return 0;
}