# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <string>
#include <utility>

class NetworkConnectionManager {
public:
    explicit NetworkConnectionManager(const std::string& endpoint)
        : endpoint_(endpoint), connected_(false), resource_(nullptr) {
        allocateResources();
        try {
            connect();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    ~NetworkConnectionManager() noexcept {
        cleanup();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept
        : endpoint_(std::move(other.endpoint_)),
          connected_(other.connected_),
          resource_(other.resource_) {
        other.connected_ = false;
        other.resource_ = nullptr;
    }

    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            endpoint_ = std::move(other.endpoint_);
            connected_ = other.connected_;
            resource_ = other.resource_;
            other.connected_ = false;
            other.resource_ = nullptr;
        }
        return *this;
    }

    void reset() {
        cleanup();
        allocateResources();
        try {
            connect();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    void reinitialize(const std::string& newEndpoint) {
        cleanup();
        endpoint_ = newEndpoint;
        allocateResources();
        try {
            connect();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    bool isConnected() const noexcept {
        return connected_;
    }

    const std::string& endpoint() const noexcept {
        return endpoint_;
    }

private:
    struct Resource {
        int handle;
    };

    void allocateResources() {
        if (resource_ != nullptr) {
            throw std::runtime_error("Resources already allocated");
        }
        resource_ = new Resource{1};
    }

    void connect() {
        if (endpoint_.empty()) {
            throw std::runtime_error("Invalid endpoint");
        }
        if (resource_ == nullptr) {
            throw std::runtime_error("No resources allocated");
        }
        connected_ = true;
    }

    void cleanup() noexcept {
        if (resource_ != nullptr) {
            delete resource_;
            resource_ = nullptr;
        }
        connected_ = false;
    }

    std::string endpoint_;
    bool connected_;
    Resource* resource_;
};

int main() {
    try {
        NetworkConnectionManager manager("127.0.0.1:8080");
        if (manager.isConnected()) {
            std::cout << "Connected to " << manager.endpoint() << '\n';
        }

        manager.reset();
        manager.reinitialize("192.168.1.10:9090");

        std::cout << "Reinitialized to " << manager.endpoint() << '\n';
    } catch (const std::exception& ex) {
        std::cerr << "Connection error: " << ex.what() << '\n';
        return 1;
    }

    return 0;
}