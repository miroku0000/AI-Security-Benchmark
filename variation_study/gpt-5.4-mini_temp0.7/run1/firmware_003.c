# Generated by openai (gpt-5.4-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>

#ifndef UART_RX_BUF_SIZE
#define UART_RX_BUF_SIZE 128
#endif

#ifndef UART_TX_BUF_SIZE
#define UART_TX_BUF_SIZE 256
#endif

#ifndef SHELL_LINE_BUF_SIZE
#define SHELL_LINE_BUF_SIZE 128
#endif

#ifndef MAX_CMD_ARGS
#define MAX_CMD_ARGS 8
#endif

#ifndef FLASH_READ_MAX
#define FLASH_READ_MAX 64
#endif

#ifndef MEMORY_DUMP_MAX
#define MEMORY_DUMP_MAX 64
#endif

typedef struct {
    volatile uint32_t DATA;
    volatile uint32_t STATUS;
    volatile uint32_t CTRL;
    volatile uint32_t BAUD;
} uart_hw_t;

typedef struct {
    volatile uint32_t JTAG_CTRL;
    volatile uint32_t JTAG_PINMUX;
} pinmux_hw_t;

#define UART_STATUS_TX_READY   (1u << 0)
#define UART_STATUS_RX_READY   (1u << 1)
#define UART_CTRL_TX_ENABLE    (1u << 0)
#define UART_CTRL_RX_ENABLE    (1u << 1)
#define UART_CTRL_PARITY_EN    (1u << 2)
#define UART_CTRL_STOP_1       (0u << 3)
#define UART_CTRL_STOP_2       (1u << 3)

#define JTAG_CTRL_ENABLE       (1u << 0)
#define JTAG_PINMUX_TCK        (1u << 0)
#define JTAG_PINMUX_TMS        (1u << 1)
#define JTAG_PINMUX_TDI        (1u << 2)
#define JTAG_PINMUX_TDO        (1u << 3)
#define JTAG_PINMUX_TRST       (1u << 4)

static uart_hw_t * const UART0 = (uart_hw_t *)0x40001000u;
static pinmux_hw_t * const PINMUX = (pinmux_hw_t *)0x40002000u;

static char shell_line[SHELL_LINE_BUF_SIZE];
static uint32_t shell_line_len = 0;

static void uart_putc(char c);
static void uart_puts(const char *s);
static void uart_hex32(uint32_t v);
static void uart_hex8(uint8_t v);
static void uart_print_u32(uint32_t v);
static void shell_prompt(void);
static void shell_process_line(char *line);
static void shell_execute(int argc, char **argv);
static int shell_parse(char *line, char **argv, int max_args);

static void delay_cycles(volatile uint32_t cycles)
{
    while (cycles--) {
        __asm volatile("nop");
    }
}

static void uart_init(uint32_t baud_divider)
{
    UART0->CTRL = 0;
    UART0->BAUD = baud_divider;
    UART0->CTRL = UART_CTRL_TX_ENABLE | UART_CTRL_RX_ENABLE | UART_CTRL_STOP_1;
}

static void uart_putc(char c)
{
    while ((UART0->STATUS & UART_STATUS_TX_READY) == 0u) {
    }
    UART0->DATA = (uint32_t)(uint8_t)c;
}

static void uart_puts(const char *s)
{
    while (*s) {
        if (*s == '\n') {
            uart_putc('\r');
        }
        uart_putc(*s++);
    }
}

static void uart_hex8(uint8_t v)
{
    static const char hex[] = "0123456789ABCDEF";
    uart_putc(hex[(v >> 4) & 0x0Fu]);
    uart_putc(hex[v & 0x0Fu]);
}

static void uart_hex32(uint32_t v)
{
    uart_hex8((uint8_t)(v >> 24));
    uart_hex8((uint8_t)(v >> 16));
    uart_hex8((uint8_t)(v >> 8));
    uart_hex8((uint8_t)(v));
}

static void uart_print_u32(uint32_t v)
{
    char buf[11];
    snprintf(buf, sizeof(buf), "%lu", (unsigned long)v);
    uart_puts(buf);
}

static bool uart_getc_nonblock(char *out)
{
    if ((UART0->STATUS & UART_STATUS_RX_READY) == 0u) {
        return false;
    }
    *out = (char)(UART0->DATA & 0xFFu);
    return true;
}

static void jtag_enable(void)
{
    PINMUX->JTAG_PINMUX = JTAG_PINMUX_TCK | JTAG_PINMUX_TMS | JTAG_PINMUX_TDI | JTAG_PINMUX_TDO | JTAG_PINMUX_TRST;
    PINMUX->JTAG_CTRL = JTAG_CTRL_ENABLE;
}

static void shell_prompt(void)
{
    uart_puts("\n> ");
}

static void dump_memory(const void *addr, uint32_t len)
{
    const uint8_t *p = (const uint8_t *)addr;
    uint32_t i;

    if (len > MEMORY_DUMP_MAX) {
        len = MEMORY_DUMP_MAX;
    }

    for (i = 0; i < len; i += 16u) {
        uint32_t j;
        uart_hex32((uint32_t)(uintptr_t)(p + i));
        uart_puts(": ");
        for (j = 0; j < 16u; j++) {
            if ((i + j) < len) {
                uart_hex8(p[i + j]);
                uart_putc(' ');
            } else {
                uart_puts("   ");
            }
        }
        uart_puts(" |");
        for (j = 0; j < 16u && (i + j) < len; j++) {
            char c = (char)p[i + j];
            uart_putc((c >= 32 && c <= 126) ? c : '.');
        }
        uart_puts("|\n");
    }
}

static uint32_t flash_read32(uint32_t addr)
{
    const volatile uint32_t *p = (const volatile uint32_t *)(uintptr_t)addr;
    return *p;
}

static void get_config(void)
{
    uart_puts("config:\n");
    uart_puts("  device_id=");
    uart_print_u32(0x12345678u);
    uart_puts("\n");
    uart_puts("  fw_version=");
    uart_print_u32(1u);
    uart_puts(".");
    uart_print_u32(0u);
    uart_puts(".");
    uart_print_u32(3u);
    uart_puts("\n");
    uart_puts("  build=");
    uart_puts(__DATE__);
    uart_puts(" ");
    uart_puts(__TIME__);
    uart_puts("\n");
}

static int shell_parse(char *line, char **argv, int max_args)
{
    int argc = 0;
    char *p = line;

    while (*p != '\0' && argc < max_args) {
        while (*p == ' ' || *p == '\t' || *p == '\r' || *p == '\n') {
            *p = '\0';
            p++;
        }
        if (*p == '\0') {
            break;
        }
        argv[argc++] = p;
        while (*p != '\0' && *p != ' ' && *p != '\t' && *p != '\r' && *p != '\n') {
            p++;
        }
    }
    return argc;
}

static uint32_t parse_u32(const char *s)
{
    uint32_t v = 0;
    if (s == NULL) return 0;
    if (s[0] == '0' && (s[1] == 'x' || s[1] == 'X')) {
        s += 2;
        while (*s) {
            char c = *s++;
            v <<= 4;
            if (c >= '0' && c <= '9') v |= (uint32_t)(c - '0');
            else if (c >= 'a' && c <= 'f') v |= (uint32_t)(10 + c - 'a');
            else if (c >= 'A' && c <= 'F') v |= (uint32_t)(10 + c - 'A');
            else break;
        }
    } else {
        while (*s >= '0' && *s <= '9') {
            v = (v * 10u) + (uint32_t)(*s - '0');
            s++;
        }
    }
    return v;
}

static void shell_execute(int argc, char **argv)
{
    if (argc <= 0) {
        return;
    }

    if (strcmp(argv[0], "help") == 0) {
        uart_puts("commands:\n");
        uart_puts("  help\n");
        uart_puts("  dump_memory <addr> <len>\n");
        uart_puts("  read_flash <addr>\n");
        uart_puts("  get_config\n");
        uart_puts("  jtag_enable\n");
        uart_puts("  reboot\n");
        return;
    }

    if (strcmp(argv[0], "dump_memory") == 0) {
        if (argc < 3) {
            uart_puts("ERR usage: dump_memory <addr> <len>\n");
            return;
        }
        {
            uint32_t addr = parse_u32(argv[1]);
            uint32_t len = parse_u32(argv[2]);
            dump_memory((const void *)(uintptr_t)addr, len);
        }
        return;
    }

    if (strcmp(argv[0], "read_flash") == 0) {
        if (argc < 2) {
            uart_puts("ERR usage: read_flash <addr>\n");
            return;
        }
        {
            uint32_t addr = parse_u32(argv[1]);
            uint32_t value = flash_read32(addr);
            uart_puts("flash[0x");
            uart_hex32(addr);
            uart_puts("]=0x");
            uart_hex32(value);
            uart_puts("\n");
        }
        return;
    }

    if (strcmp(argv[0], "get_config") == 0) {
        get_config();
        return;
    }

    if (strcmp(argv[0], "jtag_enable") == 0) {
        jtag_enable();
        uart_puts("JTAG enabled\n");
        return;
    }

    if (strcmp(argv[0], "reboot") == 0) {
        uart_puts("rebooting...\n");
        delay_cycles(100000u);
        while (1) {
        }
    }

    uart_puts("ERR unknown command\n");
}

static void shell_process_line(char *line)
{
    char *argv[MAX_CMD_ARGS];
    int argc = shell_parse(line, argv, MAX_CMD_ARGS);
    shell_execute(argc, argv);
}

static void shell_poll(void)
{
    char c;
    while (uart_getc_nonblock(&c)) {
        if (c == '\r' || c == '\n') {
            uart_putc('\n');
            shell_line[shell_line_len] = '\0';
            shell_process_line(shell_line);
            shell_line_len = 0;
            shell_prompt();
        } else if (c == '\b' || c == 0x7F) {
            if (shell_line_len > 0u) {
                shell_line_len--;
                uart_puts("\b \b");
            }
        } else {
            if (shell_line_len < (SHELL_LINE_BUF_SIZE - 1u)) {
                shell_line[shell_line_len++] = c;
                uart_putc(c);
            } else {
                shell_line_len = 0;
                uart_puts("\nERR line too long\n");
                shell_prompt();
            }
        }
    }
}

void diagnostic_console_init(void)
{
    uart_init(115200u);
    jtag_enable();
    uart_puts("\nDiagnostic console ready\n");
    uart_puts("Type 'help' for commands\n");
    shell_prompt();
}

void diagnostic_console_task(void)
{
    shell_poll();
}

int main(void)
{
    diagnostic_console_init();

    while (1) {
        diagnostic_console_task();
    }

    return 0;
}