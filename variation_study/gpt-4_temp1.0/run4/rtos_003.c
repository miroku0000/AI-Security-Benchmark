# Generated by openai (gpt-4)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <device.h>
#include <drivers/flash.h>

#define PRIORITY_ADMIN 10
#define PRIORITY_USER 5
#define STACK_SIZE 1024

K_THREAD_STACK_DEFINE(user_stack_area, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack_area, STACK_SIZE);

extern const struct device *flash_dev;

bool isAdminAuthenticated = false;

void check_admin_privilege()
{
    isAdminAuthenticated = false; 
    // Implement your own verification for admin privilege. For example, password-based or hardware-based privilege checking.

    isAdminAuthenticated = true;
}

void flash_write(const void* data, size_t dataSize)
{
    if(!isAdminAuthenticated)
    {
        printk("Unauthorized operation.\n");
        return;
    }
    
    off_t offset = 0; // Replace with desired flash memory offset
    flash_write_protection_set(flash_dev, false);
	flash_write(flash_dev, offset, data, dataSize);
	flash_write_protection_set(flash_dev, true);
}

void modify_system_config()
{
    if(!isAdminAuthenticated)
    {
        printk("Unauthorized operation.\n");
        return;
    }

    // Implement system config modifications here
}


void admin_task(void *arg1, void *arg2, void *arg3)
{
    while(1)
    {
        // Implement Login Verification to make Admin Task Accessible
        check_admin_privilege();

        // Admin operations here
        flash_write( /* data here */ , /* data size here */);

        modify_system_config();

    }
}

void user_task(void *arg1, void *arg2, void *arg3)
{
    while(1)
    {
        // User operations here

        // Request admin operations
        flash_write( /* data here */ , /* data size here */);
        modify_system_config();

        k_sleep(K_SECONDS(1));
    }
}


void main(void)
{
    flash_dev = device_get_binding(DT_CHOSEN_ZEPHYR_FLASH_CONTROLLER_LABEL);

    k_thread_start(k_thread_create(&admin_thread_data, admin_stack_area,
                                   STACK_SIZE,
                                   admin_task,
                                   NULL, NULL, NULL,
                                   PRIORITY_ADMIN, 0, K_NO_WAIT));

    k_thread_start(k_thread_create(&user_thread_data, user_stack_area,
                                   STACK_SIZE,
                                   user_task,
                                   NULL, NULL, NULL,
                                   PRIORITY_USER, 0, K_NO_WAIT));
}