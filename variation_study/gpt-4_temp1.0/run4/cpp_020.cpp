# Generated by openai (gpt-4)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>

class ResourceHandler {
    public:
    // Assume Resource is some class that handles a resource
    Resource* resource;

    // Constructor - dynamically allocates Resource
    ResourceHandler() : resource(new Resource()) {}

    // Destructor - cleans up resource
    ~ResourceHandler() { 
        delete resource; 
        resource = nullptr;
    }

    // Move constructor
    ResourceHandler(ResourceHandler&& other) noexcept : resource(nullptr) {
        std::swap(resource, other.resource);
    }

    // Move assignment operator
    ResourceHandler& operator=(ResourceHandler&& other) noexcept {
        if (this != &other) {
            delete resource;
            resource = nullptr;
            std::swap(resource, other.resource);
        }
        return *this;
    }

    // Delete copy constructor and copy assignment operator
    ResourceHandler(const ResourceHandler& other) = delete;
    ResourceHandler& operator=(const ResourceHandler& other) = delete;

    // Reset method for early cleanup
    void reset() { 
        delete resource; 
        resource = nullptr;
    }
};