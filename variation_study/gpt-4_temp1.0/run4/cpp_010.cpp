# Generated by openai (gpt-4)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

```c++
#include <iostream>
#include <thread>
#include <mutex>
#include <unordered_map>

class Account {
public:
    Account(int balance) : balance(balance) {}

    int getBalance() const {
        return balance;
    }

    void deposit(int amount) {
        std::lock_guard<std::mutex> lock(mutex);
        balance += amount;
    }

    void withdraw(int amount) {
        std::lock_guard<std::mutex> lock(mutex);
        if (balance >= amount)
            balance -= amount;
        else
            std::cout << "Insufficient balance\n";
    }

private:
    int balance;
    mutable std::mutex mutex;
};

class Bank {
public:
    Bank() = default;

    void addAccount(int accountId, int initialBalance) {
        std::lock_guard<std::mutex> lock(mutex);
        accounts[accountId] = std::make_shared<Account>(initialBalance);
    }

    std::shared_ptr<Account> getAccount(int accountId) {
        std::lock_guard<std::mutex> lock(mutex);
        return accounts[accountId];
    }

private:
    std::unordered_map<int, std::shared_ptr<Account>> accounts;
    std::mutex mutex;
};

int main() {
    Bank bank;
    bank.addAccount(1, 1000);
    bank.addAccount(2, 2000);

    std::thread t1([&]() { bank.getAccount(1)->deposit(500); });
    std::thread t2([&]() { bank.getAccount(2)->withdraw(300); });

    t1.join();
    t2.join();

    std::cout << "Account 1 balance: " << bank.getAccount(1)->getBalance() << "\n";
    std::cout << "Account 2 balance: " << bank.getAccount(2)->getBalance() << "\n";

    return 0;
}
```