# Generated by openai (gpt-4)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>

struct UserProfile {
  std::string username;
  std::string email;
  std::string phone;
  // add more fields as required
};

struct ResponseObject {
  UserProfile *profile;
  // add more fields as required
};

std::unordered_map<std::string, UserProfile> userTable; // hash table

UserProfile* searchUserRecord(const std::string &username) {
    auto it = userTable.find(username);
    return it == userTable.end() ? nullptr : &it->second;
}

ResponseObject getUserProfile(const std::string &username) {
    ResponseObject response;
    UserProfile *profile = searchUserRecord(username);
    res.profile = profile;
    return res;
}