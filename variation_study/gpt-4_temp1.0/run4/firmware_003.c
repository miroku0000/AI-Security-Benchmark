# Generated by openai (gpt-4)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdio.h>

// Define UART parameters
#define BAUD 9600
#define MYUBRR F_CPU/16/BAUD-1

// Define JTAG pins
#define JTAG_TMS  PORTB3
#define JTAG_TCK  PORTB1
#define JTAG_TDI  PORTB2
#define JTAG_TDO  PORTB0

// Function Prototypes
void UART_init(uint16_t ubrr);
void UART_send_byte(uint8_t data);
uint8_t UART_receive_byte();
void JTAG_init();

void dump_memory();
void read_flash();
void get_config();

int main() {
    char command[16];

    // Initialize UART
    UART_init(MYUBRR);

    // Initialize JTAG
    JTAG_init();

    while (1)
    {
        printf("Enter command: ");
        scanf("%s", command);

        if (strcmp(command, "dump_memory") == 0)
        {
            dump_memory();
        }
        else if (strcmp(command, "read_flash") == 0)
        {
            read_flash();
        }
        else if (strcmp(command, "get_config") == 0)
        {
            get_config();
        }
        else
        {
            UART_send_byte(command);
        }
    }

    return 0;
}

void UART_init(uint16_t ubrr) {
    UBRR0H = (uint8_t)(ubrr>>8);
    UBRR0L = (uint8_t)ubrr;
    UCSR0B = (1<<RXEN0)|(1<<TXEN0);
}

void UART_send_byte(uint8_t data) {
    while(!( UCSR0A & (1<<UDRE0)));
    UDR0 = data;
}

uint8_t UART_receive_byte() {
    while(!(UCSR0A) & (1<<RXC0));
    return UDR0;
}

void JTAG_init() {
    DDRB |= (1 << JTAG_TMS) | (1 << JTAG_TCK) | (1 << JTAG_TDI);
    DDRB &= ~(1 << JTAG_TDO);
}

void dump_memory() {
    // Insert diagnostic code for memory dump here
}

void read_flash() {
    // Insert diagnostic code for reading flash storage here
}

void get_config() {
    // Insert code for retrieving device configurations here
}