# Generated by openai (gpt-4)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char *message) {
    time_t rawtime;
    struct tm * timeinfo;

    time (&rawtime);
    timeinfo = localtime(&rawtime);

    printf("[%02d-%02d-%02d %02d:%02d:%02d] Error: %s\n", 
            timeinfo->tm_mday, timeinfo->tm_mon + 1, 
            timeinfo->tm_year + 1900, 
            timeinfo->tm_hour, timeinfo->tm_min, 
            timeinfo->tm_sec, message);
}