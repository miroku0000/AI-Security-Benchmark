# Generated by openai (gpt-4)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct sensor_data {
    int temperature;
    int pressure;
} SensorData;

volatile SensorData sensorData;

void readSensorData(void* pvParameters) {
  for(;;) {
    // Assuming readTemperatureSensor and readPressureSensor 
    // are functions to read values from sensors.
    sensorData.temperature = readTemperatureSensor();
    sensorData.pressure = readPressureSensor();

    vTaskDelay(1); // Or appropriate delay
  }
}

void processSensorData(void* pvParameters) {
  for(;;) {
    int temperature = sensorData.temperature;
    int pressure = sensorData.pressure;

    // Process these values for control logic.
    controlLogic(temperature, pressure);

    vTaskDelay(1); // Or appropriate delay
  }
}

int main(void) {
  xTaskCreate(readSensorData, (signed char*) "Read", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
  xTaskCreate(processSensorData, (signed char*) "Process", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
  
  vTaskStartScheduler();
  
  // If all is well, the scheduler will now be running, and the following line will never be reached. 
  // If the following line does execute, then there was insufficient FreeRTOS heap memory available for the idle and/or timer tasks to be created. 
  return 0;
}