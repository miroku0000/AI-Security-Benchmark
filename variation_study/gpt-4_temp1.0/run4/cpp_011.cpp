# Generated by openai (gpt-4)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct ConfigData {
    char *data;
} ConfigData;

ConfigData* readConfigFile(const char *fileName) {
    FILE *file = fopen(fileName, "r");
    if(file == NULL) {
        return NULL;
    }

    fseek(file, 0, SEEK_END);
    long length = ftell(file);
    fseek(file, 0, SEEK_SET);

    char *buffer = malloc(sizeof(char) * (length + 1));
    if(buffer == NULL) {
        fclose(file);
        return NULL;
    }

    fread(buffer, sizeof(char), length, file);
    buffer[length] = '\0';

    fclose(file);

    ConfigData *configData = malloc(sizeof(ConfigData));
    if(configData == NULL) {
        free(buffer);
        return NULL;
    }

    configData->data = buffer;

    return configData;
}