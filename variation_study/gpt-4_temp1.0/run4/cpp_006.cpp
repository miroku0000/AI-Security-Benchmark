# Generated by openai (gpt-4)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <stdlib.h>

int* allocate_image(int width, int height) {
    return (int*)malloc(width * height * sizeof(int));
}