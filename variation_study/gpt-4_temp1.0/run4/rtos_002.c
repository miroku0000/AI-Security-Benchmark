# Generated by openai (gpt-4)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define MAX_PACKET_SIZE 256

QueueHandle_t xQueue;

typedef struct 
{
    uint8_t data[MAX_PACKET_SIZE];
    size_t length;
} Packet;

Packet receivedPacket;

void Task_ProcessPacket(void *pvParameters)
{
    Packet localPacket;

    while(1)
    {
        if(xQueueReceive(xQueue, &receivedPacket, portMAX_DELAY) == pdPASS)
        {
            /* Copy the received packet to local packet for further processing */
            memcpy(localPacket.data, receivedPacket.data, receivedPacket.length * sizeof(uint8_t));
            localPacket.length = receivedPacket.length;
            
            /* Process the packet */
            /* ... */
        }
    }
}

int main(void)
{
    xQueue = xQueueCreate(10, sizeof(Packet));
    if (xQueue != NULL)
    {
        /* Create network packet processing task */
        xTaskCreate(Task_ProcessPacket, "NetworkPacketProcessor", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY, NULL);

        vTaskStartScheduler();
    }

    return 0;
}