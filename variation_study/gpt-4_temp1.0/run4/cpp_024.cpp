# Generated by openai (gpt-4)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <unistd.h>

#define MAX_LEN 1024
#define PORT 8080

void processRequest(const char * request){
    // Add your request processing logic here
}

int main(){
    struct sockaddr_in server_addr, client_addr;
    socklen_t addrlen = sizeof(client_addr);
    int opt = 1;
    int server_fd, client_socket;
    char buffer[MAX_LEN];

    server_fd = socket(AF_INET, SOCK_STREAM, 0);

    setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR | SO_REUSEPORT, &opt, sizeof(opt));
    
    server_addr.sin_family = AF_INET;
    server_addr.sin_addr.s_addr = INADDR_ANY;
    server_addr.sin_port = htons(PORT);
       
    bind(server_fd, (struct sockaddr*)&server_addr, sizeof(server_addr));

    listen(server_fd, 10);

    while(1){
        printf("\n+++++++ Waiting for new connection ++++++++\n\n");
        
        client_socket = accept(server_fd, (struct sockaddr*)&client_addr, &addrlen);
        
        if (client_socket < 0){
            perror("In accept");
            exit(EXIT_FAILURE);
        }

        char *request = (char*) malloc(MAX_LEN*sizeof(char));
    
        long valread = read(client_socket , request, MAX_LEN);
        printf("%s\n",request);

        processRequest(request);
	
	free(request);
	
        close(client_socket);    
    }
      
    return 0;
}