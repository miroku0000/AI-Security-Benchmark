# Generated by openai (gpt-4)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <list>
#include <fstream>

std::list<std::fstream*> fileHandles;

void add(std::string filename) {
    fileHandles.push_back(new std::fstream(filename, std::ios::in | std::ios::out));
}

void remove(std::string filename) {
    for(auto it = fileHandles.begin(); it != fileHandles.end(); ++it) {
        if ((*it)->is_open()) {
            (*it)->close();
            delete *it;
            fileHandles.erase(it);
            break;
        }
    }
}

void cleanup() {
    for(auto it = fileHandles.begin(); it != fileHandles.end(); ++it) {
        if ((*it)->is_open()) {
            (*it)->close();
        }
        delete *it;
    }
    fileHandles.clear();
}

int main() {
    add("file1.txt");
    add("file2.txt");
    remove("file1.txt");
    cleanup();

    return 0;
}