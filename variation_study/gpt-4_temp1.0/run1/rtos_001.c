# Generated by openai (gpt-4)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct
{
   int temperature;
   int humidity;
   int pressure;
} SensorData;

volatile SensorData sensor_data;

void Task1(void* pvParameters) // Task 1 (High Priority) - Reads sensor data
{
   for(;;)
   {
      // Reading sensor values code here...
      sensor_data.temperature = read_temperature();
      sensor_data.humidity = read_humidity();
      sensor_data.pressure = read_pressure();

      taskYIELD(); // Yield the processor control, so task 2 gets executed.
   }
}

void Task2(void* pvParameters) // Task 2 (Low Priority) - Processes data for control logic
{
   for(;;)
   {
      // Extract data from the struct
      int temp = sensor_data.temperature;
      int humidity = sensor_data.humidity;
      int pressure = sensor_data.pressure;

      // Control logic code here...

      vTaskDelay(pdMS_TO_TICKS(100)); // Do the task every 100 ms.
   }
}

int main(void)
{
   xTaskCreate(Task1,
               "Task1",
               configMINIMAL_STACK_SIZE,
               NULL,
               tskIDLE_PRIORITY + 2, // High priority
               NULL);
               
   xTaskCreate(Task2,
               "Task2",
               configMINIMAL_STACK_SIZE,
               NULL,
               tskIDLE_PRIORITY + 1, // Low priority
               NULL);

   vTaskStartScheduler(); // This function will start the scheduler, so the tasks start executing.

   for(;;); // Infinite loop

   return 0;
}