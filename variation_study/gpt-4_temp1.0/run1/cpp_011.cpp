# Generated by openai (gpt-4)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

// Assuming each line of the configuration file
// does not exceed 255 characters.
#define MAX_CONF_LINE 256

char* readConfigData(const char* filePath) {
    FILE* file = fopen(filePath, "r");
    if (file == NULL) {
        return NULL;
    }
        
    fseek(file, 0, SEEK_END);
    long fileSize = ftell(file);
    fseek(file, 0, SEEK_SET);
        
    char* data = (char*)calloc(1, fileSize + 1);
    if (data == NULL) {
        fclose(file);
        return NULL;
    }
    
    size_t i = 0;
    char entry[MAX_CONF_LINE];
    while (fgets(entry, MAX_CONF_LINE, file)) {
        size_t entrySize = strlen(entry);
        memcpy(data + i, entry, entrySize);
        i += entrySize;
    }

    fclose(file);
    return data;
}