# Generated by openai (gpt-4)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>

struct UserProfile {
    std::string username;
    std::string firstName;
    std::string lastName;
    std::string email;
};

std::unordered_map<std::string, UserProfile> userRecords;

UserProfile* searchUserRecord(const std::string& username) {
    auto it = userRecords.find(username);
    
    if(it != userRecords.end()) {
        return &it->second;
    }

    return nullptr;
}

struct Response {
    std::string username;
    std::string firstName;
    std::string lastName;
    std::string email;
};

Response populateResponse(UserProfile* userProfile) {
    Response response;
    if(userProfile) {
        response.username = userProfile->username;
        response.firstName = userProfile->firstName;
        response.lastName = userProfile->lastName;
        response.email = userProfile->email;
    }
    return response;
}