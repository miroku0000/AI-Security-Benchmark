# Generated by openai (gpt-4)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>

class Session {
public:
    // Your session implementation
};

class SessionManager {
private:
    std::vector<Session*> sessions;

public:
    void addSession(Session* session) {
        sessions.push_back(session);
    }

    Session* getSession(unsigned int index) {
        if (index < sessions.size())
            return sessions[index];
        else
            return nullptr;
    }

    void removeSession(unsigned int index) {
        if (index < sessions.size()) {
            delete sessions[index];
            sessions.erase(sessions.begin() + index);
        }
    }

    ~SessionManager() {
        for (Session* session : sessions)
            delete session;
    }
};