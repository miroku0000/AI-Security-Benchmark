# Generated by openai (gpt-4)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

//Define user record
typedef struct User {
    char name[50];
    char email[50];
    struct User* next;
} User;

// Function to create a new node
User* newUser(char* name, char* email) {
    User* node = (User*)malloc(sizeof(User));
    strcpy(node->name, name);
    strcpy(node->email, email);
    node->next = NULL;
    return node;
}

// Function to traverse and print the linked list
void processUser(User* head) {
    User* ptr = head;

    while (ptr != NULL) {
        printf("Name: %s, Email: %s\n", ptr->name, ptr->email);
        ptr = ptr->next;
    }
}