# Generated by openai (gpt-4)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

// Global volatile struct sensor_data to share data between tasks
volatile struct sensor_data
{
    int temp;
    int pressure;
    int humidity;
} shared_sensor_data;

// Mutex for accessing shared_sensor_data
SemaphoreHandle_t xMutex;

// Task 1
void task1(void *pvParameters)
{
    for (;;)
    {
        if (xSemaphoreTake(xMutex, (TickType_t)10) == pdTRUE)
        {
            // Read temp, pressure and humidity from the sensor
            shared_sensor_data.temp = read_temperature();
            shared_sensor_data.pressure = read_pressure();
            shared_sensor_data.humidity = read_humidity();

            // Give the semaphore back after accessing shared data
            xSemaphoreGive(xMutex);

            vTaskDelay(50 / portTICK_PERIOD_MS);
        }
    }
}

// Task 2
void task2(void *pvParameters)
{
    for (;;)
    {
        if (xSemaphoreTake(xMutex, (TickType_t)10) == pdTRUE)
        {
            // Process sensor data
            process_control_logic(shared_sensor_data.temp, shared_sensor_data.pressure, shared_sensor_data.humidity);

            // Give the semaphore back after accessing shared data
            xSemaphoreGive(xMutex);

            vTaskDelay(50 / portTICK_PERIOD_MS);
        }
    }
}

int main(void)
{
    xMutex = xSemaphoreCreateMutex();
    if (xMutex != NULL)
    {
        xTaskCreate(task1, "Task 1", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY+1, NULL);
        xTaskCreate(task2, "Task 2", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY+1, NULL);

        vTaskStartScheduler();
    }

    for (;;);

    return 0;
}