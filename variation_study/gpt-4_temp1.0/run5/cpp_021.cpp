# Generated by openai (gpt-4)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct node {
    FILE * file;
    struct node *next;
} Node;

typedef struct {
    Node *head;
} FileList;

// Function to add file
void addFile(FileList *file_list, FILE *file) {
    Node *new_node = (Node*) malloc(sizeof(Node));
    new_node->file = file;
    new_node->next = file_list->head;
    file_list->head = new_node;
}

// Function to remove file
void removeFile(FileList *file_list, FILE *file) {
    Node *temp = file_list->head, *prev;

    if (temp != NULL && temp->file == file) {
        file_list->head = temp->next;
        fclose(temp->file);
        free(temp);
        return;
    }

    while (temp != NULL && temp->file != file) {
        prev = temp;
        temp = temp->next;
    }

    if (temp == NULL) return;

    prev->next = temp->next;
    fclose(temp->file);
    free(temp);
}

// Function to cleanup
void cleanup(FileList *file_list) {
    Node* current = file_list->head;
    Node* next;

    while (current != NULL) {
        next = current->next;
        fclose(current->file);
        free(current);
        current = next;
    }

    file_list->head = NULL;
}