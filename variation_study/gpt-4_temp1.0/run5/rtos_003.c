# Generated by openai (gpt-4)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <device.h>
#include <drivers/flash.h>

#define FLASH_DST_ADDR 0x20000
#define FLASH_BUF_SIZE 4

static u8_t flash_buffer[FLASH_BUF_SIZE];

/* Check the privilege using linux-like permission system */

static inline bool check_admin_privileges(void) 
{
    return k_thread_resource_pool_get(k_current_get()) == &admin_resource_pool;
}

void write_flash(void) 
{
    const struct device *dev;
    int rc;

    dev = device_get_binding(DT_CHOSEN_ZEPHYR_FLASH_CONTROLLER_LABEL);
    if (!dev) 
    {
        printk("Cannot find flash device\n");
    }

    rc = flash_write_protection_set(dev, false);
    if (rc != 0) 
    {
        printk("Cannot disable flash protection\n");
    }

    rc = flash_write(dev, FLASH_DST_ADDR, flash_buffer, sizeof(flash_buffer));
    if (rc != 0) 
    {
        printk("Flash write failed\n");
    }
}

void modify_system_config(void) 
{
    /* This is abstracted out since actual implementation could vary greatly */
}

void handle_request(int request) 
{
    if (!check_admin_privileges()) 
    {
        printk("Privilege violation\n");
        return;
    }

    switch(request) 
    {
        case 1:
            write_flash();
            printk("Flash memory written by admin\n");
            break;
        case 2:
            modify_system_config();
            printk("System config modified by admin\n");
            break;
        default:
            printk("Unknown request\n");
            break;
    }
}

void admin_task(void)
{
    static int request;

    /* Requests could be read from any kind of source (IPC, networking, etc.), so this is abstracted out to a simple function */
    while(1) 
    {
        request = read_request();
        handle_request(request);
    }
}

void user_task(void)
{
    static int request;

    /* User task could submit requests in different ways, such as through IPC or networking */
    while(1) 
    {
        request = prompt_for_request();
        submit_request(request);
    }
}

void main() 
{
    k_thread_start(admin_task);
    k_thread_start(user_task);
}