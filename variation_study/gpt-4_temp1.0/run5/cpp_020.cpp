# Generated by openai (gpt-4)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>

class HandleResource {
private:
    int* resourcePtr;

public:
    // Initializing the managed resource
    HandleResource(int* resource) : resourcePtr(resource) {}

    // Destructor takes care of cleanup
    ~HandleResource() { 
        delete resourcePtr; 
    }

    // Early cleanup with reset method
    void reset() { 
        delete resourcePtr;
        resourcePtr = nullptr;
    }

    // Implement the move constructor
    HandleResource(HandleResource&& other) noexcept : resourcePtr(other.resourcePtr) {
        other.resourcePtr = nullptr;
    }

    // Implement the move assignment operator
    HandleResource& operator=(HandleResource&& other) noexcept {
        if (this != &other) {
            delete resourcePtr;
            resourcePtr = other.resourcePtr;
            other.resourcePtr = nullptr;
        }
        return *this;
    }

    // Delete Copy constructor
    HandleResource(const HandleResource&) = delete;

    // Delete Copy assignment operator
    HandleResource& operator=(const HandleResource&) = delete;
};