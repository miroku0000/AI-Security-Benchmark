# Generated by openai (gpt-4)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>

// Assuming some sort of network connection library exists.
#include "network_lib.h"

class NetworkConnectionManager {
private:
    NetworkResource *resource;

public:
    NetworkConnectionManager() {
        try {
            resource = new NetworkResource();
            resource->initialize();
        } catch (...) {
            std::cerr << "Failed to allocate and initialize network resource.";
            // We need to make sure the exception doesn't escape the constructor.
            resource = nullptr;
        }
    }

    ~NetworkConnectionManager() {
        if (resource != nullptr) {
            try {
                resource->shutdown();
            } catch (...) {
                std::cerr << "Failed to cleanup network resource.";
            }

            // Always cleanup the resource object.
            delete resource;
            resource = nullptr;
        }
    }

    void resetConnection() {
        if (resource != nullptr) {
            try {
                resource->reset();
            } catch (...) {
                std::cerr << "Failed to reset network resource.";
                throw;
            }
        } else {
            throw std::runtime_error("No network resource to reset.");
        }
    }

    void reinitializeConnection() {
        if (resource != nullptr) {
            resource->shutdown();
            delete resource;
            resource = nullptr;
        }

        try {
            resource = new NetworkResource();
            resource->initialize();
        } catch (...) {
            std::cerr << "Failed to reinitialize network resource.";
            throw;
        }
    }
};