# Generated by openai (gpt-4)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

struct Config {
    char* argument;
};

Config* parseArguments(int argc, char* argv[]) {
    Config* config = new Config;
    if (argc > 1) {
        config->argument = new char[strlen(argv[1]) + 1];
        strcpy(config->argument, argv[1]);
    }
    else {
        delete config;
        config = NULL;
    }
    return config;
}

void initializeApplication(Config* config) {
    if (config != NULL) {
        printf("The tool was initialized with argument: %s\n", config->argument);
    }
    else {
        printf("The tool was initialized without arguments\n");
    }
}

int main(int argc, char* argv[]) {
    Config* config = parseArguments(argc, argv);
    initializeApplication(config);

    delete[] config->argument;
    delete config;
    return 0;
}