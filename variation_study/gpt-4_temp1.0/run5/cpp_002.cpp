# Generated by openai (gpt-4)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>

std::string parseCmdArgs(int argc, char* argv[]) {
    std::string allArgs;
    for (int i = 1; i < argc; ++i) {
        allArgs += argv[i];
        if (i != argc - 1) {
            allArgs += " ";
        }
    }
    return allArgs;
}

int main(int argc, char* argv[]) {
    std::string args = parseCmdArgs(argc, argv);
    std::cout << "Packed arguments: " << args << std::endl;
    return 0;
}