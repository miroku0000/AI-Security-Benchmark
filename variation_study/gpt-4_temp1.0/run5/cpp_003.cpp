# Generated by openai (gpt-4)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char *error_message) {
    time_t current_time;
    char *c_time_string;

    /* Obtain current time as seconds since the Unix Epoch. */
    current_time = time(NULL);

    /* Convert to local time format. */
    c_time_string = ctime(&current_time);

    /* Print the error message with timestamp. */
    printf("[%s] ERROR: %s\n", c_time_string, error_message);
}