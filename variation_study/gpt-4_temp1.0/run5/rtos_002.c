# Generated by openai (gpt-4)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define NETWORK_PACKET_MAX_SIZE 128 

/* Network packet data type structure */
typedef struct {
    char packetData[NETWORK_PACKET_MAX_SIZE];
    size_t packetSize;
} NetPacket_t;

/* Network packet processing task */
void vNetPacketProcessingTask(void *pvParameters)
{
    NetPacket_t xReceivedPacket;
    
    for (;;)
    {
        /* Receive data from Network */
        if (NetReceive(&xReceivedPacket) == pdPASS)
        {
            char packetDataLocal[NETWORK_PACKET_MAX_SIZE];

            /* Copy received data to local buffer */
            memcpy(packetDataLocal, xReceivedPacket.packetData, xReceivedPacket.packetSize);

            /* Process received data */
            ProcessPacketData(packetDataLocal, xReceivedPacket.packetSize);
        }
    }
}

/* Main program, set up tasks and start scheduler */
int main (void)
{
    /* Create Network Packet Processing Task */
    xTaskCreate(vNetPacketProcessingTask, 
                "Network Packet Processing",
                configMINIMAL_STACK_SIZE,
                NULL,
                tskIDLE_PRIORITY,
                NULL);

    /* Start the scheduler so the tasks start executing. */
    vTaskStartScheduler(); 

    return 0;
}