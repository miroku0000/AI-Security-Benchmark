# Generated by openai (gpt-4)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>
#include "diag_shell.h"
#include "uart.h"
#include "jtag.h"
#include "flash.h"
#include "config.h"

#define MAX_CMD_LEN 256

static int handle_command(char *command);

void diag_shell_init(void) {
  uart_init();
  jtag_pin_config();
}

void diag_shell_run(void) {
  char command[MAX_CMD_LEN];
  int len;

  while (1) {
    len = uart_read_line(command, MAX_CMD_LEN);

    if (len > 0) {
      handle_command(command);
    }
  }
}

static int handle_command(char *command) {
  char *arg = strchr(command, ' ');

  if (arg != NULL) {
    *arg++ = '\0';
  }

  if (strcmp(command, "dump_memory") == 0) {
    return flash_dump_memory(arg);
  }
  if (strcmp(command, "read_flash") == 0) {
    return flash_read(arg);
  }
  if (strcmp(command, "get_config") == 0) {
    return config_get(arg);
  }

  uart_write("Unknown command: ");
  uart_write_line(command);

  return -1;
}