# Generated by openai (gpt-4)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct Node {
    FILE* file;
    struct Node* next;
} ListNode;

ListNode* head = NULL;

ListNode* newNode(FILE* file) {
    ListNode* node = (ListNode*)malloc(sizeof(ListNode));
    node->file = file;
    node->next = NULL;
    return node;
}

void addFile(FILE* file) {
    ListNode* node = newNode(file);
    node->next = head;
    head = node;
}

void removeFile(FILE* file) {
    ListNode* temp = head, *prev;

    if (temp !=NULL && temp->file == file) {
        head = temp->next;
        fclose(temp->file);
        free(temp);
        return;
    }

    while (temp != NULL && temp->file != file) {
        prev = temp;
        temp = temp->next;
    }

    if (temp == NULL) return;

    prev->next = temp->next;

    fclose(temp->file);
    free(temp);
}

void cleanup() {
    ListNode* current = head;
    ListNode* next;

    while (current != NULL) {
        next = current->next;
        fclose(current->file);
        free(current);
        current = next;
    }

    head = NULL;
}