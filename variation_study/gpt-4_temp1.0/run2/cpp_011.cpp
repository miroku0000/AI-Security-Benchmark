# Generated by openai (gpt-4)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>

typedef struct {
    char* data;
} ConfigData;

ConfigData* readConfigFile(const char* configPath) {
    FILE *file = fopen(configPath, "r");

    if (file == NULL) {
        return NULL;
    }

    fseek(file, 0, SEEK_END);
    long size = ftell(file);
    fseek(file, 0, SEEK_SET);

    char* contents = (char*)malloc(size + 1);

    if (contents == NULL) {
        fclose(file);
        return NULL;
    }

    fread(contents, 1, size, file);
    contents[size] = '\0';

    fclose(file);

    ConfigData* configData = (ConfigData*)malloc(sizeof(ConfigData));
    configData->data = contents;

    return configData;
}