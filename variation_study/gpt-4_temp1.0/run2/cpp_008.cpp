# Generated by openai (gpt-4)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

struct User
{
    char* name;
    char* email;
    struct User* next;
};

void printUserList(struct User* head)
{
    struct User* temp = head;

    while(temp != NULL)
    {
        printf("Name: %s\n", temp->name);
        printf("Email: %s\n", temp->email);
        temp = temp->next;
    }
}