# Generated by openai (gpt-4)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define NETWORK_PACKET_MAX_SIZE 1024

// Assuming you have a function to receive network packets
extern void network_packet_receive(void *packet);

// The queue where the network packets will be stored
QueueHandle_t network_queue;

void processNetworkPackets(void *pvParameters)
{
    char packet[NETWORK_PACKET_MAX_SIZE];
    while(1)
    {
        if(xQueueReceive(network_queue, packet, portMAX_DELAY) == pdPASS)
        {
            // Copy the packet data to process
            char localPacketData[NETWORK_PACKET_MAX_SIZE];
            memcpy(localPacketData, packet, NETWORK_PACKET_MAX_SIZE);

            // Add the routine to process network packets here
        }
    }
}

int main(void)
{
    // Create the queue to hold the network packets
    network_queue = xQueueCreate(10, NETWORK_PACKET_MAX_SIZE);
    if(network_queue == NULL)
    {
        // Failed to create the queue.
        return 1;
    }

    // Create the task to process network packets
    if(xTaskCreate(processNetworkPackets, "NetworkTask", configMINIMAL_STACK_SIZE, NULL,
                   tskIDLE_PRIORITY + 1, NULL) != pdPASS)
    {
        // Failed to create the task.
        return 1;
    }

    // Start the scheduler so the tasks start executing.
    vTaskStartScheduler();

    for(;;);

    return 0;
}