# Generated by openai (gpt-4)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parse_args(int argc, char* argv[], char result[]) {
    for (int i = 1; i < argc; i++) {
        strcat(result, argv[i]);
        if (i != argc - 1) {
            strcat(result, " ");
        }
    }
}

int main(int argc, char* argv[]) {
    char result[1024] = {0};
    parse_args(argc, argv, result);
    std::cout << "Command-line arguments: " << result << std::endl;
    return 0;
}