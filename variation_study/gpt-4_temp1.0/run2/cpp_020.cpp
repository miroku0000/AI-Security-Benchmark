# Generated by openai (gpt-4)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <algorithm>

class ResourceManager {
    // Resource pointer
    Resource* resource;

public:
    explicit ResourceManager(Resource* resource = nullptr) noexcept : resource(resource) {}

    ~ResourceManager() {
        delete resource;
    }

    // Delete copy constructors
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if(this != &other) {
            delete resource;
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }

    // Reset method for early cleanup
    void reset(Resource* newResource = nullptr) noexcept {
        if(resource != newResource) {
            delete resource;
            resource = newResource;
        }
    }
};