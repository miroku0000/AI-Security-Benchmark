# Generated by openai (gpt-4)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>

struct UserData {
    std::string name;
    std::string email;
    int age;
};

class UserRepository {
    std::unordered_map<std::string, UserData> table;

public:
    UserData* findUser(std::string username) {
        std::unordered_map<std::string, UserData>::iterator it = table.find(username);
        if (it != table.end()) {
            return &(it->second);
        } else {
            return nullptr;
        }
    }
};

struct Response {
    UserData* userData;
    bool success;
};

Response lookupUser(std::string username, UserRepository& repo) {
    UserData* userData = repo.findUser(username);
    return {userData, userData != nullptr};
}