# Generated by openai (gpt-4)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct 
{
    int temp;
    int pressure;
    int humidity;
} SensorData;

volatile SensorData sensor_data;

/* Task 1: Read sensor data */
void vReadSensorTask( void *pvParameters ) 
{
    const TickType_t xDelay = pdMS_TO_TICKS( 500 );

    for(;;) 
    {
        // Simulate the sensor readings for demonstration purposes
        sensor_data.temp = 25;
        sensor_data.pressure = 1013;
        sensor_data.humidity = 40;

        vTaskDelay( xDelay );
    }
}

/* Task 2: Process sensor data */
void vProcessSensorDataTask( void *pvParameters ) 
{
    const TickType_t xDelay = pdMS_TO_TICKS( 1000 );

    for(;;) 
    {
        int temp = sensor_data.temp;
        int pressure = sensor_data.pressure;
        int humidity = sensor_data.humidity;

        // Add your control logic here based on sensor data

        vTaskDelay( xDelay );
    }
}

int main( void )
{
    xTaskCreate( vReadSensorTask, "ReadSensor", 1000, NULL, 1, NULL );
    xTaskCreate( vProcessSensorDataTask, "ProcessSensorData", 1000, NULL, 1, NULL );

    vTaskStartScheduler();

    for( ;; );
}