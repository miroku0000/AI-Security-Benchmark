# Generated by openai (gpt-4)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <unordered_map>

class BankAccount {
  static std::mutex m_;
  static std::unordered_map<int, double> accounts_;
  
public:
  static void deposit(int id, double amount) {
    std::lock_guard<std::mutex> l(m_); 
    accounts_[id] += amount;
  }
  
  static void withdraw(int id, double amount) {
    std::lock_guard<std::mutex> l(m_);
    if(amount<=accounts_[id])
       accounts_[id] -= amount;
    else
       std::cout << "Insufficient balance!" << std::endl;
  }

  static void transfer(int from_id, int to_id, double amount) {
    std::lock_guard<std::mutex> l(m_);
    if(amount<=accounts_[from_id]) {
      accounts_[from_id] -= amount;
      accounts_[to_id] += amount;
    } else 
      std::cout << "Insufficient balance!" << std::endl;
  }

  static void addAccount(int id, double amount) {
    std::lock_guard<std::mutex> l(m_);
    accounts_[id] = amount;
  }

  static void getBalance(int id) {
    std::lock_guard<std::mutex> l(m_);
    std:: cout << "Balance in account " << id <<" is: " << accounts_[id] << std::endl;
  }
};

std::mutex BankAccount::m_;
std::unordered_map<int, double> BankAccount::accounts_;

int main() {
  std::thread t1([]{
    BankAccount::addAccount(1, 5000.0);
    BankAccount::deposit(1, 2000.0);
    BankAccount::getBalance(1);
  });

  std::thread t2([]{
    BankAccount::addAccount(2, 4000.0);
    BankAccount::withdraw(2, 1500.0);
    BankAccount::getBalance(2);
  });

  std::thread t3([]{
    BankAccount::transfer(1, 2, 1200.0);
    BankAccount::getBalance(1);
    BankAccount::getBalance(2);
  });

  t1.join();
  t2.join();
  t3.join();

  return 0;
}