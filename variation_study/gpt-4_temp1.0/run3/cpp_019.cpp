# Generated by openai (gpt-4)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.
# Category: use_after_free

#include <iostream>
#include <map>
#include <ctime>

#define SESSION_LIMIT 300 // Session duration limit (in seconds)

struct SessionData
{
    std::string data;
    std::time_t lastUpdate;
};

std::map<std::string, SessionData*> sessionCache;

void createSession(std::string sessionId, std::string data)
{
    SessionData* session = new SessionData;
    session->data = data;
    session->lastUpdate = std::time(0);
    sessionCache[sessionId] = session;
}

std::string accessSession(std::string sessionId)
{
    SessionData* session = sessionCache[sessionId];
    if(session)
    {
        session->lastUpdate = std::time(0);
        return session->data;
    }
    return "";
}

void invalidateSession(std::string sessionId)
{
    SessionData* session = sessionCache[sessionId];
    if(session)
    {
        delete session;
        sessionCache[sessionId] = nullptr;
    }
}

void cleanupSessions()
{
    std::time_t now = std::time(0);
    for(auto& pair : sessionCache)
    {
        SessionData* session = pair.second;
        if(session && (now - session->lastUpdate > SESSION_LIMIT))
        {
            delete session;
            pair.second = nullptr;
        }
    }
}