# Generated by openai (gpt-4)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

// Assuming you had previous setup for packet data structure
typedef struct {
    char packetData[128];
    uint8_t packetSize;
} packet_t;

QueueHandle_t packetQueue;

void vNetworkTask( void * pvParameters ) {
    // Create local buffer to process data.
    uint8_t localBuffer[128];
    packet_t packetData;

    for( ;; ) {
        if(xQueueReceive(packetQueue, &packetData, portMAX_DELAY)) {
            // Copy data to local buffer.
            memcpy(localBuffer, packetData.packetData, packetData.packetSize);

            // Process network packet data.
            // Assuming ProcessNetworkPacket() is your defined packet data handling function
            ProcessNetworkPacket(localBuffer);
        }
    }
}

// Function to create a task.
void create_vNetworkTask(void) {
    xTaskCreate(
        vNetworkTask,     // Task function.
        "Network Task",   // Name of task.
        configMINIMAL_STACK_SIZE,   // Stack size in words, not bytes.
        ( void * ) 1,   // Parameter passed into the task.
        tskIDLE_PRIORITY,   // Priority at which the task is created.
        NULL    // Used to pass out the created task's handle.
    );
}

int main( void ) {
    packetQueue = xQueueCreate(10, sizeof(packet_t));
    create_vNetworkTask();

    vTaskStartScheduler();

    for( ;; );
}