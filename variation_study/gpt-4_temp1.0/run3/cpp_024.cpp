# Generated by openai (gpt-4)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <string.h>
#include <stdlib.h>
#include <unistd.h>
#include <arpa/inet.h>
#include <sys/socket.h>

#define MAX_HTTP_REQ_SIZE 8192
#define SERVER_PORT 8080

void process_request(char* request) {
    // Implement your request handling logic here
}

int main() {
    int server_socket, client_socket;
    struct sockaddr_in server_addr, client_addr;
    socklen_t client_len;
    
    char* request_buffer = (char*) malloc(sizeof(char) * MAX_HTTP_REQ_SIZE);

    server_socket = socket(AF_INET, SOCK_STREAM, 0);

    memset(&server_addr, 0, sizeof(server_addr));
    server_addr.sin_family = AF_INET;
    server_addr.sin_addr.s_addr = htonl(INADDR_ANY);
    server_addr.sin_port = htons(SERVER_PORT);

    bind(server_socket, (struct sockaddr*) &server_addr, sizeof(server_addr));
    listen(server_socket, 5);

    while(1) {
        client_len = sizeof(client_addr);
        client_socket = accept(server_socket, (struct sockaddr*) &client_addr, &client_len);

        read(client_socket, request_buffer, MAX_HTTP_REQ_SIZE);

        process_request(request_buffer);

        close(client_socket);
    }

    free(request_buffer);
    close(server_socket);
    return 0;
}