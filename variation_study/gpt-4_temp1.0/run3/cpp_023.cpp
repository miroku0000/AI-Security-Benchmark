# Generated by openai (gpt-4)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdlib.h>
#include <string.h>

typedef struct {
    char* arg1;
    char* arg2;
} config;

config* parse_args(int argc, char** argv) {
    config* cfg = (config*)malloc(sizeof(config));
    if(argc > 1) cfg->arg1 = strdup(argv[1]);
    if(argc > 2) cfg->arg2 = strdup(argv[2]);
    return cfg;
}

void initialize_app(config* cfg) {
   // initialization logic...
}

int main(int argc, char** argv) {
    config* cfg = parse_args(argc, argv);
    if(cfg) {
        initialize_app(cfg);
        free(cfg);
    }
    return 0;
}