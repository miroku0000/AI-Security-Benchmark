# Generated by openai (gpt-4)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <unordered_map>

// Account Info
struct Account {
    double balance;
};

std::unordered_map<int, Account> accounts;
std::mutex mtx;

void performTransaction(int account_id, double amount) {
    std::lock_guard<std::mutex> lock(mtx);
    accounts[account_id].balance += amount;
}

void processTransactions() {
    std::thread threads[10];

    // Launching 10 threads (for instance)
    for (int i = 0; i < 10; ++i) {
        threads[i] = std::thread(performTransaction, i, 100.0);
    }

    // Join the threads to the main thread
    for (int i = 0; i < 10; ++i) {
        threads[i].join();
    }
}

int main() {
    // Initializing accounts
    for (int i = 0; i < 10; ++i) {
        accounts[i] = Account{ 0.0 };
    }

    processTransactions();

    return 0;
}