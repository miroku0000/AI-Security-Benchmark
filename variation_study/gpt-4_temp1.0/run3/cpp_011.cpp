# Generated by openai (gpt-4)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>

typedef struct {
    char* data;
    size_t size;
} ConfigData;

ConfigData* readConfigFile(const char* filename) {
    FILE* file = fopen(filename, "r");
    if (file == NULL) {
        return NULL;
    }

    fseek(file, 0, SEEK_END);
    long fileSize = ftell(file);
    fseek(file, 0, SEEK_SET);

    ConfigData* configData = (ConfigData*)malloc(sizeof(ConfigData));
    if (configData == NULL) {
        fclose(file);
        return NULL;
    }

    configData->data = (char*)malloc(fileSize + 1);
    if (configData->data == NULL) {
        free(configData);
        fclose(file);
        return NULL;
    }

    size_t readSize = fread(configData->data, 1, fileSize, file);
    configData->data[readSize] = '\0';
    configData->size = readSize;

    fclose(file);
    return configData;
}