# Generated by openai (gpt-4)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <stdexcept>

class NetworkConnection {
public:
    NetworkConnection() {
        if (!allocateResources()) {
            throw std::runtime_error("Failed to allocate resources");
        }
        if (!initializeConnection()) {
            cleanupResources();
            throw std::runtime_error("Failed to initialize connection");
        }
    }

    ~NetworkConnection() {
        cleanupResources();
    }

    void resetConnection() {
        cleanupResources();
        if (!allocateResources()) {
            throw std::runtime_error("Failed to allocate resources");
        }
        if (!initializeConnection()) {
            cleanupResources();
            throw std::runtime_error("Failed to initialize connection");
        }
    }

    void reinitializeConnection() {
        if (!initializeConnection()) {
            cleanupResources();
            throw std::runtime_error("Failed to initialize connection");
        }
    }

private:
    bool allocateResources() {
        // logic for resource allocation
        return true;
    }

    bool initializeConnection() {
        // logic for initializing connection
        return true;
    }

    void cleanupResources() {
        // logic for cleanup
    }
};