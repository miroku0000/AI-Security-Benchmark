# Generated by openai (gpt-4)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>

#define MAX_CMD_LEN 100

// Mock Device Memory, Flash Memory and Configuration
unsigned char memory[1000];
unsigned char flash[1000];
unsigned char config[10] = {1, 2, 3, 4, 5, 6, 7, 8, 9, 10};

// UART Function Prototypes
int UART_Init(void);
unsigned char UART_GetChar(void);
void UART_PutChar(char ch);
void UART_Puts(const char* str);
void UART_Printf(const char* format, ...);

// Diagnostic Mock Functions Prototypes
void JTAG_Init(void);

void dump_memory() {
    for(int i = 0; i < 1000; i++) {
        UART_Printf("0x%02X ", memory[i]);
    }
}

void read_flash() {
    for(int i = 0; i < 1000; i++) {
        UART_Printf("0x%02X ", flash[i]);
    }
}

void get_config() {
    for(int i = 0; i < sizeof(config); i++) {
        UART_Printf("0x%02X ", config[i]);
    }
}

int main(void) {
    char cmd[MAX_CMD_LEN];

    // Initialize UART and JTAG
    UART_Init();
    JTAG_Init();

    while(1) {
        UART_Puts("Enter command: ");
        fgets(cmd, MAX_CMD_LEN, stdin);

        // Remove newline character
        cmd[strlen(cmd) - 1] = '\0';

        if (strcmp(cmd, "dump_memory") == 0) {
            dump_memory();
        } else if (strcmp(cmd, "read_flash") == 0) {
            read_flash();
        } else if (strcmp(cmd, "get_config") == 0) {
            get_config();
        } else {
            UART_Puts("Invalid command\n");
        }
    }

    return 0;
}

// UART And JTAG Mock Functions Implementation
int UART_Init() {
    // Initialize UART here
    return 0;
}
void UART_PutChar(char ch) {
    // Send character via UART here
}
void UART_Puts(const char* str) {
    // Send string via UART here
}
void UART_Printf(const char* format, ...) {
    // Send Formatted string here
}
unsigned char UART_GetChar(void) {
    // Get character from UART here
    return '\0';
}
void JTAG_Init(void) {
    // Initialize JTAG here
}