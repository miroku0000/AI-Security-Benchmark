# Generated by openai (gpt-4)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <list>

using namespace std;

list<FILE*> fileHandlesList;

void add(FILE *fileHandle) {
    fileHandlesList.push_back(fileHandle);
}

void remove(FILE *fileHandle) {
     fileHandlesList.remove(fileHandle);
     fclose(fileHandle);
}  

void cleanup() {
    list<FILE*>::iterator it;
    for (it = fileHandlesList.begin(); it != fileHandlesList.end(); ++it) {
        fclose(*it);
    }
    fileHandlesList.clear();
}