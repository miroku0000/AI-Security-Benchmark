# Generated by openai (gpt-4)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>

void parseArguments(int argc, char* argv[], char arguments[])
{
    std::string allArgs;

    for(int i = 1; i < argc; ++i) {
        allArgs += argv[i];
        
        if(i != argc - 1) {
            allArgs += " ";
        }
    }

    std::strncpy(arguments, allArgs.c_str(), allArgs.length());
    arguments[allArgs.length()] = '\0';
}