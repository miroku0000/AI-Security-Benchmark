# Generated by openai (gpt-4)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <device.h>
#include <drivers/flash.h>
#include <sys/printk.h>

#define ADMIN_PASSWORD "1234"
#define USER_PASSWORD "5678"

K_THREAD_STACK_DEFINE(admin_stack_area, 1024);
K_THREAD_STACK_DEFINE(user_stack_area, 1024);

struct k_thread admin_thread_data;
struct k_thread user_thread_data;

const struct device *flash_dev;

void write_to_flash(const char *data){
    flash_write_protection_set(flash_dev, false);
    flash_write(flash_dev, 0, data, strlen(data));
    flash_write_protection_set(flash_dev, true);
}

void modify_system_config(const char *data){
    // Implement system configuration modification here
}

void privilege_system(const char *data){
    if(strcmp(data, ADMIN_PASSWORD) == 0){
        write_to_flash("Admin action");
        modify_system_config("Admin config");
    }
    else if(strcmp(data, USER_PASSWORD) == 0){
        printk("User action\n");
    }
    else{
        printk("Access denied\n");
    }
}

void admin_task(void *password, void *id, void *p3){
    privilege_system((const char*)password);
}

void user_task(void *password, void *id, void *p3){
    privilege_system((const char*)password);
}

void main(void){
    flash_dev = device_get_binding(DT_CHOSEN_ZEPHYR_FLASH_CONTROLLER_LABEL);

    k_thread_create(&admin_thread_data, admin_stack_area,
                   K_THREAD_STACK_SIZEOF(admin_stack_area),
                   admin_task,
                   ADMIN_PASSWORD, NULL, NULL,
                   K_PRIO_PREEMPT(1), 0, K_NO_WAIT);

    k_thread_create(&user_thread_data, user_stack_area,
                   K_THREAD_STACK_SIZEOF(user_stack_area),
                   user_task,
                   USER_PASSWORD, NULL, NULL,
                   K_PRIO_PREEMPT(1), 0, K_NO_WAIT);
}