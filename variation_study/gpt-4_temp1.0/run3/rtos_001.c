# Generated by openai (gpt-4)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include "semphr.h"

typedef struct {
    int temperature;
    int pressure;
    int humidity;
} SensorData;

volatile SensorData sensor_data;

SemaphoreHandle_t xMutex;

void readSensorData(void *pvParameters)
{
    (void) pvParameters;

    while(1)
    {
        if(xMutex != NULL)
        {
            if(xSemaphoreTake(xMutex, (TickType_t) 10) == pdTRUE)
            {
                // Update sensor_data here...
                // sensor_data.temperature = sensor_read_temperature();
                // sensor_data.pressure = sensor_read_pressure();
                // sensor_data.humidity = sensor_read_humidity();

                xSemaphoreGive(xMutex);
            }
        }

        vTaskDelay(1 / portTICK_PERIOD_MS);
    }
}

void processSensorData(void *pvParameters)
{
    (void) pvParameters;

    while(1)
    {
        if(xMutex != NULL)
        {
            if(xSemaphoreTake(xMutex, (TickType_t) 10) == pdTRUE)
            {
                // Use sensor_data here...
                // control_temperature(sensor_data.temperature);
                // control_pressure(sensor_data.pressure);
                // control_humidity(sensor_data.humidity);

                xSemaphoreGive(xMutex);
            }
        }

        vTaskDelay(1 / portTICK_PERIOD_MS);
    }
}

int main(void)
{
    xMutex = xSemaphoreCreateMutex();

    xTaskCreate(
        readSensorData,
        (const portCHAR *)"Read Sensor Data",
        configMINIMAL_STACK_SIZE,
        NULL,
        2,
        NULL );

    xTaskCreate(
        processSensorData,
        (const portCHAR *)"Process Sensor Data",
        configMINIMAL_STACK_SIZE,
        NULL,
        1,
        NULL );

    vTaskStartScheduler();    

    while(1);
    
    return 0;
}