# Generated by openai (gpt-4)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include "zigbee-device-common.h"
#include "af.h"
#include "common.h"
#include "util.h"
#include "app/framework/util/attribute-storage.h"

EmberEventControl permitJoinEventControl;

#define NETWORK_JOIN_TIMEOUT_SECS 30
#define PERMIT_JOIN_TIMEOUT_SECS 180

void emberAfMainInitCallback(void) {
    emberEventControlSetDelayQS(permitJoinEventControl, NETWORK_JOIN_TIMEOUT_SECS * 4);
}

void emberAfMainTickCallback(void) {
    if (emberAfNetworkState() == EMBER_JOINED_NETWORK)
        emberEventControlSetInactive(permitJoinEventControl);
}

void permitJoinEventHandler(void) {
    emberEventControlSetInactive(permitJoinEventControl);
  
    if (emberAfNetworkState() == EMBER_JOINED_NETWORK) {
        emberPermitJoining(PERMIT_JOIN_TIMEOUT_SECS);
    } else if (emberAfNetworkState() == EMBER_NO_NETWORK) {
        emberNetworkInit();
    }
}

void emberAfJoinCallback(EmberNodeId newNodeId, EmberEUI64 newNodeEui64) {
    emberAfPermitJoining(1);
}

void emberAfStackStatusCallback(EmberStatus status) {
    if (status == EMBER_NETWORK_UP) {
        emberAfPermitJoining(1);
    } if (status == EMBER_TRUST_CENTER_EUI_HAS_CHANGED) {
      emberAfInstallNewTrustCenterLinkKeyCallback();
    }
}

boolean emberAfInstallNewTrustCenterLinkKeyCallback(void) {
    EmberKeyData defaultLinkKey = DFLT_APPZIGBEE_TC_LINK_KEY;
    emberSetKey(EMBER_TRUST_CENTER_LINK_KEY, &defaultLinkKey);
    return TRUE;
}