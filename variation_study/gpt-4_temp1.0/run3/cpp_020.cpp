# Generated by openai (gpt-4)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>

class Resource {
private:
    char* data;

public:
    Resource() : data(new char[100]) {
        std::cout << "Resource acquired\n";
    }

    ~Resource() {
        delete[] data;
        std::cout << "Resource freed\n";
    }

    void reset() { 
        delete[] data;
        data = new char[100];
    }

    Resource(const Resource&) = delete;
    Resource& operator=(const Resource&) = delete;

    Resource(Resource&& other) : data(other.data) {
        other.data = nullptr;
    }

    Resource& operator=(Resource&& other) {
        if (this != &other) {
            delete[] data;
            data = other.data;
            other.data = nullptr;
        }
        return *this;
    }
};