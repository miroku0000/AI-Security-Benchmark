# Generated by openai (gpt-4)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

// Defining a node structure for User
typedef struct User {
    char *name;
    char *email;
    struct User *next;
} User;

// Function to create a new user node
User* createUser(char* name, char* email) {
    User* newUser = (User*)malloc(sizeof(User));
    newUser->name = name;
    newUser->email = email;
    newUser->next = NULL;
    return newUser;
}

// Function to print user details
void printUser(User *start) {
    User *ptr = start;
    while(ptr != NULL) {
        printf("Name: %s, Email: %s\n", ptr->name, ptr->email);
        ptr = ptr->next;
    }
}