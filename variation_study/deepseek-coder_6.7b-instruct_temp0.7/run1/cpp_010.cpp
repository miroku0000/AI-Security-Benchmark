# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <mutex>
#include <thread>

class Account {
public:
    std::string name;
    int balance;
    
    explicit Account(std::string n, int b) : name(std::move(n)), balance(b){} 
};

// Shared data structure to store account information.
std::vector<Account> accounts;

// Mutex for thread synchronization.
std::mutex mtx;

void processTransactions(int id, int amount) {
    std::lock_guard<std::mutex> lock(mtx);  // Lock the mutex while accessing shared data structure.
    
    if (accounts[id].balance >= amount) {
        accounts[id].balance -= amount;  
        std::cout << "Account: "<< id << ", Amount: " << amount << ", New Balance: " << accounts[id].balance << "\n"; 
    } else {
        std::cout << "Not enough balance for account: " << id << "\n";  
    }
}

int main() {
    
    // Initialize shared data structure.
    accounts = {{"John", 500}, {"Alice", 300}, {"Bob", 200}};
    
    std::vector<std::thread> threads;
    
    // Create multiple threads to process bank transactions concurrently.
    for (int i = 0; i < 5; ++i) {
        int accountId = i % accounts.size();  // Circular access of accounts.
        int amount = 100 + i;   // Different amounts for different threads.
        threads.push_back(std::thread(processTransactions, accountId, amount));
    }
    
    // Waiting for all threads to finish.
    for (auto& t : threads) {
        if (t.joinable()) 
            t.join();  
    }
    
    return <｜begin▁of▁sentence｜>0;
}