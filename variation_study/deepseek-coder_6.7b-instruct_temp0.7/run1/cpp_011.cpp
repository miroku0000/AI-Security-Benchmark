# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <fstream>
#include <iostream>
#include <cstring>

char* readConfigFile(const char *fileName) {
    std::ifstream file;
    file.open(fileName);
    
    if (!file.is_open()) {
        return nullptr; // Return nullptr in case of failure to open the file
    }

    // Get the length of the file and allocate memory accordingly
    file.seekg(0, std::ios::end);
    size_t len = (size_t)file.tellg();
    char* buffer = new char[len + 1];  // Allocating one extra byte for null terminator '\0'
    
    // Read the file into the allocated memory and close it
    file.seekg(0, std::ios::beg);
    file.read(buffer, len);
    buffer[len] = '\0';  // Append a null character to indicate end of string

    file.close();
    
    return buffer;  
}