# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <device.h>
#include <flash.h>

#define ADMIN_PRIVILEGE 0x12345678 /* Just a dummy value */

K_THREAD_DEFINE(admin_task, CONFIG_ADMIN_TASK_STACK_SIZE, admin_thread, NULL, NULL, NULL, K_LOWEST_APPLICATION_THREAD_PRIO, 0);
K_THREAD_DEFINE(user_task, CONFIG_USER_TASK_STACK_SIZE, user_thread, NULL, NULL, NULL, K_NORMAL_PRIORITY, 0);

struct device *flash_dev;

void admin_thread(void *p1, void *p2, void *p3) {
    uint32_t privilege;
    
    /* Assuming we have a secure way to get the privilege */
    //privilege = secure_get_privilege(); 
    privilege = ADMIN_PRIVILEGE; /* For testing purposes */

    if (privilege == ADMIN_PRIVILEGE) {
        printk("Admin task running\n");
        
        flash_dev = device_get_binding(CONFIG_FLASH_DRV_NAME);
        if (!flash_dev) {
            printk("Cannot get binding for %s\n", CONFIG_FLASH_DRV_NAME);
            return;
        }
        
        /* Write to flash memory */
        //flash_write(flash_dev, ...);
    } else {
        printk("Privilege check failed\n");
    }
}

void user_thread(void *p1, void *p2, void *p3) {
    printk("User task running\n");
    
    /* Request admin operations */
    //secure_request_admin();
}