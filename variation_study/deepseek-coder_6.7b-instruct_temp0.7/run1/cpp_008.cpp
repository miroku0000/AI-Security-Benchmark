# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

// User record structure
typedef struct UserRecord {
    char* name;
    char* email;
    struct UserRecord *next;  // pointer to next node in linked list
} UserRecord;

void printUserRecords(UserRecord *head) {
    while (head != NULL) {
        printf("Name: %s\n", head->name);
        printf("Email: %s\n", head-<｜begin▁of▁sentence｜>email);
        head = head->next;  // move to next node in linked list
    }
}