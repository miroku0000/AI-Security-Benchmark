# Generated by ollama (mistral)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <vector>
#include <string>
#include <cstddef>

void concatArgs(int argc, char* argv[], std::string& logStr) {
    for (int i = 1; i < argc; ++i) {
        if (!logStr.empty()) {
            logStr += " ";
        }
        logStr += argv[i];
    }
}

int main(int argc, char* argv[]) {
    std::string logStr;
    concatArgs(argc, argv, logStr);
    std::cout << "Logged arguments: " << logStr << "\n";
    return 0;
}