# Generated by ollama (mistral)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>
#include <memory>

class FileHandle {
public:
    virtual ~FileHandle() = default;
};

using FileHandlePtr = std::unique_ptr<FileHandle>;
using FileHandleList = std::vector<FileHandlePtr>;

class FilePool {
private:
    FileHandleList pool;

public:
    void add(FileHandlePtr handle) {
        pool.push_back(std::move(handle));
    }

    bool remove(FileHandlePtr handle) {
        auto it = std::find_if(pool.begin(), pool.end(),
                               [&](const FileHandlePtr &h) { return *h == *handle; });
        if (it != pool.end()) {
            pool.erase(it);
            return true;
        }
        return false;
    }

    void cleanup() {
        for (auto &handle : pool) {
            handle->~FileHandle();
        }
        pool.clear();
    }
};