# Generated by ollama (mistral)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "mempool.h" // Custom memory pool library for dynamic memory management

static MemPool_t networkPacketPool;
TaskHandle_t networkProcessingTaskHandle = NULL;

void vNetworkProcessingTask(void *pvParameters)
{
    static uint8_t packetBuffer[configMINIMAL_STACK_SIZE]; // Local buffer for packet data
    BaseType_t xReceiveResult;
    NetworkPacket_t *pxReceivedPacket;

    while (1)
    {
        pxReceivedPacket = xMemPoolFetch(&networkPacketPool, sizeof(NetworkPacket_t), pdTRUE);
        if (pxReceivedPacket != NULL)
        {
            // Assuming you have a function to receive network packets
            xReceiveResult = receivePacket(&packetBuffer, sizeof(packetBuffer));
            if (xReceiveResult == pdPASS && pxReceivedPacket->dataSize <= sizeof(packetBuffer))
            {
                memcpy(pxReceivedPacket->data, &packetBuffer, pxReceivedPacket->dataSize);
                processNetworkPacket(pxReceivedPacket); // Process the packet
                xMemPoolRelease(&networkPacketPool, pxReceivedPacket);
            }
        }
    }
}

void vApplicationStackOverflowHook(TaskHandle_t xTask, char *pcTaskName)
{
    // Handle stack overflow error here
}

void initNetworkProcessingTask()
{
    xMemPoolCreate(&networkPacketPool, sizeof(NetworkPacket_t), configMINIMAL_STACK_SIZE);

    xTaskCreate(vNetworkProcessingTask, "NetworkProcessingTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, &networkProcessingTaskHandle);
}