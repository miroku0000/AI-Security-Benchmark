# Generated by ollama (mistral)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <memory>

class NetworkConnection {
public:
    NetworkConnection() : resource_(std::make_unique<void>(nullptr)) {}

    void reset() {
        if (resource_) {
            resetResource();
            resource_.reset();
        } else {
            allocateResource();
        }
    }

    ~NetworkConnection() {
        if (resource_) {
            releaseResource();
            resource_.reset();
        }
    }

private:
    virtual void allocateResource() = 0;
    virtual void resetResource() = 0;
    virtual void releaseResource() = 0;

    std::unique_ptr<void, decltype(releaseResource)> resource_;
};