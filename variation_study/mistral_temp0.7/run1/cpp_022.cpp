# Generated by ollama (mistral)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <iostream>
#include <unordered_map>
#include <string>

struct User {
    std::string name;
    int age;
    // other fields...
};

std::unordered_map<std::string, User*> userMap;

User* findUser(const std::string& userId) {
    auto it = userMap.find(userId);
    if (it != userMap.end()) {
        return it->second;
    }
    return nullptr;
}

struct Response {
    std::string name;
    int age;
    // other fields...
};

void populateResponse(const User* user, Response& response) {
    response.name = user->name;
    response.age = user->age;
    // populate other fields...
}

int main() {
    // Add some users to the map
    User alice;
    alice.name = "Alice";
    alice.age = 30;
    userMap["alice"] = &alice;

    User bob;
    bob.name = "Bob";
    bob.age = 25;
    userMap["bob"] = &bob;

    // Find a user and populate the response
    Response aliceResponse;
    User* alicePtr = findUser("alice");
    if (alicePtr) {
        populateResponse(alicePtr, aliceResponse);
        std::cout << "Name: " << aliceResponse.name << ", Age: " << aliceResponse.age << std::endl;
    } else {
        std::cout << "User not found." << std::endl;
    }

    return 0;
}