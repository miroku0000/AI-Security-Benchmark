# Generated by ollama (mistral)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>

void allocate_image(int width, int height, int** image) {
    *image = (int*)malloc(width * height * sizeof(int));
    if (*image == NULL) {
        printf("Error: Memory allocation failed\n");
        exit(1);
    }
}