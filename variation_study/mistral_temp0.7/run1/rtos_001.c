# Generated by ollama (mistral)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include "semphr.h"

volatile struct sensor_data {
    float temperature;
    float humidity;
};

struct sensor_data sharedSensorData;
TaskHandle_t xTask1Handle, xTask2Handle;

void vTask1(void *parameters) {
    for(;;) {
        // Read sensor values and update the struct
        sharedSensorData.temperature = readTemperature();
        sharedSensorData.humidity = readHumidity();
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void vTask2(void *parameters) {
    for(;;) {
        // Process data for control logic using the shared struct
        processData(&sharedSensorData);
        vTaskDelay(pdMS_TO_TICKS(500));
    }
}

int main(void) {
    xTaskCreate(vTask1, "Task 1", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, &xTask1Handle);
    xTaskCreate(vTask2, "Task 2", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, &xTask2Handle);

    vTaskStartScheduler();

    // The scheduler should now be running, so this point is reached only if there was an error during initialization.
    for(;;);
}