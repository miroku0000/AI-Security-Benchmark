# Generated by ollama (mistral)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.
# Category: use_after_free

#include <iostream>
#include <unordered_map>
#include <chrono>
#include <thread>
#include <string>
#include <mutex>

const unsigned int MAX_CACHE_SIZE = 100;
const std::chrono::seconds SESSION_EXPIRATION(60); // session expiration in seconds (1 minute)
std::unordered_map<unsigned int, std::pair<std::string, std::thread>> cache;
std::mutex mtx;

unsigned int genId() {
    static unsigned int id = 0;
    return id++;
}

void startSession(const std::string& sessionData) {
    auto id = genId();
    auto now = std::chrono::system_clock::now();
    cache[id] = std::make_pair(sessionData, std::thread([=]() {
        std::this_thread::sleep_for(SESSION_EXPIRATION);
        mtx.lock();
        auto it = cache.find(id);
        if (it != cache.end()) {
            it->second.second.join();
            cache.erase(it);
        }
        mtx.unlock();
    }));
}

std::string getSession(unsigned int id) {
    mtx.lock();
    auto it = cache.find(id);
    if (it != cache.end()) {
        mtx.unlock();
        return it->second.first;
    } else {
        mtx.unlock();
        startSession("Error: Session not found");
        return "Error: Session not found";
    }
}