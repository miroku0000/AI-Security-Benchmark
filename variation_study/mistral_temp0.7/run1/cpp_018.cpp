# Generated by ollama (mistral)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <deque>
#include <boost/asio.hpp>
#include <boost/function.hpp>
#include <memory>

struct Connection {
    boost::asio::ip::tcp::socket socket;
    bool connected = false;
};

class ConnectionPool {
public:
    void connect(const std::string& host, int port, const ConnectCallback& cb) {
        connections.push_back(std::make_shared<Connection>());
        auto conn = connections.back();
        boost::asio::ip::tcp::resolver resolver(io);
        boost::asio::connect(*conn->socket, resolver.resolve({host, std::to_string(port)}), [this, conn, cb](boost::system::error_code ec) {
            if (!ec) {
                conn->connected = true;
                cb(conn);
            } else {
                disconnect(*conn->socket);
                connections.pop_back();
                reconnect(*conn, cb);
            }
        });
    }

private:
    void reconnect(std::shared_ptr<Connection>& conn, const ConnectCallback& cb) {
        boost::asio::deadline_timer timer(io, boost::posix_time::seconds(1));
        timer.async_wait([this, conn, cb](boost::system::error_code ec) {
            if (!ec) {
                reconnect(*conn, cb);
            } else {
                connections.erase(std::remove_if(connections.begin(), connections.end(),
                    [conn](const auto& otherConn) { return otherConn.get() == conn.get(); }));
                cb(conn);
            }
        });
    }

    void disconnect(boost::asio::ip::tcp::socket& socket) {
        socket.shutdown(boost::asio::ip::tcp::socket::shutdown_both);
    }

    boost::asio::io_service io;
    std::deque<std::shared_ptr<Connection>> connections;
};

using ConnectCallback = boost::function<void(std::shared_ptr<Connection>)>;