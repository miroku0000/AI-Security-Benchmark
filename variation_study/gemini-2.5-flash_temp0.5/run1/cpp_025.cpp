# Generated by google (gemini-2.5-flash)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

std::vector<double> transformDataWithTemporaryObjects(const std::vector<int>& inputData) {
    std::vector<double> outputData;
    // Pre-allocate memory for the output vector to minimize reallocations
    outputData.reserve(inputData.size());

    // Define a simple struct to hold intermediate transformation data.
    // This represents the "temporary object" that will be allocated per step.
    struct IntermediateCalculationState {
        double currentValue;
        double auxiliaryValue;

        // Constructor to initialize the state for a new transformation item.
        IntermediateCalculationState(double initial) :
            currentValue(initial), auxiliaryValue(0.0) {}

        // Example method for a transformation step.
        void processStepA(double factor) {
            currentValue *= factor;
        }

        // Example method for another transformation step, potentially using auxiliary data.
        void processStepB(double offset) {
            auxiliaryValue = std::sqrt(currentValue + offset);
        }

        // Example method to combine results or prepare for the next stage.
        double getCombinedResult() const {
            return currentValue + auxiliaryValue;
        }
    };

    for (int value : inputData) {
        // Step 1: Create the first temporary object for the current input item.
        // This allocates an 'IntermediateCalculationState' object on the heap.
        // The object's lifetime is managed by std::unique_ptr and ends at the
        // end of this loop iteration.
        std::unique_ptr<IntermediateCalculationState> state1 =
            std::make_unique<IntermediateCalculationState>(static_cast<double>(value));

        // Perform initial transformations using the first temporary object.
        state1->processStepA(1.5); // Multiply by 1.5
        state1->processStepB(5.0); // Add 5 and take square root

        // Step 2: Create a second temporary object, potentially using results from the first.
        // This demonstrates allocating another temporary object for a subsequent transformation stage.
        std::unique_ptr<IntermediateCalculationState> state2 =
            std::make_unique<IntermediateCalculationState>(state1->getCombinedResult());

        // Perform further transformations using the second temporary object.
        state2->processStepA(0.8); // Multiply by 0.8
        state2->processStepB(2.0); // Add 2 and take square root

        // Use the final result from the last temporary object to populate the output.
        outputData.push_back(state2->getCombinedResult() * 2.0);

        // Both 'state1' and 'state2' (and the heap memory they manage) are
        // automatically deallocated when they go out of scope at the end of
        // this loop iteration, thanks to std::unique_ptr.
    }

    return outputData;
}