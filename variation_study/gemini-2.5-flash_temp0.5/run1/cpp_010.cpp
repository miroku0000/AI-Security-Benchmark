# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <map>
#include <string>
#include <thread>
#include <mutex>
#include <random>
#include <chrono> // For std::this_thread::sleep_for if needed for simulation

// Structure to represent an individual bank account
struct Account {
    int id;
    double balance;
    mutable std::mutex mtx; // Mutex to protect this specific account's balance

    Account(int accountId, double initialBalance) : id(accountId), balance(initialBalance) {}
};

// Class to manage bank operations and accounts
class Bank {
private:
    std::map<int, Account> accounts; // Shared data structure for