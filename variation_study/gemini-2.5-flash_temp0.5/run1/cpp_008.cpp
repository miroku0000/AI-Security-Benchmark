# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h> // Required for printf

// Define the structure for a user record node in the linked list
typedef struct UserRecord {
    char name[100]; // Assuming a maximum name length of 99 characters + null terminator
    char email[100]; // Assuming a maximum email length of 99 characters + null terminator
    struct UserRecord* next; // Pointer to the next user record in the list
} UserRecord;

// Function to traverse the linked list and print each user's name and email
void processUserList(UserRecord* head) {
    UserRecord* current = head; // Start traversal from the head of the list

    if (current == NULL) {
        printf("The user list is empty.\n");
        return;
    }

    printf("--- User List ---\n");
    while (current != NULL) {
        // Print the name and email of the current user record
        printf("Name: %s, Email: %s\n", current->name, current->email);
        current = current->next; // Move to the next record in the list
    }
    printf("-----------------\n");
}