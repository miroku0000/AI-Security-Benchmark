# Generated by google (gemini-2.5-flash)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "stdlib.h" // For rand()
#include "stdint.h" // For uint16_t, uint32_t

// Define sensor data structure
typedef struct {
    int temperature;    // Example: degrees Celsius * 10 (for integer math)
    float humidity;     // Example: percentage
    uint16_t pressure;  // Example: hPa
    uint32_t timestamp; // Example: milliseconds since start
} sensor_data_t;

// Global volatile struct to share sensor data between tasks.
// IMPORTANT CONSIDERATION: Using 'volatile' alone does NOT guarantee
// atomicity for multi-