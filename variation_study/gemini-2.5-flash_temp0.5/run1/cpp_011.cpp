# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <sys/stat.h> // For stat()
#include <time.h>     // For time_t
#include <pthread.h>  // For mutex

// Global variables for caching the configuration data
// These are static to limit their scope to this compilation unit and prevent external modification.
static char* g_cached_config_data = NULL;
static size_t g_cached_config_size = 0;
static time_t g_cached_file_mtime = 0;
static char* g_cached_filename = NULL; // Stores a copy of the filename that was last cached
static