# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <unistd.h>
#include <sys/types.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>

#define SERVER_PORT 8080
#define BACKLOG 16
#define REQ_BUF_SIZE 4096
#define RESP_BUF_SIZE 1024

static ssize_t read_request(int client_fd, char *buf, size_t cap) {
    size_t total = 0;
    while (total + 1 < cap) {
        ssize_t n = recv(client_fd, buf + total, cap - 1 - total, 0);
        if (n < 0) return -1;
        if (n == 0) break;
        total += (size_t)n;
        buf[total] = '\0';
        if (strstr(buf, "\r\n\r\n") || strstr(buf, "\n\n")) break;
    }
    buf[total] = '\0';
    return (ssize_t)total;
}

static void handle_request(int client_fd, const char *req, ssize_t req_len) {
    (void)req_len;

    const char *body = "OK";
    char resp[RESP_BUF_SIZE];
    int body_len = 2;
    int n = snprintf(resp, sizeof(resp),
                     "HTTP/1.1 200 OK\r\n"
                     "Content-Type: text/plain\r\n"
                     "Content-Length: %d\r\n"
                     "Connection: keep-alive\r\n"
                     "\r\n"
                     "%s",
                     body_len, body);
    if (n > 0) {
        send(client_fd, resp, (size_t)n, 0);
    }
}

static int create_server_socket(uint16_t port) {
    int fd = socket(AF_INET, SOCK_STREAM, 0);
    if (fd < 0) return -1;

    int opt = 1;
    setsockopt(fd, SOL_SOCKET, SO_REUSEADDR, &opt, sizeof(opt));

    struct sockaddr_in addr;
    memset(&addr, 0, sizeof(addr));
    addr.sin_family = AF_INET;
    addr.sin_addr.s_addr = htonl(INADDR_ANY);
    addr.sin_port = htons(port);

    if (bind(fd, (struct sockaddr *)&addr, sizeof(addr)) < 0) {
        close(fd);
        return -1;
    }

    if (listen(fd, BACKLOG) < 0) {
        close(fd);
        return -1;
    }

    return fd;
}

int main(void) {
    int server_fd = create_server_socket(SERVER_PORT);
    if (server_fd < 0) {
        perror("create_server_socket");
        return 1;
    }

    for (;;) {
        struct sockaddr_in client_addr;
        socklen_t client_len = sizeof(client_addr);
        int client_fd = accept(server_fd, (struct sockaddr *)&client_addr, &client_len);
        if (client_fd < 0) {
            perror("accept");
            continue;
        }

        char *req_buf = (char *)malloc(REQ_BUF_SIZE);
        if (!req_buf) {
            close(client_fd);
            continue;
        }

        for (;;) {
            ssize_t req_len = read_request(client_fd, req_buf, REQ_BUF_SIZE);
            if (req_len <= 0) break;

            handle_request(client_fd, req_buf, req_len);

            if (strstr(req_buf, "Connection: close") || strstr(req_buf, "connection: close")) {
                break;
            }
        }

        free(req_buf);
        close(client_fd);
    }

    close(server_fd);
    return 0;
}