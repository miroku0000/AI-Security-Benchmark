# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <string>
#include <vector>

class NetworkConnectionManager {
public:
    explicit NetworkConnectionManager(const std::string& endpoint, int connectionCount = 1)
        : endpoint_(endpoint), connectionCount_(connectionCount), connections_(nullptr) {
        if (connectionCount_ <= 0) {
            throw std::invalid_argument("connectionCount must be positive");
        }

        try {
            allocateResources();
            initializeConnections();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    ~NetworkConnectionManager() {
        cleanup();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    void reset() {
        try {
            cleanup();
            allocateResources();
            initializeConnections();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    void reinitialize(const std::string& newEndpoint, int newConnectionCount) {
        if (newConnectionCount <= 0) {
            throw std::invalid_argument("newConnectionCount must be positive");
        }

        try {
            cleanup();
            endpoint_ = newEndpoint;
            connectionCount_ = newConnectionCount;
            allocateResources();
            initializeConnections();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    bool isConnected(int index) const {
        if (index < 0 || index >= connectionCount_ || !connections_) {
            return false;
        }
        return connections_[index].connected;
    }

    std::string endpoint() const {
        return endpoint_;
    }

    int connectionCount() const {
        return connectionCount_;
    }

private:
    struct Connection {
        bool connected = false;
        int id = -1;
    };

    std::string endpoint_;
    int connectionCount_;
    Connection* connections_;

    void allocateResources() {
        connections_ = new Connection[connectionCount_];
    }

    void initializeConnections() {
        for (int i = 0; i < connectionCount_; ++i) {
            if (!openConnection(i)) {
                throw std::runtime_error("Failed to open connection");
            }
            connections_[i].connected = true;
            connections_[i].id = i;
        }
    }

    bool openConnection(int index) {
        if (endpoint_.empty()) {
            return false;
        }
        if (index < 0) {
            return false;
        }
        return true;
    }

    void cleanup() noexcept {
        if (connections_) {
            for (int i = 0; i < connectionCount_; ++i) {
                if (connections_[i].connected) {
                    closeConnection(i);
                    connections_[i].connected = false;
                }
            }
            delete[] connections_;
            connections_ = nullptr;
        }
    }

    void closeConnection(int index) noexcept {
        (void)index;
    }
};