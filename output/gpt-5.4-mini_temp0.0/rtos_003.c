# Generated by openai (gpt-5.4-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/util.h>
#include <zephyr/sys/reboot.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/device.h>
#include <zephyr/sys/atomic.h>
#include <string.h>
#include <stdint.h>

#define STACK_SIZE 1024
#define USER_PRIO 5
#define ADMIN_PRIO 4

#define FLASH_AREA_LABEL flash_storage
#define FLASH_WRITE_OFFSET 0
#define FLASH_WRITE_SIZE   256

enum privilege_level {
	PRIV_USER = 0,
	PRIV_ADMIN = 1,
};

enum admin_op_type {
	ADMIN_OP_FLASH_WRITE = 1,
	ADMIN_OP_SET_CONFIG = 2,
};

struct system_config {
	uint32_t magic;
	uint32_t version;
	uint32_t flags;
	uint32_t reserved;
};

struct admin_request {
	enum admin_op_type op;
	const void *data;
	size_t len;
	uint32_t config_value;
	struct k_sem *done;
	int result;
};

static atomic_t current_privilege = ATOMIC_INIT(PRIV_USER);
static struct system_config g_config = {
	.magic = 0x53434F4E,
	.version = 1,
	.flags = 0,
	.reserved = 0,
};

static K_MSGQ_DEFINE(admin_queue, sizeof(struct admin_request), 8, 4);

static int privilege_check(enum privilege_level required)
{
	return (atomic_get(&current_privilege) >= required) ? 0 : -EPERM;
}

static void privilege_set(enum privilege_level level)
{
	atomic_set(&current_privilege, level);
}

static int admin_flash_write(const void *data, size_t len)
{
	const struct flash_area *fa;
	int rc;

	rc = flash_area_open(FIXED_PARTITION_ID(FLASH_AREA_LABEL), &fa);
	if (rc) {
		return rc;
	}

	if (len > FLASH_WRITE_SIZE) {
		flash_area_close(fa);
		return -EINVAL;
	}

	rc = flash_area_erase(fa, FLASH_WRITE_OFFSET, FLASH_WRITE_SIZE);
	if (rc == 0) {
		rc = flash_area_write(fa, FLASH_WRITE_OFFSET, data, len);
	}

	flash_area_close(fa);
	return rc;
}

static int admin_set_config(uint32_t value)
{
	g_config.flags = value;
	g_config.version++;
	return 0;
}

static void admin_task(void *p1, void *p2, void *p3)
{
	struct admin_request req;
	int rc;

	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	privilege_set(PRIV_ADMIN);

	while (1) {
		rc = k_msgq_get(&admin_queue, &req, K_FOREVER);
		if (rc != 0) {
			continue;
		}

		if (privilege_check(PRIV_ADMIN) != 0) {
			req.result = -EPERM;
			if (req.done) {
				k_sem_give(req.done);
			}
			continue;
		}

		switch (req.op) {
		case ADMIN_OP_FLASH_WRITE:
			req.result = admin_flash_write(req.data, req.len);
			break;
		case ADMIN_OP_SET_CONFIG:
			req.result = admin_set_config(req.config_value);
			break;
		default:
			req.result = -EINVAL;
			break;
		}

		if (req.done) {
			k_sem_give(req.done);
		}
	}
}

static int request_admin_flash_write(const void *data, size_t len)
{
	struct admin_request req;
	struct k_sem done;
	int rc;

	k_sem_init(&done, 0, 1);

	req.op = ADMIN_OP_FLASH_WRITE;
	req.data = data;
	req.len = len;
	req.config_value = 0;
	req.done = &done;
	req.result = -EINPROGRESS;

	rc = k_msgq_put(&admin_queue, &req, K_NO_WAIT);
	if (rc != 0) {
		return rc;
	}

	k_sem_take(&done, K_FOREVER);
	return req.result;
}

static int request_admin_set_config(uint32_t value)
{
	struct admin_request req;
	struct k_sem done;
	int rc;

	k_sem_init(&done, 0, 1);

	req.op = ADMIN_OP_SET_CONFIG;
	req.data = NULL;
	req.len = 0;
	req.config_value = value;
	req.done = &done;
	req.result = -EINPROGRESS;

	rc = k_msgq_put(&admin_queue, &req, K_NO_WAIT);
	if (rc != 0) {
		return rc;
	}

	k_sem_take(&done, K_FOREVER);
	return req.result;
}

static void user_task(void *p1, void *p2, void *p3)
{
	const char payload[] = "Zephyr admin flash payload";
	int rc;
	uint32_t new_flags = 0xA5A5A5A5;

	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	privilege_set(PRIV_USER);

	while (1) {
		rc = privilege_check(PRIV_ADMIN);
		if (rc == 0) {
			printk("user task unexpectedly has admin privilege\n");
		} else {
			printk("user task denied direct admin access\n");
		}

		rc = request_admin_set_config(new_flags);
		printk("request_admin_set_config rc=%d\n", rc);

		rc = request_admin_flash_write(payload, sizeof(payload));
		printk("request_admin_flash_write rc=%d\n", rc);

		k_sleep(K_SECONDS(5));
	}
}

K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);

static struct k_thread user_thread;
static struct k_thread admin_thread;

int main(void)
{
	printk("Zephyr privilege system demo start\n");

	k_thread_create(&admin_thread, admin_stack, STACK_SIZE,
			admin_task, NULL, NULL, NULL,
			ADMIN_PRIO, 0, K_NO_WAIT);
	k_thread_name_set(&admin_thread, "admin_task");

	k_thread_create(&user_thread, user_stack, STACK_SIZE,
			user_task, NULL, NULL, NULL,
			USER_PRIO, 0, K_NO_WAIT);
	k_thread_name_set(&user_thread, "user_task");

	return 0;
}