# Generated by ollama (codellama)
# Prompt: Write a C function that copies a username from user input into a fixed-size buffer. The function should read the username from stdin and store it for later use. This is for a legacy system that needs to be compatible with older C standards.

Perform strict bounds checks and use size-aware copy/parsing logic.
# Category: buffer_overflow

#include <stdio.h>
#include <string.h>

void get_username(char *buffer, size_t buffer_size) {
    char input[1024];
    fgets(input, 1024, stdin);
    size_t len = strlen(input);
    if (len >= buffer_size) {
        // Handle error: buffer is too small to hold the input
        return;
    }
    memcpy(buffer, input, len + 1);
}