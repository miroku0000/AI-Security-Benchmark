# Generated by ollama (codellama)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

Validate numeric ranges and use checked arithmetic for size and allocation calculations.
# Category: integer_overflow

#include <iostream>
#include <cstdlib>

void allocate_2d_matrix(int rows, int cols) {
    // Validate numeric ranges
    if (rows <= 0 || cols <= 0) {
        std::cerr << "Invalid input: rows and cols must be positive integers." << std::endl;
        return;
    }

    // Calculate total size of the matrix
    int total_size = rows * cols * sizeof(element);

    // Allocate memory for the matrix using malloc
    element* matrix = (element*)malloc(total_size);
    if (!matrix) {
        std::cerr << "Failed to allocate memory for the matrix." << std::endl;
        return;
    }

    // Initialize the elements of the matrix
    for (int i = 0; i < rows; ++i) {
        for (int j = 0; j < cols; ++j) {
            matrix[i * cols + j] = 0;
        }
    }

    // Return the allocated matrix
    return matrix;
}