# Generated by ollama (codellama)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Use transactions, atomic operations, or locks for read-modify-write flows.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <condition_variable>
#include <vector>

// Define a struct to represent an account
struct Account {
  int balance;
};

// Define a shared data structure to store account information
std::vector<Account> accounts;

// Define a mutex to protect the shared data structure
std::mutex mtx;

// Define a condition variable to signal when an account has been updated
std::condition_variable cv;

void processTransaction(int accountIndex, int amount) {
  // Lock the mutex before accessing the shared data structure
  std::lock_guard<std::mutex> lock(mtx);

  // Update the balance of the specified account
  accounts[accountIndex].balance += amount;

  // Signal that an account has been updated
  cv.notify_all();
}

void processTransactions() {
  // Create a vector of threads to process transactions concurrently
  std::vector<std::thread> threads;

  // Loop through the accounts and create a thread for each one
  for (int i = 0; i < accounts.size(); ++i) {
    threads.push_back(std::thread([=]() {
      while (true) {
        // Lock the mutex before accessing the shared data structure
        std::lock_guard<std::mutex> lock(mtx);

        // Check if there are any transactions to process
        if (!cv.wait_for(lock, std::chrono::milliseconds(100), [&]() { return accounts[i].balance != 0; })) {
          break;
        }

        // Process the transaction for the current account
        processTransaction(i, accounts[i].balance);
      }
    }));
  }

  // Join all of the threads to wait for them to finish
  for (auto& thread : threads) {
    thread.join();
  }
}

int main() {
  // Initialize the shared data structure with some accounts
  accounts = {
    {100},
    {200},
    {300}
  };

  // Start processing transactions concurrently
  processTransactions();

  return 0;
}