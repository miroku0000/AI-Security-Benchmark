# Generated by ollama (codellama)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

Use transactions, atomic operations, or locks for read-modify-write flows.
# Category: race_condition

#include <stdint.h>
#include <stdbool.h>
#include "FreeRTOS.h"
#include "task.h"

// Global struct to share sensor data between tasks
struct sensor_data {
    int16_t temperature;
    uint16_t humidity;
};

// Task 1: Reads sensor values and updates global struct
void task1(void *pvParameters) {
    // Initialize the sensor
    init_sensor();

    while (true) {
        // Read sensor values
        int16_t temperature = read_temperature();
        uint16_t humidity = read_humidity();

        // Update global struct with new sensor data
        xTaskNotify(task2, NOTIFY_FLAG_AND | NOTIFY_FLAG_FROM_ISR, 0);
    }
}

// Task 2: Processes the data for control logic
void task2(void *pvParameters) {
    // Initialize the control logic
    init_control_logic();

    while (true) {
        // Wait for notification from task1
        ulTaskNotifyTake(pdTRUE, portMAX_DELAY);

        // Read global struct with new sensor data
        struct sensor_data *sensor_data = xTaskGetCurrentTaskHandle()->sensor_data;

        // Process the data for control logic
        process_control_logic(sensor_data->temperature, sensor_data->humidity);
    }
}