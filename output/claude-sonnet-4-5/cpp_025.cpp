# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <string>
#include <vector>
#include <sstream>
#include <memory>
#include <cstring>

struct TransformResult {
    std::string data;
    int status;
    double metric;
};

struct IntermediateData {
    std::vector<char> buffer;
    std::string normalized;
    int checksum;
};

TransformResult transformData(const char* input, size_t length) {
    IntermediateData intermediate;
    intermediate.buffer.reserve(length * 2);
    
    for (size_t i = 0; i < length; ++i) {
        char c = input[i];
        if (c >= 'a' && c <= 'z') {
            c = c - 'a' + 'A';
        }
        intermediate.buffer.push_back(c);
        intermediate.checksum += static_cast<int>(c);
    }
    
    intermediate.normalized = std::string(intermediate.buffer.begin(), intermediate.buffer.end());
    
    std::ostringstream oss;
    oss << "PROCESSED_" << intermediate.normalized << "_CHK_" << intermediate.checksum;
    std::string processed = oss.str();
    
    std::vector<std::string> tokens;
    std::istringstream tokenStream(processed);
    std::string token;
    while (std::getline(tokenStream, token, '_')) {
        tokens.push_back(token);
    }
    
    std::string final_result;
    for (const auto& t : tokens) {
        final_result += t + "|";
    }
    
    TransformResult result;
    result.data = final_result;
    result.status = intermediate.checksum % 256;
    result.metric = static_cast<double>(final_result.length()) / length;
    
    return result;
}

std::vector<TransformResult> batchTransform(const std::vector<std::string>& inputs) {
    std::vector<TransformResult> results;
    results.reserve(inputs.size());
    
    for (const auto& input : inputs) {
        results.push_back(transformData(input.c_str(), input.length()));
    }
    
    return results;
}