# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>

typedef struct FileHandleNode {
    int fd;
    char *filename;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct {
    FileHandleNode *head;
    int count;
} FileHandleList;

FileHandleList* create_file_handle_list() {
    FileHandleList *list = (FileHandleList*)malloc(sizeof(FileHandleList));
    if (list) {
        list->head = NULL;
        list->count = 0;
    }
    return list;
}

int add_file_handle(FileHandleList *list, int fd, const char *filename) {
    if (!list) {
        return -1;
    }

    FileHandleNode *node = (FileHandleNode*)malloc(sizeof(FileHandleNode));
    if (!node) {
        return -1;
    }

    node->fd = fd;
    node->filename = NULL;
    if (filename) {
        node->filename = strdup(filename);
        if (!node->filename) {
            free(node);
            return -1;
        }
    }

    node->next = list->head;
    list->head = node;
    list->count++;

    return 0;
}

int remove_file_handle(FileHandleList *list, int fd) {
    if (!list || !list->head) {
        return -1;
    }

    FileHandleNode *current = list->head;
    FileHandleNode *prev = NULL;

    while (current) {
        if (current->fd == fd) {
            if (prev) {
                prev->next = current->next;
            } else {
                list->head = current->next;
            }

            if (current->fd >= 0) {
                close(current->fd);
            }
            free(current->filename);
            free(current);
            list->count--;
            return 0;
        }
        prev = current;
        current = current->next;
    }

    return -1;
}

void cleanup_file_handle_list(FileHandleList **list) {
    if (!list || !*list) {
        return;
    }

    FileHandleNode *current = (*list)->head;
    FileHandleNode *next;

    while (current) {
        next = current->next;
        if (current->fd >= 0) {
            close(current->fd);
        }
        free(current->filename);
        free(current);
        current = next;
    }

    (*list)->head = NULL;
    (*list)->count = 0;
    free(*list);
    *list = NULL;
}

int get_file_handle_count(FileHandleList *list) {
    if (!list) {
        return 0;
    }
    return list->count;
}

void print_file_handles(FileHandleList *list) {
    if (!list) {
        printf("List is NULL\n");
        return;
    }

    printf("File Handle List (count: %d):\n", list->count);
    FileHandleNode *current = list->head;
    while (current) {
        printf("  FD: %d, Filename: %s\n", 
               current->fd, 
               current->filename ? current->filename : "(null)");
        current = current->next;
    }
}

int main() {
    FileHandleList *list = create_file_handle_list();
    if (!list) {
        fprintf(stderr, "Failed to create file handle list\n");
        return 1;
    }

    FILE *f1 = fopen("/tmp/test1.txt", "w");
    FILE *f2 = fopen("/tmp/test2.txt", "w");
    FILE *f3 = fopen("/tmp/test3.txt", "w");

    if (f1) {
        add_file_handle(list, fileno(f1), "/tmp/test1.txt");
    }
    if (f2) {
        add_file_handle(list, fileno(f2), "/tmp/test2.txt");
    }
    if (f3) {
        add_file_handle(list, fileno(f3), "/tmp/test3.txt");
    }

    printf("After adding handles:\n");
    print_file_handles(list);

    if (f2) {
        remove_file_handle(list, fileno(f2));
        f2 = NULL;
    }

    printf("\nAfter removing one handle:\n");
    print_file_handles(list);

    cleanup_file_handle_list(&list);
    printf("\nAfter first cleanup (list should be NULL): %p\n", (void*)list);

    cleanup_file_handle_list(&list);
    printf("After second cleanup (safe to call multiple times): %p\n", (void*)list);

    return 0;
}