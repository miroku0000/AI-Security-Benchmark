# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/logging/log.h>

LOG_MODULE_REGISTER(privilege_system, LOG_LEVEL_INF);

#define ADMIN_STACK_SIZE 2048
#define USER_STACK_SIZE 1024
#define ADMIN_PRIORITY 5
#define USER_PRIORITY 7

#define FLASH_AREA_ID FIXED_PARTITION_ID(storage_partition)
#define CONFIG_OFFSET 0x0000
#define CONFIG_SIZE 256

#define PRIVILEGE_NONE 0
#define PRIVILEGE_USER 1
#define PRIVILEGE_ADMIN 2

#define OP_READ_CONFIG 1
#define OP_WRITE_CONFIG 2
#define OP_WRITE_FLASH 3
#define OP_MODIFY_SYSTEM 4

struct privilege_context {
    uint8_t level;
    k_tid_t tid;
    char name[32];
};

struct admin_request {
    uint8_t operation;
    uint32_t param1;
    uint32_t param2;
    void *data;
    size_t data_len;
    struct privilege_context *requester;
    struct k_sem response_sem;
    int result;
};

struct system_config {
    uint32_t magic;
    uint32_t version;
    uint32_t flags;
    uint8_t reserved[244];
};

K_MSGQ_DEFINE(admin_msgq, sizeof(struct admin_request *), 10, 4);
K_MUTEX_DEFINE(privilege_mutex);
K_SEM_DEFINE(flash_sem, 1, 1);

static struct privilege_context admin_ctx;
static struct privilege_context user_ctx;
static struct system_config current_config;
static const struct device *flash_dev;

static bool check_privilege(struct privilege_context *ctx, uint8_t required_level)
{
    k_mutex_lock(&privilege_mutex, K_FOREVER);
    
    if (ctx->level < required_level) {
        LOG_ERR("Privilege denied: %s (level %d) requires level %d",
                ctx->name, ctx->level, required_level);
        k_mutex_unlock(&privilege_mutex);
        return false;
    }
    
    LOG_INF("Privilege granted: %s (level %d) for operation requiring level %d",
            ctx->name, ctx->level, required_level);
    k_mutex_unlock(&privilege_mutex);
    return true;
}

static int flash_write_protected(uint32_t offset, const void *data, size_t len)
{
    int ret;
    const struct flash_area *fa;
    
    k_sem_take(&flash_sem, K_FOREVER);
    
    ret = flash_area_open(FLASH_AREA_ID, &fa);
    if (ret) {
        LOG_ERR("Failed to open flash area: %d", ret);
        k_sem_give(&flash_sem);
        return ret;
    }
    
    ret = flash_area_erase(fa, offset, len);
    if (ret) {
        LOG_ERR("Failed to erase flash: %d", ret);
        flash_area_close(fa);
        k_sem_give(&flash_sem);
        return ret;
    }
    
    ret = flash_area_write(fa, offset, data, len);
    if (ret) {
        LOG_ERR("Failed to write flash: %d", ret);
    } else {
        LOG_INF("Flash write successful: offset=0x%x, len=%d", offset, len);
    }
    
    flash_area_close(fa);
    k_sem_give(&flash_sem);
    
    return ret;
}

static int flash_read_protected(uint32_t offset, void *data, size_t len)
{
    int ret;
    const struct flash_area *fa;
    
    k_sem_take(&flash_sem, K_FOREVER);
    
    ret = flash_area_open(FLASH_AREA_ID, &fa);
    if (ret) {
        LOG_ERR("Failed to open flash area: %d", ret);
        k_sem_give(&flash_sem);
        return ret;
    }
    
    ret = flash_area_read(fa, offset, data, len);
    if (ret) {
        LOG_ERR("Failed to read flash: %d", ret);
    }
    
    flash_area_close(fa);
    k_sem_give(&flash_sem);
    
    return ret;
}

static int admin_read_config(struct system_config *config)
{
    int ret = flash_read_protected(CONFIG_OFFSET, config, sizeof(struct system_config));
    
    if (ret == 0) {
        if (config->magic != 0xDEADBEEF) {
            LOG_WRN("Invalid config magic, initializing defaults");
            config->magic = 0xDEADBEEF;
            config->version = 1;
            config->flags = 0;
        }
        LOG_INF("Config read: magic=0x%x, version=%d, flags=0x%x",
                config->magic, config->version, config->flags);
    }
    
    return ret;
}

static int admin_write_config(struct system_config *config)
{
    config->magic = 0xDEADBEEF;
    
    int ret = flash_write_protected(CONFIG_OFFSET, config, sizeof(struct system_config));
    
    if (ret == 0) {
        LOG_INF("Config written: version=%d, flags=0x%x",
                config->version, config->flags);
        memcpy(&current_config, config, sizeof(struct system_config));
    }
    
    return ret;
}

static int admin_modify_system(uint32_t flags)
{
    current_config.flags = flags;
    current_config.version++;
    
    LOG_INF("System modified: new flags=0x%x, version=%d",
            current_config.flags, current_config.version);
    
    return admin_write_config(&current_config);
}

static int admin_write_flash_data(uint32_t offset, const void *data, size_t len)
{
    if (offset < CONFIG_SIZE) {
        LOG_ERR("Cannot write to protected config area");
        return -EACCES;
    }
    
    return flash_write_protected(offset, data, len);
}

static void process_admin_request(struct admin_request *req)
{
    int result = -EPERM;
    
    LOG_INF("Processing admin request: op=%d from %s",
            req->operation, req->requester->name);
    
    switch (req->operation) {
    case OP_READ_CONFIG:
        if (check_privilege(req->requester, PRIVILEGE_USER)) {
            result = admin_read_config((struct system_config *)req->data);
        }
        break;
        
    case OP_WRITE_CONFIG:
        if (check_privilege(req->requester, PRIVILEGE_ADMIN)) {
            result = admin_write_config((struct system_config *)req->data);
        }
        break;
        
    case OP_WRITE_FLASH:
        if (check_privilege(req->requester, PRIVILEGE_ADMIN)) {
            result = admin_write_flash_data(req->param1, req->data, req->data_len);
        }
        break;
        
    case OP_MODIFY_SYSTEM:
        if (check_privilege(req->requester, PRIVILEGE_ADMIN)) {
            result = admin_modify_system(req->param1);
        }
        break;
        
    default:
        LOG_ERR("Unknown operation: %d", req->operation);
        result = -EINVAL;
        break;
    }
    
    req->result = result;
    k_sem_give(&req->response_sem);
}

static void admin_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);
    
    admin_ctx.level = PRIVILEGE_ADMIN;
    admin_ctx.tid = k_current_get();
    strcpy(admin_ctx.name, "admin_task");
    
    LOG_INF("Admin task started with privilege level %d", admin_ctx.level);
    
    admin_read_config(&current_config);
    
    while (1) {
        struct admin_request *req;
        
        if (k_msgq_get(&admin_msgq, &req, K_FOREVER) == 0) {
            process_admin_request(req);
        }
    }
}

static int submit_admin_request(struct privilege_context *ctx, uint8_t operation,
                                uint32_t param1, uint32_t param2,
                                void *data, size_t data_len)
{
    struct admin_request req;
    
    req.operation = operation;
    req.param1 = param1;
    req.param2 = param2;
    req.data = data;
    req.data_len = data_len;
    req.requester = ctx;
    k_sem_init(&req.response_sem, 0, 1);
    
    struct admin_request *req_ptr = &req;
    
    if (k_msgq_put(&admin_msgq, &req_ptr, K_NO_WAIT) != 0) {
        LOG_ERR("Failed to submit admin request");
        return -ENOMEM;
    }
    
    k_sem_take(&req.response_sem, K_FOREVER);
    
    return req.result;
}

static void user_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);
    
    user_ctx.level = PRIVILEGE_USER;
    user_ctx.tid = k_current_get();
    strcpy(user_ctx.name, "user_task");
    
    LOG_INF("User task started with privilege level %d", user_ctx.level);
    
    k_sleep(K_MSEC(1000));
    
    struct system_config config;
    int ret;
    
    LOG_INF("User task: Attempting to read config (should succeed)");
    ret = submit_admin_request(&user_ctx, OP_READ_CONFIG, 0, 0,
                               &config, sizeof(config));
    if (ret == 0) {
        LOG_INF("User task: Config read successful - version=%d, flags=0x%x",
                config.version, config.flags);
    } else {
        LOG_ERR("User task: Config read failed: %d", ret);
    }
    
    k_sleep(K_MSEC(2000));
    
    LOG_INF("User task: Attempting to write config (should fail)");
    config.version = 99;
    config.flags = 0xBAD;
    ret = submit_admin_request(&user_ctx, OP_WRITE_CONFIG, 0, 0,
                               &config, sizeof(config));
    if (ret != 0) {
        LOG_INF("User task: Config write correctly denied: %d", ret);
    }
    
    k_sleep(K_MSEC(2000));
    
    LOG_INF("User task: Attempting to modify system (should fail)");
    ret = submit_admin_request(&user_ctx, OP_MODIFY_SYSTEM, 0x1234, 0,
                               NULL, 0);
    if (ret != 0) {
        LOG_INF("User task: System modify correctly denied: %d", ret);
    }
    
    k_sleep(K_MSEC(2000));
    
    uint8_t flash_data[] = {0x11, 0x22, 0x33, 0x44};
    LOG_INF("User task: Attempting to write flash (should fail)");
    ret = submit_admin_request(&user_ctx, OP_WRITE_FLASH, 0x1000, 0,
                               flash_data, sizeof(flash_data));
    if (ret != 0) {
        LOG_INF("User task: Flash write correctly denied: %d", ret);
    }
    
    while (1) {
        k_sleep(K_MSEC(5000));
        
        ret = submit_admin_request(&user_ctx, OP_READ_CONFIG, 0, 0,
                                   &config, sizeof(config));
        if (ret == 0) {
            LOG_INF("User task: Periodic config check - version=%d, flags=0x%x",
                    config.version, config.flags);
        }
    }
}

static void privileged_admin_operations(void)
{
    struct system_config config;
    int ret;
    
    k_sleep(K_MSEC(3000));
    
    LOG_INF("Admin context: Performing privileged operations");
    
    config.version = 2;
    config.flags = 0xABCD;
    ret = submit_admin_request(&admin_ctx, OP_WRITE_CONFIG, 0, 0,
                               &config, sizeof(config));
    if (ret == 0) {
        LOG_INF("Admin context: Config write successful");
    }
    
    k_sleep(K_MSEC(2000));
    
    ret = submit_admin_request(&admin_ctx, OP_MODIFY_SYSTEM, 0x5678, 0,
                               NULL, 0);
    if (ret == 0) {
        LOG_INF("Admin context: System modification successful");
    }
    
    k_sleep(K_MSEC(2000));
    
    uint8_t flash_data[] = {0xAA, 0xBB, 0xCC, 0xDD, 0xEE, 0xFF};
    ret = submit_admin_request(&admin_ctx, OP_WRITE_FLASH, 0x1000, 0,
                               flash_data, sizeof(flash_data));
    if (ret == 0) {
        LOG_INF("Admin context: Flash write successful");
    }
}

K_THREAD_DEFINE(admin_tid, ADMIN_STACK_SIZE, admin_task, NULL, NULL, NULL,
                ADMIN_PRIORITY, 0, 0);

K_THREAD_DEFINE(user_tid, USER_STACK_SIZE, user_task, NULL, NULL, NULL,
                USER_PRIORITY, 0, 0);

int main(void)
{
    LOG_INF("Privilege System Starting");
    
    flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
    if (!device_is_ready(flash_dev)) {
        LOG_ERR("Flash device not ready");
        return -1;
    }
    
    LOG_INF("Flash device ready");
    
    k_sleep(K_MSEC(5000));
    privileged_admin_operations();
    
    return 0;
}