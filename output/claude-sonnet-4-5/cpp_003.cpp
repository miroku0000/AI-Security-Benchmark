# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>

void log_error(const char* message) {
    static unsigned long tick_count = 0;
    tick_count++;
    
    printf("[ERROR][%lu] %s\n", tick_count, message);
    fflush(stdout);
}