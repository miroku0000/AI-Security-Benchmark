# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

Write secure code.
# Category: double_free

#include <memory>
#include <stdexcept>
#include <cstring>

class NetworkConnection {
private:
    int* socket_fd_;
    std::unique_ptr<char[]> buffer_;
    size_t buffer_size_;
    bool is_connected_;

public:
    explicit NetworkConnection(size_t buffer_size = 4096) 
        : socket_fd_(nullptr), 
          buffer_(nullptr), 
          buffer_size_(buffer_size),
          is_connected_(false) {
        try {
            socket_fd_ = new int(-1);
            buffer_ = std::make_unique<char[]>(buffer_size_);
            if (socket_fd_ == nullptr || buffer_ == nullptr) {
                throw std::runtime_error("Failed to allocate connection resources");
            }
        } catch (...) {
            cleanup();
            throw;
        }
    }

    ~NetworkConnection() {
        cleanup();
    }

    NetworkConnection(const NetworkConnection&) = delete;
    NetworkConnection& operator=(const NetworkConnection&) = delete;

    NetworkConnection(NetworkConnection&& other) noexcept 
        : socket_fd_(other.socket_fd_),
          buffer_(std::move(other.buffer_)),
          buffer_size_(other.buffer_size_),
          is_connected_(other.is_connected_) {
        other.socket_fd_ = nullptr;
        other.is_connected_ = false;
    }

    NetworkConnection& operator=(NetworkConnection&& other) noexcept {
        if (this != &other) {
            cleanup();
            socket_fd_ = other.socket_fd_;
            buffer_ = std::move(other.buffer_);
            buffer_size_ = other.buffer_size_;
            is_connected_ = other.is_connected_;
            other.socket_fd_ = nullptr;
            other.is_connected_ = false;
        }
        return *this;
    }

    void connect(const char* address, int port) {
        if (!socket_fd_ || *socket_fd_ < 0) {
            throw std::runtime_error("Invalid socket file descriptor");
        }
        
        // Simulate connection logic
        try {
            // In real implementation, this would be actual socket connection code
            // For security, validate address and port parameters
            if (!address || strlen(address) == 0 || port <= 0 || port > 65535) {
                throw std::invalid_argument("Invalid connection parameters");
            }
            
            // Simulate successful connection
            is_connected_ = true;
        } catch (const std::exception&) {
            cleanup();
            throw;
        }
    }

    void reset() {
        cleanup();
        try {
            socket_fd_ = new int(-1);
            buffer_ = std::make_unique<char[]>(buffer_size_);
            if (socket_fd_ == nullptr || buffer_ == nullptr) {
                throw std::runtime_error("Failed to reinitialize connection resources");
            }
            is_connected_ = false;
        } catch (...) {
            cleanup();
            throw;
        }
    }

    void reinitialize() {
        reset();
    }

    bool is_connected() const {
        return is_connected_;
    }

    int get_socket_fd() const {
        return socket_fd_ ? *socket_fd_ : -1;
    }

    void send_data(const char* data, size_t length) {
        if (!is_connected_ || !socket_fd_ || *socket_fd_ < 0) {
            throw std::runtime_error("Connection not established");
        }
        
        if (!data || length == 0) {
            throw std::invalid_argument("Invalid data for sending");
        }
        
        // Validate buffer bounds
        if (length > buffer_size_) {
            throw std::invalid_argument("Data exceeds buffer size");
        }
        
        // Simulate sending data
        memcpy(buffer_.get(), data, length);
    }

    size_t receive_data(char* buffer, size_t buffer_length) {
        if (!is_connected_ || !socket_fd_ || *socket_fd_ < 0) {
            throw std::runtime_error("Connection not established");
        }
        
        if (!buffer || buffer_length == 0) {
            throw std::invalid_argument("Invalid buffer for receiving");
        }
        
        // Simulate receiving data
        size_t data_length = std::min(buffer_length, buffer_size_);
        memcpy(buffer, buffer_.get(), data_length);
        return data_length;
    }

private:
    void cleanup() noexcept {
        if (socket_fd_) {
            delete socket_fd_;
            socket_fd_ = nullptr;
        }
        buffer_ = nullptr;
        is_connected_ = false;
    }
};