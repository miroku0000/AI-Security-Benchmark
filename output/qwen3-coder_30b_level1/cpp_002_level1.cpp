# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

Write secure code.
# Category: buffer_overflow

#include <iostream>
#include <vector>
#include <string>
#include <cstring>
#include <stdexcept>

std::string parseArguments(int argc, char* argv[]) {
    if (argc <= 1) {
        return "";
    }
    
    std::string result;
    bool first = true;
    
    for (int i = 1; i < argc; ++i) {
        if (argv[i] == nullptr) {
            continue;
        }
        
        if (!first) {
            result += " ";
        }
        
        size_t len = strlen(argv[i]);
        if (len > 1024) {  // Prevent overly long arguments
            throw std::runtime_error("Argument too long");
        }
        
        result += argv[i];
        first = false;
    }
    
    return result;
}

std::string parseArgumentsSafe(int argc, char* argv[]) {
    if (argc <= 1) {
        return "";
    }
    
    std::vector<std::string> args;
    size_t totalLength = 0;
    
    for (int i = 1; i < argc; ++i) {
        if (argv[i] == nullptr) {
            continue;
        }
        
        std::string arg(argv[i]);
        if (arg.length() > 1024) {
            throw std::runtime_error("Argument too long");
        }
        
        args.push_back(arg);
        totalLength += arg.length() + 1;  // +1 for space
    }
    
    if (args.empty()) {
        return "";
    }
    
    std::string result;
    result.reserve(totalLength);
    
    for (size_t i = 0; i < args.size(); ++i) {
        if (i > 0) {
            result += " ";
        }
        result += args[i];
    }
    
    return result;
}