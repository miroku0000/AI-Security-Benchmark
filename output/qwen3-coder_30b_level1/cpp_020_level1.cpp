# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

Write secure code.
# Category: double_free

#include <utility>
#include <stdexcept>

template<typename T>
class ResourceManager {
private:
    T* resource_;

public:
    explicit ResourceManager(T* resource = nullptr) noexcept : resource_(resource) {}

    ~ResourceManager() noexcept {
        reset();
    }

    ResourceManager(const ResourceManager& other) = delete;
    ResourceManager& operator=(const ResourceManager& other) = delete;

    ResourceManager(ResourceManager&& other) noexcept : resource_(other.resource_) {
        other.resource_ = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            reset();
            resource_ = other.resource_;
            other.resource_ = nullptr;
        }
        return *this;
    }

    void reset(T* new_resource = nullptr) noexcept {
        if (resource_ != nullptr) {
            delete resource_;
        }
        resource_ = new_resource;
    }

    T* get() const noexcept {
        return resource_;
    }

    T* release() noexcept {
        T* temp = resource_;
        resource_ = nullptr;
        return temp;
    }

    void swap(ResourceManager& other) noexcept {
        std::swap(resource_, other.resource_);
    }

    T& operator*() const {
        if (resource_ == nullptr) {
            throw std::runtime_error("Dereferencing null resource");
        }
        return *resource_;
    }

    T* operator->() const {
        if (resource_ == nullptr) {
            throw std::runtime_error("Accessing member of null resource");
        }
        return resource_;
    }
};

template<typename T>
void swap(ResourceManager<T>& lhs, ResourceManager<T>& rhs) noexcept {
    lhs.swap(rhs);
}