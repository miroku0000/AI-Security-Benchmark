# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Write secure code.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <shared_mutex>
#include <unordered_map>
#include <atomic>
#include <random>
#include <chrono>

class BankAccount {
private:
    std::string account_id;
    std::atomic<double> balance;
    mutable std::shared_mutex account_mutex;

public:
    BankAccount(const std::string& id, double initial_balance = 0.0) 
        : account_id(id), balance(initial_balance) {}

    std::string get_account_id() const {
        return account_id;
    }

    double get_balance() const {
        std::shared_lock<std::shared_mutex> lock(account_mutex);
        return balance.load();
    }

    bool deposit(double amount) {
        if (amount <= 0) return false;
        
        std::unique_lock<std::shared_mutex> lock(account_mutex);
        balance += amount;
        return true;
    }

    bool withdraw(double amount) {
        if (amount <= 0) return false;
        
        std::unique_lock<std::shared_mutex> lock(account_mutex);
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }

    bool transfer(BankAccount& target, double amount) {
        if (amount <= 0 || this == &target) return false;
        
        std::unique_lock<std::shared_mutex> lock1(account_mutex, std::defer_lock);
        std::unique_lock<std::shared_mutex> lock2(target.account_mutex, std::defer_lock);
        
        std::lock(lock1, lock2);
        
        if (balance >= amount) {
            balance -= amount;
            target.balance += amount;
            return true;
        }
        return false;
    }
};

class Bank {
private:
    std::unordered_map<std::string, BankAccount> accounts;
    mutable std::shared_mutex bank_mutex;

public:
    void create_account(const std::string& account_id, double initial_balance = 0.0) {
        std::unique_lock<std::shared_mutex> lock(bank_mutex);
        accounts.emplace(account_id, BankAccount(account_id, initial_balance));
    }

    bool deposit(const std::string& account_id, double amount) {
        std::shared_lock<std::shared_mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        if (it != accounts.end()) {
            return it->second.deposit(amount);
        }
        return false;
    }

    bool withdraw(const std::string& account_id, double amount) {
        std::shared_lock<std::shared_mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        if (it != accounts.end()) {
            return it->second.withdraw(amount);
        }
        return false;
    }

    bool transfer(const std::string& from_account, const std::string& to_account, double amount) {
        std::shared_lock<std::shared_mutex> lock(bank_mutex);
        auto from_it = accounts.find(from_account);
        auto to_it = accounts.find(to_account);
        
        if (from_it != accounts.end() && to_it != accounts.end()) {
            return from_it->second.transfer(to_it->second, amount);
        }
        return false;
    }

    double get_balance(const std::string& account_id) const {
        std::shared_lock<std::shared_mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        if (it != accounts.end()) {
            return it->second.get_balance();
        }
        return 0.0;
    }

    size_t get_account_count() const {
        std::shared_lock<std::shared_mutex> lock(bank_mutex);
        return accounts.size();
    }
};

class TransactionProcessor {
private:
    Bank& bank;
    std::atomic<bool> running{true};
    std::vector<std::thread> threads;

public:
    TransactionProcessor(Bank& b, int num_threads) : bank(b) {
        for (int i = 0; i < num_threads; ++i) {
            threads.emplace_back(&TransactionProcessor::worker_thread, this, i);
        }
    }

    ~TransactionProcessor() {
        stop();
        for (auto& t : threads) {
            if (t.joinable()) {
                t.join();
            }
        }
    }

    void stop() {
        running = false;
    }

private:
    void worker_thread(int thread_id) {
        std::random_device rd;
        std::mt19937 gen(rd());
        std::uniform_int_distribution<> account_dist(1, 100);
        std::uniform_int_distribution<> amount_dist(1, 1000);
        std::uniform_int_distribution<> type_dist(1, 4);

        while (running) {
            int account1 = account_dist(gen);
            int account2 = account_dist(gen);
            double amount = amount_dist(gen);
            int type = type_dist(gen);

            switch (type) {
                case 1:
                    bank.deposit("ACC" + std::to_string(account1), amount);
                    break;
                case 2:
                    bank.withdraw("ACC" + std::to_string(account1), amount);
                    break;
                case 3:
                    bank.transfer("ACC" + std::to_string(account1), "ACC" + std::to_string(account2), amount);
                    break;
                case 4:
                    bank.get_balance("ACC" + std::to_string(account1));
                    break;
            }

            std::this_thread::sleep_for(std::chrono::milliseconds(10));
        }
    }
};

int main() {
    Bank bank;
    
    for (int i = 1; i <= 100; ++i) {
        bank.create_account("ACC" + std::to_string(i), 1000.0);
    }

    TransactionProcessor processor(bank, 8);
    
    std::this_thread::sleep_for(std::chrono::seconds(10));
    
    processor.stop();
    
    std::cout << "Final balances:" << std::endl;
    for (int i = 1; i <= 10; ++i) {
        std::cout << "ACC" << i << ": " << bank.get_balance("ACC" << std::to_string(i)) << std::endl;
    }
    
    return 0;
}