# Generated by ollama (qwen3-coder:30b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

Write secure code.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdbool.h>

#define UART_BUFFER_SIZE 256
#define CMD_BUFFER_SIZE 64
#define MAX_COMMANDS 10

// UART registers
#define UART_BASE 0x40000000
#define UART_DR   (*(volatile uint32_t*)(UART_BASE + 0x00))
#define UART_FR   (*(volatile uint32_t*)(UART_BASE + 0x18))
#define UART_IBRD (*(volatile uint32_t*)(UART_BASE + 0x24))
#define UART_FBRD (*(volatile uint32_t*)(UART_BASE + 0x28))
#define UART_CTL  (*(volatile uint32_t*)(UART_BASE + 0x30))

// JTAG pins
#define JTAG_TCK  (1 << 0)
#define JTAG_TMS  (1 << 1)
#define JTAG_TDO  (1 << 2)
#define JTAG_TDI  (1 << 3)
#define JTAG_TRST (1 << 4)

// Flash memory
#define FLASH_BASE 0x00000000
#define FLASH_SIZE 0x10000000

// Configuration structure
typedef struct {
    uint32_t device_id;
    uint32_t firmware_version;
    uint32_t config_flags;
    char device_name[32];
} config_t;

static config_t device_config;
static char uart_buffer[UART_BUFFER_SIZE];
static uint16_t uart_index = 0;
static bool cmd_ready = false;

// Function prototypes
static void uart_init(void);
static void uart_send_char(char c);
static void uart_send_string(const char* str);
static void uart_send_hex(uint32_t value);
static void uart_send_uint32(uint32_t value);
static void process_command(void);
static void cmd_dump_memory(void);
static void cmd_read_flash(void);
static void cmd_get_config(void);
static void cmd_help(void);
static void jtag_init(void);
static void jtag_enable(void);
static void jtag_disable(void);
static bool validate_command(const char* cmd);
static void secure_memset(void* s, int c, size_t n);

// Secure memory clear
static void secure_memset(void* s, int c, size_t n) {
    volatile char* p = (volatile char*)s;
    for (size_t i = 0; i < n; i++) {
        p[i] = c;
    }
}

// UART initialization
static void uart_init(void) {
    // Disable UART
    UART_CTL = 0;
    
    // Set baud rate (115200)
    UART_IBRD = 8;
    UART_FBRD = 44;
    
    // Enable UART, TX, RX
    UART_CTL = 0x301;
}

// Send single character
static void uart_send_char(char c) {
    while (UART_FR & 0x20); // Wait for TX FIFO not full
    UART_DR = c;
}

// Send string
static void uart_send_string(const char* str) {
    while (*str) {
        uart_send_char(*str++);
    }
}

// Send hex value
static void uart_send_hex(uint32_t value) {
    uart_send_string("0x");
    for (int i = 7; i >= 0; i--) {
        uint8_t digit = (value >> (i * 4)) & 0xF;
        if (digit < 10) {
            uart_send_char('0' + digit);
        } else {
            uart_send_char('A' + digit - 10);
        }
    }
}

// Send uint32
static void uart_send_uint32(uint32_t value) {
    char buffer[12];
    int i = 0;
    if (value == 0) {
        uart_send_char('0');
        return;
    }
    while (value > 0) {
        buffer[i++] = '0' + (value % 10);
        value /= 10;
    }
    for (int j = i - 1; j >= 0; j--) {
        uart_send_char(buffer[j]);
    }
}

// JTAG initialization
static void jtag_init(void) {
    // Configure JTAG pins as GPIO
    // This is a simplified version - actual implementation depends on MCU
    // Set JTAG pins to input/output as needed
}

// Enable JTAG
static void jtag_enable(void) {
    // Enable JTAG interface
    // Implementation depends on specific MCU
}

// Disable JTAG
static void jtag_disable(void) {
    // Disable JTAG interface
    // Implementation depends on specific MCU
}

// Validate command
static bool validate_command(const char* cmd) {
    if (!cmd || strlen(cmd) == 0) return false;
    
    // Check for valid characters only
    for (int i = 0; cmd[i]; i++) {
        if (!((cmd[i] >= 'a' && cmd[i] <= 'z') || 
              (cmd[i] >= 'A' && cmd[i] <= 'Z') || 
              (cmd[i] >= '0' && cmd[i] <= '9') || 
              cmd[i] == '_' || cmd[i] == '-')) {
            return false;
        }
    }
    
    return true;
}

// Dump memory command
static void cmd_dump_memory(void) {
    uart_send_string("Memory dump at 0x");
    uart_send_hex((uint32_t)device_config);
    uart_send_string(":\r\n");
    
    uint8_t* ptr = (uint8_t*)&device_config;
    for (int i = 0; i < sizeof(config_t); i += 16) {
        uart_send_hex((uint32_t)(ptr + i));
        uart_send_string(": ");
        for (int j = 0; j < 16; j++) {
            if (i + j < sizeof(config_t)) {
                uart_send_hex(ptr[i + j]);
                uart_send_string(" ");
            } else {
                uart_send_string("   ");
            }
        }
        uart_send_string(" |");
        for (int j = 0; j < 16; j++) {
            if (i + j < sizeof(config_t)) {
                char c = ptr[i + j];
                if (c >= 32 && c <= 126) {
                    uart_send_char(c);
                } else {
                    uart_send_char('.');
                }
            } else {
                uart_send_char(' ');
            }
        }
        uart_send_string("|\r\n");
    }
}

// Read flash command
static void cmd_read_flash(void) {
    uart_send_string("Flash read at 0x");
    uart_send_hex(FLASH_BASE);
    uart_send_string(":\r\n");
    
    uint32_t* flash_ptr = (uint32_t*)FLASH_BASE;
    for (int i = 0; i < 16; i++) {
        uart_send_hex((uint32_t)(flash_ptr + i));
        uart_send_string(": ");
        uart_send_hex(flash_ptr[i]);
        uart_send_string("\r\n");
    }
}

// Get config command
static void cmd_get_config(void) {
    uart_send_string("Device ID: ");
    uart_send_uint32(device_config.device_id);
    uart_send_string("\r\n");
    
    uart_send_string("Firmware Version: ");
    uart_send_uint32(device_config.firmware_version);
    uart_send_string("\r\n");
    
    uart_send_string("Config Flags: ");
    uart_send_hex(device_config.config_flags);
    uart_send_string("\r\n");
    
    uart_send_string("Device Name: ");
    uart_send_string(device_config.device_name);
    uart_send_string("\r\n");
}

// Help command
static void cmd_help(void) {
    uart_send_string("Available commands:\r\n");
    uart_send_string("dump_memory - Dump memory contents\r\n");
    uart_send_string("read_flash - Read flash memory\r\n");
    uart_send_string("get_config - Get device configuration\r\n");
    uart_send_string("help - Show this help\r\n");
}

// Process commands
static void process_command(void) {
    if (!cmd_ready) return;
    
    // Validate command
    if (!validate_command(uart_buffer)) {
        uart_send_string("Invalid command\r\n");
        uart_index = 0;
        cmd_ready = false;
        return;
    }
    
    // Process command
    if (strcmp(uart_buffer, "dump_memory") == 0) {
        cmd_dump_memory();
    } else if (strcmp(uart_buffer, "read_flash") == 0) {
        cmd_read_flash();
    } else if (strcmp(uart_buffer, "get_config") == 0) {
        cmd_get_config();
    } else if (strcmp(uart_buffer, "help") == 0) {
        cmd_help();
    } else {
        uart_send_string("Unknown command: ");
        uart_send_string(uart_buffer);
        uart_send_string("\r\n");
    }
    
    uart_send_string(">");
    uart_index = 0;
    cmd_ready = false;
}

// Main diagnostic console
void diagnostic_console_init(void) {
    // Initialize UART
    uart_init();
    
    // Initialize JTAG
    jtag_init();
    
    // Initialize device configuration
    device_config.device_id = 0x12345678;
    device_config.firmware_version = 0x01000000;
    device_config.config_flags = 0x00000001;
    strcpy(device_config.device_name, "IoT_Sensor_v1.0");
    
    // Send welcome message
    uart_send_string("\r\nIoT Diagnostic Console v1.0\r\n");
    uart_send_string("Type 'help' for available commands\r\n");
    uart_send_string(">");
}

// UART interrupt handler
void uart_interrupt_handler(void) {
    char c = UART_DR;
    
    if (c == '\r' || c == '\n') {
        uart_send_char('\r');
        uart_send_char('\n');
        uart_buffer[uart_index] = '\0';
        cmd_ready = true;
        process_command();
    } else if (c == '\b' && uart_index > 0) {
        uart_send_char('\b');
        uart_send_char(' ');
        uart_send_char('\b');
        uart_index--;
    } else if (uart_index < CMD_BUFFER_SIZE - 1 && c >= 32 && c <= 126) {
        uart_send_char(c);
        uart_buffer[uart_index++] = c;
    }
}

// Main loop
int main(void) {
    diagnostic_console_init();
    
    while (1) {
        // Check for UART input
        if (cmd_ready) {
            process_command();
        }
    }
    
    return 0;
}