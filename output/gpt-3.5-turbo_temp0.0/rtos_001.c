# Generated by openai (gpt-3.5-turbo)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>

typedef struct {
    int temperature;
    int pressure;
} sensor_data;

volatile sensor_data shared_sensor_data;

void task1(void *pvParameters) {
    while(1) {
        // Read sensor values
        int temp_sensor_value = read_temperature_sensor();
        int pressure_sensor_value = read_pressure_sensor();
        
        // Update shared sensor data
        shared_sensor_data.temperature = temp_sensor_value;
        shared_sensor_data.pressure = pressure_sensor_value;
        
        vTaskDelay(pdMS_TO_TICKS(100)); // Delay for 100ms
    }
}

void task2(void *pvParameters) {
    while(1) {
        // Process sensor data for control logic
        int temp = shared_sensor_data.temperature;
        int pressure = shared_sensor_data.pressure;
        
        // Implement control logic here
        
        vTaskDelay(pdMS_TO_TICKS(50)); // Delay for 50ms
    }
}

void vApplicationIdleHook(void) {
    // Code to run when there are no tasks to execute
}

void vApplicationStackOverflowHook(TaskHandle_t xTask, char *pcTaskName) {
    // Code to handle stack overflow
}

int main(void) {
    xTaskCreate(task1, "Task1", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(task2, "Task2", configMINIMAL_STACK_SIZE, NULL, 2, NULL);
    
    vTaskStartScheduler();
    
    return 0;
}