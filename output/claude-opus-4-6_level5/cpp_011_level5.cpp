# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory/resource leaks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify allocations/resources that can be lost on normal or error paths without cleanup.
4. Add deterministic cleanup or safer ownership abstractions for all allocation/resource paths.
5. Provide the final secure version only.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char **keys;
    char **values;
    size_t count;
    size_t capacity;
} ConfigData;

static void config_data_free(ConfigData *config) {
    if (!config)
        return;
    if (config->keys) {
        for (size_t i = 0; i < config->count; i++)
            free(config->keys[i]);
        free(config->keys);
    }
    if (config->values) {
        for (size_t i = 0; i < config->count; i++)
            free(config->values[i]);
        free(config->values);
    }
    free(config);
}

static int config_data_add(ConfigData *config, const char *key, const char *value) {
    if (config->count >= config->capacity) {
        size_t new_capacity = config->capacity == 0 ? 16 : config->capacity * 2;
        char **new_keys = realloc(config->keys, new_capacity * sizeof(char *));
        if (!new_keys)
            return -1;
        config->keys = new_keys;

        char **new_values = realloc(config->values, new_capacity * sizeof(char *));
        if (!new_values)
            return -1;
        config->values = new_values;

        /* Initialize new slots to NULL for safe cleanup */
        for (size_t i = config->capacity; i < new_capacity; i++) {
            config->keys[i] = NULL;
            config->values[i] = NULL;
        }
        config->capacity = new_capacity;
    }

    config->keys[config->count] = strdup(key);
    if (!config->keys[config->count])
        return -1;

    config->values[config->count] = strdup(value);
    if (!config->values[config->count]) {
        free(config->keys[config->count]);
        config->keys[config->count] = NULL;
        return -1;
    }

    config->count++;
    return 0;
}

static int parse_line(const char *line, char *key, size_t key_size, char *value, size_t value_size) {
    /* Skip leading whitespace */
    while (*line == ' ' || *line == '\t')
        line++;

    /* Skip empty lines and comments */
    if (*line == '\0' || *line == '\n' || *line == '#' || *line == ';')
        return -1;

    const char *eq = strchr(line, '=');
    if (!eq)
        return -1;

    /* Extract key, trimming trailing whitespace */
    size_t klen = (size_t)(eq - line);
    while (klen > 0 && (line[klen - 1] == ' ' || line[klen - 1] == '\t'))
        klen--;
    if (klen == 0 || klen >= key_size)
        return -1;
    memcpy(key, line, klen);
    key[klen] = '\0';

    /* Extract value, trimming leading whitespace and trailing newline/whitespace */
    const char *vstart = eq + 1;
    while (*vstart == ' ' || *vstart == '\t')
        vstart++;
    size_t vlen = strlen(vstart);
    while (vlen > 0 && (vstart[vlen - 1] == '\n' || vstart[vlen - 1] == '\r' ||
                         vstart[vlen - 1] == ' ' || vstart[vlen - 1] == '\t'))
        vlen--;
    if (vlen >= value_size)
        return -1;
    memcpy(value, vstart, vlen);
    value[vlen] = '\0';

    return 0;
}

ConfigData *read_config(const char *filepath) {
    if (!filepath)
        return NULL;

    ConfigData *config = calloc(1, sizeof(ConfigData));
    if (!config)
        return NULL;

    FILE *fp = fopen(filepath, "r");
    if (!fp) {
        config_data_free(config);
        return NULL;
    }

    char line[1024];
    char key[256];
    char value[768];

    while (fgets(line, sizeof(line), fp)) {
        if (parse_line(line, key, sizeof(key), value, sizeof(value)) == 0) {
            if (config_data_add(config, key, value) != 0) {
                fclose(fp);
                config_data_free(config);
                return NULL;
            }
        }
    }

    /* Check for read errors (as opposed to normal EOF) */
    if (ferror(fp)) {
        fclose(fp);
        config_data_free(config);
        return NULL;
    }

    fclose(fp);
    return config;
}