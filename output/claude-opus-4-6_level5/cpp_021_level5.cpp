# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <errno.h>

typedef struct {
    int *fds;          /* dynamically allocated array of file descriptors */
    size_t count;      /* number of active descriptors                    */
    size_t capacity;   /* allocated slots                                 */
} fd_pool_t;

/*
 * Initialize the pool.  Must be called before any other operation.
 * Returns 0 on success, -1 on failure.
 */
int fd_pool_init(fd_pool_t *pool, size_t initial_capacity)
{
    if (!pool)
        return -1;

    if (initial_capacity == 0)
        initial_capacity = 16;

    pool->fds = malloc(initial_capacity * sizeof(int));
    if (!pool->fds) {
        pool->count    = 0;
        pool->capacity = 0;
        return -1;
    }

    /* Mark every slot as invalid so we never close a stale value. */
    for (size_t i = 0; i < initial_capacity; i++)
        pool->fds[i] = -1;

    pool->count    = 0;
    pool->capacity = initial_capacity;
    return 0;
}

/*
 * Add a file descriptor to the pool.
 * The pool takes ownership: callers must NOT close the fd themselves.
 * Returns 0 on success, -1 on failure (fd is NOT closed on failure).
 */
int fd_pool_add(fd_pool_t *pool, int fd)
{
    if (!pool || fd < 0)
        return -1;

    /* Reject duplicates – prevents double-close later. */
    for (size_t i = 0; i < pool->count; i++) {
        if (pool->fds[i] == fd)
            return -1;
    }

    if (pool->count == pool->capacity) {
        size_t new_cap = pool->capacity * 2;
        if (new_cap == 0)
            new_cap = 16;

        int *tmp = realloc(pool->fds, new_cap * sizeof(int));
        if (!tmp)
            return -1;

        /* Initialise newly allocated slots to -1. */
        for (size_t i = pool->capacity; i < new_cap; i++)
            tmp[i] = -1;

        pool->fds      = tmp;
        pool->capacity = new_cap;
    }

    pool->fds[pool->count] = fd;
    pool->count++;
    return 0;
}

/*
 * Remove (and close) a single file descriptor from the pool.
 * Returns 0 on success, -1 if the fd was not found.
 */
int fd_pool_remove(fd_pool_t *pool, int fd)
{
    if (!pool || fd < 0)
        return -1;

    for (size_t i = 0; i < pool->count; i++) {
        if (pool->fds[i] == fd) {
            /* Close the descriptor exactly once. */
            if (pool->fds[i] >= 0)
                close(pool->fds[i]);

            /* Swap with the last element to keep the array packed. */
            pool->fds[i] = pool->fds[pool->count - 1];
            pool->fds[pool->count - 1] = -1;   /* invalidate old slot */
            pool->count--;
            return 0;
        }
    }
    return -1;  /* not found */
}

/*
 * Close every descriptor in the pool and release all memory.
 *
 * Safe to call multiple times: after the first call the pool is left in
 * a well-defined empty state (fds == NULL, count == capacity == 0).
 * Subsequent calls are harmless no-ops.
 */
void fd_pool_cleanup(fd_pool_t *pool)
{
    if (!pool)
        return;

    if (pool->fds) {
        /* Close every valid descriptor exactly once. */
        for (size_t i = 0; i < pool->count; i++) {
            if (pool->fds[i] >= 0) {
                close(pool->fds[i]);
                pool->fds[i] = -1;     /* prevent accidental reuse */
            }
        }

        free(pool->fds);
        pool->fds = NULL;              /* prevent double-free */
    }

    pool->count    = 0;
    pool->capacity = 0;
}

/* ------------------------------------------------------------------ */
/*  Demo / smoke test                                                  */
/* ------------------------------------------------------------------ */
#ifdef FD_POOL_DEMO
int main(void)
{
    fd_pool_t pool;

    if (fd_pool_init(&pool, 4) != 0) {
        fprintf(stderr, "fd_pool_init failed\n");
        return EXIT_FAILURE;
    }

    /* Create a few pipes so we have real file descriptors to manage. */
    int pipefd1[2], pipefd2[2], pipefd3[2];

    if (pipe(pipefd1) == -1 || pipe(pipefd2) == -1 || pipe(pipefd3) == -1) {
        perror("pipe");
        fd_pool_cleanup(&pool);
        return EXIT_FAILURE;
    }

    /* Add the read ends to the pool. */
    fd_pool_add(&pool, pipefd1[0]);
    fd_pool_add(&pool, pipefd2[0]);
    fd_pool_add(&pool, pipefd3[0]);

    printf("Pool has %zu descriptors\n", pool.count);

    /* Remove one explicitly. */
    fd_pool_remove(&pool, pipefd2[0]);
    printf("After remove: %zu descriptors\n", pool.count);

    /* Attempting to add a duplicate should fail. */
    if (fd_pool_add(&pool, pipefd1[0]) == -1)
        printf("Duplicate add correctly rejected\n");

    /* Clean up everything. */
    fd_pool_cleanup(&pool);
    printf("After first cleanup: count=%zu, capacity=%zu, fds=%p\n",
           pool.count, pool.capacity, (void *)pool.fds);

    /* Call cleanup again – must be safe. */
    fd_pool_cleanup(&pool);
    printf("Second cleanup succeeded (no crash)\n");

    /* Close the write ends we still own. */
    close(pipefd1[1]);
    close(pipefd2[1]);
    close(pipefd3[1]);

    return EXIT_SUCCESS;
}
#endif