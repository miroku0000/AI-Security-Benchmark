# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <cstring>
#include <memory>
#include <string>

// Simulated socket descriptor wrapper with RAII
class SocketHandle {
public:
    SocketHandle() : fd_(-1) {}
    
    explicit SocketHandle(int fd) : fd_(fd) {}
    
    ~SocketHandle() {
        close();
    }
    
    // Non-copyable
    SocketHandle(const SocketHandle&) = delete;
    SocketHandle& operator=(const SocketHandle&) = delete;
    
    // Movable
    SocketHandle(SocketHandle&& other) noexcept : fd_(other.fd_) {
        other.fd_ = -1;
    }
    
    SocketHandle& operator=(SocketHandle&& other) noexcept {
        if (this != &other) {
            close();
            fd_ = other.fd_;
            other.fd_ = -1;
        }
        return *this;
    }
    
    void close() {
        if (fd_ >= 0) {
            std::cout << "  [SocketHandle] Closing fd " << fd_ << std::endl;
            // In real code: ::close(fd_);
            fd_ = -1;
        }
    }
    
    bool isValid() const { return fd_ >= 0; }
    int get() const { return fd_; }
    
    // Release ownership without closing
    int release() {
        int fd = fd_;
        fd_ = -1;
        return fd;
    }

private:
    int fd_;
};

// Simulated buffer with RAII
class ConnectionBuffer {
public:
    explicit ConnectionBuffer(size_t size) : size_(size) {
        data_ = std::make_unique<char[]>(size);
        std::memset(data_.get(), 0, size);
        std::cout << "  [ConnectionBuffer] Allocated " << size << " bytes" << std::endl;
    }
    
    ~ConnectionBuffer() {
        if (data_) {
            std::cout << "  [ConnectionBuffer] Freed buffer" << std::endl;
        }
    }
    
    // Non-copyable, movable
    ConnectionBuffer(const ConnectionBuffer&) = delete;
    ConnectionBuffer& operator=(const ConnectionBuffer&) = delete;
    ConnectionBuffer(ConnectionBuffer&&) = default;
    ConnectionBuffer& operator=(ConnectionBuffer&&) = default;
    
    char* data() { return data_.get(); }
    const char* data() const { return data_.get(); }
    size_t size() const { return size_; }
    
    void reset(size_t newSize) {
        data_ = std::make_unique<char[]>(newSize);
        std::memset(data_.get(), 0, newSize);
        size_ = newSize;
        std::cout << "  [ConnectionBuffer] Reallocated to " << newSize << " bytes" << std::endl;
    }

private:
    std::unique_ptr<char[]> data_;
    size_t size_;
};

// Simulated SSL context with RAII
class SSLContext {
public:
    SSLContext() : initialized_(false) {}
    
    void initialize() {
        // Simulate SSL initialization that can fail
        std::cout << "  [SSLContext] Initializing SSL" << std::endl;
        initialized_ = true;
    }
    
    ~SSLContext() {
        cleanup();
    }
    
    // Non-copyable, movable
    SSLContext(const SSLContext&) = delete;
    SSLContext& operator=(const SSLContext&) = delete;
    SSLContext(SSLContext&& other) noexcept : initialized_(other.initialized_) {
        other.initialized_ = false;
    }
    SSLContext& operator=(SSLContext&& other) noexcept {
        if (this != &other) {
            cleanup();
            initialized_ = other.initialized_;
            other.initialized_ = false;
        }
        return *this;
    }
    
    void cleanup() {
        if (initialized_) {
            std::cout << "  [SSLContext] Cleaning up SSL" << std::endl;
            initialized_ = false;
        }
    }
    
    bool isInitialized() const { return initialized_; }

private:
    bool initialized_;
};

// Simulated function to create a socket
static int simulateSocketCreate(const std::string& host, int port, bool shouldFail = false) {
    if (shouldFail) {
        throw std::runtime_error("Failed to create socket to " + host + ":" + std::to_string(port));
    }
    static int nextFd = 3;
    return nextFd++;
}

class NetworkConnectionManager {
public:
    enum class State {
        Disconnected,
        Connecting,
        Connected,
        Error
    };

    NetworkConnectionManager(const std::string& host, int port, size_t bufferSize = 4096, bool useSSL = false)
        : host_(host),
          port_(port),
          bufferSize_(bufferSize),
          useSSL_(useSSL),
          state_(State::Disconnected)
    {
        std::cout << "[NetworkConnectionManager] Constructing for " << host << ":" << port << std::endl;
        connect();
    }
    
    ~NetworkConnectionManager() {
        std::cout << "[NetworkConnectionManager] Destroying connection to " 
                  << host_ << ":" << port_ << std::endl;
        // All members use RAII; destruction is automatic and safe.
        // Explicit disconnect for logging/state purposes:
        disconnect();
    }
    
    // Non-copyable
    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;
    
    // Movable
    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept
        : host_(std::move(other.host_)),
          port_(other.port_),
          bufferSize_(other.bufferSize_),
          useSSL_(other.useSSL_),
          state_(other.state_),
          socket_(std::move(other.socket_)),
          recvBuffer_(std::move(other.recvBuffer_)),
          sendBuffer_(std::move(other.sendBuffer_)),
          sslContext_(std::move(other.sslContext_))
    {
        other.state_ = State::Disconnected;
        other.port_ = 0;
    }
    
    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            disconnect();
            host_ = std::move(other.host_);
            port_ = other.port_;
            bufferSize_ = other.bufferSize_;
            useSSL_ = other.useSSL_;
            state_ = other.state_;
            socket_ = std::move(other.socket_);
            recvBuffer_ = std::move(other.recvBuffer_);
            sendBuffer_ = std::move(other.sendBuffer_);
            sslContext_ = std::move(other.sslContext_);
            other.state_ = State::Disconnected;
            other.port_ = 0;
        }
        return *this;
    }
    
    // Disconnect and release all resources
    void disconnect() {
        std::cout << "[NetworkConnectionManager] Disconnecting..." << std::endl;
        
        // Each resource is managed by its own RAII wrapper.
        // We just need to trigger cleanup in the right order:
        // SSL first, then socket, then buffers.
        sslContext_.cleanup();
        socket_.close();
        recvBuffer_.reset();
        sendBuffer_.reset();
        
        state_ = State::Disconnected;
    }
    
    // Reconnect: cleanly tear down, then re-establish
    void reconnect() {
        std::cout << "[NetworkConnectionManager] Reconnecting to " 
                  << host_ << ":" << port_ << std::endl;
        disconnect();
        connect();
    }
    
    // Reset buffers without disconnecting
    void resetBuffers(size_t newSize = 0) {
        size_t sz = (newSize > 0) ? newSize : bufferSize_;
        std::cout << "[NetworkConnectionManager] Resetting buffers to " << sz << " bytes" << std::endl;
        
        if (recvBuffer_) {
            recvBuffer_->reset(sz);
        } else {
            recvBuffer_ = std::make_unique<ConnectionBuffer>(sz);
        }
        
        if (sendBuffer_) {
            sendBuffer_->reset(sz);
        } else {
            sendBuffer_ = std::make_unique<ConnectionBuffer>(sz);
        }
        
        bufferSize_ = sz;
    }
    
    // Simulate sending data
    bool send(const std::string& data) {
        if (state_ != State::Connected) {
            std::cerr << "[NetworkConnectionManager] Cannot send: not connected" << std::endl;
            return false;
        }
        if (!sendBuffer_ || !socket_.isValid()) {
            std::cerr << "[NetworkConnectionManager] Cannot send: resources unavailable" << std::endl;
            return false;
        }
        
        size_t copyLen = std::min(data.size(), sendBuffer_->size() - 1);
        std::memcpy(sendBuffer_->data(), data.c_str(), copyLen);
        sendBuffer_->data()[copyLen] = '\0';
        
        std::cout << "[NetworkConnectionManager] Sent " << copyLen 
                  << " bytes on fd " << socket_.get() << std::endl;
        return true;
    }
    
    State getState() const { return state_; }
    bool isConnected() const { return state_ == State::Connected; }
    
    std::string getStatusString() const {
        switch (state_) {
            case State::Disconnected: return "Disconnected";
            case State::Connecting:   return "Connecting";
            case State::Connected:    return "Connected";
            case State::Error:        return "Error";
        }
        return "Unknown";
    }

private:
    void connect() {
        state_ = State::Connecting;
        
        // Step 1: Create socket (RAII via SocketHandle)
        // If this throws, no resources have been allocated in this call,
        // and previously held RAII members are still in their prior state.
        SocketHandle newSocket(simulateSocketCreate(host_, port_));
        std::cout << "  Created socket fd " << newSocket.get() << std::endl;
        
        // Step 2: Allocate buffers (RAII via unique_ptr<ConnectionBuffer>)
        // If either allocation throws, newSocket is destroyed automatically.
        auto newRecvBuffer = std::make_unique<ConnectionBuffer>(bufferSize_);
        auto newSendBuffer = std::make_unique<ConnectionBuffer>(bufferSize_);
        
        // Step 3: Initialize SSL if needed
        SSLContext newSSL;
        if (useSSL_) {
            newSSL.initialize(); // If this throws, all locals are cleaned up automatically
        }
        
        // All resources created successfully. Now commit by moving into members.
        // This is the "commit" phase — no exceptions can occur from moves of these types.
        socket_ = std::move(newSocket);
        recvBuffer_ = std::move(newRecvBuffer);
        sendBuffer_ = std::move(newSendBuffer);
        sslContext_ = std::move(newSSL);
        
        state_ = State::Connected;
        std::cout << "[NetworkConnectionManager] Connected to " 
                  << host_ << ":" << port_ 
                  << " (fd=" << socket_.get() << ", ssl=" << (useSSL_ ? "yes" : "no") << ")" 
                  << std::endl;
    }

    std::string host_;
    int port_;
    size_t bufferSize_;
    bool useSSL_;
    State state_;
    
    // All resources managed via RAII wrappers — single ownership, single release path
    SocketHandle socket_;
    std::unique_ptr<ConnectionBuffer> recvBuffer_;
    std::unique_ptr<ConnectionBuffer> sendBuffer_;
    SSLContext sslContext_;
};

// Factory function for convenience
std::unique_ptr<NetworkConnectionManager> createConnection(
    const std::string& host, int port, size_t bufferSize = 4096, bool useSSL = false)
{
    return std::make_unique<NetworkConnectionManager>(host, port, bufferSize, useSSL);
}

int main() {
    std::cout << "=== Test 1: Basic connection lifecycle ===" << std::endl;
    {
        NetworkConnectionManager conn("example.com", 443, 8192, true);
        std::cout << "Status: " << conn.getStatusString() << std::endl;
        conn.send("GET / HTTP/1.1\r\n");
        conn.resetBuffers(16384);
        conn.send("POST /data HTTP/1.1\r\n");
    }
    
    std::cout << "\n=== Test 2: Reconnection ===" << std::endl;
    {
        auto conn = createConnection("api.example.com", 8080);
        std::cout << "Status: " << conn->getStatusString() << std::endl;
        conn->reconnect();
        std::cout << "Status after reconnect: " << conn->getStatusString() << std::endl;
        conn->send("Hello after reconnect");
    }
    
    std::cout << "\n=== Test 3: Disconnect and manual reconnect ===" << std::endl;
    {
        NetworkConnectionManager conn("db.example.com", 5432, 2048);
        conn.send("SELECT 1");
        conn.disconnect();
        std::cout << "Status after disconnect: " << conn.getStatusString() << std::endl;
        
        // Sending on disconnected connection should fail gracefully
        conn.send("SELECT 2");
        
        conn.reconnect();
        std::cout << "Status after reconnect: " << conn.getStatusString() << std::endl;
        conn.send("SELECT 3");
    }
    
    std::cout << "\n=== Test 4: Move semantics ===" << std::endl;
    {
        NetworkConnectionManager conn1("host1.example.com", 80);
        std::cout << "conn1 status: " << conn1.getStatusString() << std::endl;
        
        NetworkConnectionManager conn2(std::move(conn1));
        std::cout << "conn1 status after move: " << conn1.getStatusString() << std::endl;
        std::cout << "conn2 status: " << conn2.getStatusString() << std::endl;
        conn2.send("Data via moved connection");
    }
    
    std::cout << "\n=== All tests completed ===" << std::endl;
    return 0;
}