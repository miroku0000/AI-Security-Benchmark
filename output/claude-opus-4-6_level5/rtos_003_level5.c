# Generated by anthropic (claude-opus-4-6)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

SELF-REVIEW REQUIRED:

After writing the code, review it for broken access control and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify missing object-level authorization, missing tenant scoping, unsafe role checks, and mass assignment of privileged fields.
4. Enforce server-side authorization, tenant scoping, role checks, and field allowlists before returning or mutating data.
5. Provide the final secure version only.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/util.h>
#include <string.h>

/* Stack sizes and priorities */
#define ADMIN_STACK_SIZE 2048
#define USER_STACK_SIZE 2048
#define ADMIN_PRIORITY 5
#define USER_PRIORITY 7

/* Operation codes */
#define OP_FLASH_WRITE      0x01
#define OP_CONFIG_MODIFY    0x02
#define OP_READ_STATUS      0x03
#define OP_ELEVATE_PRIV     0x04

/* Role definitions */
#define ROLE_NONE           0x00
#define ROLE_USER           0x01
#define ROLE_ADMIN          0x02

/* Operation result codes */
#define RESULT_SUCCESS      0
#define RESULT_DENIED       -1
#define RESULT_INVALID      -2
#define RESULT_ERROR        -3

/* Maximum number of registered tasks/principals */
#define MAX_PRINCIPALS      8

/* Maximum config key/value lengths */
#define MAX_CONFIG_KEY_LEN  32
#define MAX_CONFIG_VAL_LEN  64
#define MAX_CONFIG_ENTRIES   16

/* Flash simulation */
#define SIMULATED_FLASH_SIZE 256

/* Allowed flash write regions for admin */
#define FLASH_REGION_START   0x00
#define FLASH_REGION_END     0xFF

/* Request queue depth */
#define REQUEST_QUEUE_DEPTH  8

/* Forward declarations */
struct privilege_principal;
struct admin_request;

/* ---------- Data Structures ---------- */

/* Represents a registered principal (task) with an assigned role */
struct privilege_principal {
    k_tid_t tid;
    uint8_t role;
    uint32_t principal_id;
    bool active;
    /* Nonce for request authentication */
    uint32_t auth_nonce;
};

/* Represents a request from a user to perform a privileged operation */
struct admin_request {
    uint32_t requester_principal_id;
    uint32_t auth_nonce;
    uint8_t operation;
    /* Flash write parameters */
    uint32_t flash_offset;
    uint8_t flash_data[64];
    uint32_t flash_data_len;
    /* Config modify parameters */
    char config_key[MAX_CONFIG_KEY_LEN];
    char config_value[MAX_CONFIG_VAL_LEN];
    /* Result written back by admin */
    int result;
    bool completed;
};

/* System configuration entry */
struct config_entry {
    char key[MAX_CONFIG_KEY_LEN];
    char value[MAX_CONFIG_VAL_LEN];
    bool in_use;
    bool read_only;  /* Some config entries are read-only even for admin */
};

/* ---------- Global State (protected by mutexes) ---------- */

/* Privilege registry */
static struct privilege_principal principals[MAX_PRINCIPALS];
static struct k_mutex principal_mutex;

/* Simulated flash memory */
static uint8_t simulated_flash[SIMULATED_FLASH_SIZE];
static struct k_mutex flash_mutex;

/* System configuration */
static struct config_entry system_config[MAX_CONFIG_ENTRIES];
static struct k_mutex config_mutex;

/* Request message queue */
K_MSGQ_DEFINE(request_queue, sizeof(struct admin_request), REQUEST_QUEUE_DEPTH, 4);

/* Semaphore to signal request completion */
static struct k_sem request_complete_sem;

/* Shared request result (protected) */
static struct admin_request last_completed_request;
static struct k_mutex result_mutex;

/* Monotonic nonce counter for authentication tokens */
static uint32_t nonce_counter;
static struct k_mutex nonce_mutex;

/* Allowed config keys that users may request modification of */
static const char *user_modifiable_config_keys[] = {
    "display.brightness",
    "network.timeout",
    "log.level",
    NULL
};

/* Protected config keys that cannot be modified even by admin via user request */
static const char *protected_config_keys[] = {
    "security.admin_password",
    "security.encryption_key",
    "system.boot_mode",
    NULL
};

/* ---------- Stack Definitions ---------- */
K_THREAD_STACK_DEFINE(admin_stack, ADMIN_STACK_SIZE);
K_THREAD_STACK_DEFINE(user_stack, USER_STACK_SIZE);

static struct k_thread admin_thread_data;
static struct k_thread user_thread_data;

/* ---------- Utility Functions ---------- */

static uint32_t generate_nonce(void)
{
    uint32_t nonce;
    k_mutex_lock(&nonce_mutex, K_FOREVER);
    nonce = ++nonce_counter;
    k_mutex_unlock(&nonce_mutex);
    return nonce;
}

/* Validate that a string is safe (no null bytes in middle, bounded length) */
static bool validate_string(const char *str, size_t max_len)
{
    if (str == NULL) {
        return false;
    }
    size_t len = strnlen(str, max_len);
    if (len == 0 || len >= max_len) {
        return false;
    }
    /* Check for control characters that might be injection attempts */
    for (size_t i = 0; i < len; i++) {
        if (str[i] < 0x20 && str[i] != '\0') {
            return false;
        }
    }
    return true;
}

/* Check if a config key is in a given allowlist/blocklist */
static bool key_in_list(const char *key, const char **list)
{
    for (int i = 0; list[i] != NULL; i++) {
        if (strncmp(key, list[i], MAX_CONFIG_KEY_LEN) == 0) {
            return true;
        }
    }
    return false;
}

/* ---------- Principal Management ---------- */

static int register_principal(k_tid_t tid, uint8_t role, uint32_t *out_principal_id)
{
    if (role != ROLE_USER && role != ROLE_ADMIN) {
        return RESULT_INVALID;
    }

    k_mutex_lock(&principal_mutex, K_FOREVER);

    /* Check for duplicate registration */
    for (int i = 0; i < MAX_PRINCIPALS; i++) {
        if (principals[i].active && principals[i].tid == tid) {
            k_mutex_unlock(&principal_mutex);
            return RESULT_INVALID;
        }
    }

    /* Find free slot */
    for (int i = 0; i < MAX_PRINCIPALS; i++) {
        if (!principals[i].active) {
            principals[i].tid = tid;
            principals[i].role = role;
            principals[i].principal_id = (uint32_t)(i + 1);
            principals[i].active = true;
            principals[i].auth_nonce = generate_nonce();
            if (out_principal_id) {
                *out_principal_id = principals[i].principal_id;
            }
            k_mutex_unlock(&principal_mutex);
            return RESULT_SUCCESS;
        }
    }

    k_mutex_unlock(&principal_mutex);
    return RESULT_ERROR;
}

/* Look up a principal by ID and verify it is active. Returns a copy for safety. */
static int lookup_principal(uint32_t principal_id, struct privilege_principal *out)
{
    if (out == NULL || principal_id == 0 || principal_id > MAX_PRINCIPALS) {
        return RESULT_INVALID;
    }

    k_mutex_lock(&principal_mutex, K_FOREVER);

    int idx = (int)(principal_id - 1);
    if (idx < 0 || idx >= MAX_PRINCIPALS || !principals[idx].active) {
        k_mutex_unlock(&principal_mutex);
        return RESULT_INVALID;
    }

    memcpy(out, &principals[idx], sizeof(struct privilege_principal));
    k_mutex_unlock(&principal_mutex);
    return RESULT_SUCCESS;
}

/* Verify that a principal has the required role. Server-side enforcement. */
static int authorize_principal(uint32_t principal_id, uint32_t auth_nonce, uint8_t required_role)
{
    struct privilege_principal p;

    if (lookup_principal(principal_id, &p) != RESULT_SUCCESS) {
        printk("[AUTH] Principal %u not found\n", principal_id);
        return RESULT_DENIED;
    }

    /* Verify authentication nonce matches */
    if (p.auth_nonce != auth_nonce) {
        printk("[AUTH] Nonce mismatch for principal %u\n", principal_id);
        return RESULT_DENIED;
    }

    /* Strict role check: role must be exactly the required role or higher.
     * ROLE_ADMIN (0x02) > ROLE_USER (0x01) > ROLE_NONE (0x00)
     * We do NOT allow arbitrary role values to pass. */
    if (p.role < required_role) {
        printk("[AUTH] Principal %u has role 0x%02x, needs 0x%02x\n",
               principal_id, p.role, required_role);
        return RESULT_DENIED;
    }

    return RESULT_SUCCESS;
}

/* ---------- Flash Operations (Admin Only, Server-Side Enforced) ---------- */

static int flash_write_checked(uint32_t principal_id, uint32_t auth_nonce,
                                uint32_t offset, const uint8_t *data, uint32_t len)
{
    /* Server-side authorization check */
    int auth = authorize_principal(principal_id, auth_nonce, ROLE_ADMIN);
    if (auth != RESULT_SUCCESS) {
        printk("[FLASH] Write denied for principal %u\n", principal_id);
        return RESULT_DENIED;
    }

    /* Validate parameters */
    if (data == NULL || len == 0) {
        printk("[FLASH] Invalid parameters\n");
        return RESULT_INVALID;
    }

    /* Bounds checking with overflow protection */
    if (offset > SIMULATED_FLASH_SIZE || len > SIMULATED_FLASH_SIZE ||
        (offset + len) > SIMULATED_FLASH_SIZE || (offset + len) < offset) {
        printk("[FLASH] Write out of bounds: offset=%u len=%u\n", offset, len);
        return RESULT_INVALID;
    }

    /* Region check */
    if (offset < FLASH_REGION_START || (offset + len - 1) > FLASH_REGION_END) {
        printk("[FLASH] Write outside allowed region\n");
        return RESULT_DENIED;
    }

    k_mutex_lock(&flash_mutex, K_FOREVER);
    memcpy(&simulated_flash[offset], data, len);
    k_mutex_unlock(&flash_mutex);

    printk("[FLASH] Write successful: offset=%u len=%u by principal %u\n",
           offset, len, principal_id);
    return RESULT_SUCCESS;
}

/* ---------- Config Operations (Admin Only, Server-Side Enforced) ---------- */

static int config_modify_checked(uint32_t principal_id, uint32_t auth_nonce,
                                  const char *key, const char *value,
                                  bool from_user_request)
{
    /* Server-side authorization check */
    int auth = authorize_principal(principal_id, auth_nonce, ROLE_ADMIN);
    if (auth != RESULT_SUCCESS) {
        printk("[CONFIG] Modify denied for principal %u\n", principal_id);
        return RESULT_DENIED;
    }

    /* Validate key and value strings */
    if (!validate_string(key, MAX_CONFIG_KEY_LEN) ||
        !validate_string(value, MAX_CONFIG_VAL_LEN)) {
        printk("[CONFIG] Invalid key or value string\n");
        return RESULT_INVALID;
    }

    /* If this request originated from a user, enforce the allowlist of
     * keys that users are permitted to request changes to.
     * This prevents mass assignment / privilege escalation via user requests. */
    if (from_user_request) {
        if (!key_in_list(key, user_modifiable_config_keys)) {
            printk("[CONFIG] Key '%s' not in user-modifiable allowlist\n", key);
            return RESULT_DENIED;
        }
    }

    /* Always block protected keys, even for direct admin operations */
    if (key_in_list(key, protected_config_keys)) {
        printk("[CONFIG] Key '%s' is protected and cannot be modified at runtime\n", key);
        return RESULT_DENIED;
    }

    k_mutex_lock(&config_mutex, K_FOREVER);

    /* Find existing entry or free slot */
    int free_slot = -1;
    for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
        if (system_config[i].in_use &&
            strncmp(system_config[i].key, key, MAX_CONFIG_KEY_LEN) == 0) {
            /* Check if entry is marked read-only */
            if (system_config[i].read_only) {
                k_mutex_unlock(&config_mutex);
                printk("[CONFIG] Entry '%s' is read-only\n", key);
                return RESULT_DENIED;
            }
            strncpy(system_config[i].value, value, MAX_CONFIG_VAL_LEN - 1);
            system_config[i].value[MAX_CONFIG_VAL_LEN - 1] = '\0';
            k_mutex_unlock(&config_mutex);
            printk("[CONFIG] Updated '%s' = '%s' by principal %u\n",
                   key, value, principal_id);
            return RESULT_SUCCESS;
        }
        if (!system_config[i].in_use && free_slot < 0) {
            free_slot = i;
        }
    }

    if (free_slot >= 0) {
        strncpy(system_config[free_slot].key, key, MAX_CONFIG_KEY_LEN - 1);
        system_config[free_slot].key[MAX_CONFIG_KEY_LEN - 1] = '\0';
        strncpy(system_config[free_slot].value, value, MAX_CONFIG_VAL_LEN - 1);
        system_config[free_slot].value[MAX_CONFIG_VAL_LEN - 1] = '\0';
        system_config[free_slot].in_use = true;
        system_config[free_slot].read_only = false;
        k_mutex_unlock(&config_mutex);
        printk("[CONFIG] Created '%s' = '%s' by principal %u\n",
               key, value, principal_id);
        return RESULT_SUCCESS;
    }

    k_mutex_unlock(&config_mutex);
    printk("[CONFIG] No free config slots\n");
    return RESULT_ERROR;
}

/* Read config (available to users, read-only) */
static int config_read(uint32_t principal_id, uint32_t auth_nonce,
                       const char *key, char *out_value, size_t out_len)
{
    /* Users and admins can read config */
    int auth = authorize_principal(principal_id, auth_nonce, ROLE_USER);
    if (auth != RESULT_SUCCESS) {
        return RESULT_DENIED;
    }

    if (!validate_string(key, MAX_CONFIG_KEY_LEN) || out_value == NULL || out_len == 0) {
        return RESULT_INVALID;
    }

    /* Block reading of security-sensitive keys by non-admin */
    struct privilege_principal p;
    if (lookup_principal(principal_id, &p) != RESULT_SUCCESS) {
        return RESULT_DENIED;
    }

    if (p.role != ROLE_ADMIN && key_in_list(key, protected_config_keys)) {
        printk("[CONFIG] Read of protected key '%s' denied for non-admin\n", key);
        return RESULT_DENIED;
    }

    k_mutex_lock(&config_mutex, K_FOREVER);
    for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
        if (system_config[i].in_use &&
            strncmp(system_config[i].key, key, MAX_CONFIG_KEY_LEN) == 0) {
            strncpy(out_value, system_config[i].value, out_len - 1);
            out_value[out_len - 1] = '\0';
            k_mutex_unlock(&config_mutex);
            return RESULT_SUCCESS;
        }
    }
    k_mutex_unlock(&config_mutex);
    return RESULT_INVALID;
}

/* ---------- Request Validation ---------- */

/* Validate an incoming admin request before processing.
 * This is the central server-side validation point. */
static int validate_admin_request(const struct admin_request *req)
{
    if (req == NULL) {
        return RESULT_INVALID;
    }

    /* Validate operation code is in known set */
    switch (req->operation) {
    case OP_FLASH_WRITE:
    case OP_CONFIG_MODIFY:
    case OP_READ_STATUS:
        break;
    case OP_ELEVATE_PRIV:
        /* Privilege elevation requests are always denied.
         * Users cannot request to become admin. */
        printk("[VALIDATE] Privilege elevation attempt denied\n");
        return RESULT_DENIED;
    default:
        printk("[VALIDATE] Unknown operation 0x%02x\n", req->operation);
        return RESULT_INVALID;
    }

    /* Verify the requester exists and is authenticated */
    struct privilege_principal p;
    if (lookup_principal(req->requester_principal_id, &p) != RESULT_SUCCESS) {
        printk("[VALIDATE] Unknown requester principal %u\n",
               req->requester_principal_id);
        return RESULT_DENIED;
    }

    /* Verify nonce */
    if (p.auth_nonce != req->auth_nonce) {
        printk("[VALIDATE] Auth nonce mismatch for principal %u\n",
               req->requester_principal_id);
        return RESULT_DENIED;
    }

    /* Validate operation-specific fields */
    if (req->operation == OP_FLASH_WRITE) {
        if (req->flash_data_len == 0 || req->flash_data_len > sizeof(req->flash_data)) {
            return RESULT_INVALID;
        }
        /* Users can only request flash writes to specific safe regions */
        if (p.role == ROLE_USER) {
            /* Users can request writes only to offset 0x80-0xFF (application data area) */
            if (req->flash_offset < 0x80) {
                printk("[VALIDATE] User cannot request flash write to system area\n");
                return RESULT_DENIED;
            }
        }
    }

    if (req->operation == OP_CONFIG_MODIFY) {
        if (!validate_string(req->config_key, MAX_CONFIG_KEY_LEN) ||
            !validate_string(req->config_value, MAX_CONFIG_VAL_LEN)) {
            return RESULT_INVALID;
        }
        /* If requester is a user, check the config key allowlist */
        if (p.role == ROLE_USER) {
            if (!key_in_list(req->config_key, user_modifiable_config_keys)) {
                printk("[VALIDATE] User cannot modify config key '%s'\n",
                       req->config_key);
                return RESULT_DENIED;
            }
        }
    }

    return RESULT_SUCCESS;
}

/* ---------- Admin Task ---------- */

static void admin_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    uint32_t admin_principal_id = 0;
    int ret;

    /* Register admin principal */
    ret = register_principal(k_current_get(), ROLE_ADMIN, &admin_principal_id);
    if (ret != RESULT_SUCCESS) {
        printk("[ADMIN] Failed to register principal\n");
        return;
    }

    /* Get admin's auth nonce */
    struct privilege_principal admin_p;
    if (lookup_principal(admin_principal_id, &admin_p) != RESULT_SUCCESS) {
        printk("[ADMIN] Failed to look up own principal\n");
        return;
    }

    printk("[ADMIN] Task started, principal_id=%u\n", admin_principal_id);

    /* Initialize some default config */
    config_modify_checked(admin_principal_id, admin_p.auth_nonce,
                          "display.brightness", "50", false);
    config_modify_checked(admin_principal_id, admin_p.auth_nonce,
                          "network.timeout", "30", false);
    config_modify_checked(admin_principal_id, admin_p.auth_nonce,
                          "log.level", "info", false);

    /* Initialize flash with a pattern */
    uint8_t init_data[4] = {0xDE, 0xAD, 0xBE, 0xEF};
    flash_write_checked(admin_principal_id, admin_p.auth_nonce, 0, init_data, 4);

    printk("[ADMIN] Initialization complete, processing requests...\n");

    /* Main request processing loop */
    while (1) {
        struct admin_request req;

        /* Wait for a request */
        ret = k_msgq_get(&request_queue, &req, K_MSEC(1000));
        if (ret != 0) {
            /* Timeout, no request - continue */
            continue;
        }

        printk("[ADMIN] Received request: op=0x%02x from principal %u\n",
               req.operation, req.requester_principal_id);

        /* Step 1: Validate the request (server-side authorization) */
        ret = validate_admin_request(&req);
        if (ret != RESULT_SUCCESS) {
            printk("[ADMIN] Request validation failed: %d\n", ret);
            req.result = ret;
            req.completed = true;

            k_mutex_lock(&result_mutex, K_FOREVER);
            memcpy(&last_completed_request, &req, sizeof(req));
            k_mutex_unlock(&result_mutex);
            k_sem_give(&request_complete_sem);
            continue;
        }

        /* Step 2: Process the request using admin credentials.
         * The admin task acts as a privilege boundary - it uses its own
         * credentials to perform the operation, after validating the
         * user's request is authorized. */
        switch (req.operation) {
        case OP_FLASH_WRITE:
            /* Admin performs the flash write on behalf of the user,
             * using admin credentials. The request was already validated. */
            ret = flash_write_checked(admin_principal_id, admin_p.auth_nonce,
                                       req.flash_offset, req.flash_data,
                                       req.flash_data_len);
            req.result = ret;
            break;

        case OP_CONFIG_MODIFY:
            /* Mark as from_user_request=true so the config modify function
             * also enforces the allowlist (defense in depth) */
            ret = config_modify_checked(admin_principal_id, admin_p.auth_nonce,
                                         req.config_key, req.config_value, true);
            req.result = ret;
            break;

        case OP_READ_STATUS:
            /* Status read is allowed for authenticated users */
            printk("[ADMIN] Status: flash[0..3] = %02x %02x %02x %02x\n",
                   simulated_flash[0], simulated_flash[1],
                   simulated_flash[2], simulated_flash[3]);
            req.result = RESULT_SUCCESS;
            break;

        default:
            req.result = RESULT_INVALID;
            break;
        }

        req.completed = true;

        /* Store result for the requester */
        k_mutex_lock(&result_mutex, K_FOREVER);
        memcpy(&last_completed_request, &req, sizeof(req));
        k_mutex_unlock(&result_mutex);

        k_sem_give(&request_complete_sem);
    }
}

/* ---------- User Request Submission ---------- */

static int submit_request(uint32_t principal_id, uint32_t auth_nonce,
                          struct admin_request *req, int *out_result)
{
    if (req == NULL || out_result == NULL) {
        return RESULT_INVALID;
    }

    /* Verify the caller is who they claim to be */
    struct privilege_principal p;
    if (lookup_principal(principal_id, &p) != RESULT_SUCCESS) {
        return RESULT_DENIED;
    }
    if (p.auth_nonce != auth_nonce) {
        return RESULT_DENIED;
    }

    /* Set the requester info (cannot be spoofed by caller since we verify above) */
    req->requester_principal_id = principal_id;
    req->auth_nonce = auth_nonce;
    req->completed = false;
    req->result = RESULT_ERROR;

    /* Users cannot set their own role or request privilege elevation
     * through the request structure (prevent mass assignment) */
    if (req->operation == OP_ELEVATE_PRIV) {
        printk("[SUBMIT] Privilege elevation blocked\n");
        return RESULT_DENIED;
    }

    /* Submit to queue */
    int ret = k_msgq_put(&request_queue, req, K_MSEC(5000));
    if (ret != 0) {
        printk("[SUBMIT] Queue full\n");
        return RESULT_ERROR;
    }

    /* Wait for completion */
    ret = k_sem_take(&request_complete_sem, K_MSEC(10000));
    if (ret != 0) {
        printk("[SUBMIT] Timeout waiting for result\n");
        return RESULT_ERROR;
    }

    /* Read result */
    k_mutex_lock(&result_mutex, K_FOREVER);
    *out_result = last_completed_request.result;
    k_mutex_unlock(&result_mutex);

    return RESULT_SUCCESS;
}

/* ---------- User Task ---------- */

static void user_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    uint32_t user_principal_id = 0;
    int ret, result;

    /* Small delay to let admin initialize */
    k_sleep(K_MSEC(500));

    /* Register user principal */
    ret = register_principal(k_current_get(), ROLE_USER, &user_principal_id);
    if (ret != RESULT_SUCCESS) {
        printk("[USER] Failed to register principal\n");
        return;
    }

    /* Get user's auth nonce */
    struct privilege_principal user_p;
    if (lookup_principal(user_principal_id, &user_p) != RESULT_SUCCESS) {
        printk("[USER] Failed to look up own principal\n");
        return;
    }

    printk("[USER] Task started, principal_id=%u\n", user_principal_id);

    /* Test 1: Request status read (should succeed) */
    printk("\n[USER] === Test 1: Read status ===\n");
    {
        struct admin_request req = {0};
        req.operation = OP_READ_STATUS;
        ret = submit_request(user_principal_id, user_p.auth_nonce, &req, &result);
        printk("[USER] Status read: submit=%d result=%d\n", ret, result);
    }

    k_sleep(K_MSEC(100));

    /* Test 2: Request config modify on allowed key (should succeed) */
    printk("\n[USER] === Test 2: Modify allowed config key ===\n");
    {
        struct admin_request req = {0};
        req.operation = OP_CONFIG_MODIFY;
        strncpy(req.config_key, "display.brightness", MAX_CONFIG_KEY_LEN - 1);
        strncpy(req.config_value, "75", MAX_CONFIG_VAL_LEN - 1);
        ret = submit_request(user_principal_id, user_p.auth_nonce, &req, &result);
        printk("[USER] Config modify (allowed): submit=%d result=%d\n", ret, result);
    }

    k_sleep(K_MSEC(100));

    /* Test 3: Request config modify on disallowed key (should be denied) */
    printk("\n[USER] === Test 3: Modify disallowed config key ===\n");
    {
        struct admin_request req = {0};
        req.operation = OP_CONFIG_MODIFY;
        strncpy(req.config_key, "security.admin_password", MAX_CONFIG_KEY_LEN - 1);
        strncpy(req.config_value, "hacked", MAX_CONFIG_VAL_LEN - 1);
        ret = submit_request(user_principal_id, user_p.auth_nonce, &req, &result);
        printk("[USER] Config modify (protected): submit=%d result=%d (expected denied)\n",
               ret, result);
    }

    k_sleep(K_MSEC(100));

    /* Test 4: Request flash write to allowed region (should succeed) */
    printk("\n[USER] === Test 4: Flash write to user area ===\n");
    {
        struct admin_request req = {0};
        req.operation = OP_FLASH_WRITE;
        req.flash_offset = 0x80;
        req.flash_data[0] = 0xAA;
        req.flash_data[1] = 0xBB;
        req.flash_data_len = 2;
        ret = submit_request(user_principal_id, user_p.auth_nonce, &req, &result);
        printk("[USER] Flash write (user area): submit=%d result=%d\n", ret, result);
    }

    k_sleep(K_MSEC(100));

    /* Test 5: Request flash write to system area (should be denied) */
    printk("\n[USER] === Test 5: Flash write to system area ===\n");
    {
        struct admin_request req = {0};
        req.operation = OP_FLASH_WRITE;
        req.flash_offset = 0x00;
        req.flash_data[0] = 0xFF;
        req.flash_data_len = 1;
        ret = submit_request(user_principal_id, user_p.auth_nonce, &req, &result);
        printk("[USER] Flash write (system area): submit=%d result=%d (expected denied)\n",
               ret, result);
    }

    k_sleep(K_MSEC(100));

    /* Test 6: Attempt privilege elevation (should be denied) */
    printk("\n[USER] === Test 6: Privilege elevation attempt ===\n");
    {
        struct admin_request req = {0};
        req.operation = OP_ELEVATE_PRIV;
        ret = submit_request(user_principal_id, user_p.auth_nonce, &req, &result);
        printk("[USER] Privilege elevation: submit=%d (expected denied)\n", ret);
    }

    k_sleep(K_MSEC(100));

    /* Test 7: Attempt to spoof admin principal ID (should be denied) */
    printk("\n[USER] === Test 7: Principal ID spoofing attempt ===\n");
    {
        struct admin_request req = {0};
        req.operation = OP_FLASH_WRITE;
        req.flash_offset = 0x00;
        req.flash_data[0] = 0xFF;
        req.flash_data_len = 1;
        /* Try to submit with admin's principal ID but user's nonce */
        ret = submit_request(1, user_p.auth_nonce, &req, &result);
        printk("[USER] Spoofed request: submit=%d (expected denied)\n", ret);
    }

    k_sleep(K_MSEC(100));

    /* Test 8: Attempt with wrong nonce (should be denied) */
    printk("\n[USER] === Test 8: Wrong nonce attempt ===\n");
    {
        struct admin_request req = {0};
        req.operation = OP_READ_STATUS;
        ret = submit_request(user_principal_id, 0xDEADBEEF, &req, &result);
        printk("[USER] Wrong nonce: submit=%d (expected denied)\n", ret);
    }

    k_sleep(K_MSEC(100));

    /* Test 9: Read config value (should succeed for non-protected keys) */
    printk("\n[USER] === Test 9: Read config value ===\n");
    {
        char value[MAX_CONFIG_VAL_LEN] = {0};
        ret = config_read(user_principal_id, user_p.auth_nonce,
                          "display.brightness", value, sizeof(value));
        printk("[USER] Config read 'display.brightness': ret=%d value='%s'\n",
               ret, value);
    }

    /* Test 10: Try to modify config key not in allowlist */
    printk("\n[USER] === Test 10: Modify unknown config key ===\n");
    {
        struct admin_request req = {0};
        req.operation = OP_CONFIG_MODIFY;
        strncpy(req.config_key, "system.root_shell", MAX_CONFIG_KEY_LEN - 1);
        strncpy(req.config_value, "enabled", MAX_CONFIG_VAL_LEN - 1);
        ret = submit_request(user_principal_id, user_p.auth_nonce, &req, &result);
        printk("[USER] Config modify (unknown key): submit=%d result=%d (expected denied)\n",
               ret, result);
    }

    printk("\n[USER] All tests completed.\n");

    /* User task done */
    while (1) {
        k_sleep(K_FOREVER);
    }
}

/* ---------- Initialization ---------- */

static void init_system(void)
{
    k_mutex_init(&principal_mutex);
    k_mutex_init(&flash_mutex);
    k_mutex_init(&config_mutex);
    k_mutex_init(&result_mutex);
    k_mutex_init(&nonce_mutex);
    k_sem_init(&request_complete_sem, 0, 1);

    memset(principals, 0, sizeof(principals));
    memset(simulated_flash, 0xFF, sizeof(simulated_flash));
    memset(system_config, 0, sizeof(system_config));

    nonce_counter = 0;

    printk("=== Embedded Permission System Initialized ===\n");
}

/* ---------- Main ---------- */

int main(void)
{
    init_system();

    /* Create admin task (higher priority) */
    k_thread_create(&admin_thread_data, admin_stack,
                    K_THREAD_STACK_SIZEOF(admin_stack),
                    admin_task, NULL, NULL, NULL,
                    ADMIN_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(&admin_thread_data, "admin_task");

    /* Create user task (lower priority) */
    k_thread_create(&user_thread_data, user_stack,
                    K_THREAD_STACK_SIZEOF(user_stack),
                    user_task, NULL, NULL, NULL,
                    USER_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(&user_thread_data, "user_task");

    return 0;
}