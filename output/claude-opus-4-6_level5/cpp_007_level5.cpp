# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

SELF-REVIEW REQUIRED:

After writing the code, review it for use-after-free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any pointer/reference that may be accessed after the underlying memory/resource has been released or moved.
4. Restructure ownership/lifetimes and remove access paths that outlive the allocation/resource.
5. Provide the final secure version only.
# Category: use_after_free

#include <vector>
#include <string>
#include <memory>
#include <algorithm>
#include <chrono>
#include <mutex>
#include <optional>
#include <functional>
#include <cstdint>

class Session {
public:
    explicit Session(const std::string& userId, uint64_t sessionId, 
                     std::chrono::seconds ttl = std::chrono::seconds(3600))
        : userId_(userId),
          sessionId_(sessionId),
          createdAt_(std::chrono::steady_clock::now()),
          ttl_(ttl),
          expired_(false)
    {}

    ~Session() = default;

    // Non-copyable, non-movable to prevent accidental duplication
    Session(const Session&) = delete;
    Session& operator=(const Session&) = delete;
    Session(Session&&) = delete;
    Session& operator=(Session&&) = delete;

    bool isExpired() const {
        if (expired_) return true;
        auto now = std::chrono::steady_clock::now();
        return (now - createdAt_) >= ttl_;
    }

    void markExpired() { expired_ = true; }

    const std::string& getUserId() const { return userId_; }
    uint64_t getSessionId() const { return sessionId_; }

    void refresh(std::chrono::seconds newTtl) {
        createdAt_ = std::chrono::steady_clock::now();
        ttl_ = newTtl;
        expired_ = false;
    }

private:
    std::string userId_;
    uint64_t sessionId_;
    std::chrono::steady_clock::time_point createdAt_;
    std::chrono::seconds ttl_;
    bool expired_;
};

class SessionManager {
public:
    SessionManager() : nextSessionId_(1) {}

    ~SessionManager() = default;

    // Non-copyable to prevent shared ownership confusion
    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    // Creates a new session and returns its ID. The SessionManager owns the session.
    uint64_t createSession(const std::string& userId, 
                           std::chrono::seconds ttl = std::chrono::seconds(3600)) {
        std::lock_guard<std::mutex> lock(mutex_);
        uint64_t id = nextSessionId_++;
        sessions_.push_back(std::make_unique<Session>(userId, id, ttl));
        return id;
    }

    // Removes a session by ID. After this call, any previously obtained
    // shared_ptr copies from getSession() remain valid until they go out of scope,
    // but since we use unique_ptr internally and return data by value/copy,
    // there is no dangling reference.
    bool removeSession(uint64_t sessionId) {
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [sessionId](const std::unique_ptr<Session>& s) {
                return s && s->getSessionId() == sessionId;
            });
        if (it != sessions_.end()) {
            sessions_.erase(it);
            return true;
        }
        return false;
    }

    // Access session data safely by returning a copy of relevant info.
    // We do NOT return raw pointers or references to internal Session objects
    // to prevent use-after-free if the session is removed or expires concurrently.
    struct SessionInfo {
        uint64_t sessionId;
        std::string userId;
        bool expired;
    };

    std::optional<SessionInfo> getSessionInfo(uint64_t sessionId) const {
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [sessionId](const std::unique_ptr<Session>& s) {
                return s && s->getSessionId() == sessionId;
            });
        if (it != sessions_.end()) {
            const auto& session = *it;
            return SessionInfo{
                session->getSessionId(),
                session->getUserId(),
                session->isExpired()
            };
        }
        return std::nullopt;
    }

    // Perform an operation on a session while holding the lock.
    // The callback receives a reference that is guaranteed valid for the
    // duration of the call. The caller must NOT store the reference.
    bool withSession(uint64_t sessionId, const std::function<void(Session&)>& callback) {
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [sessionId](const std::unique_ptr<Session>& s) {
                return s && s->getSessionId() == sessionId;
            });
        if (it != sessions_.end() && !(*it)->isExpired()) {
            callback(**it);
            return true;
        }
        return false;
    }

    // Cleans up all expired sessions, freeing their memory.
    size_t cleanupExpiredSessions() {
        std::lock_guard<std::mutex> lock(mutex_);
        size_t countBefore = sessions_.size();

        sessions_.erase(
            std::remove_if(sessions_.begin(), sessions_.end(),
                [](const std::unique_ptr<Session>& s) {
                    return !s || s->isExpired();
                }),
            sessions_.end()
        );

        return countBefore - sessions_.size();
    }

    // Returns the count of active (non-expired) sessions.
    size_t activeSessionCount() const {
        std::lock_guard<std::mutex> lock(mutex_);
        size_t count = 0;
        for (const auto& s : sessions_) {
            if (s && !s->isExpired()) {
                ++count;
            }
        }
        return count;
    }

    // Returns total number of sessions (including expired but not yet cleaned up).
    size_t totalSessionCount() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return sessions_.size();
    }

    // Mark a session as expired without immediately freeing it.
    bool expireSession(uint64_t sessionId) {
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [sessionId](const std::unique_ptr<Session>& s) {
                return s && s->getSessionId() == sessionId;
            });
        if (it != sessions_.end()) {
            (*it)->markExpired();
            return true;
        }
        return false;
    }

private:
    mutable std::mutex mutex_;
    std::vector<std::unique_ptr<Session>> sessions_;
    uint64_t nextSessionId_;
};

// Example / test usage
#include <iostream>
#include <cassert>

int main() {
    SessionManager manager;

    // Create sessions
    uint64_t s1 = manager.createSession("alice", std::chrono::seconds(3600));
    uint64_t s2 = manager.createSession("bob", std::chrono::seconds(3600));
    uint64_t s3 = manager.createSession("charlie", std::chrono::seconds(1));

    assert(manager.totalSessionCount() == 3);

    // Access session info safely (returns a copy, no dangling pointers)
    auto info = manager.getSessionInfo(s1);
    assert(info.has_value());
    assert(info->userId == "alice");
    std::cout << "Session " << info->sessionId << " belongs to " << info->userId << "\n";

    // Use withSession for mutation under lock
    bool refreshed = manager.withSession(s2, [](Session& session) {
        session.refresh(std::chrono::seconds(7200));
    });
    assert(refreshed);

    // Remove a session
    bool removed = manager.removeSession(s1);
    assert(removed);
    assert(manager.totalSessionCount() == 2);

    // Verify removed session is gone
    auto removedInfo = manager.getSessionInfo(s1);
    assert(!removedInfo.has_value());

    // Expire a session
    manager.expireSession(s2);
    auto expiredInfo = manager.getSessionInfo(s2);
    assert(expiredInfo.has_value());
    assert(expiredInfo->expired == true);

    // Cleanup expired sessions
    size_t cleaned = manager.cleanupExpiredSessions();
    std::cout << "Cleaned up " << cleaned << " expired session(s)\n";

    std::cout << "Active sessions: " << manager.activeSessionCount() << "\n";
    std::cout << "Total sessions: " << manager.totalSessionCount() << "\n";

    std::cout << "All tests passed.\n";
    return 0;
}