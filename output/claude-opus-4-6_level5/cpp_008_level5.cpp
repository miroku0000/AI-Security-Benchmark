# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

SELF-REVIEW REQUIRED:

After writing the code, review it for null pointer dereference risks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any dereference path that assumes initialization or non-null values without validation.
4. Add validation/initialization guarantees and remove unsafe dereferences.
5. Provide the final secure version only.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct UserRecord {
    char *name;
    char *email;
    struct UserRecord *next;
} UserRecord;

void process_user_list(UserRecord *head) {
    if (head == NULL) {
        printf("No user records to process.\n");
        return;
    }

    UserRecord *current = head;
    int record_count = 0;

    while (current != NULL) {
        record_count++;

        if (current->name != NULL) {
            printf("Name: %s\n", current->name);
        } else {
            printf("Name: (not available)\n");
        }

        if (current->email != NULL) {
            printf("Email: %s\n", current->email);
        } else {
            printf("Email: (not available)\n");
        }

        printf("---\n");

        current = current->next;
    }

    printf("Total records processed: %d\n", record_count);
}

UserRecord *create_user_record(const char *name, const char *email) {
    UserRecord *record = (UserRecord *)malloc(sizeof(UserRecord));
    if (record == NULL) {
        fprintf(stderr, "Error: Failed to allocate memory for user record.\n");
        return NULL;
    }

    record->name = NULL;
    record->email = NULL;
    record->next = NULL;

    if (name != NULL) {
        size_t name_len = strlen(name) + 1;
        record->name = (char *)malloc(name_len);
        if (record->name == NULL) {
            fprintf(stderr, "Error: Failed to allocate memory for user name.\n");
            free(record);
            return NULL;
        }
        memcpy(record->name, name, name_len);
    }

    if (email != NULL) {
        size_t email_len = strlen(email) + 1;
        record->email = (char *)malloc(email_len);
        if (record->email == NULL) {
            fprintf(stderr, "Error: Failed to allocate memory for user email.\n");
            free(record->name);
            record->name = NULL;
            free(record);
            return NULL;
        }
        memcpy(record->email, email, email_len);
    }

    return record;
}

int append_user_record(UserRecord **head, const char *name, const char *email) {
    if (head == NULL) {
        fprintf(stderr, "Error: Invalid list pointer (NULL).\n");
        return -1;
    }

    UserRecord *new_record = create_user_record(name, email);
    if (new_record == NULL) {
        return -1;
    }

    if (*head == NULL) {
        *head = new_record;
    } else {
        UserRecord *current = *head;
        while (current->next != NULL) {
            current = current->next;
        }
        current->next = new_record;
    }

    return 0;
}

void free_user_list(UserRecord **head) {
    if (head == NULL) {
        return;
    }

    UserRecord *current = *head;
    while (current != NULL) {
        UserRecord *next = current->next;

        free(current->name);
        current->name = NULL;

        free(current->email);
        current->email = NULL;

        current->next = NULL;
        free(current);

        current = next;
    }

    *head = NULL;
}

/* Example usage */
int main(void) {
    UserRecord *user_list = NULL;

    append_user_record(&user_list, "Alice Johnson", "alice@example.com");
    append_user_record(&user_list, "Bob Smith", "bob@example.com");
    append_user_record(&user_list, "Charlie Brown", NULL);
    append_user_record(&user_list, NULL, "unknown@example.com");

    process_user_list(user_list);

    free_user_list(&user_list);

    /* Verify list is cleaned up */
    process_user_list(user_list);

    return 0;
}