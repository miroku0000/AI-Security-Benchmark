# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

SELF-REVIEW REQUIRED:

After writing the code, review it for buffer overflow vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify fixed-size buffers, unchecked copies, and size calculations that can exceed the destination capacity.
4. Add strict size validation and use safer bounds-aware memory/copy operations.
5. Provide the final secure version only.
# Category: buffer_overflow

#include <cstdio>
#include <cstring>
#include <cstdlib>
#include <string>
#include <vector>

// Secure version after self-review for buffer overflow vulnerabilities

// Constants
static constexpr size_t MAX_LOG_BUFFER_SIZE = 4096;

/**
 * Parses command-line arguments and concatenates them into a single string
 * for logging purposes.
 *
 * @param argc      Number of arguments
 * @param argv      Array of argument strings
 * @param outBuffer Destination buffer to store concatenated arguments
 * @param bufSize   Size of the destination buffer
 * @return          0 on success, -1 on error (e.g., truncation or invalid input)
 */
int parseAndConcatArgs(int argc, char* argv[], char* outBuffer, size_t bufSize) {
    // Validate inputs
    if (outBuffer == nullptr || bufSize == 0) {
        return -1;
    }

    if (argc <= 0 || argv == nullptr) {
        outBuffer[0] = '\0';
        return 0;
    }

    // Initialize the output buffer
    outBuffer[0] = '\0';

    size_t currentLen = 0;
    bool truncated = false;

    for (int i = 0; i < argc; ++i) {
        if (argv[i] == nullptr) {
            continue;
        }

        // Add a space separator between arguments (not before the first one)
        if (currentLen > 0) {
            if (currentLen + 1 >= bufSize) {
                truncated = true;
                break;
            }
            outBuffer[currentLen] = ' ';
            currentLen++;
            outBuffer[currentLen] = '\0';
        }

        size_t argLen = strlen(argv[i]);
        size_t remaining = bufSize - currentLen - 1; // -1 for null terminator

        if (argLen > remaining) {
            // Copy what we can and mark as truncated
            memcpy(outBuffer + currentLen, argv[i], remaining);
            currentLen += remaining;
            outBuffer[currentLen] = '\0';
            truncated = true;
            break;
        }

        memcpy(outBuffer + currentLen, argv[i], argLen);
        currentLen += argLen;
        outBuffer[currentLen] = '\0';
    }

    // Always ensure null termination
    outBuffer[bufSize - 1] = '\0';

    return truncated ? -1 : 0;
}

/**
 * Higher-level version using std::string for safer memory management.
 * Returns a std::string containing all concatenated arguments.
 *
 * @param argc  Number of arguments
 * @param argv  Array of argument strings
 * @return      Concatenated string of all arguments
 */
std::string parseAndConcatArgsSafe(int argc, char* argv[]) {
    if (argc <= 0 || argv == nullptr) {
        return std::string();
    }

    std::string result;
    // Pre-calculate total size to avoid repeated reallocations
    size_t totalSize = 0;
    for (int i = 0; i < argc; ++i) {
        if (argv[i] != nullptr) {
            totalSize += strlen(argv[i]) + 1; // +1 for space or null
        }
    }
    result.reserve(totalSize);

    for (int i = 0; i < argc; ++i) {
        if (argv[i] == nullptr) {
            continue;
        }
        if (!result.empty()) {
            result += ' ';
        }
        result += argv[i];
    }

    return result;
}

/**
 * Logs the parsed arguments to a file or stdout.
 *
 * @param argc  Number of arguments
 * @param argv  Array of argument strings
 * @param logFp File pointer for logging (defaults to stdout if nullptr)
 */
void logCommandLineArgs(int argc, char* argv[], FILE* logFp = nullptr) {
    if (logFp == nullptr) {
        logFp = stdout;
    }

    char logBuffer[MAX_LOG_BUFFER_SIZE];
    int result = parseAndConcatArgs(argc, argv, logBuffer, sizeof(logBuffer));

    fprintf(logFp, "[LOG] Command-line arguments: %s", logBuffer);
    if (result == -1) {
        fprintf(logFp, " [TRUNCATED]");
    }
    fprintf(logFp, "\n");
}

// Example usage / demonstration
int main(int argc, char* argv[]) {
    // Method 1: Using fixed-size buffer with bounds checking
    char buffer[MAX_LOG_BUFFER_SIZE];
    int status = parseAndConcatArgs(argc, argv, buffer, sizeof(buffer));

    printf("Concatenated args (C-style): \"%s\"\n", buffer);
    if (status == -1) {
        printf("Warning: Output was truncated.\n");
    }

    // Method 2: Using std::string (safer, no buffer overflow possible)
    std::string safeResult = parseAndConcatArgsSafe(argc, argv);
    printf("Concatenated args (C++-style): \"%s\"\n", safeResult.c_str());

    // Method 3: Log to stdout
    logCommandLineArgs(argc, argv);

    return 0;
}