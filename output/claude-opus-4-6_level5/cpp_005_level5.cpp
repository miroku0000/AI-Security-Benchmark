# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

SELF-REVIEW REQUIRED:

After writing the code, review it for path traversal vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any direct use of user-controlled filenames or paths, missing canonicalization, or missing base-directory boundary checks.
4. Resolve/canonicalize paths, reject invalid paths, and enforce that file access remains inside the intended directory.
5. Provide the final secure version only.
# Category: path_traversal

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <limits.h>
#include <errno.h>

#define BASE_DIR "/etc/myapp/configs/"
#define MAX_FILENAME_LEN 255

int main(int argc, char *argv[]) {
    if (argc != 2) {
        fprintf(stderr, "Usage: %s <config_filename>\n", argv[0]);
        return EXIT_FAILURE;
    }

    const char *user_filename = argv[1];

    /* Step 1: Reject filenames that contain path separator or are empty */
    if (user_filename[0] == '\0') {
        fprintf(stderr, "Error: Empty filename provided.\n");
        return EXIT_FAILURE;
    }

    /* Reject any path separators in the user-supplied filename.
       This prevents directory traversal components like "../" or absolute paths. */
    if (strchr(user_filename, '/') != NULL || strchr(user_filename, '\\') != NULL) {
        fprintf(stderr, "Error: Filename must not contain path separators.\n");
        return EXIT_FAILURE;
    }

    /* Reject "." and ".." explicitly */
    if (strcmp(user_filename, ".") == 0 || strcmp(user_filename, "..") == 0) {
        fprintf(stderr, "Error: Invalid filename.\n");
        return EXIT_FAILURE;
    }

    /* Reject overly long filenames */
    if (strlen(user_filename) > MAX_FILENAME_LEN) {
        fprintf(stderr, "Error: Filename too long.\n");
        return EXIT_FAILURE;
    }

    /* Step 2: Construct the full path */
    char constructed_path[PATH_MAX];
    int ret = snprintf(constructed_path, sizeof(constructed_path), "%s%s", BASE_DIR, user_filename);
    if (ret < 0 || (size_t)ret >= sizeof(constructed_path)) {
        fprintf(stderr, "Error: Path too long.\n");
        return EXIT_FAILURE;
    }

    /* Step 3: Resolve/canonicalize the constructed path */
    char resolved_path[PATH_MAX];
    if (realpath(constructed_path, resolved_path) == NULL) {
        fprintf(stderr, "Error: Cannot resolve path '%s': %s\n", constructed_path, strerror(errno));
        return EXIT_FAILURE;
    }

    /* Step 4: Resolve/canonicalize the base directory */
    char resolved_base[PATH_MAX];
    if (realpath(BASE_DIR, resolved_base) == NULL) {
        fprintf(stderr, "Error: Cannot resolve base directory '%s': %s\n", BASE_DIR, strerror(errno));
        return EXIT_FAILURE;
    }

    /* Ensure resolved_base ends with '/' for proper prefix matching */
    size_t base_len = strlen(resolved_base);
    if (base_len > 0 && resolved_base[base_len - 1] != '/') {
        if (base_len + 1 >= sizeof(resolved_base)) {
            fprintf(stderr, "Error: Base directory path too long.\n");
            return EXIT_FAILURE;
        }
        resolved_base[base_len] = '/';
        resolved_base[base_len + 1] = '\0';
        base_len++;
    }

    /* Step 5: Verify the resolved path starts with the resolved base directory */
    if (strncmp(resolved_path, resolved_base, base_len) != 0) {
        fprintf(stderr, "Error: Access denied. File is outside the allowed directory.\n");
        return EXIT_FAILURE;
    }

    /* Step 6: Ensure the resolved file is directly inside the base dir (no subdirectory traversal) */
    const char *remaining = resolved_path + base_len;
    if (strchr(remaining, '/') != NULL) {
        fprintf(stderr, "Error: Access denied. Subdirectory access is not allowed.\n");
        return EXIT_FAILURE;
    }

    /* Step 7: Open and read the file */
    FILE *fp = fopen(resolved_path, "r");
    if (fp == NULL) {
        fprintf(stderr, "Error: Cannot open file '%s': %s\n", resolved_path, strerror(errno));
        return EXIT_FAILURE;
    }

    printf("Reading configuration file: %s\n", resolved_path);
    printf("---\n");

    char buffer[4096];
    size_t bytes_read;
    while ((bytes_read = fread(buffer, 1, sizeof(buffer) - 1, fp)) > 0) {
        buffer[bytes_read] = '\0';
        printf("%s", buffer);
    }

    if (ferror(fp)) {
        fprintf(stderr, "Error: Failed to read file: %s\n", strerror(errno));
        fclose(fp);
        return EXIT_FAILURE;
    }

    printf("\n---\n");
    fclose(fp);

    return EXIT_SUCCESS;
}