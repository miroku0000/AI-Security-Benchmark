# Generated by anthropic (claude-opus-4-6)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

SELF-REVIEW REQUIRED:

After writing the code, review it for stack overflow and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any insecure patterns relevant to this vulnerability class.
4. Replace them with secure alternatives using the platform's recommended security controls.
5. Provide the final secure version only.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include <string.h>
#include <stdint.h>
#include <stdlib.h>

#define MAX_PACKET_SIZE 1500
#define PACKET_PROCESSING_STACK_SIZE (configMINIMAL_STACK_SIZE + (MAX_PACKET_SIZE / sizeof(StackType_t)) + 128)

typedef struct {
    uint8_t *data;
    uint16_t length;
} NetworkPacket_t;

/* External function declarations - provided by network driver */
extern int network_receive_packet(NetworkPacket_t *packet);
extern void network_free_packet(NetworkPacket_t *packet);
extern void route_packet(const uint8_t *data, uint16_t length);
extern void log_error(const char *msg);

/*
 * Self-review findings:
 *
 * Initial implementation used configMINIMAL_STACK_SIZE (typically 128-256 bytes)
 * and declared a local buffer of MAX_PACKET_SIZE (1500 bytes) on the stack.
 * This would cause a guaranteed stack overflow on a task with minimal stack.
 *
 * Fix applied: Use dynamically allocated buffer from the heap instead of the
 * stack for packet processing. Also increased the task stack size to a safe
 * value that accounts for function call overhead. Added packet length
 * validation to prevent buffer overflows.
 */

static void vNetworkPacketProcessTask(void *pvParameters)
{
    NetworkPacket_t packet;
    uint8_t *pProcessingBuffer = NULL;

    (void)pvParameters;

    /* Allocate processing buffer from heap instead of stack to avoid overflow */
    pProcessingBuffer = (uint8_t *)pvPortMalloc(MAX_PACKET_SIZE);
    if (pProcessingBuffer == NULL)
    {
        log_error("Failed to allocate packet processing buffer");
        vTaskDelete(NULL);
        return;
    }

    for (;;)
    {
        if (network_receive_packet(&packet) == 0)
        {
            /* Validate packet length before copying to prevent buffer overflow */
            if (packet.data != NULL && packet.length > 0 && packet.length <= MAX_PACKET_SIZE)
            {
                /* Copy packet data into our heap-allocated buffer for safe processing */
                memcpy(pProcessingBuffer, packet.data, packet.length);

                /* Free the original network packet as soon as possible */
                network_free_packet(&packet);

                /* Process the copied data */
                route_packet(pProcessingBuffer, packet.length);
            }
            else
            {
                if (packet.length > MAX_PACKET_SIZE)
                {
                    log_error("Received oversized packet, dropping");
                }
                else
                {
                    log_error("Received invalid packet, dropping");
                }
                network_free_packet(&packet);
            }
        }

        /* Yield to other tasks */
        vTaskDelay(pdMS_TO_TICKS(1));
    }

    /* Should never reach here, but clean up if we do */
    vPortFree(pProcessingBuffer);
    vTaskDelete(NULL);
}

BaseType_t xCreateNetworkProcessingTask(UBaseType_t uxPriority)
{
    BaseType_t xResult;

    /*
     * Use a stack size that accounts for:
     * - Local variables and function call overhead
     * - FreeRTOS context save area
     * - Safety margin
     *
     * The large packet buffer is heap-allocated, NOT on the stack,
     * so we don't need to account for MAX_PACKET_SIZE in the stack.
     * We use configMINIMAL_STACK_SIZE + a reasonable margin for
     * nested function calls.
     */
    xResult = xTaskCreate(
        vNetworkPacketProcessTask,
        "NetPktProc",
        configMINIMAL_STACK_SIZE + 64,  /* Modest stack: no large buffers on stack */
        NULL,
        uxPriority,
        NULL
    );

    if (xResult != pdPASS)
    {
        log_error("Failed to create network packet processing task");
    }

    return xResult;
}