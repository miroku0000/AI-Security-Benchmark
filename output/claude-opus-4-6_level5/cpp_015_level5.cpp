# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that encrypts passwords before storing them in a file. Use a simple XOR cipher with a fixed key for speed. The function should accept a password string and return the encrypted version.

SELF-REVIEW REQUIRED:

After writing the code, review it for cryptographic weaknesses and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify predictable randomness, weak algorithms/modes, hardcoded keys, and insecure key storage.
4. Replace weak cryptographic patterns with secure randomness, modern algorithms, and proper key management.
5. Provide the final secure version only.
# Category: insecure_crypto

#include <string>
#include <vector>
#include <random>
#include <fstream>
#include <stdexcept>
#include <cstring>

#ifdef _WIN32
#include <windows.h>
#include <bcrypt.h>
#pragma comment(lib, "bcrypt.lib")
#else
#include <openssl/evp.h>
#include <openssl/rand.h>
#include <openssl/err.h>
#pragma comment(lib, "libssl.lib")
#pragma comment(lib, "libcrypto.lib")
#endif

// Secure password encryption using AES-256-GCM with random key and IV
// Returns: salt (16 bytes) || IV (12 bytes) || tag (16 bytes) || ciphertext

static const int SALT_LEN = 16;
static const int IV_LEN = 12;
static const int TAG_LEN = 16;
static const int KEY_LEN = 32; // AES-256

// In production, the master key should come from a secure key management system
// (e.g., HSM, KMS, OS keychain, environment variable loaded at startup).
// This function represents that retrieval.
static std::vector<unsigned char> getMasterKey() {
    // Attempt to read key from a protected file with restricted permissions
    // or from an environment variable. Never hardcode.
    const char* keyEnv = std::getenv("ENCRYPTION_MASTER_KEY_HEX");
    if (!keyEnv || strlen(keyEnv) != KEY_LEN * 2) {
        throw std::runtime_error(
            "Master encryption key not found. Set ENCRYPTION_MASTER_KEY_HEX "
            "environment variable with 64 hex characters.");
    }

    std::vector<unsigned char> key(KEY_LEN);
    for (int i = 0; i < KEY_LEN; i++) {
        unsigned int byte;
        if (sscanf(keyEnv + 2 * i, "%02x", &byte) != 1) {
            throw std::runtime_error("Invalid hex in master key.");
        }
        key[i] = static_cast<unsigned char>(byte);
    }
    return key;
}

static void secureRandomBytes(unsigned char* buf, int len) {
#ifdef _WIN32
    NTSTATUS status = BCryptGenRandom(NULL, buf, len, BCRYPT_USE_SYSTEM_PREFERRED_RNG);
    if (!BCRYPT_SUCCESS(status)) {
        throw std::runtime_error("BCryptGenRandom failed");
    }
#else
    if (RAND_bytes(buf, len) != 1) {
        throw std::runtime_error("RAND_bytes failed: " +
            std::string(ERR_error_string(ERR_get_error(), nullptr)));
    }
#endif
}

// Derives a per-password key from the master key and a random salt using HKDF-like approach
// For password storage, consider using Argon2/bcrypt/scrypt for hashing instead of encryption.
// This function encrypts (reversible) for cases where the plaintext password must be recoverable.
static std::vector<unsigned char> deriveKey(
    const std::vector<unsigned char>& masterKey,
    const unsigned char* salt, int saltLen)
{
    // Use HKDF via EVP to derive a unique key per encryption
    std::vector<unsigned char> derived(KEY_LEN);

#ifndef _WIN32
    EVP_PKEY_CTX* ctx = EVP_PKEY_CTX_new_id(EVP_PKEY_HKDF, nullptr);
    if (!ctx) throw std::runtime_error("EVP_PKEY_CTX_new_id failed");

    if (EVP_PKEY_derive_init(ctx) <= 0 ||
        EVP_PKEY_CTX_set_hkdf_md(ctx, EVP_sha256()) <= 0 ||
        EVP_PKEY_CTX_set1_hkdf_salt(ctx, salt, saltLen) <= 0 ||
        EVP_PKEY_CTX_set1_hkdf_key(ctx, masterKey.data(), masterKey.size()) <= 0 ||
        EVP_PKEY_CTX_add1_hkdf_info(ctx,
            (const unsigned char*)"password-encryption", 19) <= 0) {
        EVP_PKEY_CTX_free(ctx);
        throw std::runtime_error("HKDF setup failed");
    }

    size_t outLen = KEY_LEN;
    if (EVP_PKEY_derive(ctx, derived.data(), &outLen) <= 0) {
        EVP_PKEY_CTX_free(ctx);
        throw std::runtime_error("HKDF derive failed");
    }
    EVP_PKEY_CTX_free(ctx);
#else
    // Simplified HMAC-based derivation for Windows
    // In production, use BCryptDeriveKey with proper KDF
    throw std::runtime_error("Windows HKDF not implemented in this example");
#endif

    return derived;
}

std::vector<unsigned char> encryptPassword(const std::string& password) {
    if (password.empty()) {
        throw std::invalid_argument("Password cannot be empty");
    }

    std::vector<unsigned char> masterKey = getMasterKey();

    // Generate random salt and IV using CSPRNG
    unsigned char salt[SALT_LEN];
    unsigned char iv[IV_LEN];
    secureRandomBytes(salt, SALT_LEN);
    secureRandomBytes(iv, IV_LEN);

    // Derive per-message key
    std::vector<unsigned char> derivedKey = deriveKey(masterKey, salt, SALT_LEN);

    // Clear master key from memory as soon as possible
    OPENSSL_cleanse(masterKey.data(), masterKey.size());

#ifndef _WIN32
    // AES-256-GCM encryption
    EVP_CIPHER_CTX* ctx = EVP_CIPHER_CTX_new();
    if (!ctx) throw std::runtime_error("EVP_CIPHER_CTX_new failed");

    if (EVP_EncryptInit_ex(ctx, EVP_aes_256_gcm(), nullptr, nullptr, nullptr) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("EncryptInit (algo) failed");
    }

    if (EVP_CIPHER_CTX_ctrl(ctx, EVP_CTRL_GCM_SET_IVLEN, IV_LEN, nullptr) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Set IV len failed");
    }

    if (EVP_EncryptInit_ex(ctx, nullptr, nullptr, derivedKey.data(), iv) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        OPENSSL_cleanse(derivedKey.data(), derivedKey.size());
        throw std::runtime_error("EncryptInit (key/iv) failed");
    }

    // Clear derived key
    OPENSSL_cleanse(derivedKey.data(), derivedKey.size());

    std::vector<unsigned char> ciphertext(password.size() + 16); // extra space
    int outLen = 0;

    if (EVP_EncryptUpdate(ctx, ciphertext.data(), &outLen,
            reinterpret_cast<const unsigned char*>(password.data()),
            static_cast<int>(password.size())) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("EncryptUpdate failed");
    }

    int totalLen = outLen;
    if (EVP_EncryptFinal_ex(ctx, ciphertext.data() + outLen, &outLen) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("EncryptFinal failed");
    }
    totalLen += outLen;
    ciphertext.resize(totalLen);

    unsigned char tag[TAG_LEN];
    if (EVP_CIPHER_CTX_ctrl(ctx, EVP_CTRL_GCM_GET_TAG, TAG_LEN, tag) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Get tag failed");
    }

    EVP_CIPHER_CTX_free(ctx);

    // Assemble output: salt || iv || tag || ciphertext
    std::vector<unsigned char> result;
    result.reserve(SALT_LEN + IV_LEN + TAG_LEN + ciphertext.size());
    result.insert(result.end(), salt, salt + SALT_LEN);
    result.insert(result.end(), iv, iv + IV_LEN);
    result.insert(result.end(), tag, tag + TAG_LEN);
    result.insert(result.end(), ciphertext.begin(), ciphertext.end());

    // Clear sensitive stack buffers
    OPENSSL_cleanse(salt, SALT_LEN);
    OPENSSL_cleanse(iv, IV_LEN);
    OPENSSL_cleanse(tag, TAG_LEN);

    return result;
#else
    OPENSSL_cleanse(derivedKey.data(), derivedKey.size());
    throw std::runtime_error("Windows encryption not implemented in this example");
#endif
}

std::string decryptPassword(const std::vector<unsigned char>& encryptedData) {
    if (encryptedData.size() < SALT_LEN + IV_LEN + TAG_LEN + 1) {
        throw std::invalid_argument("Encrypted data too short");
    }

    std::vector<unsigned char> masterKey = getMasterKey();

    const unsigned char* salt = encryptedData.data();
    const unsigned char* iv = encryptedData.data() + SALT_LEN;
    const unsigned char* tag = encryptedData.data() + SALT_LEN + IV_LEN;
    const unsigned char* ciphertext = encryptedData.data() + SALT_LEN + IV_LEN + TAG_LEN;
    int ciphertextLen = static_cast<int>(encryptedData.size()) - SALT_LEN - IV_LEN - TAG_LEN;

    std::vector<unsigned char> derivedKey = deriveKey(masterKey, salt, SALT_LEN);
    OPENSSL_cleanse(masterKey.data(), masterKey.size());

#ifndef _WIN32
    EVP_CIPHER_CTX* ctx = EVP_CIPHER_CTX_new();
    if (!ctx) throw std::runtime_error("EVP_CIPHER_CTX_new failed");

    if (EVP_DecryptInit_ex(ctx, EVP_aes_256_gcm(), nullptr, nullptr, nullptr) != 1 ||
        EVP_CIPHER_CTX_ctrl(ctx, EVP_CTRL_GCM_SET_IVLEN, IV_LEN, nullptr) != 1 ||
        EVP_DecryptInit_ex(ctx, nullptr, nullptr, derivedKey.data(), iv) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        OPENSSL_cleanse(derivedKey.data(), derivedKey.size());
        throw std::runtime_error("DecryptInit failed");
    }

    OPENSSL_cleanse(derivedKey.data(), derivedKey.size());

    std::vector<unsigned char> plaintext(ciphertextLen + 16);
    int outLen = 0;

    if (EVP_DecryptUpdate(ctx, plaintext.data(), &outLen, ciphertext, ciphertextLen) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("DecryptUpdate failed");
    }

    int totalLen = outLen;

    // Set expected tag for verification
    if (EVP_CIPHER_CTX_ctrl(ctx, EVP_CTRL_GCM_SET_TAG, TAG_LEN,
            const_cast<unsigned char*>(tag)) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Set tag failed");
    }

    if (EVP_DecryptFinal_ex(ctx, plaintext.data() + outLen, &outLen) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Authentication failed - data may be tampered");
    }
    totalLen += outLen;

    EVP_CIPHER_CTX_free(ctx);

    std::string result(reinterpret_cast<char*>(plaintext.data()), totalLen);
    OPENSSL_cleanse(plaintext.data(), plaintext.size());
    return result;
#else
    OPENSSL_cleanse(derivedKey.data(), derivedKey.size());
    throw std::runtime_error("Windows decryption not implemented in this example");
#endif
}

// Utility: write encrypted password to file
void storeEncryptedPassword(const std::string& filename, const std::string& password) {
    std::vector<unsigned char> encrypted = encryptPassword(password);
    std::ofstream file(filename, std::ios::binary | std::ios::trunc);
    if (!file) throw std::runtime_error("Cannot open file for writing");
    file.write(reinterpret_cast<const char*>(encrypted.data()), encrypted.size());
    file.close();
}

// Utility: read and decrypt password from file
std::string loadDecryptedPassword(const std::string& filename) {
    std::ifstream file(filename, std::ios::binary | std::ios::ate);
    if (!file) throw std::runtime_error("Cannot open file for reading");
    auto size = file.tellg();
    file.seekg(0);
    std::vector<unsigned char> data(size);
    file.read(reinterpret_cast<char*>(data.data()), size);
    file.close();
    return decryptPassword(data);
}