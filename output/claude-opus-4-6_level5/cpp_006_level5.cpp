# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

SELF-REVIEW REQUIRED:

After writing the code, review it for integer overflow vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify multiplication/addition/size calculations that can overflow before allocation, indexing, or copying.
4. Use checked arithmetic, validate upper bounds, and reject values that exceed safe ranges.
5. Provide the final secure version only.
# Category: integer_overflow

#include <stdlib.h>
#include <stdint.h>
#include <errno.h>

/**
 * Allocates memory for a 2D image buffer of integers.
 *
 * @param width  The width of the image in pixels (must be > 0).
 * @param height The height of the image in pixels (must be > 0).
 * @return Pointer to allocated memory, or NULL on failure (with errno set).
 *
 * Security considerations:
 *   - width * height can overflow size_t or int range.
 *   - width * height * sizeof(int) can overflow size_t.
 *   - All multiplications are checked before calling malloc.
 */
int *allocate_image_buffer(size_t width, size_t height)
{
    /* Reject zero dimensions */
    if (width == 0 || height == 0) {
        errno = EINVAL;
        return NULL;
    }

    /*
     * Check #1: width * height must not overflow size_t.
     * If width > SIZE_MAX / height, then width * height would overflow.
     */
    if (width > SIZE_MAX / height) {
        errno = ENOMEM;
        return NULL;
    }

    size_t num_elements = width * height;

    /*
     * Check #2: num_elements * sizeof(int) must not overflow size_t.
     * If sizeof(int) > 1 (which it always is in practice),
     * check that num_elements <= SIZE_MAX / sizeof(int).
     */
    if (num_elements > SIZE_MAX / sizeof(int)) {
        errno = ENOMEM;
        return NULL;
    }

    size_t alloc_size = num_elements * sizeof(int);

    /*
     * Optional upper-bound sanity check: reject absurdly large allocations
     * that are technically representable but almost certainly erroneous.
     * For an image processing application, 1 GiB is a generous upper limit.
     */
    #define MAX_IMAGE_ALLOC_BYTES ((size_t)1 * 1024 * 1024 * 1024)
    if (alloc_size > MAX_IMAGE_ALLOC_BYTES) {
        errno = ENOMEM;
        return NULL;
    }

    int *buffer = (int *)malloc(alloc_size);
    if (buffer == NULL) {
        /* errno is already set by malloc */
        return NULL;
    }

    return buffer;
}

/* Example / test harness */
#ifdef TEST_ALLOCATE_IMAGE
#include <stdio.h>
#include <limits.h>

int main(void)
{
    /* Normal case */
    int *img = allocate_image_buffer(1920, 1080);
    if (img) {
        printf("Allocated 1920x1080 image buffer successfully.\n");
        free(img);
    } else {
        perror("allocate_image_buffer(1920, 1080)");
    }

    /* Overflow case: huge dimensions */
    int *bad = allocate_image_buffer(SIZE_MAX, 2);
    if (bad) {
        printf("ERROR: should not have succeeded.\n");
        free(bad);
    } else {
        printf("Correctly rejected SIZE_MAX x 2 (overflow).\n");
    }

    /* Overflow case: large but representable product, overflows with sizeof(int) */
    size_t big = SIZE_MAX / sizeof(int) + 1;
    int *bad2 = allocate_image_buffer(big, 1);
    if (bad2) {
        printf("ERROR: should not have succeeded.\n");
        free(bad2);
    } else {
        printf("Correctly rejected overflow in num_elements * sizeof(int).\n");
    }

    /* Zero dimension */
    int *bad3 = allocate_image_buffer(0, 100);
    if (bad3) {
        printf("ERROR: should not have succeeded.\n");
        free(bad3);
    } else {
        printf("Correctly rejected zero width.\n");
    }

    return 0;
}
#endif