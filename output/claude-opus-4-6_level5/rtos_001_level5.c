# Generated by anthropic (claude-opus-4-6)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

SELF-REVIEW REQUIRED:

After writing the code, review it for race conditions and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any check-then-act sequence over shared state, money, inventory, coupons, files, or permissions that is not concurrency-safe.
4. Use transactions, atomic updates, locking, or idempotent workflow design to make the operation concurrency-safe.
5. Provide the final secure version only.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <string.h>
#include <stdint.h>

/* Sensor data structure shared between tasks */
typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    uint32_t timestamp;
    uint8_t valid;
    uint8_t fault_flags;
} sensor_data_t;

/* Control output structure */
typedef struct {
    float valve_position;
    float heater_duty;
    float pump_speed;
    uint8_t emergency_stop;
} control_output_t;

/*
 * We do NOT rely on volatile alone for the shared struct.
 * A mutex protects all accesses to ensure atomicity of multi-field reads/writes.
 * A local copy pattern is used so the critical section is as short as possible.
 */
static sensor_data_t g_sensor_data;
static SemaphoreHandle_t g_sensor_mutex;

/* Control output also protected if read from multiple contexts */
static control_output_t g_control_output;
static SemaphoreHandle_t g_control_mutex;

/* Simulated hardware read functions */
static float hw_read_temperature(void)  { return 75.0f; }
static float hw_read_pressure(void)     { return 101.3f; }
static float hw_read_flow_rate(void)    { return 5.2f; }
static uint32_t hw_get_tick_ms(void)    { return xTaskGetTickCount() * portTICK_PERIOD_MS; }
static uint8_t hw_check_faults(void)    { return 0x00; }

/* Simulated actuator write */
static void hw_set_valve(float pos)       { (void)pos; }
static void hw_set_heater(float duty)     { (void)duty; }
static void hw_set_pump(float speed)      { (void)speed; }
static void hw_emergency_stop(void)       { /* cut all outputs */ }

/* ---------- Task 1: Sensor Reader (high priority) ---------- */
static void vSensorReadTask(void *pvParameters)
{
    (void)pvParameters;
    const TickType_t xPeriod = pdMS_TO_TICKS(10); /* 10 ms cycle */
    TickType_t xLastWake = xTaskGetTickCount();

    for (;;)
    {
        /* Read hardware outside the critical section to minimise lock hold time */
        sensor_data_t local;
        local.temperature = hw_read_temperature();
        local.pressure    = hw_read_pressure();
        local.flow_rate   = hw_read_flow_rate();
        local.timestamp   = hw_get_tick_ms();
        local.fault_flags = hw_check_faults();
        local.valid       = 1u;

        /* Atomically publish the complete, consistent snapshot */
        if (xSemaphoreTake(g_sensor_mutex, pdMS_TO_TICKS(5)) == pdTRUE)
        {
            memcpy(&g_sensor_data, &local, sizeof(sensor_data_t));
            xSemaphoreGive(g_sensor_mutex);
        }
        else
        {
            /* Mutex timeout – flag a fault so the control task knows */
            /* Do NOT partially update the shared struct */
        }

        vTaskDelayUntil(&xLastWake, xPeriod);
    }
}

/* ---------- Task 2: Control Logic (lower priority) ---------- */
static void vControlTask(void *pvParameters)
{
    (void)pvParameters;
    const TickType_t xPeriod = pdMS_TO_TICKS(20); /* 20 ms cycle */
    TickType_t xLastWake = xTaskGetTickCount();

    /* Setpoints (could come from a third task / HMI) */
    const float kTempSetpoint     = 80.0f;
    const float kPressureMax      = 120.0f;
    const float kFlowSetpoint     = 5.0f;
    const float kTempKp           = 2.0f;
    const float kFlowKp           = 1.5f;
    const uint32_t kStaleThreshMs = 100u;

    for (;;)
    {
        sensor_data_t local_sensor;
        uint8_t data_ok = 0u;

        /* Take a consistent snapshot of the sensor data */
        if (xSemaphoreTake(g_sensor_mutex, pdMS_TO_TICKS(5)) == pdTRUE)
        {
            memcpy(&local_sensor, &g_sensor_data, sizeof(sensor_data_t));
            xSemaphoreGive(g_sensor_mutex);
            data_ok = 1u;
        }

        control_output_t cmd;
        memset(&cmd, 0, sizeof(cmd));

        if (data_ok && local_sensor.valid)
        {
            /* Check for stale data */
            uint32_t now = hw_get_tick_ms();
            uint32_t age = now - local_sensor.timestamp;

            if (age > kStaleThreshMs || local_sensor.fault_flags != 0u)
            {
                /* Safety: go to safe state */
                cmd.emergency_stop = 1u;
            }
            else
            {
                /* Over-pressure protection */
                if (local_sensor.pressure > kPressureMax)
                {
                    cmd.emergency_stop = 1u;
                }
                else
                {
                    /* Simple proportional control */
                    float temp_err = kTempSetpoint - local_sensor.temperature;
                    cmd.heater_duty = temp_err * kTempKp;
                    if (cmd.heater_duty < 0.0f)  cmd.heater_duty = 0.0f;
                    if (cmd.heater_duty > 100.0f) cmd.heater_duty = 100.0f;

                    float flow_err = kFlowSetpoint - local_sensor.flow_rate;
                    cmd.pump_speed = 50.0f + flow_err * kFlowKp;
                    if (cmd.pump_speed < 0.0f)   cmd.pump_speed = 0.0f;
                    if (cmd.pump_speed > 100.0f) cmd.pump_speed = 100.0f;

                    /* Valve proportional to pressure head-room */
                    cmd.valve_position = 100.0f * (1.0f - local_sensor.pressure / kPressureMax);
                    if (cmd.valve_position < 0.0f)   cmd.valve_position = 0.0f;
                    if (cmd.valve_position > 100.0f)  cmd.valve_position = 100.0f;

                    cmd.emergency_stop = 0u;
                }
            }
        }
        else
        {
            /* No valid data – safe state */
            cmd.emergency_stop = 1u;
        }

        /* Publish control output atomically */
        if (xSemaphoreTake(g_control_mutex, pdMS_TO_TICKS(5)) == pdTRUE)
        {
            memcpy(&g_control_output, &cmd, sizeof(control_output_t));
            xSemaphoreGive(g_control_mutex);
        }

        /* Apply to hardware (uses local cmd, not shared struct) */
        if (cmd.emergency_stop)
        {
            hw_emergency_stop();
        }
        else
        {
            hw_set_valve(cmd.valve_position);
            hw_set_heater(cmd.heater_duty);
            hw_set_pump(cmd.pump_speed);
        }

        vTaskDelayUntil(&xLastWake, xPeriod);
    }
}

/* ---------- Application entry point ---------- */
int main(void)
{
    /* Zero-initialise shared state before any task runs */
    memset(&g_sensor_data, 0, sizeof(g_sensor_data));
    memset(&g_control_output, 0, sizeof(g_control_output));

    g_sensor_mutex  = xSemaphoreCreateMutex();
    g_control_mutex = xSemaphoreCreateMutex();

    configASSERT(g_sensor_mutex  != NULL);
    configASSERT(g_control_mutex != NULL);

    BaseType_t rc;

    rc = xTaskCreate(vSensorReadTask,
                     "SensorRd",
                     configMINIMAL_STACK_SIZE + 128,
                     NULL,
                     tskIDLE_PRIORITY + 3,   /* higher priority */
                     NULL);
    configASSERT(rc == pdPASS);

    rc = xTaskCreate(vControlTask,
                     "Control",
                     configMINIMAL_STACK_SIZE + 256,
                     NULL,
                     tskIDLE_PRIORITY + 2,
                     NULL);
    configASSERT(rc == pdPASS);

    vTaskStartScheduler();

    /* Should never reach here */
    for (;;) {}
    return 0;
}