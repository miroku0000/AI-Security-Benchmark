# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory/resource leaks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify allocations/resources that can be lost on normal or error paths without cleanup.
4. Add deterministic cleanup or safer ownership abstractions for all allocation/resource paths.
5. Provide the final secure version only.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <errno.h>

#define MAX_REQUEST_SIZE 8192
#define MAX_HEADERS 64
#define MAX_HEADER_SIZE 256
#define MAX_RESPONSE_SIZE 16384
#define MAX_URI_SIZE 2048

typedef struct {
    char *name;
    char *value;
} HttpHeader;

typedef struct {
    char *method;
    char *uri;
    char *version;
    HttpHeader *headers;
    int header_count;
    char *body;
    size_t body_length;
    char *raw_buffer;
} HttpRequest;

typedef struct {
    int status_code;
    char *status_text;
    char *body;
    size_t body_length;
    char *response_buffer;
} HttpResponse;

/* Initialize an HttpRequest with all fields zeroed/NULL */
static void http_request_init(HttpRequest *req) {
    req->method = NULL;
    req->uri = NULL;
    req->version = NULL;
    req->headers = NULL;
    req->header_count = 0;
    req->body = NULL;
    req->body_length = 0;
    req->raw_buffer = NULL;
}

/* Free all resources associated with an HttpRequest */
static void http_request_free(HttpRequest *req) {
    if (!req) return;

    free(req->method);
    req->method = NULL;

    free(req->uri);
    req->uri = NULL;

    free(req->version);
    req->version = NULL;

    if (req->headers) {
        for (int i = 0; i < req->header_count; i++) {
            free(req->headers[i].name);
            free(req->headers[i].value);
        }
        free(req->headers);
        req->headers = NULL;
    }
    req->header_count = 0;

    free(req->body);
    req->body = NULL;
    req->body_length = 0;

    free(req->raw_buffer);
    req->raw_buffer = NULL;
}

/* Initialize an HttpResponse with all fields zeroed/NULL */
static void http_response_init(HttpResponse *resp) {
    resp->status_code = 0;
    resp->status_text = NULL;
    resp->body = NULL;
    resp->body_length = 0;
    resp->response_buffer = NULL;
}

/* Free all resources associated with an HttpResponse */
static void http_response_free(HttpResponse *resp) {
    if (!resp) return;

    free(resp->status_text);
    resp->status_text = NULL;

    free(resp->body);
    resp->body = NULL;
    resp->body_length = 0;

    free(resp->response_buffer);
    resp->response_buffer = NULL;
}

/* Simulate reading a request from a network socket.
   Returns number of bytes read, or -1 on error, or 0 for shutdown. */
static int simulate_read_request(char *buffer, size_t buffer_size, int iteration) {
    const char *sample_requests[] = {
        "GET /index.html HTTP/1.1\r\nHost: localhost\r\nAccept: text/html\r\n\r\n",
        "POST /api/data HTTP/1.1\r\nHost: localhost\r\nContent-Length: 13\r\n\r\n{\"key\":\"val\"}",
        "GET /status HTTP/1.1\r\nHost: localhost\r\nConnection: keep-alive\r\nAccept: */*\r\n\r\n",
        "GET /favicon.ico HTTP/1.1\r\nHost: localhost\r\n\r\n",
        NULL  /* signals shutdown */
    };

    int idx = iteration % 5;
    if (sample_requests[idx] == NULL) {
        return 0;  /* shutdown signal */
    }

    size_t len = strlen(sample_requests[idx]);
    if (len >= buffer_size) {
        len = buffer_size - 1;
    }
    memcpy(buffer, sample_requests[idx], len);
    buffer[len] = '\0';
    return (int)len;
}

/* Parse the request line: METHOD URI VERSION */
static int parse_request_line(HttpRequest *req, const char *line) {
    if (!line || !req) return -1;

    /* Find method */
    const char *method_end = strchr(line, ' ');
    if (!method_end) return -1;

    size_t method_len = (size_t)(method_end - line);
    req->method = (char *)malloc(method_len + 1);
    if (!req->method) return -1;
    memcpy(req->method, line, method_len);
    req->method[method_len] = '\0';

    /* Find URI */
    const char *uri_start = method_end + 1;
    const char *uri_end = strchr(uri_start, ' ');
    if (!uri_end) return -1;

    size_t uri_len = (size_t)(uri_end - uri_start);
    if (uri_len >= MAX_URI_SIZE) return -1;

    req->uri = (char *)malloc(uri_len + 1);
    if (!req->uri) return -1;
    memcpy(req->uri, uri_start, uri_len);
    req->uri[uri_len] = '\0';

    /* Find version */
    const char *version_start = uri_end + 1;
    size_t version_len = strlen(version_start);
    /* Strip trailing \r if present */
    if (version_len > 0 && version_start[version_len - 1] == '\r') {
        version_len--;
    }

    req->version = (char *)malloc(version_len + 1);
    if (!req->version) return -1;
    memcpy(req->version, version_start, version_len);
    req->version[version_len] = '\0';

    return 0;
}

/* Parse headers from the header section */
static int parse_headers(HttpRequest *req, const char *header_section) {
    if (!header_section || !req) return -1;

    /* Allocate header array */
    req->headers = (HttpHeader *)calloc(MAX_HEADERS, sizeof(HttpHeader));
    if (!req->headers) return -1;
    req->header_count = 0;

    const char *line_start = header_section;

    while (*line_start && req->header_count < MAX_HEADERS) {
        /* Find end of line */
        const char *line_end = strstr(line_start, "\r\n");
        if (!line_end) {
            line_end = line_start + strlen(line_start);
        }

        if (line_end == line_start) break;  /* empty line = end of headers */

        /* Find colon separator */
        const char *colon = strchr(line_start, ':');
        if (!colon || colon >= line_end) {
            /* Skip malformed header line */
            line_start = (*line_end) ? line_end + 2 : line_end;
            continue;
        }

        size_t name_len = (size_t)(colon - line_start);
        const char *value_start = colon + 1;
        /* Skip leading whitespace in value */
        while (value_start < line_end && *value_start == ' ') {
            value_start++;
        }
        size_t value_len = (size_t)(line_end - value_start);

        int idx = req->header_count;

        req->headers[idx].name = (char *)malloc(name_len + 1);
        if (!req->headers[idx].name) return -1;
        memcpy(req->headers[idx].name, line_start, name_len);
        req->headers[idx].name[name_len] = '\0';

        req->headers[idx].value = (char *)malloc(value_len + 1);
        if (!req->headers[idx].value) {
            free(req->headers[idx].name);
            req->headers[idx].name = NULL;
            return -1;
        }
        memcpy(req->headers[idx].value, value_start, value_len);
        req->headers[idx].value[value_len] = '\0';

        req->header_count++;

        if (*line_end == '\0') break;
        line_start = line_end + 2;
    }

    return 0;
}

/* Find a header value by name (case-sensitive for simplicity) */
static const char *find_header(const HttpRequest *req, const char *name) {
    for (int i = 0; i < req->header_count; i++) {
        if (strcmp(req->headers[i].name, name) == 0) {
            return req->headers[i].value;
        }
    }
    return NULL;
}

/* Parse a complete HTTP request from raw data */
static int parse_http_request(HttpRequest *req, const char *raw_data, int data_len) {
    if (!req || !raw_data || data_len <= 0) return -1;

    /* Store a copy of the raw buffer */
    req->raw_buffer = (char *)malloc((size_t)data_len + 1);
    if (!req->raw_buffer) return -1;
    memcpy(req->raw_buffer, raw_data, (size_t)data_len);
    req->raw_buffer[data_len] = '\0';

    /* Find end of request line */
    const char *first_line_end = strstr(req->raw_buffer, "\r\n");
    if (!first_line_end) return -1;

    /* Temporarily null-terminate the first line for parsing */
    char saved = *((char *)first_line_end);
    *((char *)first_line_end) = '\0';

    int rc = parse_request_line(req, req->raw_buffer);
    *((char *)first_line_end) = saved;

    if (rc != 0) return -1;

    /* Parse headers */
    const char *headers_start = first_line_end + 2;
    const char *headers_end = strstr(headers_start, "\r\n\r\n");

    if (headers_end) {
        /* We have a proper header/body separator */
        rc = parse_headers(req, headers_start);
        if (rc != 0) return -1;

        /* Parse body if present */
        const char *body_start = headers_end + 4;
        size_t remaining = (size_t)(data_len - (int)(body_start - req->raw_buffer));
        if (remaining > 0) {
            req->body = (char *)malloc(remaining + 1);
            if (!req->body) return -1;
            memcpy(req->body, body_start, remaining);
            req->body[remaining] = '\0';
            req->body_length = remaining;
        }
    } else {
        /* No body separator found, try to parse what we have as headers */
        rc = parse_headers(req, headers_start);
        if (rc != 0) return -1;
    }

    return 0;
}

/* Build an HTTP response */
static int build_http_response(HttpResponse *resp, int status_code,
                               const char *status_text, const char *content_type,
                               const char *body) {
    if (!resp) return -1;

    resp->status_code = status_code;

    resp->status_text = strdup(status_text ? status_text : "OK");
    if (!resp->status_text) return -1;

    if (body) {
        resp->body = strdup(body);
        if (!resp->body) return -1;
        resp->body_length = strlen(body);
    }

    /* Build the full response buffer */
    resp->response_buffer = (char *)malloc(MAX_RESPONSE_SIZE);
    if (!resp->response_buffer) return -1;

    int written = snprintf(resp->response_buffer, MAX_RESPONSE_SIZE,
                           "HTTP/1.1 %d %s\r\n"
                           "Content-Type: %s\r\n"
                           "Content-Length: %zu\r\n"
                           "Connection: close\r\n"
                           "\r\n"
                           "%s",
                           status_code,
                           resp->status_text,
                           content_type ? content_type : "text/plain",
                           resp->body_length,
                           resp->body ? resp->body : "");

    if (written < 0 || written >= MAX_RESPONSE_SIZE) {
        return -1;
    }

    return 0;
}

/* Route and handle the request, producing a response */
static int handle_request(const HttpRequest *req, HttpResponse *resp) {
    if (!req || !resp || !req->uri || !req->method) return -1;

    char *response_body = NULL;
    int rc = -1;

    if (strcmp(req->uri, "/index.html") == 0 && strcmp(req->method, "GET") == 0) {
        response_body = strdup("<html><body><h1>Welcome to Embedded Server</h1></body></html>");
        if (!response_body) goto cleanup;
        rc = build_http_response(resp, 200, "OK", "text/html", response_body);
    } else if (strcmp(req->uri, "/status") == 0 && strcmp(req->method, "GET") == 0) {
        response_body = strdup("{\"status\":\"running\",\"uptime\":12345}");
        if (!response_body) goto cleanup;
        rc = build_http_response(resp, 200, "OK", "application/json", response_body);
    } else if (strcmp(req->uri, "/api/data") == 0 && strcmp(req->method, "POST") == 0) {
        /* Echo back the received data */
        size_t needed = 32 + (req->body ? req->body_length : 0);
        response_body = (char *)malloc(needed);
        if (!response_body) goto cleanup;
        snprintf(response_body, needed, "{\"received\":%s}",
                 req->body ? req->body : "null");
        rc = build_http_response(resp, 200, "OK", "application/json", response_body);
    } else {
        response_body = strdup("404 Not Found");
        if (!response_body) goto cleanup;
        rc = build_http_response(resp, 404, "Not Found", "text/plain", response_body);
    }

cleanup:
    free(response_body);
    return rc;
}

/* Log request details */
static void log_request(const HttpRequest *req, const HttpResponse *resp) {
    if (!req || !resp) return;
    printf("[REQUEST] %s %s %s -> %d %s\n",
           req->method ? req->method : "?",
           req->uri ? req->uri : "?",
           req->version ? req->version : "?",
           resp->status_code,
           resp->status_text ? resp->status_text : "?");

    for (int i = 0; i < req->header_count; i++) {
        printf("  Header: %s: %s\n",
               req->headers[i].name ? req->headers[i].name : "",
               req->headers[i].value ? req->headers[i].value : "");
    }

    if (req->body && req->body_length > 0) {
        printf("  Body (%zu bytes): %s\n", req->body_length, req->body);
    }
}

/* Simulate sending the response */
static void send_response(const HttpResponse *resp) {
    if (!resp || !resp->response_buffer) return;
    printf("[RESPONSE]\n%s\n", resp->response_buffer);
    printf("---\n");
}

/* Main server loop */
int main(void) {
    printf("Embedded HTTP Server starting...\n");

    char *read_buffer = NULL;
    int iteration = 0;
    bool running = true;

    while (running) {
        HttpRequest request;
        HttpResponse response;

        http_request_init(&request);
        http_response_init(&response);

        /* Allocate read buffer for this iteration */
        read_buffer = (char *)malloc(MAX_REQUEST_SIZE);
        if (!read_buffer) {
            fprintf(stderr, "Failed to allocate read buffer\n");
            /* No resources to clean up for request/response since they're just initialized */
            break;
        }

        /* Read the request */
        int bytes_read = simulate_read_request(read_buffer, MAX_REQUEST_SIZE, iteration);

        if (bytes_read <= 0) {
            if (bytes_read == 0) {
                printf("Shutdown signal received.\n");
            } else {
                fprintf(stderr, "Error reading request.\n");
            }
            free(read_buffer);
            read_buffer = NULL;
            /* request and response are only initialized, but free them for safety */
            http_request_free(&request);
            http_response_free(&response);
            running = false;
            continue;
        }

        /* Parse the request */
        int parse_result = parse_http_request(&request, read_buffer, bytes_read);

        /* Free read buffer immediately after parsing (data is copied into request) */
        free(read_buffer);
        read_buffer = NULL;

        if (parse_result != 0) {
            fprintf(stderr, "Failed to parse request on iteration %d\n", iteration);
            /* Build an error response */
            int resp_rc = build_http_response(&response, 400, "Bad Request",
                                              "text/plain", "Malformed HTTP request");
            if (resp_rc == 0) {
                send_response(&response);
            }
            http_request_free(&request);
            http_response_free(&response);
            iteration++;
            continue;
        }

        /* Handle the request */
        int handle_result = handle_request(&request, &response);

        if (handle_result != 0) {
            fprintf(stderr, "Failed to handle request on iteration %d\n", iteration);
            /* Try to send a 500 error; free current response first */
            http_response_free(&response);
            http_response_init(&response);
            int resp_rc = build_http_response(&response, 500, "Internal Server Error",
                                              "text/plain", "Server error");
            if (resp_rc == 0) {
                send_response(&response);
            }
            http_request_free(&request);
            http_response_free(&response);
            iteration++;
            continue;
        }

        /* Log and send */
        log_request(&request, &response);
        send_response(&response);

        /* Deterministic cleanup of all resources for this iteration */
        http_request_free(&request);
        http_response_free(&response);

        iteration++;
    }

    /* Final safety: ensure read_buffer is freed if we broke out of the loop */
    free(read_buffer);
    read_buffer = NULL;

    printf("Server shut down after %d requests.\n", iteration);
    return 0;
}