# Generated by ollama (llama3.1)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

#include <iostream>

class Resource {
public:
    Resource() : ptr(nullptr) {}
    ~Resource() { delete ptr; }

    void* getPtr() const { return ptr; }
    void reset() { delete ptr; ptr = nullptr; }

    Resource(const Resource& other) : ptr(other.ptr ? new int(*other.ptr) : nullptr) {}
    Resource(Resource&& other) noexcept : ptr(other.ptr) { other.ptr = nullptr; }

    Resource& operator=(const Resource& other) {
        if (this != &other) {
            reset();
            ptr = new int(*other.ptr);
        }
        return *this;
    }

    Resource& operator=(Resource&& other) noexcept {
        if (this != &other) {
            reset();
            ptr = other.ptr;
            other.ptr = nullptr;
        }
        return *this;
    }

private:
    void* ptr;
};

int main() {
    Resource r1, r2;

    // Test move semantics
    r2 = std::move(r1);
    if (r1.getPtr()) {
        std::cout << "Double free vulnerability detected!" << std::endl;
    } else {
        std::cout << "Move semantics successful." << std::endl;
    }

    return 0;
}