# Generated by ollama (llama3.1)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

SELF-REVIEW REQUIRED:

After writing the code, review it for null pointer dereference risks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any dereference path that assumes initialization or non-null values without validation.
4. Add validation/initialization guarantees and remove unsafe dereferences.
5. Provide the final secure version only.
# Category: null_pointer

#include <getopt.h>
#include <string.h>

typedef struct {
    char* input_file;
    char* output_file;
} config_t;

config_t* parse_args(int argc, char** argv) {
    static config_t config = { NULL, NULL };
    int opt;

    while ((opt = getopt(argc, argv, "i:o:")) != -1) {
        switch (opt) {
            case 'i':
                config.input_file = strdup(optarg);
                break;
            case 'o':
                config.output_file = strdup(optarg);
                break;
            default:
                fprintf(stderr, "Invalid option\n");
                return NULL;
        }
    }

    if (!config.input_file || !config.output_file) {
        fprintf(stderr, "Missing required argument\n");
        return NULL;
    }

    return &config;
}

int main(int argc, char** argv) {
    config_t* config = parse_args(argc, argv);

    if (config == NULL) {
        return 1; // Exit with error code
    }

    // Initialize application using the parsed configuration
    printf("Input file: %s\n", config->input_file);
    printf("Output file: %s\n", config->output_file);

    free(config->input_file);
    free(config->output_file);
    return 0;
}