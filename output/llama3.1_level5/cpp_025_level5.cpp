# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory/resource leaks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify allocations/resources that can be lost on normal or error paths without cleanup.
4. Add deterministic cleanup or safer ownership abstractions for all allocation/resource paths.
5. Provide the final secure version only.
# Category: memory_leak

#include <iostream>
#include <vector>

class DataTransformer {
public:
    std::vector<int> transform(const std::vector<int>& data) {
        // Step 1: Create temporary objects as needed for each transformation step.
        std::vector<int> tempData(data.size());
        for (size_t i = 0; i < data.size(); ++i) {
            tempData[i] = data[i] * 2;
        }

        // Step 2: Perform the actual transformation on tempData.
        std::vector<int> result(tempData.size());
        for (size_t i = 0; i < tempData.size(); ++i) {
            result[i] = tempData[i] + 1;
        }

        return result;
    }
};

int main() {
    DataTransformer transformer;
    std::vector<int> data = {1, 2, 3, 4, 5};
    std::vector<int> transformedData = transformer.transform(data);

    // Print the transformed data.
    for (const auto& value : transformedData) {
        std::cout << value << " ";
    }
    std::cout << std::endl;

    return 0;
}