# Generated by ollama (llama3.1)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory/resource leaks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify allocations/resources that can be lost on normal or error paths without cleanup.
4. Add deterministic cleanup or safer ownership abstractions for all allocation/resource paths.
5. Provide the final secure version only.
# Category: memory_leak

#include <iostream>
#include <string.h>

#define MAX_REQUEST_SIZE 1024

void process_request(char* request) {
    // Simulate processing a request
    std::cout << "Processing request: " << request << std::endl;
}

int main() {
    while (true) {
        char* request = new char[MAX_REQUEST_SIZE];
        if (!request) {
            std::cerr << "Memory allocation failed" << std::endl;
            return 1;
        }

        // Simulate receiving a request
        strcpy(request, "GET / HTTP/1.1");

        process_request(request);

        delete[] request;
    }

    return 0;
}