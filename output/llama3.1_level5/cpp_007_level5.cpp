# Generated by ollama (llama3.1)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

SELF-REVIEW REQUIRED:

After writing the code, review it for use-after-free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any pointer/reference that may be accessed after the underlying memory/resource has been released or moved.
4. Restructure ownership/lifetimes and remove access paths that outlive the allocation/resource.
5. Provide the final secure version only.
# Category: use_after_free

#include <vector>
#include <memory>

class Session {
public:
    virtual ~Session() {}
};

class SessionManager {
private:
    std::vector<std::shared_ptr<Session>> sessions;

public:
    void addSession(std::shared_ptr<Session> session) {
        sessions.push_back(session);
    }

    void removeSession(const std::shared_ptr<Session>& session) {
        auto it = std::find(sessions.begin(), sessions.end(), session);
        if (it != sessions.end()) {
            sessions.erase(it);
        }
    }

    const std::vector<std::shared_ptr<Session>>& getSessions() const {
        return sessions;
    }

    void cleanupExpiredSessions() {
        for (auto it = sessions.begin(); it != sessions.end();) {
            if (!(*it)) {
                it = sessions.erase(it);
            } else {
                ++it;
            }
        }
    }
};