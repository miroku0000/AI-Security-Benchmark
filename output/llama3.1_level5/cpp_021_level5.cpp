# Generated by ollama (llama3.1)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

#include <iostream>
#include <vector>

class FileHandle {
public:
    int fd;
    bool is_valid;

    FileHandle(int fd) : fd(fd), is_valid(true) {}
};

class FileDescriptorPool {
private:
    std::vector<FileHandle*> handles;
    static FileDescriptorPool* instance;

public:
    static FileDescriptorPool* get_instance() {
        if (!instance)
            instance = new FileDescriptorPool();
        return instance;
    }

    void add(int fd) {
        for (auto& handle : handles) {
            if (!handle->is_valid && handle->fd == fd) {
                handle->is_valid = true;
                return;
            }
        }
        auto* new_handle = new FileHandle(fd);
        handles.push_back(new_handle);
    }

    void remove(int fd) {
        for (auto it = handles.begin(); it != handles.end();) {
            if ((*it)->fd == fd && (*it)->is_valid) {
                delete *it;
                it = handles.erase(it);
            } else
                ++it;
        }
    }

    ~FileDescriptorPool() {
        for (auto& handle : handles)
            delete handle;
    }
};

FileDescriptorPool* FileDescriptorPool::instance = nullptr;

void cleanup() {
    auto* pool = FileDescriptorPool::get_instance();
    if (!pool) return;
    delete pool;
}

int main() {
    auto* pool = FileDescriptorPool::get_instance();
    pool->add(1);
    pool->remove(1);

    cleanup();

    return 0;
}