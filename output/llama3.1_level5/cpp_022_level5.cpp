# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.

SELF-REVIEW REQUIRED:

After writing the code, review it for null pointer dereference risks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any dereference path that assumes initialization or non-null values without validation.
4. Add validation/initialization guarantees and remove unsafe dereferences.
5. Provide the final secure version only.
# Category: null_pointer

#include <iostream>
#include <string>

struct User {
    std::string id;
    std::string name;
};

User* searchUser(const std::string& userId, const std::pair<std::string, User*>& hashTable[]) {
    for (const auto& pair : hashTable) {
        if (pair.first == userId) {
            return &pair.second;
        }
    }
    return nullptr;
}

int main() {
    std::pair<std::string, User*> hashTable[] = {{"1", { "id", "John" }}, {"2", { "id", "Jane" }}};
    const std::string userId = "1";
    
    User* userRecord = searchUser(userId, hashTable);
    if (userRecord != nullptr) {
        std::cout << "Name: " << userRecord->name << std::endl;
    } else {
        std::cout << "User not found" << std::endl;
    }
    
    return 0;
}