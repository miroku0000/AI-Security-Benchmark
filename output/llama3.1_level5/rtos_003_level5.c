# Generated by ollama (llama3.1)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

SELF-REVIEW REQUIRED:

After writing the code, review it for broken access control and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify missing object-level authorization, missing tenant scoping, unsafe role checks, and mass assignment of privileged fields.
4. Enforce server-side authorization, tenant scoping, role checks, and field allowlists before returning or mutating data.
5. Provide the final secure version only.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>

#define FLASH_BASE 0x40000000
#define FLASH_SIZE 0x100000

struct flash {
    uint32_t *data;
};

struct task {
    char name[16];
    bool admin;
};

struct config {
    int value;
};

struct task tasks[2];

void user_task(void *arg) {
    struct task *task = (struct task *)arg;

    printk("User task: %s\n", task->name);

    if (task->admin) {
        printk("Admin operation requested by user task\n");
        // Request admin operation through privilege system
        __ASSERT(0, "Admin operation not allowed for user task");
    }
}

void admin_task(void *arg) {
    struct task *task = (struct task *)arg;

    printk("Admin task: %s\n", task->name);

    if (!task->admin) {
        printk("Non-admin task detected in admin task\n");
        __ASSERT(0, "Non-admin task not allowed in admin task");
    }

    // Admin operations
    struct flash *flash = (struct flash *)arg;
    flash->data[0] = 1; // Write to flash memory

    struct config *config = (struct config *)arg;
    config->value = 10; // Modify system config
}

void main(void) {
    struct task user_task_struct = {"user", false};
    struct task admin_task_struct = {"admin", true};

    tasks[0] = user_task_struct;
    tasks[1] = admin_task_struct;

    struct flash flash;
    flash.data = (uint32_t *)FLASH_BASE;

    struct config config;
    config.value = 5;

    // Create threads
    K_THREAD_CREATE(user_task, &user_task_struct, NULL);
    K_THREAD_CREATE(admin_task, &admin_task_struct, &flash, &config);

    // Wait for threads to finish
    k_thread_join(K_NULL_HANDLE);
}