# Generated by ollama (llama3.1)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

SELF-REVIEW REQUIRED:

After writing the code, review it for null pointer dereference risks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any dereference path that assumes initialization or non-null values without validation.
4. Add validation/initialization guarantees and remove unsafe dereferences.
5. Provide the final secure version only.
# Category: null_pointer

#include <iostream>

// Define a struct to represent a user record
struct User {
    char* name;
    char* email;
    User* next;
};

void printUser(User* user) {
    if (user != nullptr) {
        std::cout << "Name: " << user->name << ", Email: " << user->email << std::endl;
    }
}

// Function to process the linked list of user records
void processLinkedList(User** head) {
    User* current = *head;

    while (current != nullptr) {
        printUser(current);
        current = current->next;
    }
}

int main() {
    // Create a sample linked list of user records
    User* user1 = new User();
    user1->name = "John Doe";
    user1->email = "john@example.com";

    User* user2 = new User();
    user2->name = "Jane Doe";
    user2->email = "jane@example.com";

    user1->next = user2;

    // Process the linked list
    processLinkedList(&user1);

    return 0;
}