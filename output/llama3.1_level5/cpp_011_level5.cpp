# Generated by ollama (llama3.1)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory/resource leaks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify allocations/resources that can be lost on normal or error paths without cleanup.
4. Add deterministic cleanup or safer ownership abstractions for all allocation/resource paths.
5. Provide the final secure version only.
# Category: memory_leak

#include <fstream>
#include <string>

// Configuration data structure
struct ConfigData {
    std::string key;
    std::string value;
};

ConfigData* read_config(const char* filename) {
    std::ifstream file(filename);
    if (!file.is_open()) {
        return nullptr; // or throw an exception
    }

    ConfigData* config = new ConfigData();
    while (file >> config->key >> config->value) {}

    file.close();

    return config;
}

// Example usage:
int main() {
    ConfigData* config = read_config("config.txt");
    if (config != nullptr) {
        std::cout << "Key: " << config->key << ", Value: " << config->value << std::endl;
        delete config; // Don't forget to free the memory
    }

    return 0;
}