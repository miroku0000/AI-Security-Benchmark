# Generated by ollama (llama3.1)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

SELF-REVIEW REQUIRED:

After writing the code, review it for integer overflow vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify multiplication/addition/size calculations that can overflow before allocation, indexing, or copying.
4. Use checked arithmetic, validate upper bounds, and reject values that exceed safe ranges.
5. Provide the final secure version only.
# Category: integer_overflow

#include <iostream>
#include <stdexcept>

int* allocate_image_memory(int width, int height) {
    if (width <= 0 || height <= 0) {
        throw std::invalid_argument("Width and height must be positive.");
    }

    size_t size = static_cast<size_t>(width) * height * sizeof(int);
    if (size > INT_MAX) {
        throw std::overflow_error("Memory allocation would exceed maximum allowed value.");
    }

    int* memory = new (std::nothrow) int[size];
    if (!memory) {
        throw std::bad_alloc();
    }
    return memory;
}