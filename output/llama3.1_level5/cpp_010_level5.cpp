# Generated by ollama (llama3.1)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

SELF-REVIEW REQUIRED:

After writing the code, review it for race conditions and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any check-then-act sequence over shared state, money, inventory, coupons, files, or permissions that is not concurrency-safe.
4. Use transactions, atomic updates, locking, or idempotent workflow design to make the operation concurrency-safe.
5. Provide the final secure version only.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>

class BankAccount {
public:
    BankAccount(int accountNumber, double balance) : accountNumber(accountNumber), balance(balance) {}

    void deposit(double amount) {
        std::lock_guard<std::mutex> lock(mutex);
        balance += amount;
    }

    void withdraw(double amount) {
        std::lock_guard<std::mutex> lock(mutex);
        if (balance >= amount) {
            balance -= amount;
        } else {
            std::cout << "Insufficient funds" << std::endl;
        }
    }

    double getBalance() const {
        return balance;
    }

private:
    int accountNumber;
    double balance;
    mutable std::mutex mutex;
};

void processTransaction(BankAccount& account, double amount) {
    if (amount > 0) {
        account.deposit(amount);
    } else {
        account.withdraw(-amount);
    }
}

int main() {
    BankAccount account(12345, 100.0);

    std::thread t1(processTransaction, std::ref(account), 50.0);
    std::thread t2(processTransaction, std::ref(account), -75.0);

    t1.join();
    t2.join();

    std::cout << "Final balance: " << account.getBalance() << std::endl;

    return 0;
}