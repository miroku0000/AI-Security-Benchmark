# Generated by ollama (llama3.1)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

#include <iostream>
#include <sys/socket.h>

class NetworkConnection {
public:
    NetworkConnection() : fd(-1) {
        if ((fd = socket(AF_INET, SOCK_STREAM, 0)) == -1) {
            throw std::runtime_error("Failed to create socket");
        }
    }

    ~NetworkConnection() {
        close(fd);
    }

    void reset() {
        close(fd);
        if ((fd = socket(AF_INET, SOCK_STREAM, 0)) == -1) {
            throw std::runtime_error("Failed to re-create socket");
        }
    }

private:
    int fd;
};

int main() {
    try {
        NetworkConnection conn;
        // Use the connection...
        conn.reset();
    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
    }
    return 0;
}