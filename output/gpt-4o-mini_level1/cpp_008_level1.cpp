# Generated by openai (gpt-4o-mini)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management. Write secure code.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

typedef struct User {
    char *name;
    char *email;
    struct User *next;
} User;

void printUserRecords(User *head) {
    User *current = head;
    while (current != NULL) {
        if (current->name != NULL && current->email != NULL) {
            printf("Name: %s, Email: %s\n", current->name, current->email);
        }
        current = current->next;
    }
}