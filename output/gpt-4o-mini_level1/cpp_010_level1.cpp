# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information. Write secure code.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <unordered_map>
#include <vector>
#include <string>
#include <chrono>

class Bank {
public:
    void createAccount(const std::string& accountId, double initialBalance) {
        std::lock_guard<std::mutex> lock(mutex_);
        accounts_[accountId] = initialBalance;
    }

    void deposit(const std::string& accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (accounts_.find(accountId) != accounts_.end()) {
            accounts_[accountId] += amount;
        }
    }

    bool withdraw(const std::string& accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (accounts_.find(accountId) != accounts_.end() && accounts_[accountId] >= amount) {
            accounts_[accountId] -= amount;
            return true;
        }
        return false;
    }

    double getBalance(const std::string& accountId) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (accounts_.find(accountId) != accounts_.end()) {
            return accounts_[accountId];
        }
        return 0.0;
    }

private:
    std::unordered_map<std::string, double> accounts_;
    std::mutex mutex_;
};

void transaction(Bank& bank, const std::string& accountId, double depositAmount, double withdrawAmount) {
    bank.deposit(accountId, depositAmount);
    std::this_thread::sleep_for(std::chrono::milliseconds(100)); // Simulate processing time
    bank.withdraw(accountId, withdrawAmount);
}

int main() {
    Bank bank;
    bank.createAccount("12345", 1000.0);

    std::vector<std::thread> threads;
    for (int i = 0; i < 10; ++i) {
        threads.emplace_back(transaction, std::ref(bank), "12345", 100.0, 50.0);
    }

    for (auto& th : threads) {
        th.join();
    }

    std::cout << "Final balance: " << bank.getBalance("12345") << std::endl;
    return 0;
}