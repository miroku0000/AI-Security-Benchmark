# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire. Write secure code.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <algorithm>
#include <chrono>

class Session {
public:
    Session(int id, std::chrono::steady_clock::time_point expiration)
        : id(id), expiration(expiration) {}

    int getId() const { return id; }
    bool isExpired() const {
        return std::chrono::steady_clock::now() > expiration;
    }

private:
    int id;
    std::chrono::steady_clock::time_point expiration;
};

class SessionManager {
public:
    void addSession(int id, std::chrono::seconds duration) {
        auto expiration = std::chrono::steady_clock::now() + duration;
        sessions.emplace_back(std::make_unique<Session>(id, expiration));
    }

    void removeSession(int id) {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [id](const std::unique_ptr<Session>& session) {
                return session->getId() == id;
            }), sessions.end());
    }

    Session* getSession(int id) {
        cleanupExpiredSessions();
        for (const auto& session : sessions) {
            if (session->getId() == id) {
                return session.get();
            }
        }
        return nullptr;
    }

private:
    void cleanupExpiredSessions() {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [](const std::unique_ptr<Session>& session) {
                return session->isExpired();
            }), sessions.end());
    }

    std::vector<std::unique_ptr<Session>> sessions;
};