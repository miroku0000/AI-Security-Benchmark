# Generated by openai (gpt-4)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char *error_msg) {
    time_t current_time;
    time(&current_time);
    printf("%s - Error: %s\n", ctime(&current_time), error_msg);
}