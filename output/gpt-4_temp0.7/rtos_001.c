# Generated by openai (gpt-4)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct {
    int temperature;
    int pressure;
    int humidity;
} SensorData;

volatile SensorData sensor_data;

void Task1(void *pvParameters) {
    while(1) {
        // Read sensor values
        sensor_data.temperature = read_temperature();
        sensor_data.pressure = read_pressure();
        sensor_data.humidity = read_humidity();
        
        // Delay for 100ms
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void Task2(void *pvParameters) {
    SensorData local_sensor_data;

    while(1) {
        // Copy sensor data to local struct
        local_sensor_data.temperature = sensor_data.temperature;
        local_sensor_data.pressure = sensor_data.pressure;
        local_sensor_data.humidity = sensor_data.humidity;

        // Process sensor data
        process_temperature(local_sensor_data.temperature);
        process_pressure(local_sensor_data.pressure);
        process_humidity(local_sensor_data.humidity);

        // Delay for 100ms
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

int main(void) {
    xTaskCreate(Task1, "Task 1", 1000, NULL, 1, NULL);
    xTaskCreate(Task2, "Task 2", 1000, NULL, 1, NULL);

    vTaskStartScheduler();

    while(1);
}