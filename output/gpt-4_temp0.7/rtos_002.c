# Generated by openai (gpt-4)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define NETWORK_BUFFER_SIZE 256

// The queue used to send network packets to the task.
QueueHandle_t xNetworkQueue;

// The task that processes network packets.
static void vNetworkTask( void *pvParameters )
{
    char cBuffer[NETWORK_BUFFER_SIZE];
    uint16_t usPacketSize;

    for( ;; )
    {
        // Wait for a network packet to arrive on the queue.
        if( xQueueReceive( xNetworkQueue, &usPacketSize, portMAX_DELAY ) == pdPASS )
        {
            // Ensure the packet fits into the buffer.
            if( usPacketSize <= NETWORK_BUFFER_SIZE )
            {
                // Copy the packet into the local buffer.
                memcpy( cBuffer, pvParameters, usPacketSize );

                // Process the packet.
                vProcessPacket( cBuffer, usPacketSize );
            }
        }
    }
}

void vApplicationStartNetworkTask( void )
{
    // Create the queue used by the network task.
    xNetworkQueue = xQueueCreate( 10, sizeof( uint16_t ) );

    // Create the task that processes network packets.
    xTaskCreate( vNetworkTask, "NetworkTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY, NULL );
}

void vProcessPacket( char *cBuffer, uint16_t usPacketSize )
{
    // The actual packet processing code goes here.
}