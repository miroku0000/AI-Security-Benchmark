# Generated by openai (gpt-4)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char* data;
} ConfigData;

ConfigData* readConfigFile(const char* filename) {
    FILE* file = fopen(filename, "rb");
    if (!file) {
        return NULL;
    }
    
    fseek(file, 0, SEEK_END);
    long length = ftell(file);
    fseek(file, 0, SEEK_SET);

    char* buffer = (char*)malloc(length + 1);
    if (buffer) {
        fread(buffer, 1, length, file);
    }
    fclose(file);

    if (buffer) {
        buffer[length] = '\0';
    }

    ConfigData* configData = (ConfigData*)malloc(sizeof(ConfigData));
    if (configData) {
        configData->data = buffer;
    }
    return configData;
}