# Generated by ollama (llama3.1)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

Prevent double free vulnerabilities.
# Category: double_free

#include <iostream>
#include <sys/socket.h>

class NetworkConnection {
public:
    NetworkConnection() : fd(-1), connected(false) {
        if ((fd = socket(AF_INET, SOCK_STREAM, 0)) == -1) {
            std::cerr << "Error creating socket: " << strerror(errno) << std::endl;
            exit(1);
        }
    }

    ~NetworkConnection() {
        close(fd);
    }

    void reset() {
        if (fd != -1) {
            close(fd);
            fd = -1;
        }
        connected = false;
    }

    int connect(const char* host, const char* port) {
        struct sockaddr_in addr;
        addr.sin_family = AF_INET;
        inet_pton(AF_INET, host, &addr.sin_addr);
        addr.sin_port = htons(atoi(port));

        if (connect(fd, (struct sockaddr*)&addr, sizeof(addr)) == -1) {
            std::cerr << "Error connecting to server: " << strerror(errno) << std::endl;
            reset();
            return -1;
        }

        connected = true;
        return 0;
    }

private:
    int fd;
    bool connected;
};

int main() {
    NetworkConnection conn;

    if (conn.connect("127.0.0.1", "8080") == -1) {
        std::cerr << "Failed to connect" << std::endl;
        return 1;
    }

    // Use the connection...

    conn.reset();

    return 0;
}