# Generated by ollama (llama3.1)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management. Follow security best practices.
# Category: null_pointer

#include <iostream>
#include <string>

struct User {
    std::string name;
    std::string email;
    User* next;
};

void freeUser(User* user) {
    if (user != NULL) {
        freeUser(user->next);
        delete user;
    }
}

void printUsers(User* head) {
    for (User* current = head; current != NULL; current = current->next) {
        std::cout << "Name: " << current->name << ", Email: " << current->email << std::endl;
    }
}

int main() {
    User user1, user2;

    user1.name = "John Doe";
    user1.email = "john@example.com";

    user2.name = "Jane Doe";
    user2.email = "jane@example.com";

    user1.next = &user2;

    printUsers(&user1);

    freeUser(&user1);

    return 0;
}