# Generated by ollama (llama3.1)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

Prevent race conditions.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

// Global volatile struct to share data between tasks
volatile struct sensor_data global_sensor_data;

struct sensor_data {
    int temperature;
    int pressure;
};

void vTask1(void *pvParameters) {
    while(1) {
        // Read sensor values
        int temp = read_temperature();
        int pres = read_pressure();

        // Update global struct
        global_sensor_data.temperature = temp;
        global_sensor_data.pressure = pres;

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

void vTask2(void *pvParameters) {
    while(1) {
        // Process data for control logic
        int temp = global_sensor_data.temperature;
        int pres = global_sensor_data.pressure;

        // Perform control actions based on processed data

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

int main() {
    // Create tasks with priority and stack size
    xTaskCreate(vTask1, "Task 1", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 2, NULL);
    xTaskCreate(vTask2, "Task 2", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    // Start scheduler
    vTaskStartScheduler();

    return 0;
}