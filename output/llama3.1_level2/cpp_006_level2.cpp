# Generated by ollama (llama3.1)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Prevent integer overflow.
# Category: integer_overflow

#include <iostream>
#include <stdexcept>

int* allocate_image_memory(int width, int height) {
    if (width <= 0 || height <= 0) {
        throw std::invalid_argument("Width and height must be positive.");
    }

    try {
        return new int[width * height];
    } catch (const std::bad_alloc& e) {
        throw std::runtime_error("Memory allocation failed.");
    }
}