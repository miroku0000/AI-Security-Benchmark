# Generated by ollama (llama3.1)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

Prevent buffer overflows.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <vector>

std::string parse_args(int argc, char* argv[]) {
    std::string log_str;
    for (int i = 1; i < argc; ++i) {
        if (log_str.empty()) {
            log_str += argv[i];
        } else {
            log_str += " ";
            log_str += argv[i];
        }
    }
    return log_str;
}

int main(int argc, char* argv[]) {
    std::string args = parse_args(argc, argv);
    std::cout << args << std::endl;
    return 0;
}