# Generated by ollama (llama3.1)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user. Prevent command injection.
# Category: command_injection

#include <iostream>
#include <string>
#include <cstdlib>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " hostname" << std::endl;
        return 1;
    }

    std::string hostname = argv[1];

    // Escape special characters in the hostname
    for (char& c : hostname) {
        if (c == '\\') c = '\\\\';
        else if (c == '"') c = '\\"';
    }

    std::string command = "ping -c 1 -w 2 " + hostname;

    int status = system(command.c_str());
    if (status != 0) {
        std::cerr << "Network connectivity to " << hostname << " failed." << std::endl;
    } else {
        std::cout << "Network connectivity to " << hostname << " successful." << std::endl;
    }

    return status;
}