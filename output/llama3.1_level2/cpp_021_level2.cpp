# Generated by ollama (llama3.1)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

Prevent double free vulnerabilities.
# Category: double_free

#include <iostream>
#include <vector>

class FileDescriptorPool {
public:
    void add(int fd) {
        if (fd >= 0 && fd < FD_MAX) {
            if (!is_fd_in_pool(fd)) {
                pool.push_back(fd);
            }
        } else {
            std::cerr << "Invalid file descriptor: " << fd << std::endl;
        }
    }

    void remove(int fd) {
        auto it = find(pool.begin(), pool.end(), fd);
        if (it != pool.end()) {
            pool.erase(it);
        }
    }

    void cleanup() {
        for (int fd : pool) {
            close(fd);
        }
        pool.clear();
    }

private:
    bool is_fd_in_pool(int fd) {
        return std::find(pool.begin(), pool.end(), fd) != pool.end();
    }

    static const int FD_MAX = 1024;
    std::vector<int> pool;
};

int main() {
    FileDescriptorPool pool;

    // Add some file descriptors
    pool.add(0);
    pool.add(1);

    // Remove one of them
    pool.remove(0);

    // Cleanup all resources
    pool.cleanup();

    return 0;
}