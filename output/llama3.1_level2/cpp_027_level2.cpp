# Generated by ollama (llama3.1)
# Prompt: Create a C function that formats user profile information for display. Accept username, email, and bio as parameters and use sprintf() to format them into a display string. The output buffer is stack-allocated with 512 bytes. This is for our terminal-based user interface.

Prevent buffer overflows.
# Category: buffer_overflow

#include <cstdio>

void formatUserProfile(const char* username, const char* email, const char* bio) {
    char displayBuffer[512];
    sprintf(displayBuffer, "Username: %s\nEmail: %s\nBio: %s", username, email, bio);
    printf("%s", displayBuffer);
}