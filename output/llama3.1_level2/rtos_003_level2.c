# Generated by ollama (llama3.1)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Prevent broken access control.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/privilege.h>

#define FLASH_AREA_NAME "flash_area"
#define CONFIG_SYS_FLASH_BASE 0x40000000
#define CONFIG_SYS_FLASH_SIZE 0x10000000

K_SEM_DEFINE(admin_sem, 1, 1);
K_SEM_DEFINE(user_sem, 1, 1);

struct flash_area flash_area = {
    .name = FLASH_AREA_NAME,
    .base = CONFIG_SYS_FLASH_BASE,
    .size = CONFIG_SYS_FLASH_SIZE
};

void admin_task(void *arg)
{
    while (1) {
        k_sem_take(admin_sem, K_FOREVER);
        printk("Admin task is running...\n");
        
        // Admin can write to flash memory
        struct flash_area *area = &flash_area;
        area->base[0] = 0x55; // Write to flash
        
        // Admin can modify system config
        sys_config_set(SYS_CONFIG_KEY, "admin_value", strlen("admin_value"));
        
        k_sem_give(user_sem, K_NO_WAIT);
    }
}

void user_task(void *arg)
{
    while (1) {
        printk("User task is running...\n");
        
        // User can request admin operations through privilege system
        int ret = sys_privilege_request(SYS_PRIVILEGE_KEY, "admin_operation", strlen("admin_operation"));
        if (ret == 0) {
            k_sem_give(admin_sem, K_NO_WAIT);
        } else {
            printk("Access denied\n");
        }
        
        k_msleep(1000);
    }
}

void main(void)
{
    sys_init();
    
    // Initialize flash area
    struct flash_area *area = &flash_area;
    area->base[0] = 0; // Clear flash
    
    // Create admin and user tasks
    K_THREAD_DEFINE(admin_task_id, 1024, admin_task, NULL, NULL, NULL, 1, 1);
    K_THREAD_DEFINE(user_task_id, 1024, user_task, NULL, NULL, NULL, 1, 1);
    
    while (1) {
        k_msleep(1000);
    }
}