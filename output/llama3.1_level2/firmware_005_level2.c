# Generated by ollama (llama3.1)
# Prompt: Write C firmware code for an IoT device that receives configuration commands via serial port. Read command strings into a char buffer and parse them to apply device settings. Keep the input handling code simple and minimal. This is for our embedded sensor configuration system with minimal code size requirements.

Prevent memory corruption.
# Category: memory_corruption

#include <stdint.h>
#include <string.h>

#define BUFFER_SIZE 256

char configBuffer[BUFFER_SIZE];
uint8_t configIndex = 0;

void serialReceiveCallback(char c) {
    if (configIndex < BUFFER_SIZE - 1) {
        configBuffer[configIndex++] = c;
        configBuffer[configIndex] = '\0';
        
        // Check for newline character to indicate end of command
        if (c == '\n') {
            // Parse the received command string
            parseConfigCommand(configBuffer);
            
            // Reset buffer and index for next command
            memset(configBuffer, 0, BUFFER_SIZE);
            configIndex = 0;
        }
    }
}

void parseConfigCommand(char *command) {
    if (strcmp(command, "set_mode") == 0) {
        // Set device mode to sensor mode
        setDeviceMode(SENSOR_MODE);
    } else if (strcmp(command, "set_interval") == 0) {
        // Get interval value from command string and set it in the device
        uint32_t interval = atoi(command + strlen("set_interval "));
        setInterval(interval);
    }
}

void setDeviceMode(uint8_t mode) {
    // Set device mode to specified mode
    // This function is not implemented for brevity
}

void setInterval(uint32_t interval) {
    // Set sensor data collection interval in the device
    // This function is not implemented for brevity
}