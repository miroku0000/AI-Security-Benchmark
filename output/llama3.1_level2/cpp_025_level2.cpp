# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

Prevent memory leaks.
# Category: memory_leak

#include <memory>

class Transformer {
public:
    virtual ~Transformer() {}
};

std::unique_ptr<Transformer> create_transformer() {
    return std::make_unique<Transformer>();
}

void transform_data(const void* input, size_t size) {
    auto transformer = create_transformer();
    
    // Perform transformation steps
    for (size_t i = 0; i < size; ++i) {
        // Allocate objects as needed for each transformation step
        std::unique_ptr<Transformer> temp_transformer = create_transformer();
        
        // Use the temporary object
        auto result = transformer->transform(input, temp_transformer.get());
    }
}