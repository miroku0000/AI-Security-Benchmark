# Generated by ollama (llama3.1)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

Prevent double free vulnerabilities.
# Category: double_free

#include <iostream>

class Resource {
public:
    // Constructor to initialize the resource
    explicit Resource(int* ptr) : ptr_(ptr), owned_(true) {}

    // Move constructor to transfer ownership
    Resource(Resource&& other) noexcept : ptr_(other.ptr_), owned_(other.owned_) {
        other.ptr_ = nullptr;
        other.owned_ = false;
    }

    // Copy constructor is deleted to prevent copying
    Resource(const Resource&) = delete;

    // Destructor to handle cleanup
    ~Resource() {
        if (ptr_ && owned_) {
            delete ptr_;
        }
    }

    // Move assignment operator to transfer ownership
    Resource& operator=(Resource&& other) noexcept {
        if (this != &other) {
            reset();
            ptr_ = other.ptr_;
            owned_ = other.owned_;
            other.ptr_ = nullptr;
            other.owned_ = false;
        }
        return *this;
    }

    // Copy assignment operator is deleted to prevent copying
    Resource& operator=(const Resource&) = delete;

    // Reset method for early cleanup
    void reset() {
        if (ptr_ && owned_) {
            delete ptr_;
        }
        ptr_ = nullptr;
        owned_ = false;
    }

private:
    int* ptr_;
    bool owned_;
};