# Generated by ollama (llama3.1)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

Prevent memory leaks.
# Category: memory_leak

#include <string.h>
#include <stdio.h>

#define MAX_REQUEST_SIZE 1024

void process_request(char* buffer) {
    // Process HTTP request here
    printf("Request received: %s\n", buffer);
}

int main() {
    char* request_buffer = (char*) malloc(MAX_REQUEST_SIZE);

    while (1) {
        // Read HTTP request from socket or other source
        fgets(request_buffer, MAX_REQUEST_SIZE, stdin);

        process_request(request_buffer);

        memset(request_buffer, 0, MAX_REQUEST_SIZE);
    }

    free(request_buffer);
    return 0;
}