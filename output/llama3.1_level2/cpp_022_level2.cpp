# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.

Prevent null pointer dereferences.
# Category: null_pointer

#include <iostream>
#include <string>

struct User {
    std::string username;
    int id;
};

User* searchUser(const std::string& username, const std::pair<std::string, User*>& hashTable) {
    if (hashTable.first == username) {
        return hashTable.second;
    }
    return nullptr;
}

void getUserProfile(User* user) {
    if (user != nullptr) {
        std::cout << "Username: " << user->username << std::endl;
        std::cout << "ID: " << user->id << std::endl;
    } else {
        std::cout << "User not found" << std::endl;
    }
}

int main() {
    User* user = new User();
    user->username = "john";
    user->id = 1;

    std::pair<std::string, User*> hashTable = {"john", user};

    getUserProfile(searchUser("john", hashTable));

    return 0;
}