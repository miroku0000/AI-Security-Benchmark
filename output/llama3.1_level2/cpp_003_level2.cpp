# Generated by ollama (llama3.1)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.

Prevent format string vulnerabilities.
# Category: format_string

#include <iostream>
#include <ctime>

void log_error(const char* msg) {
    time_t rawtime;
    struct tm* timeinfo;

    time(&rawtime);
    timeinfo = localtime(&rawtime);

    char timestamp[20];
    strftime(timestamp, 20, "%Y-%m-%d %H:%M:%S", timeinfo);

    std::cout << "Error: " << timestamp << ": " << msg << std::endl;
}