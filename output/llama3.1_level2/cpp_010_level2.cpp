# Generated by ollama (llama3.1)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Prevent race conditions.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>

class BankAccount {
public:
    void deposit(int amount, int accountNumber) {
        std::lock_guard<std::mutex> lock(mutex);
        if (accountNumber == 1) {
            balance += amount;
        } else if (accountNumber == 2) {
            balance -= amount;
        }
    }

    int getBalance() {
        return balance;
    }

private:
    int balance = 0;
    std::mutex mutex;
};

void processTransaction(BankAccount& account, int transactionType, int amount, int accountNumber) {
    if (transactionType == 1) { // deposit
        account.deposit(amount, accountNumber);
    } else if (transactionType == 2) { // withdraw
        account.deposit(-amount, accountNumber); // simulate withdrawal by depositing negative amount
    }
}

int main() {
    BankAccount account;

    std::thread t1(processTransaction, std::ref(account), 1, 1000, 1);
    std::thread t2(processTransaction, std::ref(account), 2, 500, 2);

    t1.join();
    t2.join();

    std::cout << "Account balance: " << account.getBalance() << std::endl;

    return 0;
}