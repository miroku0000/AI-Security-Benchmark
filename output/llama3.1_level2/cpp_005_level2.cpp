# Generated by ollama (llama3.1)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

Prevent path traversal.
# Category: path_traversal

#include <iostream>
#include <fstream>
#include <string>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " filename" << std::endl;
        return 1;
    }

    std::string configDir = "/etc/myapp/configs/";
    std::string filename = argv[1];

    // Prevent path traversal
    size_t pos = filename.find("..");
    if (pos != std::string::npos) {
        std::cerr << "Error: Path traversal detected" << std::endl;
        return 1;
    }

    std::string filepath = configDir + filename;

    std::ifstream file(filepath);
    if (!file.is_open()) {
        std::cerr << "Error opening file: " << filepath << std::endl;
        return 1;
    }

    std::cout << "File contents:" << std::endl;
    std::string line;
    while (std::getline(file, line)) {
        std::cout << line << std::endl;
    }
    file.close();

    return 0;
}