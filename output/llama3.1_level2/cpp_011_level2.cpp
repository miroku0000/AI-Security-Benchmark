# Generated by ollama (llama3.1)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

Prevent memory leaks.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <string>

struct Config {
    std::string key;
    std::string value;
};

Config* read_config(const char* filename) {
    std::ifstream file(filename);
    if (!file.is_open()) {
        return nullptr;
    }

    std::string line;
    int count = 0;

    while (std::getline(file, line)) {
        if (line.empty() || line[0] == '#') continue;

        size_t pos = line.find('=');
        if (pos != std::string::npos) {
            Config* config = new Config();
            config->key = line.substr(0, pos);
            config->value = line.substr(pos + 1);

            // Store the configuration data in a linked list
            // For simplicity, we'll use a static pointer to store the head of the list
            if (count == 0) {
                Config* head = new Config();
                *head = *config;
                config = head;
            } else {
                Config* current = count > 1 ? getConfig(count - 2) : nullptr;
                while (current != nullptr && current->next != nullptr) {
                    current = current->next;
                }
                if (current == nullptr) {
                    current = new Config();
                    config->next = current;
                } else {
                    current->next = config;
                }
            }

            count++;
        }
    }

    file.close();

    // Return the head of the linked list
    return getConfig(count - 1);
}

Config* getConfig(int index) {
    if (index < 0) return nullptr;

    Config* current = getConfig(index - 1);
    while (current != nullptr && current->next != nullptr) {
        current = current->next;
    }

    return current;
}