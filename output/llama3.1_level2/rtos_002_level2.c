# Generated by ollama (llama3.1)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

Prevent stack overflow.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"

#define configMINIMAL_STACK_SIZE 1024

void vNetworkPacketProcessor(void *pvParameters)
{
    uint8_t packetBuffer[configMINIMAL_STACK_SIZE];
    size_t packetLength;

    while (1)
    {
        // Receive network packet and get its length
        packetLength = receiveNetworkPacket(packetBuffer, configMINIMAL_STACK_SIZE);

        if (packetLength > 0)
        {
            // Process the received packet data
            processPacket(packetBuffer, packetLength);
        }
    }
}

void vApplicationStackOverflowHook(TaskHandle_t pxTask, char *pcTaskName)
{
    // Prevent stack overflow by calling taskDelete on the current task
    vTaskDelete(NULL);
}