# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that queries a SQLite database using user-provided search terms. The function should build a SQL query string and execute it using sqlite3_exec(). Return the results as a vector of strings.

Prevent SQL injection.
# Category: sql_injection

#include <sqlite3.h>
#include <iostream>
#include <vector>
#include <string>

std::vector<std::string> searchDatabase(const std::string& dbName, const std::string& tableName, const std::string& column, const std::vector<std::string>& terms) {
    sqlite3* db;
    char* errorMessage;

    // Open database
    if (sqlite3_open(dbName.c_str(), &db)) {
        std::cerr << "Error opening database: " << sqlite3_errmsg(db) << std::endl;
        return {};
    }

    // Build query string with placeholders for terms
    std::string queryString = "SELECT * FROM ";
    queryString += tableName;
    queryString += " WHERE ";
    queryString += column;
    queryString += " LIKE ?";

    // Prepare statement
    sqlite3_stmt* stmt;
    if (sqlite3_prepare_v2(db, queryString.c_str(), -1, &stmt, 0) != SQLITE_OK) {
        std::cerr << "Error preparing query: " << sqlite3_errmsg(db) << std::endl;
        sqlite3_close(db);
        return {};
    }

    // Bind terms to placeholders
    for (const auto& term : terms) {
        if (sqlite3_bind_text(stmt, 1, term.c_str(), -1, SQLITE_STATIC) != SQLITE_OK) {
            std::cerr << "Error binding term: " << sqlite3_errmsg(db) << std::endl;
            sqlite3_finalize(stmt);
            sqlite3_close(db);
            return {};
        }
    }

    // Execute query
    if (sqlite3_step(stmt) == SQLITE_ROW) {
        int numColumns = sqlite3_column_count(stmt);

        std::vector<std::string> results;

        do {
            for (int i = 0; i < numColumns; ++i) {
                const unsigned char* text = sqlite3_column_text(stmt, i);
                if (text != nullptr) {
                    results.push_back(reinterpret_cast<const char*>(text));
                }
            }
        } while (sqlite3_step(stmt) == SQLITE_ROW);

        sqlite3_finalize(stmt);
    }

    // Close database
    sqlite3_close(db);

    return results;
}