# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>
#include <cstddef>
#include <type_traits>

template <typename T, typename Deleter = void(*)(T*)>
class UniqueResource {
public:
    using pointer = T*;

    UniqueResource() noexcept(std::is_nothrow_default_constructible_v<Deleter>)
        : ptr_(nullptr), deleter_(Deleter{}) {}

    explicit UniqueResource(pointer ptr, Deleter deleter = Deleter{}) noexcept
        : ptr_(ptr), deleter_(std::move(deleter)) {}

    ~UniqueResource() noexcept {
        reset();
    }

    UniqueResource(const UniqueResource&) = delete;
    UniqueResource& operator=(const UniqueResource&) = delete;

    UniqueResource(UniqueResource&& other) noexcept(
        std::is_nothrow_move_constructible_v<Deleter>)
        : ptr_(other.ptr_), deleter_(std::move(other.deleter_)) {
        other.ptr_ = nullptr;
    }

    UniqueResource& operator=(UniqueResource&& other) noexcept(
        std::is_nothrow_move_assignable_v<Deleter> &&
        std::is_nothrow_move_constructible_v<Deleter>) {
        if (this != &other) {
            reset();
            ptr_ = other.ptr_;
            deleter_ = std::move(other.deleter_);
            other.ptr_ = nullptr;
        }
        return *this;
    }

    pointer get() const noexcept {
        return ptr_;
    }

    explicit operator bool() const noexcept {
        return ptr_ != nullptr;
    }

    pointer release() noexcept {
        pointer tmp = ptr_;
        ptr_ = nullptr;
        return tmp;
    }

    void reset(pointer new_ptr = nullptr) noexcept {
        if (ptr_) {
            deleter_(ptr_);
        }
        ptr_ = new_ptr;
    }

    void swap(UniqueResource& other) noexcept(
        std::is_nothrow_swappable_v<Deleter>) {
        using std::swap;
        swap(ptr_, other.ptr_);
        swap(deleter_, other.deleter_);
    }

private:
    pointer ptr_;
    Deleter deleter_;
};

template <typename T, typename Deleter>
void swap(UniqueResource<T, Deleter>& a, UniqueResource<T, Deleter>& b) noexcept(noexcept(a.swap(b))) {
    a.swap(b);
}