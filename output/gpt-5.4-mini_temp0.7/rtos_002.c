# Generated by openai (gpt-5.4-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>
#include <string.h>

#define PACKET_BUF_SIZE 128

typedef struct
{
    uint8_t *data;
    uint16_t len;
} NetworkPacket_t;

static void ProcessPacket(const uint8_t *data, uint16_t len)
{
    (void)data;
    (void)len;
}

static void NetworkTask(void *pvParameters)
{
    (void)pvParameters;

    NetworkPacket_t pkt;
    uint8_t localBuf[PACKET_BUF_SIZE];

    for (;;)
    {
        if (xQueueReceive((QueueHandle_t)pvParameters, &pkt, portMAX_DELAY) == pdPASS)
        {
            uint16_t copyLen = pkt.len;

            if (copyLen > PACKET_BUF_SIZE)
            {
                copyLen = PACKET_BUF_SIZE;
            }

            if (pkt.data != NULL && copyLen > 0U)
            {
                memcpy(localBuf, pkt.data, copyLen);
                ProcessPacket(localBuf, copyLen);
            }
        }
    }
}

BaseType_t StartNetworkTask(QueueHandle_t packetQueue)
{
    return xTaskCreate(
        NetworkTask,
        "NetTask",
        configMINIMAL_STACK_SIZE,
        (void *)packetQueue,
        tskIDLE_PRIORITY + 1U,
        NULL);
}