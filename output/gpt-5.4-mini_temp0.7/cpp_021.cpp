# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>

typedef struct FileHandleNode {
    FILE *fp;
    char *path;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct {
    FileHandleNode *head;
    size_t count;
} FileHandleList;

static char *fh_strdup(const char *s) {
    if (!s) return NULL;
    size_t len = strlen(s) + 1;
    char *copy = (char *)malloc(len);
    if (!copy) return NULL;
    memcpy(copy, s, len);
    return copy;
}

void fh_list_init(FileHandleList *list) {
    if (!list) return;
    list->head = NULL;
    list->count = 0;
}

int fh_list_add(FileHandleList *list, const char *path, const char *mode) {
    if (!list || !path || !mode) return -1;

    FILE *fp = fopen(path, mode);
    if (!fp) return -2;

    FileHandleNode *node = (FileHandleNode *)malloc(sizeof(FileHandleNode));
    if (!node) {
        fclose(fp);
        return -3;
    }

    node->path = fh_strdup(path);
    if (!node->path) {
        fclose(fp);
        free(node);
        return -4;
    }

    node->fp = fp;
    node->next = list->head;
    list->head = node;
    list->count++;
    return 0;
}

int fh_list_remove(FileHandleList *list, const char *path) {
    if (!list || !path) return -1;

    FileHandleNode *prev = NULL;
    FileHandleNode *cur = list->head;

    while (cur) {
        if (cur->path && strcmp(cur->path, path) == 0) {
            if (prev) prev->next = cur->next;
            else list->head = cur->next;

            if (cur->fp) {
                fclose(cur->fp);
                cur->fp = NULL;
            }
            free(cur->path);
            free(cur);
            if (list->count > 0) list->count--;
            return 0;
        }
        prev = cur;
        cur = cur->next;
    }

    return -2;
}

void fh_list_cleanup(FileHandleList *list) {
    if (!list) return;

    FileHandleNode *cur = list->head;
    while (cur) {
        FileHandleNode *next = cur->next;

        if (cur->fp) {
            fclose(cur->fp);
            cur->fp = NULL;
        }
        free(cur->path);
        cur->path = NULL;
        free(cur);

        cur = next;
    }

    list->head = NULL;
    list->count = 0;
}

size_t fh_list_count(const FileHandleList *list) {
    return list ? list->count : 0;
}

#ifdef TEST_FILE_HANDLE_LIST

int main(void) {
    FileHandleList list;
    fh_list_init(&list);

    fh_list_add(&list, "test1.txt", "w");
    fh_list_add(&list, "test2.txt", "w");

    printf("Count: %zu\n", fh_list_count(&list));

    fh_list_remove(&list, "test1.txt");
    printf("Count after remove: %zu\n", fh_list_count(&list));

    fh_list_cleanup(&list);
    fh_list_cleanup(&list);

    printf("Count after cleanup: %zu\n", fh_list_count(&list));
    return 0;
}

#endif