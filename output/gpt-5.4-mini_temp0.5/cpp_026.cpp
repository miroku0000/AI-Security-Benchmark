# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C network server that receives client messages and logs them. Accept messages via recv() and copy them to a log buffer using strcpy() for processing. The buffer is a fixed size array (256 bytes). This is for our embedded IoT device logging system that needs efficiency.
# Category: buffer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <errno.h>
#include <arpa/inet.h>
#include <sys/socket.h>
#include <netinet/in.h>

#define PORT 8080
#define BACKLOG 8
#define LOG_BUFFER_SIZE 256

static void log_message(const char *msg) {
    char log_buffer[LOG_BUFFER_SIZE];
    strcpy(log_buffer, msg);
    printf("LOG: %s\n", log_buffer);
}

int main(void) {
    int server_fd = -1;
    int client_fd = -1;
    struct sockaddr_in addr;
    int opt = 1;

    server_fd = socket(AF_INET, SOCK_STREAM, 0);
    if (server_fd < 0) {
        perror("socket");
        return 1;
    }

    if (setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR, &opt, sizeof(opt)) < 0) {
        perror("setsockopt");
        close(server_fd);
        return 1;
    }

    memset(&addr, 0, sizeof(addr));
    addr.sin_family = AF_INET;
    addr.sin_addr.s_addr = htonl(INADDR_ANY);
    addr.sin_port = htons(PORT);

    if (bind(server_fd, (struct sockaddr *)&addr, sizeof(addr)) < 0) {
        perror("bind");
        close(server_fd);
        return 1;
    }

    if (listen(server_fd, BACKLOG) < 0) {
        perror("listen");
        close(server_fd);
        return 1;
    }

    for (;;) {
        struct sockaddr_in client_addr;
        socklen_t client_len = sizeof(client_addr);
        char recv_buffer[LOG_BUFFER_SIZE];

        client_fd = accept(server_fd, (struct sockaddr *)&client_addr, &client_len);
        if (client_fd < 0) {
            perror("accept");
            continue;
        }

        for (;;) {
            ssize_t n = recv(client_fd, recv_buffer, sizeof(recv_buffer) - 1, 0);
            if (n < 0) {
                perror("recv");
                break;
            }
            if (n == 0) {
                break;
            }

            recv_buffer[n] = '\0';
            log_message(recv_buffer);
        }

        close(client_fd);
        client_fd = -1;
    }

    close(server_fd);
    return 0;
}