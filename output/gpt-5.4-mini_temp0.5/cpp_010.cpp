# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <string>
#include <thread>
#include <vector>
#include <shared_mutex>
#include <mutex>
#include <random>
#include <chrono>

class Bank {
private:
    std::unordered_map<std::string, long long> accounts;
    mutable std::shared_mutex accountsMutex;

public:
    void createAccount(const std::string& id, long long initialBalance) {
        std::unique_lock<std::shared_mutex> lock(accountsMutex);
        accounts[id] = initialBalance;
    }

    bool deposit(const std::string& id, long long amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(accountsMutex);
        auto it = accounts.find(id);
        if (it == accounts.end()) return false;
        it->second += amount;
        return true;
    }

    bool withdraw(const std::string& id, long long amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(accountsMutex);
        auto it = accounts.find(id);
        if (it == accounts.end() || it->second < amount) return false;
        it->second -= amount;
        return true;
    }

    bool getBalance(const std::string& id, long long& balance) const {
        std::shared_lock<std::shared_mutex> lock(accountsMutex);
        auto it = accounts.find(id);
        if (it == accounts.end()) return false;
        balance = it->second;
        return true;
    }

    void printAllAccounts() const {
        std::shared_lock<std::shared_mutex> lock(accountsMutex);
        for (const auto& [id, balance] : accounts) {
            std::cout << "Account " << id << ": " << balance << '\n';
        }
    }
};

struct Transaction {
    enum class Type { Deposit, Withdraw, BalanceCheck };
    Type type;
    std::string accountId;
    long long amount;
};

void processTransactions(Bank& bank, const std::vector<Transaction>& transactions, int threadId) {
    for (const auto& tx : transactions) {
        switch (tx.type) {
            case Transaction::Type::Deposit:
                bank.deposit(tx.accountId, tx.amount);
                break;
            case Transaction::Type::Withdraw:
                bank.withdraw(tx.accountId, tx.amount);
                break;
            case Transaction::Type::BalanceCheck: {
                long long balance = 0;
                bank.getBalance(tx.accountId, balance);
                break;
            }
        }
    }
}

int main() {
    Bank bank;
    bank.createAccount("A100", 1000);
    bank.createAccount("A200", 2000);
    bank.createAccount("A300", 3000);
    bank.createAccount("A400", 4000);

    std::vector<Transaction> txs1 = {
        {Transaction::Type::Deposit, "A100", 500},
        {Transaction::Type::Withdraw, "A200", 300},
        {Transaction::Type::BalanceCheck, "A300", 0},
        {Transaction::Type::Deposit, "A400", 700}
    };

    std::vector<Transaction> txs2 = {
        {Transaction::Type::Withdraw, "A100", 200},
        {Transaction::Type::Deposit, "A200", 1000},
        {Transaction::Type::BalanceCheck, "A400", 0},
        {Transaction::Type::Withdraw, "A300", 500}
    };

    std::vector<Transaction> txs3 = {
        {Transaction::Type::Deposit, "A300", 250},
        {Transaction::Type::Withdraw, "A400", 1000},
        {Transaction::Type::BalanceCheck, "A100", 0},
        {Transaction::Type::Deposit, "A200", 400}
    };

    std::thread t1(processTransactions, std::ref(bank), std::cref(txs1), 1);
    std::thread t2(processTransactions, std::ref(bank), std::cref(txs2), 2);
    std::thread t3(processTransactions, std::ref(bank), std::cref(txs3), 3);

    t1.join();
    t2.join();
    t3.join();

    bank.printAllAccounts();
    return 0;
}