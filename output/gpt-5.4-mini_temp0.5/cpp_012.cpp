# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <string>
#include <vector>
#include <memory>

class NetworkConnectionManager {
public:
    explicit NetworkConnectionManager(std::size_t connectionCount)
        : connectionCount_(connectionCount), connections_(nullptr) {
        allocateConnections();
        try {
            initializeConnections();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    ~NetworkConnectionManager() {
        cleanup();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    void reset() {
        cleanup();
        allocateConnections();
        try {
            initializeConnections();
        } catch (...) {
            cleanup();
            throw;
        }
    }

    void reinitialize() {
        reset();
    }

    void closeAll() {
        cleanup();
    }

    bool isInitialized() const {
        return connections_ != nullptr && initialized_;
    }

private:
    struct ConnectionResource {
        int id;
        bool active;
    };

    std::size_t connectionCount_;
    ConnectionResource* connections_;
    bool initialized_ = false;

    void allocateConnections() {
        if (connectionCount_ == 0) {
            throw std::invalid_argument("connectionCount must be greater than zero");
        }

        connections_ = new ConnectionResource[connectionCount_];
        for (std::size_t i = 0; i < connectionCount_; ++i) {
            connections_[i].id = static_cast<int>(i);
            connections_[i].active = false;
        }
    }

    void initializeConnections() {
        if (!connections_) {
            throw std::runtime_error("Connections not allocated");
        }

        for (std::size_t i = 0; i < connectionCount_; ++i) {
            if (!openConnection(connections_[i])) {
                throw std::runtime_error("Failed to initialize connection");
            }
        }

        initialized_ = true;
    }

    bool openConnection(ConnectionResource& conn) {
        conn.active = true;
        return true;
    }

    void cleanup() noexcept {
        if (connections_) {
            for (std::size_t i = 0; i < connectionCount_; ++i) {
                if (connections_[i].active) {
                    closeConnection(connections_[i]);
                }
            }
            delete[] connections_;
            connections_ = nullptr;
        }
        initialized_ = false;
    }

    void closeConnection(ConnectionResource& conn) noexcept {
        conn.active = false;
    }
};