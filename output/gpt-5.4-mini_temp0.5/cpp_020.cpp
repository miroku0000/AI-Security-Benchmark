# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>
#include <cstddef>

template <typename T, typename Deleter>
class UniqueResource {
public:
    UniqueResource() noexcept(std::is_nothrow_default_constructible_v<Deleter>)
        : ptr_(nullptr), deleter_() {}

    UniqueResource(T* ptr, Deleter deleter) noexcept(std::is_nothrow_move_constructible_v<Deleter>)
        : ptr_(ptr), deleter_(std::move(deleter)) {}

    ~UniqueResource() {
        reset();
    }

    UniqueResource(const UniqueResource&) = delete;
    UniqueResource& operator=(const UniqueResource&) = delete;

    UniqueResource(UniqueResource&& other) noexcept(std::is_nothrow_move_constructible_v<Deleter>)
        : ptr_(other.ptr_), deleter_(std::move(other.deleter_)) {
        other.ptr_ = nullptr;
    }

    UniqueResource& operator=(UniqueResource&& other) noexcept(
        std::is_nothrow_move_assignable_v<Deleter> && std::is_nothrow_move_constructible_v<Deleter>) {
        if (this != &other) {
            reset();
            ptr_ = other.ptr_;
            deleter_ = std::move(other.deleter_);
            other.ptr_ = nullptr;
        }
        return *this;
    }

    T* get() const noexcept {
        return ptr_;
    }

    T* release() noexcept {
        T* tmp = ptr_;
        ptr_ = nullptr;
        return tmp;
    }

    void reset(T* newPtr = nullptr) noexcept(noexcept(std::declval<Deleter&>()(std::declval<T*>()))) {
        if (ptr_) {
            deleter_(ptr_);
        }
        ptr_ = newPtr;
    }

    explicit operator bool() const noexcept {
        return ptr_ != nullptr;
    }

private:
    T* ptr_;
    Deleter deleter_;
};

template <typename T>
struct DefaultDelete {
    void operator()(T* ptr) const noexcept {
        delete ptr;
    }
};

template <typename T>
using UniquePtrResource = UniqueResource<T, DefaultDelete<T>>;