# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

#define REQUEST_BUFFER_SIZE 4096
#define RESPONSE_BUFFER_SIZE 4096

typedef struct {
    char *data;
    size_t capacity;
    size_t length;
} Buffer;

static int buffer_init(Buffer *buf, size_t capacity) {
    buf->data = (char *)malloc(capacity);
    if (!buf->data) return -1;
    buf->capacity = capacity;
    buf->length = 0;
    return 0;
}

static void buffer_free(Buffer *buf) {
    if (buf->data) free(buf->data);
    buf->data = NULL;
    buf->capacity = 0;
    buf->length = 0;
}

static void process_request(const char *request, size_t request_len, Buffer *response) {
    const char *ok = "HTTP/1.1 200 OK\r\nContent-Length: 2\r\nConnection: keep-alive\r\n\r\nOK";
    size_t ok_len = strlen(ok);
    if (response->capacity < ok_len + 1) return;
    memcpy(response->data, ok, ok_len);
    response->data[ok_len] = '\0';
    response->length = ok_len;

    (void)request;
    (void)request_len;
}

static ssize_t read_request(int fd, char *buf, size_t cap) {
    (void)fd;
    const char *mock = "GET / HTTP/1.1\r\nHost: localhost\r\n\r\n";
    size_t len = strlen(mock);
    if (len >= cap) len = cap - 1;
    memcpy(buf, mock, len);
    buf[len] = '\0';
    return (ssize_t)len;
}

static void send_response(int fd, const char *buf, size_t len) {
    (void)fd;
    fwrite(buf, 1, len, stdout);
    fputc('\n', stdout);
}

int main(void) {
    Buffer request_buf;
    Buffer response_buf;

    if (buffer_init(&request_buf, REQUEST_BUFFER_SIZE) != 0) {
        return 1;
    }
    if (buffer_init(&response_buf, RESPONSE_BUFFER_SIZE) != 0) {
        buffer_free(&request_buf);
        return 1;
    }

    int client_fd = 0;

    for (;;) {
        ssize_t nread = read_request(client_fd, request_buf.data, request_buf.capacity);
        if (nread <= 0) {
            continue;
        }

        request_buf.length = (size_t)nread;

        process_request(request_buf.data, request_buf.length, &response_buf);
        if (response_buf.length > 0) {
            send_response(client_fd, response_buf.data, response_buf.length);
        }

        request_buf.length = 0;
        response_buf.length = 0;
    }

    buffer_free(&request_buf);
    buffer_free(&response_buf);
    return 0;
}