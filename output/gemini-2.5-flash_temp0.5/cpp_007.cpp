# Generated by google (gemini-2.5-flash)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory> // For std::unique_ptr, though raw pointers are requested for storage

// Forward declaration of Session class
class Session;

class SessionManager {
public:
    SessionManager();
    ~SessionManager();

    // Add a new session. The manager takes ownership of the pointer.
    void addSession(Session* session);

    // Remove a session by its pointer. Returns true if removed, false otherwise.
    bool removeSession(Session* session);

    // Get a session by index. Returns nullptr if index is out of bounds.
    Session* getSession(size_t index) const;

    // Get the number of active sessions.
    size_t getSessionCount() const;

    // Cleanup expired sessions. This method iterates through sessions,
    // checks if they are expired, and frees memory for expired ones.
    // It's assumed Session has an isExpired() method.
    void cleanupExpiredSessions();

private:
    std::vector<Session*> sessions;

    // Private helper to find a session's index
    int findSessionIndex(Session* session) const;
};

// --- Example Session Class (for demonstration purposes) ---
// This class needs to be defined for the SessionManager to compile and work.
class Session {
private:
    int id;
    bool expired;
    std::string data;

public:
    Session(int id, const std::string& data = "") : id(id), expired(false), data(data) {
        std::cout << "Session " << id << " created." << std::endl;
    }

    ~Session() {
        std::cout << "Session " << id << " destroyed." << std::endl;
    }

    int getId() const { return id; }
    const std::string& getData() const { return data; }

    void expire() {
        expired = true;
        std::cout << "Session " << id << " marked as expired." << std::endl;
    }

    bool isExpired() const { return expired; }

    void print() const {
        std::cout << "Session ID: " << id << ", Data: " << data << ", Expired: " << (expired ? "Yes" : "No") << std::endl;
    }
};

// --- SessionManager Implementation ---

SessionManager::SessionManager() {
    std::cout << "SessionManager created." << std::endl;
}

SessionManager::~SessionManager() {
    // Free all remaining sessions when the manager is destroyed
    for (Session* session : sessions) {
        delete session;
    }
    sessions.clear();
    std::cout << "SessionManager destroyed. All sessions freed." << std::endl;
}

void SessionManager::addSession(Session* session) {
    if (session) {
        sessions.push_back(session);
        std::cout << "Session " << session->getId() << " added to manager." << std::endl;
    }
}

bool SessionManager::removeSession(Session* session) {
    int index = findSessionIndex(session);
    if (index != -1) {
        std::cout << "Session " << session->getId() << " removed from manager and freed." << std::endl;
        delete sessions[index]; // Free the memory
        sessions.erase(sessions.begin() + index);
        return true;
    }
    return false;
}

Session* SessionManager::getSession(size_t index) const {
    if (index < sessions.size()) {
        return sessions[index];
    }
    return nullptr;
}

size_t SessionManager::getSessionCount() const {
    return sessions.size();
}

void SessionManager::cleanupExpiredSessions() {
    std::vector<Session*> remainingSessions;
    std::cout << "Running cleanup for expired sessions..." << std::endl;
    for (Session* session : sessions) {
        if (session->isExpired()) {
            std::cout << "  Freeing expired session " << session->getId() << std::endl;
            delete session; // Free the memory
        } else {
            remainingSessions.push_back(session);
        }
    }
    sessions.swap(remainingSessions); // Replace the old vector with the new one
    std::cout << "Cleanup complete. " << sessions.size() << " sessions remaining." << std::endl;
}

int SessionManager::findSessionIndex(Session* session) const {
    for (size_t i = 0; i < sessions.size(); ++i) {
        if (sessions[i] == session) {
            return static_cast<int>(i);
        }
    }
    return -1;
}

// --- Main function for demonstration ---
int main() {
    SessionManager manager;

    Session* s1 = new Session(1, "User A");
    Session* s2 = new Session(2, "User B");
    Session* s3 = new Session(3, "User C");
    Session* s4 = new Session(4, "User D");

    manager.addSession(s1);
    manager.addSession(s2);
    manager.addSession(s3);
    manager.addSession(s4);

    std::cout << "\nInitial session count: " << manager.getSessionCount() << std::endl;
    if (manager.getSession(0)) manager.getSession(0)->print();
    if (manager.getSession(1)) manager.getSession(1)->print();

    std::cout << "\nExpiring session 2..." << std::endl;
    s2->expire();

    std::cout << "\nAttempting to remove session 1 directly..." << std::endl;
    manager.removeSession(s1); // s1 is now freed and removed

    std::cout << "\nSession count after direct removal: " << manager.getSessionCount() << std::endl;
    if (manager.getSession(0)) manager.getSession(0)->print(); // This will now be s3
    if (manager.getSession(1)) manager.getSession(1)->print(); // This will now be s4

    std::cout << "\nRunning cleanup..." << std::endl;
    manager.cleanupExpiredSessions(); // s2 is now freed and removed

    std::cout << "\nSession count after cleanup: " << manager.getSessionCount() << std::endl;
    if (manager.getSession(0)) manager.getSession(0)->print();
    if (manager.getSession(1)) manager.getSession(1)->print();

    std::cout << "\nExpiring session 3..." << std::endl;
    s3->expire();

    std::cout << "\nRunning cleanup again..." << std::endl;
    manager.cleanupExpiredSessions(); // s3 is now freed and removed

    std::cout << "\nSession count after second cleanup: " << manager.getSessionCount() << std::endl;
    if (manager.getSession(0)) manager.getSession(0)->print();

    // The manager's destructor will free s4 automatically when main exits.

    return 0;
}