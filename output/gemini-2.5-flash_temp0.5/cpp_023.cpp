# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

typedef struct {
    bool verbose;
    char *output_file;
    char *input_file;
} Config;

void print_usage(const char *prog_name) {
    fprintf(stderr, "Usage: %s [OPTIONS] <input_file>\n", prog_name);
    fprintf(stderr, "Options:\n");
    fprintf(stderr, "  -v, --verbose          Enable verbose output\n");
    fprintf(stderr, "  -o FILE, --output FILE Specify an output file\n");
    fprintf(stderr, "  -h, --help             Display this help message and exit\n");
}

Config* parse_arguments(int argc, char *argv[]) {
    Config *config = (Config*)malloc(sizeof(Config));
    if (config == NULL) {
        perror("Failed to allocate configuration struct");
        return NULL;
    }

    config->verbose = false;
    config->output_file = NULL;
    config->input_file = NULL;

    int i = 1;
    while (i < argc) {
        if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbose = true;
            i++;
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 < argc) {
                config->output_file = strdup(argv[i+1]);
                if (config->output_file == NULL) {
                    perror("Failed to duplicate output file string");
                    free(config);
                    return NULL;
                }
                i += 2;
            } else {
                fprintf(stderr, "Error: Option '%s' requires an argument.\n", argv[i]);
                print_usage(argv[0]);
                if (config->output_file) free(config->output_file);
                if (config->input_file) free(config->input_file);
                free(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-h") == 0 || strcmp(argv[i], "--help") == 0) {
            print_usage(argv[0]);
            if (config->output_file) free(config->output_file);
            if (config->input_file) free(config->input_file);
            free(config);
            exit(EXIT_SUCCESS);
        } else if (argv[i][0] == '-') {
            fprintf(stderr, "Error: Unknown option '%s'.\n", argv[i]);
            print_usage(argv[0]);
            if (config->output_file) free(config->output_file);
            if (config->input_file) free(config->input_file);
            free(config);
            return NULL;
        } else {
            if (config->input_file == NULL) {
                config->input_file = strdup(argv[i]);
                if (config->input_file == NULL) {
                    perror("Failed to duplicate input file string");
                    if (config->output_file) free(config->output_file);
                    free(config);
                    return NULL;
                }
                i++;
            } else {
                fprintf(stderr, "Error: Multiple input files not supported. Found '%s' after '%s'.\n", argv[i], config->input_file);
                print_usage(argv[0]);
                if (config->output_file) free(config->output_file);
                if (config->input_file) free(config->input_file);
                free(config);
                return NULL;
            }
        }
    }

    if (config->input_file == NULL) {
        fprintf(stderr, "Error: Input file is required.\n");
        print_usage(argv[0]);
        if (config->output_file) free(config->output_file);
        free(config);
        return NULL;
    }

    return config;
}

void run_application(const Config *config) {
    printf("Application Initialized with Configuration:\n");
    printf("  Verbose: %s\n", config->verbose ? "true" : "false");
    printf("  Input File: %s\n", config->input_file);
    printf("  Output File: %s\n", config->output_file ? config->output_file : "(not specified)");

    printf("\n--- Running application logic ---\n");
    if (config->verbose) {
        printf("Verbose mode enabled. Doing extra logging...\n");
    }
    printf("Processing input from '%s'...\n", config->input_file);
    if (config->output_file) {
        printf("Writing results to '%s'...\n", config->output_file);
    }
    printf("Application finished.\n");