# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

template <typename T>
class ManagedResource {
private:
    T* resource_ptr;

    // Helper function to safely delete the resource
    void delete_resource() noexcept {
        if (resource_ptr != nullptr) {
            delete resource_ptr;
            resource_ptr = nullptr;
        }
    }

public:
    // Default constructor: Initializes to manage no resource.
    ManagedResource() noexcept : resource_ptr(nullptr) {}

    // Constructor: Takes ownership of a raw pointer.
    // The caller must ensure 'ptr' points to a dynamically allocated object.
    explicit ManagedResource(T* ptr) noexcept : resource_ptr(ptr) {}

    // Destructor: Ensures the managed resource is deallocated.
    ~ManagedResource() noexcept {
        delete_resource();
    }

    // Delete copy constructor and copy assignment operator.
    // ManagedResource objects represent unique ownership and cannot be copied.
    ManagedResource(const ManagedResource&) = delete;
    ManagedResource& operator=(const ManagedResource&) = delete;

    // Move constructor: Transfers ownership from another ManagedResource.
    // The source object 'other' will no longer manage the resource.
    ManagedResource(ManagedResource&& other) noexcept : resource_ptr(nullptr) {
        // Use std::exchange to atomically get other's pointer and set other's pointer to nullptr
        resource_ptr = std::exchange(other.resource_ptr, nullptr);
    }

    // Move assignment operator: Transfers ownership from another ManagedResource.
    // Releases the currently managed resource, then takes ownership from 'other'.
    ManagedResource& operator=(ManagedResource&& other) noexcept {
        if (this != &other) { // Prevent self-assignment
            delete_resource(); // Release current resource

            // Take ownership from 'other'
            resource_ptr = std::exchange(other.resource_ptr, nullptr);
        }
        return *this;
    }

    // Returns the raw pointer to the managed resource.
    // Does not transfer ownership.
    T* get() const noexcept {
        return resource_ptr;
    }

    // Dereference operator: Provides direct access to the managed object.
    T& operator*() const noexcept {
        return *resource_ptr;
    }

    // Arrow operator: Provides member access for the managed object.
    T* operator->() const noexcept {
        return resource_ptr;
    }

    // Explicit boolean conversion: Returns true if managing a resource, false otherwise.
    explicit operator bool() const noexcept {
        return resource_ptr != nullptr;
    }

    // Releases the current resource and optionally takes ownership of a new one.
    // If 'new_ptr' is nullptr, it simply releases the current resource and becomes empty.
    void reset(T* new_ptr = nullptr) noexcept {
        if (resource_ptr != new_ptr) { // Avoid deleting and re-assigning the same pointer
            delete_resource();
            resource_ptr = new_ptr;
        }
    }

    // Releases ownership of the managed resource and returns the raw pointer.
    // The caller becomes responsible for deleting the returned pointer.
    // The ManagedResource object will no longer manage any resource.
    T* release() noexcept {
        return std::exchange(resource_ptr, nullptr);
    }

    // Swaps the managed resources between two ManagedResource objects.
    void swap(ManagedResource& other) noexcept {
        std::swap(resource_ptr, other.resource_ptr);
    }
};

// Global swap function for ManagedResource, enabling ADL (Argument-Dependent Lookup).
template <typename T>
void swap(ManagedResource<T>& lhs, ManagedResource<T>& rhs) noexcept {
    lhs.swap(rhs);
}