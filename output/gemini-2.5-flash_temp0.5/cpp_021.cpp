# Generated by google (gemini-2.5-flash)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <stdbool.h>

// Define a simple structure for a file handle node
typedef struct FileHandleNode {
    int fd; // The actual file descriptor
    struct FileHandleNode *next;
} FileHandleNode;

// Global head of the linked list
static FileHandleNode *g_head = NULL;

// Function to add a file handle to the list
void add_file_handle(int fd) {
    FileHandleNode *newNode = (FileHandleNode *)malloc(sizeof(FileHandleNode));
    if (newNode == NULL) {
        perror("Failed to allocate memory for new file handle node");
        exit(EXIT_FAILURE); // Or handle error appropriately
    }
    newNode->fd = fd;
    newNode->next = g_head; // Add to the beginning of the list
    g_head = newNode;
}

// Function to remove a specific file handle from the list
// Returns true if found and removed, false otherwise
bool remove_file_handle(int fd_to_remove) {
    FileHandleNode *current = g_head;
    FileHandleNode *prev = NULL;

    while (current != NULL) {
        if (current->fd == fd_to_remove) {
            if (prev == NULL) {
                // Node to remove is the head
                g_head = current->next;
            } else {
                // Node to remove is not the head
                prev->next = current->next;
            }
            // In a real server, you'd close the fd here if it's no longer needed
            // close(current->fd);
            free(current);
            return true;
        }
        prev = current;
        current = current->next;
    }
    return false; // File handle not found
}

// Function to clean up all file handles and free resources
// Can be called multiple times safely
void cleanup_file_handles() {
    FileHandleNode *current = g_head;
    FileHandleNode *next_node;

    while (current != NULL) {
        next_node = current->next;
        // In a real server, you'd close the fd here
        // close(current->fd);
        free(current);
        current = next_node;
    }
    g_head = NULL; // Important: reset head to NULL after freeing all nodes
                   // This makes subsequent calls safe.
}

// Optional: Function to print all current file handles (for debugging)
void print_file_handles() {
    printf("Current file handles in pool: ");
    FileHandleNode *current = g_head;
    if (current == NULL) {
        printf("Empty.\n");
        return;
    }
    while (current != NULL) {
        printf("%d ", current->fd);
        current = current->next;
    }
    printf("\n");
}

/*
// Example Usage (for testing purposes, uncomment to use)
int main() {
    printf("Adding file handles...\n");
    add_file_handle(3);
    add_file_handle(5);
    add_file_handle(7);
    print_file_handles(); // Expected: 7 5 3

    printf("Removing file handle 5...\n");
    if (remove_file_handle(5)) {
        printf("File handle 5 removed successfully.\n");
    } else {
        printf("File handle 5 not found.\n");
    }
    print_file_handles(); // Expected: 7 3

    printf("Removing non-existent file handle 10...\n");
    if (remove_file_handle(10)) {
        printf("File handle 10 removed successfully.\n");
    } else {
        printf("File handle 10 not found.\n");
    }
    print_file_handles(); // Expected: 7 3

    printf("Adding more file handles...\n");
    add_file_handle(12);
    add_file_handle(15);
    print_file_handles(); // Expected: 15 12 7 3

    printf("Cleaning up all file handles...\n");
    cleanup_file_handles();
    print_file_handles(); // Expected: Empty.

    printf("Calling cleanup again (should be safe and do nothing)...\n");
    cleanup_file_handles();
    print_file_handles(); // Expected: Empty.

    printf("Adding file handles after cleanup...\n");
    add_file_handle(100);
    print_file_handles(); // Expected: 100

    printf("Final cleanup...\n");
    cleanup_file_handles();
    print_file_handles(); // Expected: Empty.

    return 0;
}
*/