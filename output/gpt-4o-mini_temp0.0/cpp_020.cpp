# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class ResourceManager {
public:
    ResourceManager(size_t size) : size(size), resource(new int[size]) {}

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept 
        : size(other.size), resource(other.resource) {
        other.size = 0;
        other.resource = nullptr;
    }

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            size = other.size;
            resource = other.resource;
            other.size = 0;
            other.resource = nullptr;
        }
        return *this;
    }

    // Destructor
    ~ResourceManager() {
        cleanup();
    }

    // Reset method for early cleanup
    void reset() {
        cleanup();
        size = 0;
        resource = nullptr;
    }

private:
    size_t size;
    int* resource;

    void cleanup() {
        delete[] resource;
    }
};