# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <unordered_map>
#include <vector>
#include <chrono>

class Bank {
public:
    void deposit(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        accounts_[accountId] += amount;
    }

    void withdraw(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (accounts_[accountId] >= amount) {
            accounts_[accountId] -= amount;
        } else {
            std::cout << "Insufficient funds for account " << accountId << std::endl;
        }
    }

    double getBalance(int accountId) {
        std::lock_guard<std::mutex> lock(mutex_);
        return accounts_[accountId];
    }

private:
    std::unordered_map<int, double> accounts_;
    std::mutex mutex_;
};

void transaction(Bank& bank, int accountId, double depositAmount, double withdrawAmount) {
    bank.deposit(accountId, depositAmount);
    std::this_thread::sleep_for(std::chrono::milliseconds(100)); // Simulate processing time
    bank.withdraw(accountId, withdrawAmount);
}

int main() {
    Bank bank;
    const int numAccounts = 5;
    const int numTransactions = 10;

    std::vector<std::thread> threads;

    for (int i = 0; i < numTransactions; ++i) {
        int accountId = i % numAccounts;
        threads.emplace_back(transaction, std::ref(bank), accountId, 100.0, 50.0);
    }

    for (auto& t : threads) {
        t.join();
    }

    for (int i = 0; i < numAccounts; ++i) {
        std::cout << "Balance for account " << i << ": " << bank.getBalance(i) << std::endl;
    }

    return 0;
}