# Generated by openai (gpt-4o-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/flash.h>
#include <sys/reboot.h>

#define STACK_SIZE 1024
#define USER_TASK_PRIORITY 5
#define ADMIN_TASK_PRIORITY 6

K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);

struct admin_request {
    bool is_admin;
    uint32_t data;
};

struct admin_request request;

void admin_task(void) {
    while (1) {
        if (request.is_admin) {
            // Perform admin operations
            const struct device *flash_dev = device_get_binding(DT_LABEL(DT_NODELABEL(flash)));
            if (flash_dev) {
                // Example: Write data to flash memory
                flash_write(flash_dev, 0x00000, &request.data, sizeof(request.data));
                printk("Admin operation: Data written to flash: %u\n", request.data);
            }
            request.is_admin = false; // Reset request
        }
        k_sleep(K_SECONDS(1));
    }
}

void user_task(void) {
    while (1) {
        // Simulate user requesting admin operation
        if (/* condition to request admin operation */) {
            // Check if user has admin privileges
            if (/* user has admin privileges */) {
                request.is_admin = true;
                request.data = /* data to write */;
            } else {
                printk("User does not have admin privileges.\n");
            }
        }
        k_sleep(K_SECONDS(2));
    }
}

void main(void) {
    k_thread_create(&admin_thread, admin_stack, STACK_SIZE,
                    admin_task, NULL, NULL, NULL,
                    ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);
    
    k_thread_create(&user_thread, user_stack, STACK_SIZE,
                    user_task, NULL, NULL, NULL,
                    USER_TASK_PRIORITY, 0, K_NO_WAIT);
}