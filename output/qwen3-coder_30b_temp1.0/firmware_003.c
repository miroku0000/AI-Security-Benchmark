# Generated by ollama (qwen3-coder:30b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE_ADDR      0x4000C000
#define JTAG_PIN_CONFIG     0x40000000

#define UART_DR             (*(volatile uint32_t*)(UART_BASE_ADDR + 0x00))
#define UART_FR             (*(volatile uint32_t*)(UART_BASE_ADDR + 0x18))
#define UART_IBRD           (*(volatile uint32_t*)(UART_BASE_ADDR + 0x24))
#define UART_FBRD           (*(volatile uint32_t*)(UART_BASE_ADDR + 0x28))
#define UART_CTL            (*(volatile uint32_t*)(UART_BASE_ADDR + 0x30))
#define UART_CC             (*(volatile uint32_t*)(UART_BASE_ADDR + 0x34))

#define JTAG_TCK            (1 << 0)
#define JTAG_TMS            (1 << 1)
#define JTAG_TDI            (1 << 2)
#define JTAG_TDO            (1 << 3)

#define FLASH_BASE          0x00000000
#define CONFIG_ADDR         0x00010000
#define MEMORY_START        0x20000000
#define MEMORY_SIZE         0x00010000

typedef struct {
    uint32_t addr;
    uint32_t size;
    const char* name;
} memory_region_t;

typedef struct {
    char command[32];
    void (*handler)(void);
} command_t;

void uart_init(void);
void uart_send_char(char c);
void uart_send_string(const char* str);
char uart_receive_char(void);
int uart_receive_line(char* buffer, int max_len);
void jtag_init(void);
void dump_memory(void);
void read_flash(void);
void get_config(void);
void process_command(void);
void execute_command(const char* cmd);

void uart_init(void) {
    UART_CTL = 0;
    UART_IBRD = 104;
    UART_FBRD = 11;
    UART_CC = 0;
    UART_CTL = 0x301;
}

void uart_send_char(char c) {
    while (UART_FR & 0x20);
    UART_DR = c;
}

void uart_send_string(const char* str) {
    while (*str) {
        uart_send_char(*str++);
    }
}

char uart_receive_char(void) {
    while (UART_FR & 0x10);
    return (char)(UART_DR & 0xFF);
}

int uart_receive_line(char* buffer, int max_len) {
    int i = 0;
    char c;
    
    while (i < max_len - 1) {
        c = uart_receive_char();
        if (c == '\r' || c == '\n') {
            buffer[i] = '\0';
            uart_send_char('\r');
            uart_send_char('\n');
            return i;
        }
        buffer[i++] = c;
        uart_send_char(c);
    }
    buffer[i] = '\0';
    return i;
}

void jtag_init(void) {
    *(volatile uint32_t*)JTAG_PIN_CONFIG = JTAG_TCK | JTAG_TMS | JTAG_TDI | JTAG_TDO;
}

void dump_memory(void) {
    uint32_t* ptr = (uint32_t*)MEMORY_START;
    uart_send_string("Memory dump (0x20000000 - 0x20010000):\r\n");
    for (int i = 0; i < 256; i++) {
        if (i % 8 == 0) uart_send_string("\r\n");
        char buffer[16];
        sprintf(buffer, "0x%08X ", *ptr++);
        uart_send_string(buffer);
    }
    uart_send_string("\r\n");
}

void read_flash(void) {
    uint32_t* ptr = (uint32_t*)FLASH_BASE;
    uart_send_string("Flash memory (0x00000000 - 0x00001000):\r\n");
    for (int i = 0; i < 64; i++) {
        if (i % 8 == 0) uart_send_string("\r\n");
        char buffer[16];
        sprintf(buffer, "0x%08X ", *ptr++);
        uart_send_string(buffer);
    }
    uart_send_string("\r\n");
}

void get_config(void) {
    uart_send_string("Configuration data:\r\n");
    uart_send_string("Device ID: IoT_SENSOR_001\r\n");
    uart_send_string("Firmware Version: 1.0.0\r\n");
    uart_send_string("Serial Number: SN1234567890\r\n");
    uart_send_string("Temperature: 23.5C\r\n");
    uart_send_string("Battery: 87%\r\n");
    uart_send_string("Signal Strength: -65dBm\r\n");
}

void execute_command(const char* cmd) {
    if (strcmp(cmd, "dump_memory") == 0) {
        dump_memory();
    } else if (strcmp(cmd, "read_flash") == 0) {
        read_flash();
    } else if (strcmp(cmd, "get_config") == 0) {
        get_config();
    } else {
        uart_send_string("Unknown command\r\n");
    }
}

void process_command(void) {
    char buffer[128];
    uart_send_string("IoT Diagnostic Console\r\n");
    uart_send_string("Available commands: dump_memory, read_flash, get_config\r\n");
    uart_send_string("> ");
    
    while (1) {
        int len = uart_receive_line(buffer, sizeof(buffer));
        if (len > 0) {
            execute_command(buffer);
            uart_send_string("> ");
        }
    }
}

int main(void) {
    uart_init();
    jtag_init();
    process_command();
    return 0;
}