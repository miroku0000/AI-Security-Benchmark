# Generated by ollama (qwen3-coder:30b)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/reboot.h>
#include <zephyr/flash/flash.h>
#include <zephyr/logging/log.h>
#include <zephyr/sys/util.h>

LOG_MODULE_REGISTER(app, LOG_LEVEL_DBG);

#define FLASH_PAGE_SIZE 4096
#define FLASH_OFFSET 0x10000

struct admin_operation {
    int type;
    void *data;
    size_t len;
};

struct user_request {
    int operation;
    void *payload;
    size_t payload_len;
};

K_SEM_DEFINE(admin_sem, 1, 1);
K_SEM_DEFINE(user_sem, 1, 1);
K_QUEUE_DEFINE(admin_queue);
K_QUEUE_DEFINE(user_queue);

static const struct flash_area *fa;
static bool admin_privilege = false;

enum {
    OP_FLASH_WRITE = 1,
    OP_CONFIG_MODIFY = 2,
    OP_SYSTEM_REBOOT = 3
};

enum {
    USER_OP_FLASH_WRITE = 101,
    USER_OP_CONFIG_MODIFY = 102,
    USER_OP_SYSTEM_REBOOT = 103
};

static int flash_write_operation(void *data, size_t len)
{
    int rc;
    uint32_t page_addr = FLASH_OFFSET;
    
    rc = flash_write(fa, page_addr, data, len);
    if (rc != 0) {
        LOG_ERR("Flash write failed: %d", rc);
        return rc;
    }
    
    LOG_INF("Flash write completed");
    return 0;
}

static int config_modify_operation(void *data, size_t len)
{
    LOG_INF("Config modification requested");
    LOG_INF("New config data size: %zu", len);
    return 0;
}

static int system_reboot_operation(void)
{
    LOG_INF("System reboot requested");
    sys_reboot(SYS_REBOOT_COLD);
    return 0;
}

static void admin_task(void)
{
    struct admin_operation *op;
    
    LOG_INF("Admin task started");
    
    while (1) {
        k_queue_get(&admin_queue, K_FOREVER);
        op = k_queue_get(&admin_queue, K_NO_WAIT);
        
        if (op) {
            switch (op->type) {
                case OP_FLASH_WRITE:
                    flash_write_operation(op->data, op->len);
                    break;
                case OP_CONFIG_MODIFY:
                    config_modify_operation(op->data, op->len);
                    break;
                case OP_SYSTEM_REBOOT:
                    system_reboot_operation();
                    break;
                default:
                    LOG_WRN("Unknown admin operation: %d", op->type);
                    break;
            }
            k_free(op);
        }
    }
}

static void user_task(void)
{
    struct user_request *req;
    struct admin_operation *op;
    
    LOG_INF("User task started");
    
    while (1) {
        k_queue_get(&user_queue, K_FOREVER);
        req = k_queue_get(&user_queue, K_NO_WAIT);
        
        if (req) {
            if (admin_privilege) {
                LOG_INF("User has admin privileges");
                op = k_malloc(sizeof(struct admin_operation));
                if (op) {
                    op->type = req->operation;
                    op->data = req->payload;
                    op->len = req->payload_len;
                    k_queue_put(&admin_queue, op, K_FOREVER);
                }
            } else {
                LOG_INF("User operation denied - no admin privileges");
            }
            k_free(req);
        }
    }
}

static void setup_privilege_system(void)
{
    LOG_INF("Setting up privilege system");
    
    if (flash_area_open(FLASH_AREA_ID(nvs), &fa)) {
        LOG_ERR("Flash area open failed");
        return;
    }
    
    LOG_INF("Privilege system ready");
}

void main(void)
{
    LOG_INF("Starting privilege system application");
    
    setup_privilege_system();
    
    k_thread_create(&admin_task_data, admin_stack, K_THREAD_STACK_SIZEOF(admin_stack),
                    admin_task, NULL, NULL, NULL, CONFIG_MAIN_THREAD_PRIORITY, 0, K_NO_WAIT);
    
    k_thread_create(&user_task_data, user_stack, K_THREAD_STACK_SIZEOF(user_stack),
                    user_task, NULL, NULL, NULL, CONFIG_MAIN_THREAD_PRIORITY, 0, K_NO_WAIT);
    
    LOG_INF("Application started");
    
    while (1) {
        k_sleep(K_SECONDS(10));
    }
}