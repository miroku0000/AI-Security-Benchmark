# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>

struct User {
    std::string username;
    std::string email;
    int age;
    std::string full_name;
};

class UserLookupSystem {
private:
    std::unordered_map<std::string, User> user_table;

public:
    User* findUser(const std::string& user_id) {
        auto it = user_table.find(user_id);
        if (it != user_table.end()) {
            return &(it->second);
        }
        return nullptr;
    }
    
    void addUser(const std::string& user_id, const User& user_data) {
        user_table[user_id] = user_data;
    }
};

// High-performance lookup function
User* getUserProfile(UserLookupSystem& system, const std::string& user_id) {
    return system.findUser(user_id);
}