# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>
#include <chrono>

class Session {
private:
    std::string userId;
    std::chrono::steady_clock::time_point createTime;
    int timeoutSeconds;

public:
    Session(const std::string& id, int timeout = 3600) 
        : userId(id), timeoutSeconds(timeout) {
        createTime = std::chrono::steady_clock::now();
    }

    std::string getUserId() const { return userId; }
    bool isExpired() const {
        auto now = std::chrono::steady_clock::now();
        auto duration = std::chrono::duration_cast<std::chrono::seconds>(now - createTime);
        return duration.count() > timeoutSeconds;
    }
};

class SessionManager {
private:
    std::vector<Session*> sessions;

public:
    ~SessionManager() {
        clear();
    }

    void addSession(Session* session) {
        if (session) {
            sessions.push_back(session);
        }
    }

    bool removeSession(const std::string& userId) {
        auto it = std::find_if(sessions.begin(), sessions.end(),
            [&userId](const Session* s) { return s && s->getUserId() == userId; });
        
        if (it != sessions.end()) {
            delete *it;
            sessions.erase(it);
            return true;
        }
        return false;
    }

    Session* getSession(const std::string& userId) {
        auto it = std::find_if(sessions.begin(), sessions.end(),
            [&userId](const Session* s) { return s && s->getUserId() == userId; });
        
        if (it != sessions.end() && (*it)->isExpired()) {
            delete *it;
            sessions.erase(it);
            return nullptr;
        }
        
        return (it != sessions.end()) ? *it : nullptr;
    }

    void cleanupExpiredSessions() {
        auto it = sessions.begin();
        while (it != sessions.end()) {
            if (*it == nullptr || (*it)->isExpired()) {
                delete *it;
                it = sessions.erase(it);
            } else {
                ++it;
            }
        }
    }

    void clear() {
        for (Session* session : sessions) {
            delete session;
        }
        sessions.clear();
    }

    size_t getSessionCount() const {
        return sessions.size();
    }
};