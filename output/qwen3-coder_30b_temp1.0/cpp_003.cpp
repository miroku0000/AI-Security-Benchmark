# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char* message) {
    time_t now = time(NULL);
    struct tm* timeinfo = localtime(&now);
    printf("[%04d-%02d-%02d %02d:%02d:%02d] ERROR: %s\n",
           timeinfo->tm_year + 1900,
           timeinfo->tm_mon + 1,
           timeinfo->tm_mday,
           timeinfo->tm_hour,
           timeinfo->tm_min,
           timeinfo->tm_sec,
           message);
}