# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

// Define the configuration struct for our CLI tool
typedef struct {
    char *inputFile;
    char *outputFile;
    bool verbose;
    bool help;
} Config;

// Function to print usage information
void print_usage(const char *prog_name) {
    fprintf(stderr, "Usage: %s [OPTIONS]\n", prog_name);
    fprintf(stderr, "Options:\n");
    fprintf(stderr, "  -i, --input <file>   Specify an input file.\n");
    fprintf(stderr, "  -o, --output <file>  Specify an output file.\n");
    fprintf(stderr, "  -v, --verbose        Enable verbose output.\n");
    fprintf(stderr, "  -h, --help           Display this help message.\n");
}

// Function to free the allocated Config struct and its members
void free_config(Config *config) {
    if (config == NULL) {
        return;
    }
    free(config->inputFile);  // Free dynamically allocated input file string
    free(config->outputFile); // Free dynamically allocated output file string
    free(config);             // Free the Config struct itself
}

// Function to parse command-line arguments and return a Config pointer
Config* parse_arguments(int argc, char *argv[]) {
    // Allocate memory for the Config struct
    Config *config = (Config*) malloc(sizeof(Config));
    if (config == NULL) {
        perror("Failed to allocate memory for Config");
        return NULL; // Indicate allocation failure
    }

    // Initialize with default values
    config->inputFile = NULL;
    config->outputFile = NULL;
    config->verbose = false;
    config->help = false;

    // Iterate through command-line arguments, starting from the second argument (argv[0] is program name)
    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-h") == 0 || strcmp(argv[i], "--help") == 0) {
            config->help = true;
        } else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbose = true;
        } else if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            // Check if there's a next argument for the file name
            if (i + 1 < argc) {
                config->inputFile = strdup(argv[++i]); // Duplicate the string and advance index
                if (config->inputFile == NULL) {
                    perror("Failed to duplicate input file string");
                    free_config(config); // Clean up before returning NULL
                    return NULL;
                }
            } else {
                fprintf(stderr, "Error: Option '%s' requires an argument.\n", argv[i]);
                free_config(config); // Clean up before returning NULL
                return NULL;
            }
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            // Check if there's a next argument for the file name
            if (i + 1 < argc) {
                config->outputFile = strdup(argv[++i]); // Duplicate the string and advance index
                if (config->outputFile == NULL) {
                    perror("Failed to duplicate output file string");
                    free_config(config); // Clean up before returning NULL
                    return NULL;
                }
            } else {
                fprintf(stderr, "Error: Option '%s' requires an argument.\n", argv[i]);
                free_config(config); // Clean up before returning NULL
                return NULL;
            }
        } else {
            // Unknown option encountered
            fprintf(stderr, "Error: Unknown option '%s'\n", argv[i]);
            free_config(config); // Clean up before returning NULL
            return NULL;
        }
    }

    return config; // Return the pointer to the populated Config struct
}

// This function simulates the application's initialization logic
// It takes the parsed configuration and sets up the application state.
void initialize_application(const Config *config) {
    printf("--- Application Initializing ---\n");
    printf("  Input File: %s\n", config->inputFile ? config->inputFile : "None specified");
    printf("  Output File: %s\n", config->outputFile ? config->outputFile : "None specified");
    printf("  Verbose Mode: %s\n", config->verbose ? "Enabled" : "Disabled");
    printf("  Help Requested: %s\n", config->help ? "Yes" : "No");

    // In a real application, you would use these config values to:
    // - Open files (e.g., fopen(config->inputFile, "r"))
    // - Set logging levels
    // - Initialize modules or services
    // - Validate configuration (e.g., ensure input/output files are not the same)

    if (config->inputFile) {
        printf("  (Simulating opening input file '%s' for reading...)\n", config->inputFile);
        // FILE *in_fp = fopen(config->inputFile, "r");
        // if (!in_fp) { perror("Failed to open input file"); /* handle error */ }
        // else { fclose(in_fp); }
    }
    if (config->outputFile) {
        printf("