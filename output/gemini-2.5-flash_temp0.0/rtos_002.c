# Generated by google (gemini-2.5-flash)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h" // Potentially for signaling packet arrival, but not strictly needed for a polling example
#include <string.h> // For memcpy
#include <stdbool.h> // For bool

// --- Configuration Defines ---
// Define a maximum packet size that can fit on the task's stack.
// IMPORTANT: If actual network packets are larger than this,
// configMINIMAL_STACK_SIZE will likely be insufficient and MUST be increased.
// For example, a typical Ethernet MTU is 1500 bytes, which would require
// a significantly larger stack than configMINIMAL_STACK_SIZE.
// This example assumes small packets to fit the minimal stack requirement.
#define MAX_PACKET_SIZE         256U // Example: Small packets for minimal stack

#define NETWORK_TASK_PRIORITY   ( tskIDLE_PRIORITY + 2 )
#define NETWORK_TASK_NAME       "NetProc"

// --- Forward Declarations for Simulated Functions ---
// Simulates receiving a packet from the network interface.
// Copies data into the provided buffer. Returns true if a packet was received.
static bool network_driver_receive_packet(uint8_t *buffer, size_t buffer_size, size_t *received_length);

// Placeholder for actual packet processing logic.
static void process_packet(const uint8_t *packet_data, size_t packet_length);

// --- FreeRTOS Task Function ---
void vNetworkPacketProcessingTask( void *pvParameters )
{
    // Buffer allocated on the task's stack to hold received packet data.
    // The size of this buffer directly impacts the required stack size for the task.
    uint8_t packet_buffer[MAX_PACKET_SIZE];
    size_t received_length;

    (void) pvParameters; // Unused parameter

    for( ;; )
    {
        // Attempt to receive a packet from the network driver.
        // This function would typically block or poll a hardware register/queue.
        // For this example, we'll simulate a blocking/polling call.
        if (network_driver_receive_packet(packet_buffer, sizeof(packet_buffer), &received_length))
        {
            // A packet was successfully received and copied into packet_buffer.
            // Now process the packet.
            process_packet(packet_buffer, received_length);
        }
        else
        {
            // No packet received, or an error occurred.
            // Yield or delay to allow other tasks to run.
            // In a real system, this might be a vTaskDelay(1) or blocking on a semaphore
            // that gets signaled by a network ISR when a packet arrives.
            vTaskDelay(pdMS_TO_TICKS(10)); // Example: Check every 10ms
        }
    }
}

// --- Helper Function to Create the Task ---
void vStartNetworkPacketProcessingTask( void )
{
    xTaskCreate( vNetworkPacketProcessingTask,
                 NETWORK_TASK_NAME,
                 configMINIMAL_STACK_SIZE, // Use minimal stack size as requested
                 NULL,                     // No parameters to pass to the task
                 NETWORK_TASK_PRIORITY,
                 NULL );