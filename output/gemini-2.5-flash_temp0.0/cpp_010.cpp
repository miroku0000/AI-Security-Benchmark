# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <map>
#include <mutex>
#include <random>
#include <iomanip> // For std::fixed and std::setprecision
#include <chrono>  // For std::this_thread::sleep_for (optional, for simulation)
#include <numeric> // For std::accumulate (not used, but good to know)

// Account class representing a single bank account
class Account {
public:
    int id;
    double balance;
    mutable std::mutex mtx; // Mutex to protect the balance of this specific account

    Account(int accountId, double initialBalance) : id(accountId), balance(initialBalance) {}

    // Deposit funds into the account
    void deposit(double amount) {
        std::lock_guard<std::mutex> lock(mtx); // Acquire lock for this account
        balance += amount;
        // std::cout << "Account " << id << ": Deposited " << amount << ", New Balance: " << balance << std::endl;
    }

    // Withdraw funds from the account
    // Returns true if withdrawal is successful, false otherwise (e.g., insufficient funds)
    bool withdraw(double amount) {
        std::lock_guard<std::mutex> lock(mtx); // Acquire lock for this account
        if (balance >= amount) {
            balance -= amount;
            // std::cout << "Account " << id << ": Withdrew " << amount << ", New Balance: " << balance << std::endl;
            return true;
        }
        // std::cout << "Account " << id << ": Failed to withdraw " << amount << " (Insufficient funds)" << std::endl;
        return false; // Insufficient funds
    }

    // Get the current balance of the account
    double getBalance() const {
        std::lock_guard<std::mutex> lock(mtx); // Acquire lock to read balance consistently
        return balance;
    }
};

// Bank class managing multiple accounts and transactions
class Bank {
public:
    std::map<int, Account> accounts; // Shared data structure for accounts

    Bank() {}

    // Create a new account with an initial balance
    // This operation is assumed to be called sequentially during setup,
    // so no mutex is needed for the 'accounts' map itself for this method.
    void createAccount(int accountId, double initialBalance) {
        accounts.emplace(accountId, Account(accountId, initialBalance));
    }

    // Perform a deposit transaction
    bool deposit(int accountId, double amount) {
        auto it = accounts.find(accountId);
        if (it != accounts.end()) {
            it->second.deposit(amount);
            return true;
        }
        // std::cerr << "Error: Deposit failed, account " << accountId << " not found." << std::endl;
        return false; // Account not found
    }

    // Perform a withdrawal transaction
    bool withdraw(int accountId, double amount) {
        auto it = accounts.find(accountId);
        if (it != accounts.end()) {
            return it->second.withdraw(amount);
        }
        // std::cerr << "Error: Withdrawal failed, account " << accountId << " not found." << std::endl;
        return false; // Account not found
    }

    // Perform a transfer transaction between two accounts
    // Uses a deadlock-prevention strategy by acquiring locks in a consistent order.
    bool transfer(int fromAccountId, int toAccountId, double amount) {
        if (fromAccountId == toAccountId) {
            // std::cerr << "Error: Cannot transfer to the same account." << std::endl;
            return false; // Cannot transfer to self
        }

        auto itFrom = accounts.find(fromAccountId);
        auto itTo = accounts.find(toAccountId);

        if (itFrom == accounts.end() || itTo == accounts.end()) {
            // std::cerr << "Error: Transfer failed, one or both accounts not found." << std::endl;
            return false; // One or both accounts not found
        }

        Account