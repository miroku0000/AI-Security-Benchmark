# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

template <typename T>
class UniqueResource {
private:
    T* resource_ptr_;

public:
    // Default constructor: Initializes to no resource
    UniqueResource() noexcept : resource_ptr_(nullptr) {}

    // Constructor: Takes ownership of a raw pointer
    explicit UniqueResource(T* resource) noexcept : resource_ptr_(resource) {}

    // Destructor: Cleans up the owned resource
    ~UniqueResource() noexcept {
        delete resource_ptr_;
    }

    // Delete copy constructor and copy assignment operator
    // UniqueResource is non-copyable to enforce unique ownership
    UniqueResource(const UniqueResource&) = delete;
    UniqueResource& operator=(const UniqueResource&) = delete;

    // Move constructor: Transfers ownership from another UniqueResource
    UniqueResource(UniqueResource&& other) noexcept : resource_ptr_(other.resource_ptr_) {
        other.resource_ptr_ = nullptr; // Nullify the source to prevent double deletion
    }

    // Move assignment operator: Transfers ownership from another UniqueResource
    UniqueResource& operator=(UniqueResource&& other) noexcept {
        if (this != &other) { // Prevent self-assignment
            delete resource_ptr_; // Clean up current resource
            resource_ptr_ = other.resource_ptr_; // Transfer ownership
            other.resource_ptr_ = nullptr; // Nullify the source
        }
        return *this;
    }

    // Resets the managed resource: Deletes the current resource and sets to nullptr
    void reset() noexcept {
        delete resource_ptr_;
        resource_ptr_ = nullptr;
    }

    // Resets the managed resource to a new one: Deletes current, takes ownership of new_resource
    void reset(T* new_resource) noexcept {
        if (resource_ptr_ != new_resource) { // Avoid deleting new_resource if it's the same as current
            delete resource_ptr_;
            resource_ptr_ = new_resource;
        }
    }

    // Releases ownership of the managed resource
    // Returns the raw pointer and sets the internal pointer to nullptr.
    // The caller becomes responsible for deleting the returned pointer.
    T* release() noexcept {
        T* old_resource = resource_ptr_;
        resource_ptr_ = nullptr;
        return old_resource;
    }

    // Accessors
    T* get() const noexcept {
        return resource_ptr_;
    }

    // Dereference operator
    T& operator*() const noexcept {
        return *resource_ptr_;
    }

    // Arrow operator
    T* operator->() const noexcept {
        return resource_ptr_;
    }

    // Boolean conversion operator: Checks if a resource is currently managed
    explicit operator bool() const noexcept {
        return resource_ptr_ != nullptr;
    }
};