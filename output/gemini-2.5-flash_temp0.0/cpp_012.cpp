# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <stdexcept> // For std::runtime_error
#include <random>    // For simulating success/failure
#include <chrono>    // For seeding random number generator
#include <functional> // For std::hash

// Simulate a network resource handle.
// In a real scenario, this would be a socket file descriptor,
// a pointer to a connection object, or a library-specific handle.
using ConnectionHandle = int;
const ConnectionHandle INVALID_HANDLE = -1;

class NetworkConnectionManager {
private:
    ConnectionHandle connection_handle_;
    bool is_connected_;
    std::string current_host_;
    int current_port_;

    // Static