# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
#include <stdarg.h>
#include <time.h>
#include <string.h> // For strerror, often useful with error logging
#include <errno.h>  // For errno, often useful with error logging

// Global file pointer for the log file
static FILE *g_log_file = NULL;
static const char *g_log_filename = "error.log"; // Default log file name

// Function to initialize the log file.
// Call this once at the start of your application to open the log file.
// If filename is NULL, it uses the default "error.log".
// Returns 0 on success, -1 on failure.
int init_logger(const char *filename) {
    if (filename) {
        g_log_filename = filename;
    }
    // Open in append mode ("a") so new messages are added to the end.
    g_log_file = fopen(g_log_filename, "a");
    if (g_log_file == NULL) {
        perror("Failed to open log file");
        return -1; // Indicate failure
    }
    return 0; // Indicate success
}

// Function to close the log file.
// Call this once at the end of your application to release the file resource.
void close_logger() {
    if (g_log_file != NULL) {
        fclose(g_log_file);
        g_log_file = NULL;
    }
}

// Internal logging function that accepts file and line number.
// This function logs detailed error information including timestamp,
// the file and line where the error occurred, and the formatted error message.
// Users should typically use the `log_error` macro for convenience.
void _log_error_internal(const char *file, int line, const char *format, ...) {
    // If the log file is not initialized, print to stderr as a fallback.
    if (g_log_file == NULL) {
        fprintf(stderr, "ERROR: Log file not initialized. Message from %s:%d: ", file, line);
        va_list args_stderr;
        va_start(args_stderr, format);
        vfprintf(stderr, format, args_stderr);
        va_end(args_stderr);
        fprintf(stderr, "\n");
        return;
    }

    time_t timer;
    char timestamp_buffer[26]; // Buffer for timestamp (e.g., YYYY-MM-DD HH:MM:SS\0)
    struct tm* tm_info;

    // Get current time and format it
    time(&timer);
    tm_info = localtime(&timer);
    strftime(timestamp_buffer, sizeof(timestamp_buffer), "%Y-%m-%d %H:%M:%S", tm_info);

    // Write the detailed log prefix: timestamp, severity, file, and line number
    fprintf(g_log_file, "[%s] ERROR (%s:%d): ", timestamp_buffer, file, line);

    // Write the user-provided error message and its arguments
    va_list args;
    va_start(args, format);
    v