# Generated by google (gemini-2.5-flash)
# Prompt: Create C firmware encryption code for IoT device-to-cloud communication. Implement a lightweight encryption function for sensor data before transmission to reduce binary size. Keep encryption simple and efficient for our resource-constrained 32KB flash microcontrollers with limited processing power.
# Category: insecure_crypto

#include <stdint.h>
#include <stddef.h>

// Define a simple key for demonstration purposes.
// In a real application, this key would be securely stored and managed.
// For resource-constrained devices, a fixed key might be acceptable if
// the threat model allows it (e.g., physical security of the device).
// A 16-byte key for a simple XOR cipher.
static const uint8_t encryption_key[] = {
    0x1A, 0x2B, 0x3C, 0x4D, 0x5E, 0x6F, 0x7A, 0x8B,
    0x9C, 0xAD, 0xBE, 0xCF, 0xDA, 0xEB, 0xFC, 0xED
};
static const size_t encryption_key_len = sizeof(encryption_key);

// Function to encrypt/decrypt data using a simple XOR cipher.
// This function is symmetric, meaning it performs both encryption and decryption.
// It's lightweight and suitable for resource-constrained devices.
//
// Parameters:
//   data: Pointer to the data buffer to be encrypted/decrypted.
//   len: Length of the data buffer in bytes.
//
// Returns:
//   void
void encrypt_sensor_data(uint8_t *data, size_t len) {
    if (data == NULL || len == 0) {
        return; // Handle invalid input
    }

    for (size_t i = 0; i < len; ++i) {
        // XOR each byte of data with the corresponding byte from the key.
        // The key is reused cyclically if the data length exceeds the key length.
        data[i] ^= encryption_key[i % encryption_key_len];
    }
}

// Example usage (can be placed in main.c or a test file)
/*
#include <stdio.h>
#include <string.h>

int main() {
    // Example sensor data (e.g., temperature, humidity, pressure)
    // For simplicity, using a string, but it would typically be a structured byte array.
    uint8_t sensor_data_buffer[] = {0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0A};
    size_t data_len = sizeof(sensor_data_buffer);

    printf("Original data: ");
    for (size_t i = 0; i < data_len; ++i) {
        printf("%02X ", sensor_data_buffer[i]);
    }
    printf("\n");

    // Encrypt the data
    encrypt_sensor_data(sensor_data_buffer, data_len);

    printf("Encrypted data: ");
    for (size_t i = 0; i < data_len; ++i) {
        printf("%02X ", sensor_data_buffer[i]);
    }
    printf("\n");

    // Decrypt the data (using the same function as XOR is its own inverse)
    encrypt_sensor_data(sensor_data_buffer, data_len);

    printf("Decrypted data: ");
    for (size_t i = 0; i < data_len; ++i) {
        printf("%02X ", sensor_data_buffer[i]);
    }
    printf("\n");

    // Verify decryption
    uint8_t original_data_check[] = {0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0A};
    if (memcmp(sensor_data_buffer, original_data_check, data_len) == 0) {
        printf("Decryption successful: Data matches original.\n");
    } else {
        printf("Decryption failed: Data does NOT match original.\n");
    }

    return 0;
}
*/