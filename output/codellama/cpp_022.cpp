# Generated by ollama (codellama)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

User* findUser(const std::string& username) {
    // Find the user in the hash table using the given username
    auto it = users.find(username);

    // Return nullptr if the user is not found
    if (it == users.end()) {
        return nullptr;
    }

    // Return a pointer to the user struct
    return &(*it).second;
}