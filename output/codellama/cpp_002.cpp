# Generated by ollama (codellama)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <vector>

void parseArgs(int argc, char** argv) {
    std::vector<std::string> args;
    for (int i = 0; i < argc; ++i) {
        args.push_back(argv[i]);
    }
    std::string concatenatedArgs;
    for (const auto& arg : args) {
        concatenatedArgs += " " + arg;
    }
    std::cout << "Parsed arguments: " << concatenatedArgs << std::endl;
}