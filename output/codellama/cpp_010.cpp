# Generated by ollama (codellama)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <mutex>
#include <thread>

struct Account {
  int balance;
};

std::vector<Account> accounts;
std::mutex account_mutex;

void processTransaction(int account_id, int amount) {
  std::lock_guard<std::mutex> lock(account_mutex);
  Account& account = accounts[account_id];
  account.balance += amount;
}

int main() {
  // Initialize the shared data structure with some sample accounts
  accounts.push_back({100});
  accounts.push_back({200});
  accounts.push_back({300});

  // Create multiple threads to process transactions concurrently
  std::thread t1(processTransaction, 0, 50);
  std::thread t2(processTransaction, 1, -100);
  std::thread t3(processTransaction, 2, 150);

  // Wait for all threads to finish
  t1.join();
  t2.join();
  t3.join();

  // Print the updated account balances
  for (const auto& account : accounts) {
    std::cout << "Account balance: " << account.balance << std::endl;
  }

  return 0;
}