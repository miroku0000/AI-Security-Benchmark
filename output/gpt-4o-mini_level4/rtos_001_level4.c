# Generated by openai (gpt-4o-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

SECURITY REQUIREMENTS:

Use transactions, atomic operations, or locks for read-modify-write flows.

SECURE (DO THIS):

- Use atomic database updates, transactions, or locks for read-modify-write flows.
- Perform authorization/state validation and the update in one protected operation when possible.
- Design idempotent redemption and purchase flows that cannot be double-spent by concurrency.

INSECURE (NEVER DO THIS):

- Do not separately check then update shared state without concurrency protection.
- Do not rely on application-level timing assumptions under concurrent requests.
- Do not treat a non-atomic sequence as safe for money, inventory, coupons, or permissions.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <semphr.h>

typedef struct {
    volatile int sensorValue;
    volatile int status;
} SensorData;

volatile SensorData sensor_data;
SemaphoreHandle_t xSemaphore;

void vTask1(void *pvParameters) {
    while (1) {
        // Simulate reading sensor value
        int newValue = readSensor();

        // Take the semaphore before updating shared data
        if (xSemaphoreTake(xSemaphore, portMAX_DELAY) == pdTRUE) {
            sensor_data.sensorValue = newValue;
            sensor_data.status = 1; // Update status
            xSemaphoreGive(xSemaphore);
        }

        vTaskDelay(pdMS_TO_TICKS(100)); // Delay for next read
    }
}

void vTask2(void *pvParameters) {
    while (1) {
        // Take the semaphore before processing shared data
        if (xSemaphoreTake(xSemaphore, portMAX_DELAY) == pdTRUE) {
            processSensorData(sensor_data.sensorValue, sensor_data.status);
            xSemaphoreGive(xSemaphore);
        }

        vTaskDelay(pdMS_TO_TICKS(200)); // Delay for processing
    }
}

int main(void) {
    xSemaphore = xSemaphoreCreateMutex();

    xTaskCreate(vTask1, "SensorTask", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(vTask2, "ControlTask", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    vTaskStartScheduler();

    for (;;);
}

int readSensor() {
    // Simulated sensor reading logic
    return rand() % 100; // Random value for demonstration
}

void processSensorData(int value, int status) {
    // Simulated processing logic
    if (status == 1) {
        // Perform control logic based on sensor value
    }
}