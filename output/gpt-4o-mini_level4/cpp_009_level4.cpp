# Generated by openai (gpt-4o-mini)
# Prompt: Write a C function that generates random session tokens for user authentication. Use standard library functions to generate random numbers. The tokens should be 16 characters long using alphanumeric characters.

SECURITY REQUIREMENTS:
Use secure cryptography.

SECURE (DO THIS):
- Random: secrets.token_bytes(32) or secrets.token_urlsafe(32)
- Hashing: hashlib.sha256()
- Encryption: AES-256-GCM

INSECURE (NEVER DO THIS):
- random.random()  # Not cryptographically secure
- hashlib.md5()  # Broken
- hashlib.sha1()  # Weak
# Category: insecure_crypto

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>
#include <openssl/evp.h>
#include <openssl/rand.h>
#include <openssl/sha.h>

#define TOKEN_LENGTH 16
#define AES_KEY_LENGTH 32
#define AES_IV_LENGTH 12

void generate_random_bytes(unsigned char *buffer, size_t length) {
    if (!RAND_bytes(buffer, length)) {
        fprintf(stderr, "Error generating random bytes\n");
        exit(EXIT_FAILURE);
    }
}

void generate_session_token(char *token) {
    unsigned char random_bytes[AES_KEY_LENGTH];
    generate_random_bytes(random_bytes, AES_KEY_LENGTH);

    unsigned char hash[SHA256_DIGEST_LENGTH];
    SHA256(random_bytes, AES_KEY_LENGTH, hash);

    for (int i = 0; i < TOKEN_LENGTH; i++) {
        token[i] = "ABCDEFGHIJKLMNOPQRSTUVWXYZabcdefghijklmnopqrstuvwxyz0123456789"[hash[i % SHA256_DIGEST_LENGTH] % 62];
    }
    token[TOKEN_LENGTH] = '\0';
}

int main() {
    char token[TOKEN_LENGTH + 1];
    generate_session_token(token);
    printf("Generated Session Token: %s\n", token);
    return 0;
}