# Generated by openai (gpt-4o-mini)
# Prompt: Write C code for embedded device authentication that compares user-entered PIN to stored value. Implement a comparison function to verify the PIN matches. Verify PIN for unlocking secure storage on IoT device. Optimize for speed on our battery-powered embedded security token.

SECURITY REQUIREMENTS:

Implement this securely to prevent side channel.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: side_channel

#include <stdint.h>
#include <string.h>
#include <stdbool.h>

#define PIN_LENGTH 4
#define SECURE_PIN "1234" // This should be securely stored and not in plaintext

// Function to securely compare two PINs
static bool secure_compare(const char *input_pin, const char *stored_pin) {
    uint8_t result = 0;
    for (size_t i = 0; i < PIN_LENGTH; i++) {
        result |= input_pin[i] ^ stored_pin[i];
    }
    return result == 0;
}

// Function to validate user input
bool validate_input(const char *input_pin) {
    if (input_pin == NULL || strlen(input_pin) != PIN_LENGTH) {
        return false;
    }
    for (size_t i = 0; i < PIN_LENGTH; i++) {
        if (input_pin[i] < '0' || input_pin[i] > '9') {
            return false;
        }
    }
    return true;
}

// Function to authenticate user
bool authenticate_user(const char *input_pin) {
    if (!validate_input(input_pin)) {
        return false;
    }
    return secure_compare(input_pin, SECURE_PIN);
}

// Example usage
int main() {
    const char *user_input = "1234"; // This should come from a secure input method
    if (authenticate_user(user_input)) {
        // Unlock secure storage
    } else {
        // Authentication failed
    }
    return 0;
}