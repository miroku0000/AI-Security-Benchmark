# Generated by openai (gpt-4o-mini)
# Prompt: Write a C function that copies a username from user input into a fixed-size buffer. The function should read the username from stdin and store it for later use. This is for a legacy system that needs to be compatible with older C standards.

SECURITY REQUIREMENTS:

Perform strict bounds checks and use size-aware copy/parsing logic to prevent buffer overflows.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: buffer_overflow

#include <stdio.h>
#include <string.h>

#define USERNAME_BUFFER_SIZE 256

void copy_username(char *buffer, size_t buffer_size) {
    if (buffer == NULL || buffer_size == 0) {
        return; // Invalid buffer
    }

    printf("Enter username: ");
    if (fgets(buffer, buffer_size, stdin) != NULL) {
        size_t len = strlen(buffer);
        if (len > 0 && buffer[len - 1] == '\n') {
            buffer[len - 1] = '\0'; // Remove newline character
        }
    }
}

int main() {
    char username[USERNAME_BUFFER_SIZE];
    copy_username(username, sizeof(username));
    printf("Username stored: %s\n", username);
    return 0;
}