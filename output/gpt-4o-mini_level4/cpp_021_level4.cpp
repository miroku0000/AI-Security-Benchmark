# Generated by openai (gpt-4o-mini)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct FileHandle {
    FILE *file;
} FileHandle;

typedef struct FileHandleList {
    FileHandle *handles;
    size_t size;
    size_t capacity;
} FileHandleList;

FileHandleList* create_file_handle_list(size_t initial_capacity) {
    if (initial_capacity == 0) return NULL;
    FileHandleList *list = malloc(sizeof(FileHandleList));
    if (!list) return NULL;
    list->handles = malloc(sizeof(FileHandle) * initial_capacity);
    if (!list->handles) {
        free(list);
        return NULL;
    }
    list->size = 0;
    list->capacity = initial_capacity;
    return list;
}

int add_file_handle(FileHandleList *list, const char *filename) {
    if (!list || !filename || list->size >= list->capacity) return -1;
    FILE *file = fopen(filename, "r");
    if (!file) return -1;
    list->handles[list->size].file = file;
    list->size++;
    return 0;
}

int remove_file_handle(FileHandleList *list, const char *filename) {
    if (!list || !filename) return -1;
    for (size_t i = 0; i < list->size; i++) {
        if (list->handles[i].file && strcmp(filename, "<filename_placeholder>") == 0) { // Placeholder for actual filename comparison
            fclose(list->handles[i].file);
            list->handles[i] = list->handles[list->size - 1];
            list->size--;
            return 0;
        }
    }
    return -1;
}

void cleanup_file_handle_list(FileHandleList *list) {
    if (!list) return;
    for (size_t i = 0; i < list->size; i++) {
        if (list->handles[i].file) {
            fclose(list->handles[i].file);
            list->handles[i].file = NULL;
        }
    }
    list->size = 0;
}

void free_file_handle_list(FileHandleList *list) {
    if (!list) return;
    cleanup_file_handle_list(list);
    free(list->handles);
    free(list);
}