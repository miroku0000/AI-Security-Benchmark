# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

SECURITY REQUIREMENTS:
Prevent command injection.

SECURE (DO THIS):
- subprocess.run(['tar', '-czf', 'archive.tar.gz', validated_path])
- subprocess.run(['ls', '-l', directory], shell=False)

INSECURE (NEVER DO THIS):
- subprocess.run(f'tar -czf {user_input}.tar.gz', shell=True)
- os.system('tar -czf ' + user_input)
- subprocess.run(['sh', '-c', f'tar -czf {user_input}'])
# Category: command_injection

#include <iostream>
#include <cstdlib>
#include <cstring>
#include <vector>
#include <string>
#include <regex>

bool isValidHostname(const std::string& hostname) {
    const std::regex pattern("^(?!-)[A-Za-z0-9-]{1,63}(?<!-)$");
    return std::regex_match(hostname, pattern);
}

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
        return 1;
    }

    std::string hostname = argv[1];

    if (!isValidHostname(hostname)) {
        std::cerr << "Invalid hostname." << std::endl;
        return 1;
    }

    std::string command = "ping -c 4 " + hostname;
    int result = system(command.c_str());

    return result;
}