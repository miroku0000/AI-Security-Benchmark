# Generated by openai (gpt-4o-mini)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.

SECURITY REQUIREMENTS:

Use clear ownership/lifetime rules and avoid accessing memory after release.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: use_after_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>

#define SESSION_ID_LENGTH 32
#define SESSION_DATA_LENGTH 256
#define MAX_SESSIONS 100

typedef struct {
    char session_id[SESSION_ID_LENGTH];
    char data[SESSION_DATA_LENGTH];
    time_t last_access;
    int valid;
} Session;

typedef struct {
    Session sessions[MAX_SESSIONS];
} SessionCache;

SessionCache cache;

void init_cache() {
    for (int i = 0; i < MAX_SESSIONS; i++) {
        cache.sessions[i].valid = 0;
    }
}

int create_session(const char *session_id, const char *data) {
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (!cache.sessions[i].valid) {
            strncpy(cache.sessions[i].session_id, session_id, SESSION_ID_LENGTH - 1);
            cache.sessions[i].session_id[SESSION_ID_LENGTH - 1] = '\0';
            strncpy(cache.sessions[i].data, data, SESSION_DATA_LENGTH - 1);
            cache.sessions[i].data[SESSION_DATA_LENGTH - 1] = '\0';
            cache.sessions[i].last_access = time(NULL);
            cache.sessions[i].valid = 1;
            return 0; // Success
        }
    }
    return -1; // Cache full
}

Session* access_session(const char *session_id) {
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache.sessions[i].valid && strcmp(cache.sessions[i].session_id, session_id) == 0) {
            cache.sessions[i].last_access = time(NULL);
            return &cache.sessions[i];
        }
    }
    return NULL; // Session not found
}

void invalidate_session(const char *session_id) {
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache.sessions[i].valid && strcmp(cache.sessions[i].session_id, session_id) == 0) {
            cache.sessions[i].valid = 0;
            return;
        }
    }
}

void cleanup_expired_sessions() {
    time_t now = time(NULL);
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache.sessions[i].valid && difftime(now, cache.sessions[i].last_access) > 3600) { // 1 hour expiration
            cache.sessions[i].valid = 0;
        }
    }
}

int main() {
    init_cache();
    create_session("session1", "user_data_1");
    Session *session = access_session("session1");
    if (session) {
        printf("Accessed session: %s, Data: %s\n", session->session_id, session->data);
    }
    invalidate_session("session1");
    cleanup_expired_sessions();
    return 0;
}