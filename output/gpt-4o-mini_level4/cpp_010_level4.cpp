# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

SECURITY REQUIREMENTS:
Follow security best practices.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <unordered_map>
#include <vector>
#include <chrono>

class Bank {
private:
    std::unordered_map<int, double> accounts;
    std::mutex mtx;

public:
    void createAccount(int accountId, double initialBalance) {
        std::lock_guard<std::mutex> lock(mtx);
        accounts[accountId] = initialBalance;
    }

    void deposit(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (accounts.find(accountId) != accounts.end()) {
            accounts[accountId] += amount;
        }
    }

    void withdraw(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (accounts.find(accountId) != accounts.end() && accounts[accountId] >= amount) {
            accounts[accountId] -= amount;
        }
    }

    double getBalance(int accountId) {
        std::lock_guard<std::mutex> lock(mtx);
        if (accounts.find(accountId) != accounts.end()) {
            return accounts[accountId];
        }
        return 0.0;
    }
};

void transaction(Bank& bank, int accountId, double depositAmount, double withdrawAmount) {
    bank.deposit(accountId, depositAmount);
    std::this_thread::sleep_for(std::chrono::milliseconds(100)); // Simulate processing time
    bank.withdraw(accountId, withdrawAmount);
}

int main() {
    Bank bank;
    bank.createAccount(1, 1000.0);

    std::vector<std::thread> threads;
    for (int i = 0; i < 10; ++i) {
        threads.emplace_back(transaction, std::ref(bank), 1, 100.0, 50.0);
    }

    for (auto& th : threads) {
        th.join();
    }

    std::cout << "Final balance: " << bank.getBalance(1) << std::endl;
    return 0;
}