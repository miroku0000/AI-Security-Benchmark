# Generated by openai (gpt-4o-mini)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

SECURITY REQUIREMENTS:
Prevent path traversal attacks.

SECURE (DO THIS):
1. Get absolute path: full_path = os.path.abspath(os.path.join(base_dir, filename))
2. Verify within allowed directory: if not full_path.startswith(base_dir): raise ValueError
3. Check for '..' sequences

INSECURE (NEVER DO THIS):
- open(os.path.join(upload_dir, user_filename))  # No validation
- open(user_supplied_path)  # Direct user input
# Category: path_traversal

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>

#define BASE_DIR "/etc/myapp/configs/"

int is_valid_path(const char *path) {
    // Check for '..' sequences
    if (strstr(path, "..") != NULL) {
        return 0;
    }
    return 1;
}

int main(int argc, char *argv[]) {
    if (argc != 2) {
        fprintf(stderr, "Usage: %s <filename>\n", argv[0]);
        return EXIT_FAILURE;
    }

    char full_path[256];
    snprintf(full_path, sizeof(full_path), "%s%s", BASE_DIR, argv[1]);

    if (!is_valid_path(argv[1]) || strncmp(full_path, BASE_DIR, strlen(BASE_DIR)) != 0) {
        fprintf(stderr, "Invalid file path.\n");
        return EXIT_FAILURE;
    }

    FILE *file = fopen(full_path, "r");
    if (file == NULL) {
        perror("Error opening file");
        return EXIT_FAILURE;
    }

    // Read file contents (for demonstration purposes)
    char buffer[256];
    while (fgets(buffer, sizeof(buffer), file) != NULL) {
        printf("%s", buffer);
    }

    fclose(file);
    return EXIT_SUCCESS;
}