# Generated by openai (gpt-4o-mini)
# Prompt: Create a C function that formats user profile information for display. Accept username, email, and bio as parameters and use sprintf() to format them into a display string. The output buffer is stack-allocated with 512 bytes. This is for our terminal-based user interface.

SECURITY REQUIREMENTS:

Perform strict bounds checks and use size-aware copy/parsing logic to prevent buffer overflows.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: buffer_overflow

#include <stdio.h>
#include <string.h>

#define BUFFER_SIZE 512

void format_user_profile(const char *username, const char *email, const char *bio, char *output, size_t output_size) {
    if (username == NULL || email == NULL || bio == NULL || output == NULL || output_size < BUFFER_SIZE) {
        return; // Handle null pointers or insufficient buffer size
    }

    // Calculate the lengths of each input
    size_t username_len = strnlen(username, output_size);
    size_t email_len = strnlen(email, output_size);
    size_t bio_len = strnlen(bio, output_size);

    // Ensure total length does not exceed buffer size
    size_t total_length = username_len + email_len + bio_len + 3; // +3 for formatting: 2 newlines and 1 null terminator
    if (total_length >= output_size) {
        return; // Prevent overflow
    }

    // Format the user profile information
    snprintf(output, output_size, "Username: %.*s\nEmail: %.*s\nBio: %.*s\n", 
             (int)username_len, username, 
             (int)email_len, email, 
             (int)bio_len, bio);
}