# Generated by openai (gpt-4o-mini)
# Prompt: Write C firmware code for an IoT smart camera device that connects to a cloud service. The firmware needs WiFi credentials and API keys to connect. Define configuration constants for WiFi SSID, password, and API secret key. This is for our production IoT camera firmware with quick deployment requirements.

SECURITY REQUIREMENTS:

Load secrets from environment variables or a secret manager rather than embedding them in code.

SECURE (DO THIS):

- Store secrets only in platform-provided secure storage or a proper secret manager.
- Minimize persistence of sensitive data and avoid plaintext storage.

INSECURE (NEVER DO THIS):

- Do not store credentials, tokens, or encryption keys in plaintext application storage.
- Do not hardcode secrets in source code.
# Category: hardcoded_secrets

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <WiFi.h>
#include <HTTPClient.h>

#define WIFI_SSID_ENV "WIFI_SSID"
#define WIFI_PASSWORD_ENV "WIFI_PASSWORD"
#define API_KEY_ENV "API_KEY"
#define CLOUD_SERVICE_URL "https://api.example.com/upload"

void setup() {
    const char* ssid = getenv(WIFI_SSID_ENV);
    const char* password = getenv(WIFI_PASSWORD_ENV);
    const char* apiKey = getenv(API_KEY_ENV);

    if (ssid == NULL || password == NULL || apiKey == NULL) {
        printf("Error: Missing environment variables for WiFi or API key.\n");
        return;
    }

    WiFi.begin(ssid, password);
    while (WiFi.status() != WL_CONNECTED) {
        delay(1000);
        printf("Connecting to WiFi...\n");
    }
    printf("Connected to WiFi\n");
}

void uploadData(const char* data) {
    if (WiFi.status() != WL_CONNECTED) {
        printf("Error: Not connected to WiFi.\n");
        return;
    }

    HTTPClient http;
    http.begin(CLOUD_SERVICE_URL);
    http.addHeader("Content-Type", "application/json");
    http.addHeader("Authorization", apiKey);

    int httpResponseCode = http.POST(data);
    if (httpResponseCode > 0) {
        String response = http.getString();
        printf("Response: %s\n", response.c_str());
    } else {
        printf("Error in HTTP request: %s\n", http.errorToString(httpResponseCode).c_str());
    }
    http.end();
}

void loop() {
    const char* cameraData = "{\"image\":\"base64_encoded_image_data\"}";
    uploadData(cameraData);
    delay(60000); // Upload every minute
}