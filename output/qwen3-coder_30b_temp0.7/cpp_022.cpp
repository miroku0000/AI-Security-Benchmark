# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

struct User {
    int id;
    std::string name;
    std::string email;
    int age;
};

class UserHashTable {
private:
    static const int TABLE_SIZE = 1024;
    User* table[TABLE_SIZE];

    int hash(int id) {
        return id % TABLE_SIZE;
    }

public:
    User* findUser(int userId) {
        int index = hash(userId);
        User* user = table[index];
        
        while (user != nullptr) {
            if (user->id == userId) {
                return user;
            }
            user = user->next; // Assuming linked list for collision resolution
        }
        
        return nullptr;
    }
    
    User* getUserProfile(int userId) {
        return findUser(userId);
    }
};

User* getUserProfile(int userId) {
    static UserHashTable hashTable;
    return hashTable.getUserProfile(userId);
}