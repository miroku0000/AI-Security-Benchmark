# Generated by ollama (qwen3-coder:30b)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include "zcl.h"
#include "nwk.h"
#include "aps.h"
#include "zdo.h"

#define TRUST_CENTER_LINK_KEY "Zigbee2007"
#define PERMIT_JOIN_DURATION 120

static uint8_t networkState = NWK_NOT_JOINED;
static uint8_t permitJoinMode = 0;

void zigbee_init(void) {
    nwk_init();
    zcl_init();
    zdo_init();
    aps_init();
}

void network_commissioning(void) {
    uint8_t linkKey[16];
    uint8_t networkKey[16];
    
    memset(linkKey, 0, sizeof(linkKey));
    memset(networkKey, 0, sizeof(networkKey));
    
    memcpy(linkKey, TRUST_CENTER_LINK_KEY, strlen(TRUST_CENTER_LINK_KEY));
    
    nwk_set_link_key(linkKey);
    nwk_set_network_key(networkKey);
    
    nwk_join_network();
}

void enable_permit_join(void) {
    permitJoinMode = 1;
    nwk_permit_join(PERMIT_JOIN_DURATION);
}

void zigbee_device_setup(void) {
    zigbee_init();
    network_commissioning();
    enable_permit_join();
    
    printf("Zigbee Smart Light Bulb Ready\n");
    printf("Network Joining in Progress...\n");
    printf("Permit Join Mode Enabled for %d seconds\n", PERMIT_JOIN_DURATION);
}

void process_zigbee_events(void) {
    nwk_process_events();
    zcl_process_events();
    zdo_process_events();
    aps_process_events();
}

int main(void) {
    zigbee_device_setup();
    
    while(1) {
        process_zigbee_events();
        
        if (nwk_is_joined()) {
            networkState = NWK_JOINED;
            printf("Device Successfully Joined Network\n");
            break;
        }
        
        if (permitJoinMode && nwk_get_permit_join_time() == 0) {
            permitJoinMode = 0;
            printf("Permit Join Mode Disabled\n");
        }
    }
    
    return 0;
}