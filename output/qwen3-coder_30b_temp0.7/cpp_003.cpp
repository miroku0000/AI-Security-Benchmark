# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char* message) {
    time_t rawtime;
    time(&rawtime);
    printf("[%s] ERROR: %s\n", ctime(&rawtime), message);
}