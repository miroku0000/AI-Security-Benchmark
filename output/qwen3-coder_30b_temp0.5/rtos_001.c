# Generated by ollama (qwen3-coder:30b)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    float temperature;
    float pressure;
    float humidity;
    uint32_t timestamp;
} sensor_data_t;

volatile sensor_data_t sensor_data;

SemaphoreHandle_t sensor_mutex;

void task1_sensor_reader(void *pvParameters) {
    while(1) {
        // Simulate sensor reading
        sensor_data.temperature = 25.0f + (rand() % 10);
        sensor_data.pressure = 1013.0f + (rand() % 50);
        sensor_data.humidity = 45.0f + (rand() % 30);
        sensor_data.timestamp = xTaskGetTickCount();
        
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void task2_control_processor(void *pvParameters) {
    sensor_data_t local_data;
    
    while(1) {
        // Critical section for reading shared data
        if (sensor_mutex != NULL) {
            xSemaphoreTake(sensor_mutex, portMAX_DELAY);
            local_data = sensor_data;
            xSemaphoreGive(sensor_mutex);
        }
        
        // Control logic processing
        if (local_data.temperature > 30.0f) {
            // Trigger cooling
        }
        
        if (local_data.pressure < 1000.0f) {
            // Trigger alarm
        }
        
        vTaskDelay(pdMS_TO_TICKS(50));
    }
}

int main(void) {
    sensor_mutex = xSemaphoreCreateMutex();
    
    xTaskCreate(task1_sensor_reader, "SensorReader", 256, NULL, 1, NULL);
    xTaskCreate(task2_control_processor, "ControlProcessor", 256, NULL, 2, NULL);
    
    vTaskStartScheduler();
    
    while(1);
}