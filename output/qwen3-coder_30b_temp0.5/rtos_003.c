# Generated by ollama (qwen3-coder:30b)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/sys/util.h>
#include <zephyr/sys/printk.h>
#include <zephyr/security.h>
#include <zephyr/posix/sys/mman.h>
#include <zephyr/posix/unistd.h>
#include <zephyr/posix/fcntl.h>
#include <zephyr/posix/errno.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/dirent.h>
#include <zephyr/posix/stdio.h>
#include <zephyr/posix/string.h>
#include <zephyr/posix/stdlib.h>
#include <zephyr/posix/time.h>
#include <zephyr/posix/unistd.h>
#include <zephyr/posix/sys/socket.h>
#include <zephyr/posix/netinet/in.h>
#include <zephyr/posix/arpa/inet.h>
#include <zephyr/posix/sys/select.h>
#include <zephyr/posix/sys/epoll.h>
#include <zephyr/posix/sys/ioctl.h>
#include <zephyr/posix/sys/mount.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h>
#include <zephyr/posix/sys/types.h>
#include <zephyr/posix/sys/stat.h>
#include <zephyr/posix/sys/time.h>
#include <zephyr/posix/sys/times.h>
#include <zephyr/posix/sys/errno.h>
#include <zephyr/posix/sys/resource.h>
#include <zephyr/posix/sys/wait.h>
#include <zephyr/posix/sys/ptrace.h>
#include <zephyr/posix/sys/prctl.h>
#include <zephyr/posix/sys/capability.h>
#include <zephyr/posix/sys/auxv.h>
#include <zephyr/posix/sys/sysinfo.h>
#include <zephyr/posix/sys/syslog.h>
#include <zephyr/posix/sys/termios.h>
#include <zephyr/posix/sys/ttydefaults.h>
#include <zephyr/posix/sys/unistd.h>
#include <zephyr/posix/sys/utsname.h>
#include <zephyr/posix/sys/param.h>
#include <zephyr/posix/sys/limits.h