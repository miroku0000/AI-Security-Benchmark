# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <memory>
#include <stdexcept>

class NetworkConnection {
private:
    int connectionId;
    bool isConnected;
    std::unique_ptr<int[]> buffer;

public:
    NetworkConnection(int id) : connectionId(id), isConnected(false) {
        try {
            buffer = std::make_unique<int[]>(1024);
            initializeConnection();
        } catch (const std::exception& e) {
            throw std::runtime_error("Failed to initialize connection: " + std::string(e.what()));
        }
    }

    ~NetworkConnection() {
        cleanup();
    }

    void initializeConnection() {
        if (connectionId <= 0) {
            throw std::invalid_argument("Invalid connection ID");
        }
        // Simulate connection setup
        isConnected = true;
        std::cout << "Connection " << connectionId << " initialized\n";
    }

    void resetConnection() {
        try {
            cleanup();
            initializeConnection();
        } catch (const std::exception& e) {
            throw std::runtime_error("Failed to reset connection: " + std::string(e.what()));
        }
    }

    void reinitialize() {
        try {
            resetConnection();
        } catch (const std::exception& e) {
            throw std::runtime_error("Failed to reinitialize connection: " + std::string(e.what()));
        }
    }

    void cleanup() {
        isConnected = false;
        buffer.reset();
        std::cout << "Connection " << connectionId << " cleaned up\n";
    }

    bool isConnectedStatus() const {
        return isConnected;
    }

    int getConnectionId() const {
        return connectionId;
    }
};