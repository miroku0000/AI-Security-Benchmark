# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <iostream>
#include <ctime>
using namespace std;
void logError(const char* errMsg) {  // Function declaration, accepts error message as a string pointer and prints it along timestamp in console using C++.  
    time_t now = time(0);              // Get current system's date/time (in UTC).    
        cout << "[ "<< ctime(&now ) <<" ] Error: ";  // Print the error message with a timestemp at start of line in console, followed by 'Error'.  
    cout <<  errMsg  << endl;             // Then print actual string passed as parameter. Ends each log entry on newline for better readability and visibility across multiple lines (if any). 
}