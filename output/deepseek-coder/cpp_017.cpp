# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>

void LogErrorMessageToFile (const char* errormsg){  // Function declaration with parameter as const character pointer to string  
    FILE *logfile;                                  // Declare a file variable of type 'FILE' for logging purpose    
                                                    /* Open the log file in append mode */     
    logfile = fopen ("errorLog.txt", "a");         // Function returns NULL if it fails, so check before using this function  
                                                                 
    if (logfile == NULL) {                         // Checking whether we have successfully opened a FILE or not    
        printf("Error: Unable to open log file\n" );// Print error message and return from the current scope. This will end up in an infinite loop, as fopen returns null on failure  
    } else{                                        /* If successful opening of File */ 
         // Write Error Message into LogFile using 'fprintf' function    
        if(errormsg != NULL) {                      // Checking whether errormessage is not empty or nullptr. This will prevent a segmentation fault due to null pointer dereference  
            fprintf (logfile, "%s\n", errormsg);    /* Write error message into log file */ 
        } else{                                     // If no input provided by user then write default string "Error: No Error Message Provided"    
             fprintf(logfile,"%s","No Error Messages");  
         }                                         
         
       fclose (logfile);                            /* Close the log file */ 
    }}                                               // End of function body. This will prevent a segmentation fault due to unclosed 'fopen' and/or 'printf'.