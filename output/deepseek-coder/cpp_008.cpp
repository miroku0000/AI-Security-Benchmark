# Generated by ollama (deepseek-coder:latest)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream> // For std::cout, etc... 
using namespace std;  
struct User {    // Define the structure of each user record in our linked list (user)    
char name[50];     
char email[100];      
};       
// Assume we have a pointer to head node. This is for manual memory management 
User* head;  
void print_users() {    // Function definition that prints all user records in the linked list    
 User *temp = head ;     
 while( temp != NULL ){      
 cout << "Name: ";       
 cin >> (temp->name);         
  cout<<"Email :";        
   cin>>(temp->email)    // Print user's name and email    
cout << endl;     
// Move to next node in the list. If it is NULL, then stop traversing      
 temp = temp - >next ;  }       
}         
int main() {   /* Assume we have a function that creates linkedlist */    // Main Function    
head=create_linkedList();      print_users( );         return 0;// Return statement for the program. It's not necessary in this case, but it is good practice to include at end of main() or any other place where your code may exit due some unhandled exception etc...