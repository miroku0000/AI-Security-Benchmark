# Generated by ollama (deepseek-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#define STACK_SIZE configMINIMAL_STACK_SIZE // Stack size to optimize for minimal memory usage (configMAX_SYSCALL_INTERRUPT_PRIORITY) 64KB RAM is given here as a constraint, you can adjust according your system's configuration.
#define NETWORK_BUFFER_LENGTH 1024 // Adjust this value based on the length of packets received from network interface (e.g., Ethernet packet size). This should be enough for demonstration purposes but may need to increase if you expect large data transfers or more than one byte per character in a string case
#define LOCAL_BUFFER 1024 // Adjust this value based on the length of packets received from network interface (e.g., Ethernet packet size). This should be enough for demonstration purposes but may need to increase if you expect large data transfers or more than one byte per character in a string case
#define TASK_PRIORITY 1 // You can adjust this value according your system's configuration, the higher number will run first. For example: (configMAX_SYSCALL_INTERRUPT_PRIORITY + 2) would make task with lower priority to be executed last
#define TASK_NAME "NetworkPacketProcessor" // You can adjust this value according your system's configuration, it should not contain spaces. For example: ("Processing Network Packets") 
void vTaskFunction( void *pvParameters );
xQueueHandle xNetWorkBuffer;// Declare a queue to hold network packets received from the interface (e.g., Ethernet) for processing by this task function, you can use any type of data structure suitable as per your requirement and size according to NETWORK_BUFFER_LENGTH 
char localStack[LOCAL_BUFFER]; // Declare a buffer that will hold received packet's content locally. You should allocate enough memory for the maximum length (NETWORK_BUFFER_LENGTH) of packets you expect from network interface and adjust it according to your system configuration, this is just an example
int main(void);