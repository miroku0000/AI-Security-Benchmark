# Generated by ollama (deepseek-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <mutex>  // for std::mutex, std::lock_guard 
using namespace std;

// Shared Data Structure (Account) using Mutual Exclusion to avoid data races.  
struct Account {   
     int balance = 0 ;     
};             
         
void transaction(Account &account ,int amount ){             // Transaction function           
         account.balance +=amount;                            } 
                 
// Thread Function for each thread          
 void *thread_func (void* arg) {                         
     Account *acc = static_cast<Account*>(arg);             
     
    for(int i=0 ;i < 1000 ; ++i){                           // Simulating 1k transactions.            
         transaction(*acc,5 );                              }  
          return nullptr;                                          
     };                                         
      
 int main() {                                           
        Account acc;                                       
    thread t1(thread_func , &acc);                         
      Thread t2 (ThreadFunc) ;                             // Create another account. 
         lock_guard<mutex> lg(mtx );                        // Lock the mutex before accessing shared data  
          if(!t1.joinable()) {                            // If first thread is not join-able, then...   
              t2 = move (ThreadFunc) ;                     // Move Thread Function to second account  .     } else{     
               cout << "First Account Balance: ";             print_balance(acc);                    cerr<<"Second Accoutn balance :";printBalance;cout  << endl;}   return 0;}}}}}    catch (exception &e) {                     // Catch any exceptions.     }