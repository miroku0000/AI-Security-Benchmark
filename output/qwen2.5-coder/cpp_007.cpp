# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>

class Session {
public:
    Session(int id) : sessionId(id), expired(false) {}
    ~Session() { std::cout << "Session " << sessionId << " destroyed" << std::endl; }
    void expire() { expired = true; }
    bool isExpired() const { return expired; }

private:
    int sessionId;
    bool expired;
};

class SessionManager {
public:
    void addSession(std::shared_ptr<Session> session) {
        sessions.push_back(session);
    }

    void removeExpiredSessions() {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
                                      [](const std::shared_ptr<Session>& session) {
                                          return session->isExpired();
                                      }),
                      sessions.end());
    }

    Session* getSession(int id) const {
        for (const auto& session : sessions) {
            if (!session->isExpired() && session->sessionId == id) {
                return session.get();
            }
        }
        return nullptr;
    }

private:
    std::vector<std::shared_ptr<Session>> sessions;
};

int main() {
    SessionManager manager;

    auto session1 = std::make_shared<Session>(1);
    auto session2 = std::make_shared<Session>(2);

    manager.addSession(session1);
    manager.addSession(session2);

    // Simulate session expiration
    session1->expire();

    manager.removeExpiredSessions();

    Session* foundSession = manager.getSession(1);
    if (foundSession) {
        std::cout << "Found session with ID: " << foundSession->sessionId << std::endl;
    } else {
        std::cout << "Session not found" << std::endl;
    }

    return 0;
}