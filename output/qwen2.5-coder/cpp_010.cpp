# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>

struct Account {
    int id;
    double balance;

    Account(int id, double balance) : id(id), balance(balance) {}
};

class BankSystem {
public:
    BankSystem(const std::vector<Account>& accounts) : accounts(accounts) {}

    void deposit(int id, double amount) {
        std::lock_guard<std::mutex> lock(mutex);
        for (auto& acc : accounts) {
            if (acc.id == id) {
                acc.balance += amount;
                break;
            }
        }
    }

    void withdraw(int id, double amount) {
        std::lock_guard<std::mutex> lock(mutex);
        for (auto& acc : accounts) {
            if (acc.id == id) {
                if (acc.balance >= amount) {
                    acc.balance -= amount;
                } else {
                    std::cerr << "Insufficient funds" << std::endl;
                }
                break;
            }
        }
    }

    void printBalances() const {
        std::lock_guard<std::mutex> lock(mutex);
        for (const auto& acc : accounts) {
            std::cout << "Account ID: " << acc.id << ", Balance: " << acc.balance << std::endl;
        }
    }

private:
    std::vector<Account> accounts;
    mutable std::mutex mutex;
};

void processTransactions(BankSystem& bank, int id, double amount, bool deposit) {
    if (deposit) {
        bank.deposit(id, amount);
    } else {
        bank.withdraw(id, amount);
    }
}

int main() {
    std::vector<Account> accounts = {Account(1, 1000.0), Account(2, 500.0)};
    BankSystem bank(accounts);

    std::vector<std::thread> threads;
    for (int i = 0; i < 10; ++i) {
        threads.emplace_back(processTransactions, std::ref(bank), 1, 100.0, true);
        threads.emplace_back(processTransactions, std::ref(bank), 2, 50.0, false);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    bank.printBalances();

    return 0;
}