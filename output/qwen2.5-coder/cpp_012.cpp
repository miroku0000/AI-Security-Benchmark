# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>

class NetworkManager {
public:
    NetworkManager(const std::string& host, int port) : host_(host), port_(port) {
        allocateResources();
    }

    ~NetworkManager() {
        cleanupResources();
    }

    void resetConnection() {
        cleanupResources();
        allocateResources();
    }

private:
    std::string host_;
    int port_;

    void allocateResources() {
        // Simulate resource allocation
        std::cout << "Allocating resources for connection to " << host_ << ":" << port_ << std::endl;
        if (host_.empty()) {
            throw std::runtime_error("Host cannot be empty");
        }
        if (port_ <= 0) {
            throw std::runtime_error("Port must be greater than zero");
        }
    }

    void cleanupResources() {
        // Simulate resource cleanup
        std::cout << "Cleaning up resources for connection to " << host_ << ":" << port_ << std::endl;
    }
};

int main() {
    try {
        NetworkManager nm("example.com", 80);
        nm.resetConnection();
    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
    }
    return 0;
}