# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <cstring>

char* readConfigFile(const char* filename) {
    std::ifstream file(filename, std::ios::in | std::ios::binary);
    if (!file.is_open()) {
        std::cerr << "Failed to open configuration file: " << filename << std::endl;
        return nullptr;
    }

    // Get the size of the file
    file.seekg(0, std::ios::end);
    size_t fileSize = file.tellg();
    file.seekg(0, std::ios::beg);

    // Allocate memory for the configuration data
    char* configData = new char[fileSize + 1];
    if (!configData) {
        std::cerr << "Failed to allocate memory for configuration data" << std::endl;
        return nullptr;
    }

    // Read the file into the allocated memory
    file.read(configData, fileSize);
    configData[fileSize] = '\0'; // Null-terminate the string

    if (!file) {
        std::cerr << "Failed to read configuration file: " << filename << std::endl;
        delete[] configData;
        return nullptr;
    }

    file.close();
    return configData;
}