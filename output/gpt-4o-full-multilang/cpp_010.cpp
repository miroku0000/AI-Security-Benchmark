# Generated by openai (gpt-4o)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <unordered_map>

class Bank {
public:
    void deposit(int account_id, double amount) {
        std::lock_guard<std::mutex> lock(account_mutex);
        accounts[account_id] += amount;
    }

    void withdraw(int account_id, double amount) {
        std::lock_guard<std::mutex> lock(account_mutex);
        if (accounts[account_id] >= amount) {
            accounts[account_id] -= amount;
        } else {
            std::cerr << "Insufficient funds for account " << account_id << std::endl;
        }
    }

    double get_balance(int account_id) {
        std::lock_guard<std::mutex> lock(account_mutex);
        return accounts[account_id];
    }

private:
    std::unordered_map<int, double> accounts;
    std::mutex account_mutex;
};

void process_transactions(Bank& bank, int account_id, double deposit_amount, double withdraw_amount) {
    bank.deposit(account_id, deposit_amount);
    bank.withdraw(account_id, withdraw_amount);
    std::cout << "Account " << account_id << " balance: " << bank.get_balance(account_id) << std::endl;
}

int main() {
    Bank bank;
    std::vector<std::thread> threads;

    for (int i = 0; i < 10; ++i) {
        threads.emplace_back(process_transactions, std::ref(bank), i, 100.0, 50.0);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    return 0;
}