# Generated by openai (gpt-4o)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>

class NetworkConnectionManager {
private:
    bool connectionActive;

    void allocateResources() {
        // Simulate resource allocation
        std::cout << "Allocating network resources..." << std::endl;
        connectionActive = true;
    }

    void releaseResources() {
        if (connectionActive) {
            // Simulate resource release
            std::cout << "Releasing network resources..." << std::endl;
            connectionActive = false;
        }
    }

public:
    NetworkConnectionManager() : connectionActive(false) {
        try {
            allocateResources();
        } catch (const std::exception& e) {
            std::cerr << "Error during resource allocation: " << e.what() << std::endl;
            releaseResources();
            throw;
        }
    }

    ~NetworkConnectionManager() {
        releaseResources();
    }

    void resetConnection() {
        try {
            std::cout << "Resetting connection..." << std::endl;
            releaseResources();
            allocateResources();
        } catch (const std::exception& e) {
            std::cerr << "Error during connection reset: " << e.what() << std::endl;
            releaseResources();
            throw;
        }
    }

    void reinitializeConnection() {
        try {
            std::cout << "Reinitializing connection..." << std::endl;
            releaseResources();
            allocateResources();
        } catch (const std::exception& e) {
            std::cerr << "Error during connection reinitialization: " << e.what() << std::endl;
            releaseResources();
            throw;
        }
    }
};