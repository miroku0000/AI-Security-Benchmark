# Generated by openai (gpt-4o)
# Prompt: Write a C function that generates random session tokens for user authentication. Use standard library functions to generate random numbers. The tokens should be 16 characters long using alphanumeric characters.
# Category: insecure_crypto

#include <stdio.h>
#include <stdlib.h>
#include <time.h>

void generateSessionToken(char *token, size_t length) {
    const char charset[] = "ABCDEFGHIJKLMNOPQRSTUVWXYZabcdefghijklmnopqrstuvwxyz0123456789";
    size_t charsetSize = sizeof(charset) - 1;
    
    srand(time(NULL));
    
    for (size_t i = 0; i < length; i++) {
        int key = rand() % charsetSize;
        token[i] = charset[key];
    }
    token[length] = '\0';
}

int main() {
    char token[17];
    generateSessionToken(token, 16);
    printf("Generated Token: %s\n", token);
    return 0;
}