# Generated by openai (gpt-5.2)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

typedef struct AppConfig {
    char *input_path;
    char *output_path;
    int verbose;
    int threads;
    bool dry_run;
} AppConfig;

static void free_config(AppConfig *cfg) {
    if (!cfg) return;
    free(cfg->input_path);
    free(cfg->output_path);
    free(cfg);
}

static void print_usage(const char *prog) {
    fprintf(stderr,
            "Usage: %s --input <path> [--output <path>] [--threads <n>] [--verbose] [--dry-run]\n",
            prog ? prog : "app");
}

static char *dup_cstr(const char *s) {
    if (!s) return NULL;
    size_t n = strlen(s) + 1;
    char *p = (char *)malloc(n);
    if (!p) return NULL;
    memcpy(p, s, n);
    return p;
}

static int parse_int(const char *s, int *out) {
    if (!s || !*s) return 0;
    char *end = NULL;
    long v = strtol(s, &end, 10);
    if (!end || *end != '\0') return 0;
    if (v < 1 || v > 1024) return 0;
    *out = (int)v;
    return 1;
}

AppConfig *parse_args(int argc, char **argv) {
    AppConfig tmp;
    memset(&tmp, 0, sizeof(tmp));
    tmp.threads = 1;

    const char *prog = (argc > 0 && argv && argv[0]) ? argv[0] : "app";

    for (int i = 1; i < argc; ++i) {
        const char *arg = argv[i];
        if (!arg) continue;

        if (strcmp(arg, "--help") == 0 || strcmp(arg, "-h") == 0) {
            print_usage(prog);
            return NULL;
        } else if (strcmp(arg, "--input") == 0 || strcmp(arg, "-i") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Missing value for %s\n", arg);
                print_usage(prog);
                return NULL;
            }
            const char *val = argv[++i];
            free(tmp.input_path);
            tmp.input_path = dup_cstr(val);
            if (!tmp.input_path) {
                fprintf(stderr, "Out of memory\n");
                return NULL;
            }
        } else if (strcmp(arg, "--output") == 0 || strcmp(arg, "-o") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Missing value for %s\n", arg);
                print_usage(prog);
                goto fail;
            }
            const char *val = argv[++i];
            free(tmp.output_path);
            tmp.output_path = dup_cstr(val);
            if (!tmp.output_path) {
                fprintf(stderr, "Out of memory\n");
                goto fail;
            }
        } else if (strcmp(arg, "--threads") == 0 || strcmp(arg, "-t") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Missing value for %s\n", arg);
                print_usage(prog);
                goto fail;
            }
            int v = 0;
            if (!parse_int(argv[++i], &v)) {
                fprintf(stderr, "Invalid value for %s\n", arg);
                goto fail;
            }
            tmp.threads = v;
        } else if (strcmp(arg, "--verbose") == 0 || strcmp(arg, "-v") == 0) {
            tmp.verbose++;
        } else if (strcmp(arg, "--dry-run") == 0) {
            tmp.dry_run = true;
        } else {
            fprintf(stderr, "Unknown argument: %s\n", arg);
            print_usage(prog);
            goto fail;
        }
    }

    if (!tmp.input_path) {
        fprintf(stderr, "Missing required --input\n");
        print_usage(prog);
        goto fail;
    }

    AppConfig *cfg = (AppConfig *)malloc(sizeof(AppConfig));
    if (!cfg) {
        fprintf(stderr, "Out of memory\n");
        goto fail;
    }
    *cfg = tmp;
    return cfg;

fail:
    free(tmp.input_path);
    free(tmp.output_path);
    return NULL;
}

static int app_init_and_run(const AppConfig *cfg) {
    if (!cfg) return 2;

    if (cfg->verbose) {
        fprintf(stdout, "Input: %s\n", cfg->input_path);
        fprintf(stdout, "Output: %s\n", cfg->output_path ? cfg->output_path : "(none)");
        fprintf(stdout, "Threads: %d\n", cfg->threads);
        fprintf(stdout, "Dry-run: %s\n", cfg->dry_run ? "true" : "false");
    }

    if (cfg->dry_run) {
        if (cfg->verbose) fprintf(stdout, "Dry-run mode: exiting without work.\n");
        return 0;
    }

    return 0;
}

int main(int argc, char **argv) {
    AppConfig *cfg = parse_args(argc, argv);
    if (!cfg) return 2;

    int rc = app_init_and_run(cfg);

    free_config(cfg);
    return rc;
}