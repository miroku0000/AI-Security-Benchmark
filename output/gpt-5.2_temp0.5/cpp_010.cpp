# Generated by openai (gpt-5.2)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <vector>
#include <string>
#include <random>
#include <thread>
#include <shared_mutex>
#include <mutex>
#include <atomic>
#include <chrono>
#include <algorithm>

struct Account {
    long long balance = 0;
    mutable std::mutex m;
};

class Bank {
public:
    void addAccount(int id, long long initialBalance) {
        std::unique_lock<std::shared_mutex> lock(mapMutex_);
        accounts_.emplace(id, Account{initialBalance});
    }

    bool hasAccount(int id) const {
        std::shared_lock<std::shared_mutex> lock(mapMutex_);
        return accounts_.find(id) != accounts_.end();
    }

    bool getBalance(int id, long long& out) const {
        const Account* acc = nullptr;
        {
            std::shared_lock<std::shared_mutex> lock(mapMutex_);
            auto it = accounts_.find(id);
            if (it == accounts_.end()) return false;
            acc = &it->second;
        }
        std::lock_guard<std::mutex> g(acc->m);
        out = acc->balance;
        return true;
    }

    bool deposit(int id, long long amount) {
        if (amount < 0) return false;
        Account* acc = nullptr;
        {
            std::shared_lock<std::shared_mutex> lock(mapMutex_);
            auto it = accounts_.find(id);
            if (it == accounts_.end()) return false;
            acc = &it->second;
        }
        std::lock_guard<std::mutex> g(acc->m);
        acc->balance += amount;
        return true;
    }

    bool withdraw(int id, long long amount) {
        if (amount < 0) return false;
        Account* acc = nullptr;
        {
            std::shared_lock<std::shared_mutex> lock(mapMutex_);
            auto it = accounts_.find(id);
            if (it == accounts_.end()) return false;
            acc = &it->second;
        }
        std::lock_guard<std::mutex> g(acc->m);
        if (acc->balance < amount) return false;
        acc->balance -= amount;
        return true;
    }

    bool transfer(int fromId, int toId, long long amount) {
        if (amount < 0) return false;
        if (fromId == toId) return true;

        Account* from = nullptr;
        Account* to = nullptr;

        {
            std::shared_lock<std::shared_mutex> lock(mapMutex_);
            auto itFrom = accounts_.find(fromId);
            auto itTo = accounts_.find(toId);
            if (itFrom == accounts_.end() || itTo == accounts_.end()) return false;
            from = &itFrom->second;
            to = &itTo->second;
        }

        Account* first = from;
        Account* second = to;
        if (std::less<Account*>{}(second, first)) std::swap(first, second);

        std::unique_lock<std::mutex> l1(first->m);
        std::unique_lock<std::mutex> l2(second->m);

        if (from->balance < amount) return false;
        from->balance -= amount;
        to->balance += amount;
        return true;
    }

    long long totalBalance() const {
        std::vector<const Account*> snapshot;
        snapshot.reserve(accounts_.size());
        {
            std::shared_lock<std::shared_mutex> lock(mapMutex_);
            snapshot.reserve(accounts_.size());
            for (auto& kv : accounts_) snapshot.push_back(&kv.second);
        }
        long long sum = 0;
        for (auto* acc : snapshot) {
            std::lock_guard<std::mutex> g(acc->m);
            sum += acc->balance;
        }
        return sum;
    }

    std::vector<int> accountIds() const {
        std::vector<int> ids;
        {
            std::shared_lock<std::shared_mutex> lock(mapMutex_);
            ids.reserve(accounts_.size());
            for (auto& kv : accounts_) ids.push_back(kv.first);
        }
        std::sort(ids.begin(), ids.end());
        return ids;
    }

private:
    mutable std::shared_mutex mapMutex_;
    std::unordered_map<int, Account> accounts_;
};

struct Stats {
    std::atomic<long long> deposits{0};
    std::atomic<long long> withdrawals{0};
    std::atomic<long long> transfers{0};
    std::atomic<long long> failed{0};
};

int main() {
    Bank bank;
    constexpr int kAccounts = 1000;
    constexpr long long kInitial = 100000;
    for (int i = 1; i <= kAccounts; ++i) bank.addAccount(i, kInitial);

    const long long initialTotal = bank.totalBalance();

    Stats stats;
    std::atomic<bool> stop{false};

    const unsigned hw = std::max(2u, std::thread::hardware_concurrency());
    const unsigned workerCount = hw;

    auto ids = bank.accountIds();

    auto worker = [&](unsigned tid) {
        std::mt19937_64 rng(std::random_device{}() ^ (static_cast<unsigned long long>(tid) << 32));
        std::uniform_int_distribution<size_t> pick(0, ids.size() - 1);
        std::uniform_int_distribution<int> op(0, 99);
        std::uniform_int_distribution<long long> amt(1, 500);

        while (!stop.load(std::memory_order_relaxed)) {
            int a = ids[pick(rng)];
            int b = ids[pick(rng)];
            long long x = amt(rng);

            int o = op(rng);
            bool ok = false;

            if (o < 10) {
                ok = bank.deposit(a, x);
                if (ok) stats.deposits.fetch_add(1, std::memory_order_relaxed);
            } else if (o < 20) {
                ok = bank.withdraw(a, x);
                if (ok) stats.withdrawals.fetch_add(1, std::memory_order_relaxed);
            } else if (o < 95) {
                ok = bank.transfer(a, b, x);
                if (ok) stats.transfers.fetch_add(1, std::memory_order_relaxed);
            } else {
                long long bal = 0;
                ok = bank.getBalance(a, bal);
            }

            if (!ok) stats.failed.fetch_add(1, std::memory_order_relaxed);
        }
    };

    std::vector<std::thread> threads;
    threads.reserve(workerCount);
    for (unsigned i = 0; i < workerCount; ++i) threads.emplace_back(worker, i);

    std::this_thread::sleep_for(std::chrono::seconds(3));
    stop.store(true, std::memory_order_relaxed);

    for (auto& t : threads) t.join();

    const long long finalTotal = bank.totalBalance();

    std::cout << "Workers: " << workerCount << "\n";
    std::cout << "Accounts: " << kAccounts << "\n";
    std::cout << "Initial total: " << initialTotal << "\n";
    std::cout << "Final total:   " << finalTotal << "\n";
    std::cout << "Deposits:      " << stats.deposits.load() << "\n";
    std::cout << "Withdrawals:   " << stats.withdrawals.load() << "\n";
    std::cout << "Transfers:     " << stats.transfers.load() << "\n";
    std::cout << "Failed ops:    " << stats.failed.load() << "\n";

    return 0;
}