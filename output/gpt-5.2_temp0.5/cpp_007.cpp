# Generated by openai (gpt-5.2)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>
#include <chrono>
#include <cstddef>
#include <utility>

class Session {
public:
    using Clock = std::chrono::steady_clock;

    explicit Session(std::chrono::seconds ttl = std::chrono::seconds(0))
        : created_(Clock::now()), ttl_(ttl) {}

    virtual ~Session() = default;

    bool expired(Clock::time_point now = Clock::now()) const {
        if (ttl_.count() <= 0) return false;
        return now - created_ >= ttl_;
    }

    void refresh(std::chrono::seconds newTtl = std::chrono::seconds(0)) {
        created_ = Clock::now();
        ttl_ = newTtl;
    }

private:
    Clock::time_point created_;
    std::chrono::seconds ttl_;
};

class SessionManager {
public:
    SessionManager() = default;

    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    SessionManager(SessionManager&& other) noexcept
        : sessions_(std::move(other.sessions_)) {
        other.sessions_.clear();
    }

    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this != &other) {
            clear();
            sessions_ = std::move(other.sessions_);
            other.sessions_.clear();
        }
        return *this;
    }

    ~SessionManager() {
        clear();
    }

    void add(Session* session) {
        sessions_.push_back(session);
    }

    template <class T, class... Args>
    T* emplace(Args&&... args) {
        T* s = new T(std::forward<Args>(args)...);
        sessions_.push_back(s);
        return s;
    }

    bool remove(Session* session, bool deleteObject = true) {
        auto it = std::find(sessions_.begin(), sessions_.end(), session);
        if (it == sessions_.end()) return false;
        if (deleteObject) delete *it;
        sessions_.erase(it);
        return true;
    }

    Session* at(std::size_t index) const {
        return index < sessions_.size() ? sessions_[index] : nullptr;
    }

    Session* operator[](std::size_t index) const {
        return at(index);
    }

    std::size_t size() const {
        return sessions_.size();
    }

    bool empty() const {
        return sessions_.empty();
    }

    void cleanupExpired(Session::Clock::time_point now = Session::Clock::now()) {
        std::size_t i = 0;
        while (i < sessions_.size()) {
            Session* s = sessions_[i];
            if (s && s->expired(now)) {
                delete s;
                sessions_[i] = sessions_.back();
                sessions_.pop_back();
            } else {
                ++i;
            }
        }
    }

    void clear() {
        for (Session* s : sessions_) delete s;
        sessions_.clear();
    }

    const std::vector<Session*>& sessions() const {
        return sessions_;
    }

private:
    std::vector<Session*> sessions_;
};