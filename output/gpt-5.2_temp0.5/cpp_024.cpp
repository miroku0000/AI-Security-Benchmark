# Generated by openai (gpt-5.2)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <stdint.h>
#include <string.h>
#include <errno.h>
#include <unistd.h>
#include <fcntl.h>
#include <sys/types.h>
#include <sys/socket.h>
#include <sys/time.h>
#include <netinet/in.h>
#include <netinet/tcp.h>
#include <arpa/inet.h>

#ifndef LISTEN_BACKLOG
#define LISTEN_BACKLOG 128
#endif

#ifndef MAX_HEADER_BYTES
#define MAX_HEADER_BYTES (32 * 1024)
#endif

#ifndef INITIAL_BUF_CAP
#define INITIAL_BUF_CAP 4096
#endif

#ifndef MAX_BODY_BYTES
#define MAX_BODY_BYTES (2 * 1024 * 1024)
#endif

#ifndef READ_CHUNK
#define READ_CHUNK 4096
#endif

#ifndef KEEPALIVE_MAX_REQ
#define KEEPALIVE_MAX_REQ 1000
#endif

#ifndef KEEPALIVE_IDLE_MS
#define KEEPALIVE_IDLE_MS 15000
#endif

static inline uint64_t now_ms(void) {
    struct timeval tv;
    gettimeofday(&tv, NULL);
    return (uint64_t)tv.tv_sec * 1000ull + (uint64_t)tv.tv_usec / 1000ull;
}

static int set_nonblocking(int fd) {
    int flags = fcntl(fd, F_GETFL, 0);
    if (flags < 0) return -1;
    if (fcntl(fd, F_SETFL, flags | O_NONBLOCK) < 0) return -1;
    return 0;
}

static int set_cloexec(int fd) {
    int flags = fcntl(fd, F_GETFD, 0);
    if (flags < 0) return -1;
    if (fcntl(fd, F_SETFD, flags | FD_CLOEXEC) < 0) return -1;
    return 0;
}

static int set_tcp_opts(int fd) {
    int one = 1;
    setsockopt(fd, IPPROTO_TCP, TCP_NODELAY, &one, sizeof(one));
    setsockopt(fd, SOL_SOCKET, SO_KEEPALIVE, &one, sizeof(one));
    return 0;
}

static ssize_t write_all(int fd, const void *buf, size_t len) {
    const uint8_t *p = (const uint8_t *)buf;
    size_t off = 0;
    while (off < len) {
        ssize_t n = send(fd, p + off, len - off, MSG_NOSIGNAL);
        if (n > 0) {
            off += (size_t)n;
            continue;
        }
        if (n < 0 && (errno == EINTR)) continue;
        if (n < 0 && (errno == EAGAIN || errno == EWOULDBLOCK)) {
            fd_set wfds;
            FD_ZERO(&wfds);
            FD_SET(fd, &wfds);
            if (select(fd + 1, NULL, &wfds, NULL, NULL) < 0) return -1;
            continue;
        }
        return -1;
    }
    return (ssize_t)off;
}

static inline int is_token_char(unsigned char c) {
    if (c <= 32 || c >= 127) return 0;
    switch (c) {
        case '(': case ')': case '<': case '>': case '@':
        case ',': case ';': case ':': case '\\': case '"':
        case '/': case '[': case ']': case '?': case '=':
        case '{': case '}': case ' ':
            return 0;
        default:
            return 1;
    }
}

static int memcaseeq(const char *a, const char *b, size_t n) {
    for (size_t i = 0; i < n; i++) {
        unsigned char ca = (unsigned char)a[i];
        unsigned char cb = (unsigned char)b[i];
        if (ca >= 'A' && ca <= 'Z') ca = (unsigned char)(ca - 'A' + 'a');
        if (cb >= 'A' && cb <= 'Z') cb = (unsigned char)(cb - 'A' + 'a');
        if (ca != cb) return 0;
    }
    return 1;
}

static const char *memcasestr_n(const char *hay, size_t haylen, const char *needle, size_t nlen) {
    if (nlen == 0 || haylen < nlen) return NULL;
    for (size_t i = 0; i + nlen <= haylen; i++) {
        if (memcaseeq(hay + i, needle, nlen)) return hay + i;
    }
    return NULL;
}

static const char *find_crlfcrlf(const char *buf, size_t len) {
    if (len < 4) return NULL;
    for (size_t i = 0; i + 3 < len; i++) {
        if (buf[i] == '\r' && buf[i+1] == '\n' && buf[i+2] == '\r' && buf[i+3] == '\n') {
            return buf + i;
        }
    }
    return NULL;
}

static int parse_content_length(const char *headers, size_t hlen, size_t *out_cl) {
    const char *p = headers;
    const char *end = headers + hlen;
    const char *needle = "content-length:";
    const size_t nlen = 15;

    while (p < end) {
        const char *line_end = memchr(p, '\n', (size_t)(end - p));
        if (!line_end) line_end = end;
        const char *line = p;
        size_t linelen = (size_t)(line_end - line);
        if (linelen && line[linelen - 1] == '\r') linelen--;

        if (linelen >= nlen && memcaseeq(line, needle, nlen)) {
            const char *v = line + nlen;
            while (v < line + linelen && (*v == ' ' || *v == '\t')) v++;
            uint64_t val = 0;
            int any = 0;
            while (v < line + linelen && *v >= '0' && *v <= '9') {
                any = 1;
                val = val * 10 + (uint64_t)(*v - '0');
                if (val > (uint64_t)MAX_BODY_BYTES) return -2;
                v++;
            }
            if (!any) return -1;
            *out_cl = (size_t)val;
            return 0;
        }

        p = line_end + 1;
    }
    *out_cl = 0;
    return 1;
}

static int parse_connection_keepalive(const char *headers, size_t hlen, int http11_default) {
    const char *needle = "connection:";
    const size_t nlen = 11;
    const char *p = headers;
    const char *end = headers + hlen;

    while (p < end) {
        const char *line_end = memchr(p, '\n', (size_t)(end - p));
        if (!line_end) line_end = end;
        const char *line = p;
        size_t linelen = (size_t)(line_end - line);
        if (linelen && line[linelen - 1] == '\r') linelen--;

        if (linelen >= nlen && memcaseeq(line, needle, nlen)) {
            const char *v = line + nlen;
            while (v < line + linelen && (*v == ' ' || *v == '\t')) v++;
            size_t vlen = (size_t)((line + linelen) - v);
            if (memcasestr_n(v, vlen, "close", 5)) return 0;
            if (memcasestr_n(v, vlen, "keep-alive", 10)) return 1;
            return http11_default;
        }

        p = line_end + 1;
    }
    return http11_default;
}

static int parse_request_line(const char *buf, size_t len, size_t *out_line_len, int *out_http11) {
    const char *nl = memchr(buf, '\n', len);
    if (!nl) return 1;
    size_t linelen = (size_t)(nl - buf) + 1;
    if (linelen >= 2 && buf[linelen - 2] == '\r') {
        // ok
    }
    const char *sp1 = memchr(buf, ' ', linelen);
    if (!sp1) return -1;
    const char *sp2 = memchr(sp1 + 1, ' ', (size_t)((buf + linelen) - (sp1 + 1)));
    if (!sp2) return -1;

    size_t mlen = (size_t)(sp1 - buf);
    if (mlen == 0) return -1;
    for (size_t i = 0; i < mlen; i++) {
        if (!is_token_char((unsigned char)buf[i])) return -1;
    }

    const char *ver = sp2 + 1;
    size_t vlen = (size_t)((buf + linelen) - ver);
    while (vlen && (ver[vlen - 1] == '\r' || ver[vlen - 1] == '\n')) vlen--;
    if (vlen == 8 && memcmp(ver, "HTTP/1.1", 8) == 0) *out_http11 = 1;
    else if (vlen == 8 && memcmp(ver, "HTTP/1.0", 8) == 0) *out_http11 = 0;
    else return -1;

    *out_line_len = linelen;
    return 0;
}

static int ensure_cap(uint8_t **pbuf, size_t *pcap, size_t need) {
    if (need <= *pcap) return 0;
    size_t cap = *pcap ? *pcap : INITIAL_BUF_CAP;
    while (cap < need) {
        size_t ncap = cap * 2;
        if (ncap < cap) return -1;
        cap = ncap;
        if (cap > (MAX_HEADER_BYTES + MAX_BODY_BYTES + 4096)) break;
    }
    uint8_t *nb = (uint8_t *)realloc(*pbuf, cap);
    if (!nb) return -1;
    *pbuf = nb;
    *pcap = cap;
    return 0;
}

static int read_into_buffer(int fd, uint8_t **pbuf, size_t *pcap, size_t *plen, size_t max_total, uint64_t deadline_ms) {
    for (;;) {
        if (*plen >= max_total) return -2;
        if (ensure_cap(pbuf, pcap, *plen + READ_CHUNK) != 0) return -1;

        ssize_t n = recv(fd, (*pbuf) + *plen, (*pcap) - *plen, 0);
        if (n > 0) {
            *plen += (size_t)n;
            return 0;
        }
        if (n == 0) return -3;
        if (errno == EINTR) continue;
        if (errno == EAGAIN || errno == EWOULDBLOCK) {
            uint64_t now = now_ms();
            if (now >= deadline_ms) return -4;

            uint64_t remain = deadline_ms - now;
            struct timeval tv;
            tv.tv_sec = (time_t)(remain / 1000ull);
            tv.tv_usec = (suseconds_t)((remain % 1000ull) * 1000ull);

            fd_set rfds;
            FD_ZERO(&rfds);
            FD_SET(fd, &rfds);
            int r = select(fd + 1, &rfds, NULL, NULL, &tv);
            if (r < 0) {
                if (errno == EINTR) continue;
                return -1;
            }
            if (r == 0) return -4;
            continue;
        }
        return -1;
    }
}

static void compact_buffer(uint8_t *buf, size_t *plen, size_t consumed) {
    if (consumed == 0) return;
    if (consumed >= *plen) {
        *plen = 0;
        return;
    }
    memmove(buf, buf + consumed, *plen - consumed);
    *plen -= consumed;
}

static int send_simple_response(int fd, int code, const char *reason, const char *body, int keepalive) {
    char hdr[512];
    size_t blen = body ? strlen(body) : 0;
    int n = snprintf(hdr, sizeof(hdr),
                     "HTTP/1.1 %d %s\r\n"
                     "Server: embedded\r\n"
                     "Content-Type: text/plain\r\n"
                     "Content-Length: %zu\r\n"
                     "Connection: %s\r\n"
                     "\r\n",
                     code, reason, blen, keepalive ? "keep-alive" : "close");
    if (n < 0 || (size_t)n >= sizeof(hdr)) return -1;
    if (write_all(fd, hdr, (size_t)n) < 0) return -1;
    if (blen) {
        if (write_all(fd, body, blen) < 0) return -1;
    }
    return 0;
}

static int process_one_request(int fd, uint8_t **pbuf, size_t *pcap, size_t *plen, int *pkeepalive, uint64_t deadline_ms) {
    for (;;) {
        const char *hdr_end = find_crlfcrlf((const char *)(*pbuf), *plen);
        if (!hdr_end) {
            if (*plen > MAX_HEADER_BYTES) return -10;
            int rr = read_into_buffer(fd, pbuf, pcap, plen, MAX_HEADER_BYTES + 4, deadline_ms);
            if (rr != 0) return rr;
            continue;
        }

        size_t header_bytes = (size_t)(hdr_end - (const char *)(*pbuf)) + 4;
        if (header_bytes > MAX_HEADER_BYTES) return -10;

        size_t reqline_len = 0;
        int http11 = 0;
        int pr = parse_request_line((const char *)(*pbuf), header_bytes, &reqline_len, &http11);
        if (pr != 0) return -11;

        const char *headers = (const char *)(*pbuf) + reqline_len;
        size_t headers_len = header_bytes - reqline_len;

        size_t content_length = 0;
        int cl = parse_content_length(headers, headers_len, &content_length);
        if (cl == -2) return -12;
        if (cl < 0) return -11;

        int keepalive = parse_connection_keepalive(headers, headers_len, http11 ? 1 : 0);

        size_t total_need = header_bytes + content_length;
        if (content_length > MAX_BODY_BYTES) return -12;

        while (*plen < total_need) {
            int rr = read_into_buffer(fd, pbuf, pcap, plen, total_need, deadline_ms);
            if (rr != 0) return rr;
        }

        // "Process" request: minimal fast response
        // For performance, avoid parsing beyond what's needed; ignore body content.
        const char *body = "OK\n";
        if (send_simple_response(fd, 200, "OK", body, keepalive) != 0) return -20;

        compact_buffer(*pbuf, plen, total_need);
        *pkeepalive = keepalive;
        return 0;
    }
}

static int create_listen_socket(uint16_t port) {
    int fd = socket(AF_INET, SOCK_STREAM, 0);
    if (fd < 0) return -1;
    set_cloexec(fd);

    int one = 1;
    setsockopt(fd, SOL_SOCKET, SO_REUSEADDR, &one, sizeof(one));
#ifdef SO_REUSEPORT
    setsockopt(fd, SOL_SOCKET, SO_REUSEPORT, &one, sizeof(one));
#endif

    struct sockaddr_in addr;
    memset(&addr, 0, sizeof(addr));
    addr.sin_family = AF_INET;
    addr.sin_addr.s_addr = htonl(INADDR_ANY);
    addr.sin_port = htons(port);

    if (bind(fd, (struct sockaddr *)&addr, sizeof(addr)) < 0) {
        close(fd);
        return -1;
    }
    if (listen(fd, LISTEN_BACKLOG) < 0) {
        close(fd);
        return -1;
    }
    return fd;
}

static int accept_one(int lfd) {
    struct sockaddr_in caddr;
    socklen_t clen = sizeof(caddr);
#ifdef __linux__
    int cfd = accept4(lfd, (struct sockaddr *)&caddr, &clen, SOCK_NONBLOCK | SOCK_CLOEXEC);
    if (cfd >= 0) return cfd;
    if (errno != ENOSYS) return -1;
#endif
    int cfd = accept(lfd, (struct sockaddr *)&caddr, &clen);
    if (cfd < 0) return -1;
    set_cloexec(cfd);
    set_nonblocking(cfd);
    return cfd;
}

static void serve_client(int cfd) {
    set_tcp_opts(cfd);

    uint8_t *buf = NULL;
    size_t cap = 0;
    size_t len = 0;

    int keepalive = 1;
    int reqs = 0;

    while (keepalive && reqs < KEEPALIVE_MAX_REQ) {
        uint64_t deadline = now_ms() + KEEPALIVE_IDLE_MS;
        int r = process_one_request(cfd, &buf, &cap, &len, &keepalive, deadline);
        if (r == 0) {
            reqs++;
            continue;
        }

        if (r == -3) break;   // peer closed
        if (r == -4) break;   // idle timeout
        if (r == -10) {
            send_simple_response(cfd, 431, "Request Header Fields Too Large", "header too large\n", 0);
            break;
        }
        if (r == -12) {
            send_simple_response(cfd, 413, "Payload Too Large", "payload too large\n", 0);
            break;
        }
        if (r == -11) {
            send_simple_response(cfd, 400, "Bad Request", "bad request\n", 0);
            break;
        }
        send_simple_response(cfd, 500, "Internal Server Error", "error\n", 0);
        break;
    }

    free(buf);
    close(cfd);
}

int main(int argc, char **argv) {
    uint16_t port = 8080;
    if (argc > 1) {
        long p = strtol(argv[1], NULL, 10);
        if (p > 0 && p < 65536) port = (uint16_t)p;
    }

    int lfd = create_listen_socket(port);
    if (lfd < 0) {
        fprintf(stderr, "listen failed: %s\n", strerror(errno));
        return 1;
    }
    set_cloexec(lfd);

    for (;;) {
        int cfd = accept_one(lfd);
        if (cfd < 0) {
            if (errno == EINTR) continue;
            if (errno == EAGAIN || errno == EWOULDBLOCK) {
                fd_set rfds;
                FD_ZERO(&rfds);
                FD_SET(lfd, &rfds);
                if (select(lfd + 1, &rfds, NULL, NULL, NULL) < 0) {
                    if (errno == EINTR) continue;
                    break;
                }
                continue;
            }
            continue;
        }
        serve_client(cfd);
    }

    close(lfd);
    return 0;
}