# Generated by openai (gpt-5.2)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>

static void *cfg_realloc(void *p, size_t n) {
    void *q = realloc(p, n);
    return q;
}

char *read_config_file(const char *path, size_t *out_size) {
    if (out_size) *out_size = 0;
    if (!path) return NULL;

    FILE *f = fopen(path, "rb");
    if (!f) return NULL;

    char *buf = NULL;
    size_t len = 0;

#if defined(_WIN32) || defined(_WIN64)
    if (_fseeki64(f, 0, SEEK_END) == 0) {
        long long sz = _ftelli64(f);
        if (sz >= 0) {
            if (_fseeki64(f, 0, SEEK_SET) != 0) {
                fclose(f);
                return NULL;
            }
            size_t need = (size_t)sz;
            buf = (char *)malloc(need + 1);
            if (!buf) {
                fclose(f);
                return NULL;
            }
            size_t got = fread(buf, 1, need, f);
            if (got != need && ferror(f)) {
                free(buf);
                fclose(f);
                return NULL;
            }
            len = got;
            buf[len] = '\0';
            fclose(f);
            if (out_size) *out_size = len;
            return buf;
        }
        (void)_fseeki64(f, 0, SEEK_SET);
    }
#else
    if (fseeko(f, 0, SEEK_END) == 0) {
        off_t sz = ftello(f);
        if (sz >= 0) {
            if (fseeko(f, 0, SEEK_SET) != 0) {
                fclose(f);
                return NULL;
            }
            size_t need = (size_t)sz;
            buf = (char *)malloc(need + 1);
            if (!buf) {
                fclose(f);
                return NULL;
            }
            size_t got = fread(buf, 1, need, f);
            if (got != need && ferror(f)) {
                free(buf);
                fclose(f);
                return NULL;
            }
            len = got;
            buf[len] = '\0';
            fclose(f);
            if (out_size) *out_size = len;
            return buf;
        }
        (void)fseeko(f, 0, SEEK_SET);
    }
#endif

    size_t cap = 0;
    const size_t chunk = 64 * 1024;

    for (;;) {
        if (len + chunk + 1 > cap) {
            size_t newcap = cap ? cap : chunk;
            while (newcap < len + chunk + 1) {
                size_t prev = newcap;
                newcap = newcap + (newcap >> 1);
                if (newcap < prev) {
                    free(buf);
                    fclose(f);
                    return NULL;
                }
            }
            char *nb = (char *)cfg_realloc(buf, newcap);
            if (!nb) {
                free(buf);
                fclose(f);
                return NULL;
            }
            buf = nb;
            cap = newcap;
        }

        size_t n = fread(buf + len, 1, chunk, f);
        len += n;

        if (n < chunk) {
            if (ferror(f)) {
                free(buf);
                fclose(f);
                return NULL;
            }
            break;
        }
    }

    if (!buf) {
        buf = (char *)malloc(1);
        if (!buf) {
            fclose(f);
            return NULL;
        }
        buf[0] = '\0';
    } else {
        buf[len] = '\0';
        char *nb = (char *)cfg_realloc(buf, len + 1);
        if (nb) buf = nb;
    }

    fclose(f);
    if (out_size) *out_size = len;
    return buf;
}