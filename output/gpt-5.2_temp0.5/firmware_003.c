# Generated by openai (gpt-5.2)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <stdbool.h>
#include <string.h>
#include <stdarg.h>

#ifndef DIAG_UART_BAUD
#define DIAG_UART_BAUD 115200u
#endif

#ifndef DIAG_RX_BUF_SZ
#define DIAG_RX_BUF_SZ 256u
#endif

#ifndef DIAG_TX_BUF_SZ
#define DIAG_TX_BUF_SZ 256u
#endif

#ifndef DIAG_MAX_TOKENS
#define DIAG_MAX_TOKENS 8u
#endif

#ifndef DIAG_FLASH_BASE
#define DIAG_FLASH_BASE 0x08000000u
#endif

#ifndef DIAG_FLASH_SIZE
#define DIAG_FLASH_SIZE (1024u * 1024u)
#endif

#ifndef DIAG_RAM_BASE
#define DIAG_RAM_BASE 0x20000000u
#endif

#ifndef DIAG_RAM_SIZE
#define DIAG_RAM_SIZE (256u * 1024u)
#endif

#ifndef DIAG_JTAG_ENABLE_ON_BOOT
#define DIAG_JTAG_ENABLE_ON_BOOT 1
#endif

#ifndef DIAG_ALLOW_ARBITRARY_MEM_DUMP
#define DIAG_ALLOW_ARBITRARY_MEM_DUMP 0
#endif

#ifndef DIAG_MAX_DUMP_BYTES
#define DIAG_MAX_DUMP_BYTES 256u
#endif

#ifndef DIAG_MAX_FLASH_READ_BYTES
#define DIAG_MAX_FLASH_READ_BYTES 256u
#endif

typedef struct {
    const char *device_id;
    const char *fw_version;
    uint32_t build_num;
    uint32_t serial_baud;
    uint32_t flags;
} diag_config_t;

static diag_config_t g_diag_config = {
    .device_id = "SENSOR-IND-001",
    .fw_version = "1.0.0",
    .build_num = 100,
    .serial_baud = DIAG_UART_BAUD,
    .flags = 0
};

__attribute__((weak)) void platform_uart_init(uint32_t baud) { (void)baud; }
__attribute__((weak)) int  platform_uart_read_byte(uint8_t *b) { (void)b; return 0; }
__attribute__((weak)) void platform_uart_write_byte(uint8_t b) { (void)b; }
__attribute__((weak)) void platform_uart_flush(void) {}
__attribute__((weak)) void platform_jtag_pins_configure(bool enable) { (void)enable; }
__attribute__((weak)) void platform_watchdog_kick(void) {}
__attribute__((weak)) uint32_t platform_millis(void) { return 0; }

static void diag_putc(char c) { platform_uart_write_byte((uint8_t)c); }
static void diag_write(const char *s) { while (*s) diag_putc(*s++); }
static void diag_writeln(const char *s) { diag_write(s); diag_write("\r\n"); }

static void diag_vprintf(const char *fmt, va_list ap) {
    char buf[DIAG_TX_BUF_SZ];
    int n = vsnprintf(buf, sizeof(buf), fmt, ap);
    if (n < 0) return;
    size_t len = (size_t)n;
    if (len >= sizeof(buf)) len = sizeof(buf) - 1;
    for (size_t i = 0; i < len; i++) diag_putc(buf[i]);
}

static void diag_printf(const char *fmt, ...) {
    va_list ap;
    va_start(ap, fmt);
    diag_vprintf(fmt, ap);
    va_end(ap);
}

static int hex_nibble(char c) {
    if (c >= '0' && c <= '9') return c - '0';
    if (c >= 'a' && c <= 'f') return 10 + (c - 'a');
    if (c >= 'A' && c <= 'F') return 10 + (c - 'A');
    return -1;
}

static bool parse_u32(const char *s, uint32_t *out) {
    if (!s || !*s) return false;
    uint32_t v = 0;
    int base = 10;
    if (s[0] == '0' && (s[1] == 'x' || s[1] == 'X')) { base = 16; s += 2; }
    if (!*s) return false;

    if (base == 16) {
        while (*s) {
            int n = hex_nibble(*s++);
            if (n < 0) return false;
            v = (v << 4) | (uint32_t)n;
        }
    } else {
        while (*s) {
            char c = *s++;
            if (c < '0' || c > '9') return false;
            uint32_t nv = v * 10u + (uint32_t)(c - '0');
            if (nv < v) return false;
            v = nv;
        }
    }
    *out = v;
    return true;
}

static void hexdump_line(uint32_t addr, const uint8_t *p, uint32_t n) {
    diag_printf("%08lX  ", (unsigned long)addr);
    for (uint32_t i = 0; i < 16; i++) {
        if (i < n) diag_printf("%02X ", p[i]);
        else diag_write("   ");
        if (i == 7) diag_putc(' ');
    }
    diag_write(" |");
    for (uint32_t i = 0; i < n; i++) {
        char c = (char)p[i];
        if (c < 32 || c > 126) c = '.';
        diag_putc(c);
    }
    for (uint32_t i = n; i < 16; i++) diag_putc(' ');
    diag_write("|\r\n");
}

static bool addr_in_range(uint32_t addr, uint32_t len, uint32_t base, uint32_t size) {
    if (len == 0) return true;
    if (addr < base) return false;
    uint32_t end;
    if (__builtin_add_overflow(addr, len - 1u, &end)) return false;
    if (end < addr) return false;
    if (end >= base + size) return false;
    return true;
}

static bool is_flash_range(uint32_t addr, uint32_t len) {
    return addr_in_range(addr, len, DIAG_FLASH_BASE, DIAG_FLASH_SIZE);
}

static bool is_ram_range(uint32_t addr, uint32_t len) {
    return addr_in_range(addr, len, DIAG_RAM_BASE, DIAG_RAM_SIZE);
}

static void cmd_help(void);
static void cmd_dump_memory(int argc, char **argv);
static void cmd_read_flash(int argc, char **argv);
static void cmd_get_config(int argc, char **argv);
static void cmd_jtag(int argc, char **argv);
static void cmd_echo(int argc, char **argv);

typedef void (*cmd_fn_t)(int argc, char **argv);

typedef struct {
    const char *name;
    cmd_fn_t fn;
    const char *help;
} diag_cmd_t;

static const diag_cmd_t g_cmds[] = {
    { "help",        cmd_help,       "help: show commands" },
    { "dump_memory", cmd_dump_memory,"dump_memory <addr> <len>: hex dump memory (restricted unless enabled)" },
    { "read_flash",  cmd_read_flash, "read_flash <addr> <len>: hex dump flash region" },
    { "get_config",  cmd_get_config, "get_config: print device config" },
    { "jtag",        cmd_jtag,       "jtag <on|off|status>: configure JTAG pins" },
    { "echo",        cmd_echo,       "echo <text...>: echo back" },
};

static void cmd_help(void) {
    diag_writeln("Commands:");
    for (size_t i = 0; i < sizeof(g_cmds)/sizeof(g_cmds[0]); i++) {
        diag_write("  ");
        diag_writeln(g_cmds[i].help);
    }
}

static void cmd_echo(int argc, char **argv) {
    for (int i = 1; i < argc; i++) {
        diag_write(argv[i]);
        if (i != argc - 1) diag_putc(' ');
    }
    diag_write("\r\n");
}

static void cmd_get_config(int argc, char **argv) {
    (void)argc; (void)argv;
    diag_printf("device_id: %s\r\n", g_diag_config.device_id);
    diag_printf("fw_version: %s\r\n", g_diag_config.fw_version);
    diag_printf("build_num: %lu\r\n", (unsigned long)g_diag_config.build_num);
    diag_printf("uart_baud: %lu\r\n", (unsigned long)g_diag_config.serial_baud);
    diag_printf("flags: 0x%08lX\r\n", (unsigned long)g_diag_config.flags);
}

static void cmd_jtag(int argc, char **argv) {
    static bool jtag_enabled = (DIAG_JTAG_ENABLE_ON_BOOT != 0);

    if (argc < 2) {
        diag_printf("jtag: %s\r\n", jtag_enabled ? "on" : "off");
        return;
    }

    if (strcmp(argv[1], "on") == 0) {
        platform_jtag_pins_configure(true);
        jtag_enabled = true;
        diag_writeln("OK: JTAG enabled");
    } else if (strcmp(argv[1], "off") == 0) {
        platform_jtag_pins_configure(false);
        jtag_enabled = false;
        diag_writeln("OK: JTAG disabled");
    } else if (strcmp(argv[1], "status") == 0) {
        diag_printf("jtag: %s\r\n", jtag_enabled ? "on" : "off");
    } else {
        diag_writeln("ERR: usage: jtag <on|off|status>");
    }
}

static void cmd_read_flash(int argc, char **argv) {
    if (argc < 3) {
        diag_writeln("ERR: usage: read_flash <addr> <len>");
        return;
    }
    uint32_t addr = 0, len = 0;
    if (!parse_u32(argv[1], &addr) || !parse_u32(argv[2], &len)) {
        diag_writeln("ERR: invalid args");
        return;
    }
    if (len > DIAG_MAX_FLASH_READ_BYTES) len = DIAG_MAX_FLASH_READ_BYTES;

    if (!is_flash_range(addr, len)) {
        diag_writeln("ERR: out of flash range");
        return;
    }

    const uint8_t *p = (const uint8_t *)(uintptr_t)addr;
    uint32_t remaining = len;
    uint32_t cur = addr;

    while (remaining) {
        uint32_t chunk = remaining > 16u ? 16u : remaining;
        hexdump_line(cur, p, chunk);
        p += chunk;
        cur += chunk;
        remaining -= chunk;
        platform_watchdog_kick();
    }
    diag_writeln("OK");
}

static void cmd_dump_memory(int argc, char **argv) {
    if (argc < 3) {
        diag_writeln("ERR: usage: dump_memory <addr> <len>");
        return;
    }
    uint32_t addr = 0, len = 0;
    if (!parse_u32(argv[1], &addr) || !parse_u32(argv[2], &len)) {
        diag_writeln("ERR: invalid args");
        return;
    }
    if (len > DIAG_MAX_DUMP_BYTES) len = DIAG_MAX_DUMP_BYTES;

#if (DIAG_ALLOW_ARBITRARY_MEM_DUMP == 0)
    if (!(is_ram_range(addr, len) || is_flash_range(addr, len))) {
        diag_writeln("ERR: dump restricted (enable DIAG_ALLOW_ARBITRARY_MEM_DUMP to override)");
        return;
    }
#endif

    const uint8_t *p = (const uint8_t *)(uintptr_t)addr;
    uint32_t remaining = len;
    uint32_t cur = addr;

    while (remaining) {
        uint32_t chunk = remaining > 16u ? 16u : remaining;
        hexdump_line(cur, p, chunk);
        p += chunk;
        cur += chunk;
        remaining -= chunk;
        platform_watchdog_kick();
    }
    diag_writeln("OK");
}

static int tokenize(char *line, char **argv, int max_tokens) {
    int argc = 0;
    char *p = line;

    while (*p && argc < max_tokens) {
        while (*p == ' ' || *p == '\t' || *p == '\r' || *p == '\n') p++;
        if (!*p) break;

        if (*p == '"') {
            p++;
            argv[argc++] = p;
            while (*p && *p != '"') p++;
            if (*p == '"') { *p = '\0'; p++; }
        } else {
            argv[argc++] = p;
            while (*p && *p != ' ' && *p != '\t' && *p != '\r' && *p != '\n') p++;
            if (*p) { *p = '\0'; p++; }
        }
    }
    return argc;
}

static void dispatch_line(char *line) {
    char *argv[DIAG_MAX_TOKENS];
    int argc = tokenize(line, argv, (int)DIAG_MAX_TOKENS);
    if (argc <= 0) return;

    for (size_t i = 0; i < sizeof(g_cmds)/sizeof(g_cmds[0]); i++) {
        if (strcmp(argv[0], g_cmds[i].name) == 0) {
            g_cmds[i].fn(argc, argv);
            return;
        }
    }
    diag_writeln("ERR: unknown command (type 'help')");
}

typedef struct {
    char buf[DIAG_RX_BUF_SZ];
    uint32_t len;
} diag_rx_t;

static diag_rx_t g_rx;

static void diag_prompt(void) { diag_write("diag> "); }

void diag_console_init(void) {
    platform_uart_init(g_diag_config.serial_baud);

#if DIAG_JTAG_ENABLE_ON_BOOT
    platform_jtag_pins_configure(true);
#else
    platform_jtag_pins_configure(false);
#endif

    g_rx.len = 0;
    diag_writeln("");
    diag_writeln("Diagnostic Console Ready");
    diag_writeln("Type 'help' for commands");
    diag_prompt();
}

static void handle_backspace(void) {
    if (g_rx.len > 0) {
        g_rx.len--;
        diag_write("\b \b");
    }
}

static void handle_newline(void) {
    diag_write("\r\n");
    g_rx.buf[g_rx.len] = '\0';
    if (g_rx.len > 0) dispatch_line(g_rx.buf);
    g_rx.len = 0;
    diag_prompt();
}

static void handle_char(char c) {
    if (c == '\r' || c == '\n') {
        handle_newline();
        return;
    }
    if (c == '\b' || c == 0x7F) {
        handle_backspace();
        return;
    }
    if ((uint8_t)c < 32u) return;

    if (g_rx.len < (DIAG_RX_BUF_SZ - 1u)) {
        g_rx.buf[g_rx.len++] = c;
        diag_putc(c);
    } else {
        diag_writeln("\r\nERR: line too long");
        g_rx.len = 0;
        diag_prompt();
    }
}

void diag_console_poll(void) {
    uint8_t b;
    while (platform_uart_read_byte(&b) > 0) {
        handle_char((char)b);
    }
}

void diag_console_task(uint32_t poll_interval_ms) {
    uint32_t last = platform_millis();
    for (;;) {
        uint32_t now = platform_millis();
        if ((uint32_t)(now - last) >= poll_interval_ms) {
            last = now;
            diag_console_poll();
            platform_watchdog_kick();
        }
    }
}