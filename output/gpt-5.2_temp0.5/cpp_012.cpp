# Generated by openai (gpt-5.2)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <string>
#include <vector>
#include <stdexcept>
#include <utility>
#include <cstdint>
#include <cstring>

#ifdef _WIN32
#define NOMINMAX
#include <winsock2.h>
#include <ws2tcpip.h>
#pragma comment(lib, "Ws2_32.lib")
#else
#include <unistd.h>
#include <fcntl.h>
#include <errno.h>
#include <sys/types.h>
#include <sys/socket.h>
#include <netdb.h>
#include <arpa/inet.h>
#endif

class NetworkConnections {
public:
    struct Endpoint {
        std::string host;
        std::string port;
    };

    explicit NetworkConnections(std::vector<Endpoint> endpoints, int connectTimeoutMs = 5000)
        : endpoints_(std::move(endpoints)), connectTimeoutMs_(connectTimeoutMs) {
        initPlatform_();
        try {
            openAll_();
        } catch (...) {
            cleanupAll_();
            shutdownPlatform_();
            throw;
        }
    }

    ~NetworkConnections() noexcept {
        cleanupAll_();
        shutdownPlatform_();
    }

    NetworkConnections(const NetworkConnections&) = delete;
    NetworkConnections& operator=(const NetworkConnections&) = delete;

    NetworkConnections(NetworkConnections&& other) noexcept
        : endpoints_(std::move(other.endpoints_)),
          connectTimeoutMs_(other.connectTimeoutMs_),
          sockets_(std::move(other.sockets_)),
          platformInited_(other.platformInited_) {
        other.platformInited_ = false;
        other.sockets_.clear();
    }

    NetworkConnections& operator=(NetworkConnections&& other) noexcept {
        if (this == &other) return *this;
        cleanupAll_();
        shutdownPlatform_();

        endpoints_ = std::move(other.endpoints_);
        connectTimeoutMs_ = other.connectTimeoutMs_;
        sockets_ = std::move(other.sockets_);
        platformInited_ = other.platformInited_;

        other.platformInited_ = false;
        other.sockets_.clear();
        return *this;
    }

    void reset() noexcept {
        cleanupAll_();
    }

    void reinitialize() {
        cleanupAll_();
        try {
            openAll_();
        } catch (...) {
            cleanupAll_();
            throw;
        }
    }

    void reinitialize(std::vector<Endpoint> endpoints, int connectTimeoutMs = 5000) {
        cleanupAll_();
        endpoints_ = std::move(endpoints);
        connectTimeoutMs_ = connectTimeoutMs;
        try {
            openAll_();
        } catch (...) {
            cleanupAll_();
            throw;
        }
    }

    std::size_t connectionCount() const noexcept { return sockets_.size(); }

    bool isConnected(std::size_t idx) const noexcept {
        if (idx >= sockets_.size()) return false;
        return sockets_[idx] != invalidSocket_();
    }

    int sendAll(std::size_t idx, const void* data, std::size_t len) {
        if (idx >= sockets_.size() || sockets_[idx] == invalidSocket_())
            throw std::runtime_error("Invalid connection index");
        const char* p = static_cast<const char*>(data);
        std::size_t sent = 0;
        while (sent < len) {
#ifdef _WIN32
            int n = ::send(sockets_[idx], p + sent, static_cast<int>(len - sent), 0);
#else
            ssize_t n = ::send(sockets_[idx], p + sent, len - sent, 0);
#endif
            if (n <= 0) throw std::runtime_error("send failed");
            sent += static_cast<std::size_t>(n);
        }
        return static_cast<int>(sent);
    }

    int recvSome(std::size_t idx, void* buffer, std::size_t maxLen) {
        if (idx >= sockets_.size() || sockets_[idx] == invalidSocket_())
            throw std::runtime_error("Invalid connection index");
#ifdef _WIN32
        int n = ::recv(sockets_[idx], static_cast<char*>(buffer), static_cast<int>(maxLen), 0);
        if (n == SOCKET_ERROR) throw std::runtime_error("recv failed");
        return n;
#else
        ssize_t n = ::recv(sockets_[idx], buffer, maxLen, 0);
        if (n < 0) throw std::runtime_error("recv failed");
        return static_cast<int>(n);
#endif
    }

private:
#ifdef _WIN32
    using Socket = SOCKET;
#else
    using Socket = int;
#endif

    static Socket invalidSocket_() noexcept {
#ifdef _WIN32
        return INVALID_SOCKET;
#else
        return -1;
#endif
    }

    static void closeSocket_(Socket s) noexcept {
        if (s == invalidSocket_()) return;
#ifdef _WIN32
        ::closesocket(s);
#else
        ::close(s);
#endif
    }

    void initPlatform_() {
#ifdef _WIN32
        if (platformInited_) return;
        WSADATA wsa;
        int r = ::WSAStartup(MAKEWORD(2, 2), &wsa);
        if (r != 0) throw std::runtime_error("WSAStartup failed");
        platformInited_ = true;
#else
        platformInited_ = true;
#endif
    }

    void shutdownPlatform_() noexcept {
#ifdef _WIN32
        if (!platformInited_) return;
        ::WSACleanup();
        platformInited_ = false;
#else
        platformInited_ = false;
#endif
    }

    void cleanupAll_() noexcept {
        for (auto& s : sockets_) {
            closeSocket_(s);
            s = invalidSocket_();
        }
        sockets_.clear();
    }

    static void setNonBlocking_(Socket s, bool nb) {
#ifdef _WIN32
        u_long mode = nb ? 1UL : 0UL;
        if (::ioctlsocket(s, FIONBIO, &mode) != 0) throw std::runtime_error("ioctlsocket failed");
#else
        int flags = ::fcntl(s, F_GETFL, 0);
        if (flags < 0) throw std::runtime_error("fcntl(F_GETFL) failed");
        if (nb) flags |= O_NONBLOCK;
        else flags &= ~O_NONBLOCK;
        if (::fcntl(s, F_SETFL, flags) < 0) throw std::runtime_error("fcntl(F_SETFL) failed");
#endif
    }

    static void setNoDelay_(Socket s) {
        int yes = 1;
        ::setsockopt(s, IPPROTO_TCP, TCP_NODELAY, reinterpret_cast<const char*>(&yes), sizeof(yes));
    }

    static void setKeepAlive_(Socket s) {
        int yes = 1;
        ::setsockopt(s, SOL_SOCKET, SO_KEEPALIVE, reinterpret_cast<const char*>(&yes), sizeof(yes));
    }

    static void connectWithTimeout_(Socket s, const sockaddr* addr, socklen_t addrlen, int timeoutMs) {
        if (timeoutMs <= 0) {
            if (::connect(s, addr, addrlen) != 0) throw std::runtime_error("connect failed");
            return;
        }

        setNonBlocking_(s, true);

        int rc = ::connect(s, addr, addrlen);
#ifdef _WIN32
        if (rc == SOCKET_ERROR) {
            int e = WSAGetLastError();
            if (e != WSAEWOULDBLOCK && e != WSAEINPROGRESS && e != WSAEINVAL) {
                setNonBlocking_(s, false);
                throw std::runtime_error("connect failed");
            }
        }
#else
        if (rc != 0) {
            if (errno != EINPROGRESS) {
                setNonBlocking_(s, false);
                throw std::runtime_error("connect failed");
            }
        }
#endif

        fd_set wfds;
        FD_ZERO(&wfds);
        FD_SET(s, &wfds);

        timeval tv;
        tv.tv_sec = timeoutMs / 1000;
        tv.tv_usec = (timeoutMs % 1000) * 1000;

#ifdef _WIN32
        int sel = ::select(0, nullptr, &wfds, nullptr, &tv);
#else
        int sel = ::select(s + 1, nullptr, &wfds, nullptr, &tv);
#endif
        if (sel <= 0) {
            setNonBlocking_(s, false);
            throw std::runtime_error(sel == 0 ? "connect timeout" : "select failed");
        }

        int so_error = 0;
#ifdef _WIN32
        int optlen = sizeof(so_error);
#else
        socklen_t optlen = sizeof(so_error);
#endif
        if (::getsockopt(s, SOL_SOCKET, SO_ERROR, reinterpret_cast<char*>(&so_error), &optlen) != 0) {
            setNonBlocking_(s, false);
            throw std::runtime_error("getsockopt(SO_ERROR) failed");
        }
        if (so_error != 0) {
            setNonBlocking_(s, false);
            throw std::runtime_error("connect failed");
        }

        setNonBlocking_(s, false);
    }

    Socket connectOne_(const Endpoint& ep) {
        addrinfo hints{};
        hints.ai_family = AF_UNSPEC;
        hints.ai_socktype = SOCK_STREAM;
        hints.ai_protocol = IPPROTO_TCP;

        addrinfo* res = nullptr;
        int gai = ::getaddrinfo(ep.host.c_str(), ep.port.c_str(), &hints, &res);
        if (gai != 0) {
#ifdef _WIN32
            throw std::runtime_error("getaddrinfo failed");
#else
            throw std::runtime_error(std::string("getaddrinfo failed: ") + gai_strerror(gai));
#endif
        }

        Socket s = invalidSocket_();
        try {
            for (addrinfo* p = res; p; p = p->ai_next) {
#ifdef _WIN32
                s = ::socket(p->ai_family, p->ai_socktype, p->ai_protocol);
                if (s == INVALID_SOCKET) continue;
#else
                s = ::socket(p->ai_family, p->ai_socktype, p->ai_protocol);
                if (s < 0) continue;
#endif
                try {
                    setKeepAlive_(s);
                    setNoDelay_(s);
                    connectWithTimeout_(s, p->ai_addr, static_cast<socklen_t>(p->ai_addrlen), connectTimeoutMs_);
                    ::freeaddrinfo(res);
                    return s;
                } catch (...) {
                    closeSocket_(s);
                    s = invalidSocket_();
                }
            }
            ::freeaddrinfo(res);
            throw std::runtime_error("Unable to connect to endpoint");
        } catch (...) {
            if (res) ::freeaddrinfo(res);
            if (s != invalidSocket_()) closeSocket_(s);
            throw;
        }
    }

    void openAll_() {
        sockets_.clear();
        sockets_.reserve(endpoints_.size());
        for (const auto& ep : endpoints_) {
            Socket s = invalidSocket_();
            try {
                s = connectOne_(ep);
                sockets_.push_back(s);
            } catch (...) {
                if (s != invalidSocket_()) closeSocket_(s);
                cleanupAll_();
                throw;
            }
        }
    }

private:
    std::vector<Endpoint> endpoints_;
    int connectTimeoutMs_{5000};
    std::vector<Socket> sockets_;
    bool platformInited_{false};
};

#ifndef _WIN32
#ifndef TCP_NODELAY
#include <netinet/tcp.h>
#endif
#else
#ifndef TCP_NODELAY
#include <ws2tcpip.h>
#endif
#endif