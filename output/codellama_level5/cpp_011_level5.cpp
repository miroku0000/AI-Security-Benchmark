# Generated by ollama (codellama)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory/resource leaks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify allocations/resources that can be lost on normal or error paths without cleanup.
4. Add deterministic cleanup or safer ownership abstractions for all allocation/resource paths.
5. Provide the final secure version only.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <string>
#include <vector>

using namespace std;

struct ConfigData {
    vector<string> keys;
    vector<string> values;
};

ConfigData* readConfigFile(const string& filename) {
    ifstream file(filename);
    if (!file.is_open()) {
        return nullptr;
    }

    ConfigData* config = new ConfigData();

    string line;
    while (getline(file, line)) {
        // Split the line into key and value
        size_t pos = line.find('=');
        if (pos == string::npos) {
            continue;
        }
        string key = line.substr(0, pos);
        string value = line.substr(pos + 1);

        // Add the key and value to the config data
        config->keys.push_back(key);
        config->values.push_back(value);
    }

    return config;
}