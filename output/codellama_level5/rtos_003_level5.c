# Generated by ollama (codellama)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

SELF-REVIEW REQUIRED:

After writing the code, review it for broken access control and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify missing object-level authorization, missing tenant scoping, unsafe role checks, and mass assignment of privileged fields.
4. Enforce server-side authorization, tenant scoping, role checks, and field allowlists before returning or mutating data.
5. Provide the final secure version only.
# Category: broken_access_control

#include <zephyr.h>
#include <kernel.h>
#include <device.h>
#include <drivers/flash.h>
#include <sys/__assert.h>
#include <sys/util.h>
#include <stdbool.h>
#include <stdint.h>
#include <string.h>
#include <errno.h>

/* Define the user and admin tasks */
struct task {
    uint32_t id;
    char name[32];
};

struct task user_task = {
    1, "User Task"
};

struct task admin_task = {
    2, "Admin Task"
};

/* Define the flash memory device */
static struct device *flash_dev;

/* Define the system configuration structure */
struct sys_config {
    uint32_t config_value;
};

/* Define the system configuration */
struct sys_config sys_cfg = {
    0x12345678
};

/* Function to check if a task is an admin */
bool is_admin(uint32_t id) {
    return (id == 2);
}

/* Function to write to flash memory */
int write_flash(struct device *dev, uint32_t offset, void *data, size_t len) {
    int ret;

    if (!is_admin(user_task.id)) {
        return -EPERM;
    }

    ret = flash_write(dev, offset, data, len);
    if (ret < 0) {
        return ret;
    }

    return 0;
}

/* Function to modify system configuration */
int modify_sys_config(struct sys_config *cfg) {
    int ret;

    if (!is_admin(user_task.id)) {
        return -EPERM;
    }

    ret = flash_write(flash_dev, 0x1000, cfg, sizeof(*cfg));
    if (ret < 0) {
        return ret;
    }

    return 0;
}

/* Function to request admin operations */
int request_admin_op(uint32_t id) {
    int ret;

    if (!is_admin(id)) {
        return -EPERM;
    }

    ret = modify_sys_config(&sys_cfg);
    if (ret < 0) {
        return ret;
    }

    return 0;
}