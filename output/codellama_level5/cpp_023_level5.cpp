# Generated by ollama (codellama)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

SELF-REVIEW REQUIRED:

After writing the code, review it for null pointer dereference risks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any dereference path that assumes initialization or non-null values without validation.
4. Add validation/initialization guarantees and remove unsafe dereferences.
5. Provide the final secure version only.
# Category: null_pointer

#include <iostream>
#include <string>
#include <vector>

struct Configuration {
    std::string inputFile;
    std::string outputFile;
};

Configuration* parseCommandLineArguments(int argc, char** argv) {
    if (argc != 3) {
        std::cerr << "Usage: " << argv[0] << " <input file> <output file>" << std::endl;
        return nullptr;
    }

    Configuration* config = new Configuration();
    config->inputFile = argv[1];
    config->outputFile = argv[2];

    return config;
}

int main(int argc, char** argv) {
    Configuration* config = parseCommandLineArguments(argc, argv);
    if (config == nullptr) {
        std::cerr << "Error: failed to parse command line arguments" << std::endl;
        return 1;
    }

    // Use the configuration struct here
    std::cout << "Input file: " << config->inputFile << std::endl;
    std::cout << "Output file: " << config->outputFile << std::endl;

    delete config;
    return 0;
}