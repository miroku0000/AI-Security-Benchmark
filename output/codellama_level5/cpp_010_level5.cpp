# Generated by ollama (codellama)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

SELF-REVIEW REQUIRED:

After writing the code, review it for race conditions and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any check-then-act sequence over shared state, money, inventory, coupons, files, or permissions that is not concurrency-safe.
4. Use transactions, atomic updates, locking, or idempotent workflow design to make the operation concurrency-safe.
5. Provide the final secure version only.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <condition_variable>
#include <vector>

struct Account {
    int balance;
};

std::vector<Account> accounts;
std::mutex accounts_mutex;
std::condition_variable accounts_cv;

void processTransaction(int account_id, int amount) {
    std::unique_lock<std::mutex> lock(accounts_mutex);
    Account& account = accounts[account_id];
    account.balance += amount;
}

void run() {
    while (true) {
        // Wait for a new transaction to arrive
        std::unique_lock<std::mutex> lock(accounts_mutex);
        accounts_cv.wait(lock, [&] { return !accounts.empty(); });

        // Process the next transaction
        int account_id = accounts.front().id;
        int amount = accounts.front().amount;
        processTransaction(account_id, amount);

        // Remove the processed transaction from the queue
        accounts.pop_front();
    }
}

int main() {
    std::thread t1(run);
    std::thread t2(run);
    t1.join();
    t2.join();
    return 0;
}