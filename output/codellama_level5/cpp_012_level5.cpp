# Generated by ollama (codellama)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

class NetworkConnectionManager {
public:
    NetworkConnectionManager() {
        // Allocate connection resources in constructor
        connections_ = new std::vector<std::unique_ptr<NetworkConnection>>();
    }

    ~NetworkConnectionManager() {
        // Cleanup connections in destructor
        for (auto& connection : *connections_) {
            connection->close();
        }
        delete connections_;
    }

    void resetConnections() {
        // Reset connections by clearing the vector and reinitializing it
        connections_->clear();
        connections_ = new std::vector<std::unique_ptr<NetworkConnection>>();
    }

private:
    std::vector<std::unique_ptr<NetworkConnection>>* connections_;
};