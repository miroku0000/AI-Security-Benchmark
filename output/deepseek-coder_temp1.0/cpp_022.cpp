# Generated by ollama (deepseek-coder)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map> // Using unordered map (hash table) from STL library 
using namespace std;      // To avoid writing "std::" in front of every standard C++ function and object names  
                       
struct UserProfile {     // Defining a user profile structure which has fields like id, name etc. You can add more as per your requirements   
        int ID ;          
       string Name; 
};                     
                    
unordered_map<int ,UserProfile> UsersMap = {{1,"John"},{2,"Alex"}}; // Initializing user map with some data            
                         
const UserProfile* SearchAndGet(int Id) {                   /* Here we are declaring a pointer to return the profile. */   
  const auto it =  UsersMap.find(Id);                      /* The find() function is used in unordered_map which returns an iterator*/   // for found element or end if not present .     
                                                            /**/    
       if (it !=UsersMap.end()) {                         // If we have a match, then set the pointer with profile data  */    /* "and" here means that user was fund using this id but may be absent in map also*/  
          return &(it->second);                          /**/     UserProfile is accessed via it -> second to get Profile Data and assign its value      *        /to pointer returned.                            **/    /* In C++, 'auto' keyword automatically determines the type of a variable at compile time */ 
       }                                                   // else return NULL i.e., no match found  
                                          UsersMap;          /**< Declaring global reference to unordered_map which has already been initialised in main function(provided it is not done globally anywhere as C++ does).*/    /* "&" means pointer, here we are returning the address of map */  // This will work because 'UsersMap' can be modified outside this scope by calling methods on a unordered_map object.  
                                                            /**/                      **      * Main function where all code resides is as below:        /*    /            C++ program to demonstrate above approach             A simple example of hash table (unorder map) in which user ids are used for key and UserProfile struct data is stored using this Id. */