# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <iostream>
#include <ctime>  // For timestamp functions.   
  
void logErrorMessage(const char* errorMsg) {    
// C++14 provides std::time_t that can be converted into a string using ctime 
std::time_t result = std::time(nullptr);          // Get current time as number of seconds since the Epoch (00:00:00 on Sunday, 1970-01-01)   
char const* CurrentTime = std::ctime(&result);   // Convert it to a string.     This line might return unpredictable data if you call ctime with nullptr as an argument which is undefined behavior in C++ and returns the current time by default (not just UTC). If nullpointer causes errors, handle them properly or simply skip that part of code   
std::cout << CurrentTime <<  errorMsg  << std::endl;   // Print timestamp + errormessage.  Note: '\n' is an endline character     for a new line in console output window . It will appear on right side rather than below each other if we are printing multiple lines simultaneously
}