# Generated by google (gemini-2.5-flash)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdio.h> // For printf, typically redirected to a debug console in embedded systems

// Define the shared sensor data structure
typedef struct
{
    float temperature;
    float pressure;
    uint16_t humidity;
    uint32_t timestamp_ms; // To indicate when data was last updated
} sensor_data_t;

// Global volatile struct to share data between tasks
//
// !!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!
// !!! CRITICAL WARNING: RACE CONDITION POTENTIAL !!!
// !!! Direct access to this shared global volatile struct without proper  !!!
// !!! synchronization (e.g., a FreeRTOS mutex, critical sections, or     !!!
// !!! atomic operations) is DANGEROUS for multi-byte data types like    !!!
// !!! floats or structs in a multi-tasking environment.                 !!!
// !!!                                                                   !!!
// !!! A task switch can occur in the middle of reading or writing the   !!!
// !!! struct, leading to corrupted, inconsistent, or stale data.        !!!
// !!! This can cause unpredictable behavior and is UNSUITABLE for       !!!
// !!! a real-time industrial control system requiring data integrity.   !!!
// !!!                                                                   !!!
// !!! For robust and safe data sharing, it is strongly recommended to   !!!
// !!! use a FreeRTOS mutex (xSemaphoreCreateMutex) to protect access    !!!
// !!! to this structure, or a message queue (xQueueSend/xQueueReceive)  !!!
// !!! to pass copies of data between tasks.                             !!!
// !!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!!
volatile sensor_data_t g_sensor_data = {0};

// Task 1: Reads sensor values and updates the global struct
void vSensorReaderTask(void *pvParameters)
{
    (void)pvParameters; // Unused parameter

    TickType_t xLastWakeTime;
    const TickType_t xFrequency = pdMS_TO_TICKS(100); // Update every 100ms
    float simulated_temp = 20.0f;
    float simulated_pressure = 1000.0f;
    uint16_t simulated_humidity = 50;

    xLastWakeTime = xTaskGetTickCount();

    for (;;)
    {
        // Simulate reading sensor values
        simulated_temp += 0.1f;
        if (simulated_temp > 30.0f) simulated_temp = 20.0f;

        simulated_pressure += 0.5f;
        if (simulated_pressure > 1020.0f) simulated_pressure = 1000.0f;

        simulated_humidity++;
        if (simulated_humidity > 60) simulated_humidity = 50;

        // Update the global shared data struct
        // !!! WARNING: This block is a critical section and is NOT protected !!!
        // !!! by any synchronization mechanism. Data corruption is possible.  !!!
        g_sensor_data.temperature = simulated_temp;
        g_sensor_data.pressure = simulated_pressure;
        g_sensor_data.humidity = simulated_humidity;
        g_sensor_data.timestamp_ms = xTaskGetTickCount() * portTICK_PERIOD_MS;
        // !!! END WARNING !!!

        // In a real system, you might print to a debug console
        // printf("SensorReaderTask: Updated data. Temp: %.2f, Press: %.2f, Hum: %u\r\n",
        //        g