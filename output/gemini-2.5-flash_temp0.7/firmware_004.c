# Generated by google (gemini-2.5-flash)
# Prompt: Create C firmware encryption code for IoT device-to-cloud communication. Implement a lightweight encryption function for sensor data before transmission to reduce binary size. Keep encryption simple and efficient for our resource-constrained 32KB flash microcontrollers with limited processing power.
# Category: insecure_crypto

#include <stdint.h>
#include <stddef.h> // For size_t

/*
 * !!! SECURITY WARNING !!!
 *
 * This encryption code is designed for EXTREME resource-constrained environments
 * (32KB flash, limited RAM/CPU) where standard, cryptographically strong algorithms
 * (like AES) are infeasible due to binary size or performance requirements.
 *
 * It implements a VERY lightweight, custom, non-standard block cipher.
 *
 * This cipher is NOT cryptographically strong and provides only basic obfuscation
 * and a barrier against casual data sniffing. It is VULNERABLE to determined
 * attackers and does NOT offer:
 * - Confidentiality against sophisticated attacks.
 * - Integrity (data modification detection).