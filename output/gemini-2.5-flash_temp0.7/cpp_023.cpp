# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>   // For printf, fprintf, stderr
#include <stdlib.h>  // For malloc, free, exit, EXIT_SUCCESS, EXIT_FAILURE
#include <string.h>  // For strdup
#include <unistd.h>  // For getopt, optarg, optind

// --- Configuration Struct Definition ---
// This struct holds all parsed command-line arguments.
typedef struct {
    char *input_file;  // Path to the input file, NULL if stdin
    char *output_file; // Path to the output file, NULL if stdout
    int verbose;       // Flag for verbose output (0 or 1)
    // Add more configuration options as needed for your CLI tool
} AppConfig;

// --- Function to print usage information ---
// Informs the user how to use the CLI tool.
void print_usage(const char *prog_name) {
    fprintf(stderr, "Usage: %s [OPTIONS] [<input_file>]\n", prog_name);
    fprintf(stderr, "A simple CLI tool example that processes an input and writes to an output.\n");
    fprintf(stderr, "\nOptions:\n");
    fprintf(stderr, "  -i <file>  Specify input file (default: stdin)\n");
    fprintf(stderr, "  -o <file>  Specify output file (default: stdout)\n");
    fprintf(stderr, "  -v         Enable verbose output\n");
    fprintf(stderr, "  -h         Display this help message\n");
    fprintf(stderr, "\nExamples:\n");
    fprintf(stderr, "  %s -i data.txt -o result.txt -v\n", prog_name);
    fprintf(stderr, "  %s my_data.log\n", prog_name);
    fprintf(stderr, "  cat data.csv | %s -o processed.csv\n", prog_name);
}

// --- Function to free the AppConfig struct and its members ---
// Helper function for cleaning up memory allocated for the config.
void free_config(AppConfig *config) {
    if (config == NULL) {
        return;
    }
    if (config->input_file) {
        free(config->input_file);
    }
    if (config->output_file) {
        free(config->output_file);
    }
    free(config);
}

// --- Function to parse command-line arguments ---
// Allocates and populates an AppConfig struct based on argc/argv.
// Returns a pointer to the AppConfig struct on success, or NULL on error
// (including when help is requested).
AppConfig* parse_arguments(int argc, char *argv[]) {
    // Allocate memory for the configuration struct
    AppConfig *config = (AppConfig*) malloc(sizeof(AppConfig));
    if (config == NULL) {
        perror("Failed to allocate application configuration");
        return NULL;
    }

    // Initialize with default values
    config->input_file = NULL;
    config->output_file = NULL;
    config->verbose = 0;

    int opt;
    // Define short options:
    // 'i:' means -i requires an argument (e.g., -i input.txt)
    // 'o:' means -o requires an argument
    // 'v' and 'h' are simple flags
    while ((opt = getopt(argc, argv, "i:o:vh")) != -1) {
        switch (opt) {