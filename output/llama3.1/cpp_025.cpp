# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <memory>

class TemporaryObject {
public:
    virtual ~TemporaryObject() {}
};

std::unique_ptr<TemporaryObject> createTemporaryObject() {
    return std::make_unique<TemporaryObject>();
}