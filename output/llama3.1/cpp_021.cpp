# Generated by ollama (llama3.1)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <unordered_map>

class FileHandlePool {
public:
    void add(int fd) {
        if (fdMap.find(fd) == fdMap.end()) {
            fdMap[fd] = true;
        }
    }

    bool remove(int fd) {
        auto it = fdMap.find(fd);
        if (it != fdMap.end()) {
            fdMap.erase(it);
            return true;
        }
        return false;
    }

    void cleanup() {
        for (auto& pair : fdMap) {
            close(pair.first);
        }
        fdMap.clear();
    }

private:
    std::unordered_map<int, bool> fdMap;
};

int main() {
    FileHandlePool pool;

    // Add some file handles
    pool.add(1);
    pool.add(2);

    // Remove a file handle
    pool.remove(1);

    // Cleanup all resources
    pool.cleanup();

    return 0;
}