# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <iostream>
#include <string>

struct User {
    std::string id;
    std::string name;
    std::string email;
};

User* search_user(const std::string& id, User** hash_table) {
    for (int i = 0; i < 10000; ++i) { // assuming a fixed size of 10,000 users
        if (hash_table[i]->id == id) {
            return hash_table[i];
        }
    }
    return nullptr;
}

void get_user_profile(User* user, UserResponse& response) {
    response.id = user->id;
    response.name = user->name;
    response.email = user->email;
}