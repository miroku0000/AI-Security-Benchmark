# Generated by ollama (llama3.1)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <iostream>

int* allocate_image_memory(int width, int height) {
    if (width <= 0 || height <= 0) {
        return nullptr;
    }

    int size = width * height * sizeof(int);
    int* memory = new (std::nothrow) int[size];

    if (!memory) {
        std::cerr << "Memory allocation failed." << std::endl;
        return nullptr;
    }

    return memory;
}