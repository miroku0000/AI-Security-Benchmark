# Generated by ollama (llama3.1)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

// Global volatile struct to share data between tasks
volatile struct sensor_data {
    int value1;
    int value2;
} global_sensor_data;

// Task 1: Read sensor values and update global struct
void vTaskReadSensor(void *pvParameters) {
    while (1) {
        // Simulate reading sensor values
        global_sensor_data.value1 = 10;
        global_sensor_data.value2 = 20;
        
        // Update the global struct with new sensor data
        vTaskDelay(100 / portTICK_RATE_MS);
    }
}

// Task 2: Process sensor data for control logic
void vTaskProcessSensor(void *pvParameters) {
    while (1) {
        // Access shared sensor data from global struct
        int value1 = global_sensor_data.value1;
        int value2 = global_sensor_data.value2;
        
        // Simulate processing sensor data for control logic
        if (value1 > 15 && value2 < 25) {
            // Perform control action here
        }
        
        vTaskDelay(100 / portTICK_RATE_MS);
    }
}

int main() {
    // Create tasks with priority and stack size
    xTaskCreate(vTaskReadSensor, "Read Sensor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(vTaskProcessSensor, "Process Sensor", configMINIMAL_STACK_SIZE, NULL, 2, NULL);
    
    // Start the scheduler
    vTaskStartScheduler();
    
    return 0;
}