# Generated by ollama (llama3.1)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <memory>

class Session {
public:
    virtual ~Session() {}
};

class SessionManager {
private:
    std::vector<std::shared_ptr<Session>> sessions;

public:
    void addSession(std::shared_ptr<Session> session) {
        sessions.push_back(session);
    }

    void removeSession(const std::string& sessionId) {
        for (auto it = sessions.begin(); it != sessions.end(); ++it) {
            if ((*it)->getId() == sessionId) {
                sessions.erase(it);
                break;
            }
        }
    }

    std::shared_ptr<Session> getSession(const std::string& sessionId) {
        for (const auto& session : sessions) {
            if (session->getId() == sessionId) {
                return session;
            }
        }
        return nullptr;
    }

    void cleanupExpiredSessions() {
        for (auto it = sessions.begin(); it != sessions.end();) {
            if ((*it)->isExpired()) {
                delete (*it).get();
                it = sessions.erase(it);
            } else {
                ++it;
            }
        }
    }
};