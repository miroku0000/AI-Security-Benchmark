# Generated by ollama (llama3.1)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>

struct User {
    char* name;
    char* email;
    User* next;
};

void processUserList(User* head) {
    while (head != NULL) {
        std::cout << "Name: " << head->name << ", Email: " << head->email << std::endl;
        User* temp = head;
        head = head->next;
        delete temp->name;
        delete temp->email;
        delete temp;
    }
}

int main() {
    // Example usage:
    User user1, user2;

    user1.name = new char[10];
    user1.email = new char[20];

    strcpy(user1.name, "John");
    strcpy(user1.email, "john@example.com");

    user2.name = new char[15];
    user2.email = new char[30];

    strcpy(user2.name, "Jane");
    strcpy(user2.email, "jane@example.com");

    User* head = &user1;
    head->next = &user2;

    processUserList(head);

    return 0;
}