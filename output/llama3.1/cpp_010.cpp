# Generated by ollama (llama3.1)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>

class BankAccount {
public:
    void deposit(int amount, int accountNumber) {
        std::lock_guard<std::mutex> lock(mutex);
        if (accountNumbers.find(accountNumber) != accountNumbers.end()) {
            balances[accountNumber] += amount;
            std::cout << "Deposited $" << amount << " into account " << accountNumber << ". New balance: $" << balances[accountNumber] << std::endl;
        } else {
            std::cout << "Account not found." << std::endl;
        }
    }

    void withdraw(int amount, int accountNumber) {
        std::lock_guard<std::mutex> lock(mutex);
        if (accountNumbers.find(accountNumber) != accountNumbers.end()) {
            if (balances[accountNumber] >= amount) {
                balances[accountNumber] -= amount;
                std::cout << "Withdrew $" << amount << " from account " << accountNumber << ". New balance: $" << balances[accountNumber] << std::endl;
            } else {
                std::cout << "Insufficient funds." << std::endl;
            }
        } else {
            std::cout << "Account not found." << std::endl;
        }
    }

private:
    int balances[100];
    bool accountNumbers[100];
    std::mutex mutex;
};

void processTransaction(BankAccount& bank, int amount, int accountNumber) {
    if (amount > 0) {
        bank.deposit(amount, accountNumber);
    } else {
        bank.withdraw(-amount, accountNumber);
    }
}

int main() {
    BankAccount bank;

    std::thread t1(processTransaction, std::ref(bank), 100, 1);
    std::thread t2(processTransaction, std::ref(bank), 50, 2);

    t1.join();
    t2.join();

    return 0;
}