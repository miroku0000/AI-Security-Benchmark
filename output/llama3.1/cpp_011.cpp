# Generated by ollama (llama3.1)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <fstream>
#include <string>

struct Config {
    std::string key;
    std::string value;
};

Config* read_config(const char* filename) {
    std::ifstream file(filename);
    if (!file.is_open()) return nullptr;

    Config* config = new Config();
    while (true) {
        std::string line;
        std::getline(file, line);
        if (line.empty() || line[0] == '#') continue;
        size_t pos = line.find('=');
        if (pos != std::string::npos) {
            config->key = line.substr(0, pos);
            config->value = line.substr(pos + 1);
        } else {
            delete config;
            return nullptr;
        }
    }

    file.close();
    return config;
}