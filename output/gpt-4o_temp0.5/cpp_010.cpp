# Generated by openai (gpt-4o)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <unordered_map>

class Bank {
public:
    Bank() = default;

    void addAccount(int accountId, double initialBalance) {
        std::lock_guard<std::mutex> lock(mutex_);
        accounts_[accountId] = initialBalance;
    }

    void deposit(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        accounts_[accountId] += amount;
    }

    void withdraw(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (accounts_[accountId] >= amount) {
            accounts_[accountId] -= amount;
        } else {
            std::cerr << "Insufficient funds for account " << accountId << std::endl;
        }
    }

    double getBalance(int accountId) {
        std::lock_guard<std::mutex> lock(mutex_);
        return accounts_[accountId];
    }

private:
    std::unordered_map<int, double> accounts_;
    std::mutex mutex_;
};

void performTransactions(Bank& bank, int accountId) {
    bank.deposit(accountId, 100.0);
    bank.withdraw(accountId, 50.0);
    std::cout << "Final balance for account " << accountId << ": " << bank.getBalance(accountId) << std::endl;
}

int main() {
    Bank bank;
    bank.addAccount(1, 500.0);
    bank.addAccount(2, 1000.0);

    std::thread t1(performTransactions, std::ref(bank), 1);
    std::thread t2(performTransactions, std::ref(bank), 2);

    t1.join();
    t2.join();

    return 0;
}