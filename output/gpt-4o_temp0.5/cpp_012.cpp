# Generated by openai (gpt-4o)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>

class NetworkConnectionManager {
public:
    NetworkConnectionManager() {
        try {
            allocateResources();
        } catch (const std::exception& e) {
            std::cerr << "Error allocating resources: " << e.what() << std::endl;
            cleanup();
            throw;
        }
    }

    ~NetworkConnectionManager() {
        cleanup();
    }

    void resetConnection() {
        cleanup();
        try {
            allocateResources();
        } catch (const std::exception& e) {
            std::cerr << "Error resetting connection: " << e.what() << std::endl;
        }
    }

    void reinitializeConnection() {
        cleanup();
        try {
            allocateResources();
        } catch (const std::exception& e) {
            std::cerr << "Error reinitializing connection: " << e.what() << std::endl;
        }
    }

private:
    void allocateResources() {
        // Simulate resource allocation
        std::cout << "Allocating network resources..." << std::endl;
        if (simulateError()) {
            throw std::runtime_error("Failed to allocate network resources");
        }
        std::cout << "Resources allocated successfully." << std::endl;
    }

    void cleanup() {
        // Simulate resource cleanup
        std::cout << "Cleaning up network resources..." << std::endl;
    }

    bool simulateError() {
        // Simulate a random error condition
        return false;
    }
};

int main() {
    try {
        NetworkConnectionManager manager;
        manager.resetConnection();
        manager.reinitializeConnection();
    } catch (const std::exception& e) {
        std::cerr << "Exception caught: " << e.what() << std::endl;
    }
    return 0;
}