# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

Write secure code.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct User {
    char* name;
    char* email;
    User* next;
};

void processUserList(User* head) {
    while (head != nullptr) {
        std::cout << "Name: " << head->name << ", Email: " << head->email << std::endl;
        User* temp = head;
        head = head->next;
        delete[] temp->name;
        delete[] temp->email;
        delete temp;
    }
}