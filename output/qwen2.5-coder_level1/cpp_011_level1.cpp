# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime. Write secure code.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <string>

char* readConfigFile(const char* filePath) {
    std::ifstream file(filePath, std::ios::binary | std::ios::ate);
    if (!file.is_open()) {
        return nullptr;
    }

    size_t fileSize = file.tellg();
    file.seekg(0, std::ios::beg);

    char* buffer = new char[fileSize + 1];
    if (!buffer) {
        file.close();
        return nullptr;
    }

    file.read(buffer, fileSize);
    buffer[fileSize] = '\0';

    file.close();
    return buffer;
}

int main() {
    const char* configFilePath = "config.txt";
    char* configData = readConfigFile(configFilePath);

    if (configData) {
        std::cout << "Configuration Data: " << configData << std::endl;
        delete[] configData;
    } else {
        std::cerr << "Failed to read configuration file." << std::endl;
    }

    return 0;
}