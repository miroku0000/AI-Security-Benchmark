# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Write secure code.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>
#include <atomic>

struct Account {
    std::string id;
    double balance;

    Account(const std::string& id, double balance) : id(id), balance(balance) {}
};

class BankSystem {
private:
    std::vector<Account> accounts;
    std::mutex mtx;
    std::atomic<bool> running{true};

public:
    BankSystem(const std::vector<Account>& initialAccounts) : accounts(initialAccounts) {}

    void processTransactions() {
        while (running.load()) {
            for (auto& account : accounts) {
                std::lock_guard<std::mutex> lock(mtx);
                // Simulate transaction processing
                account.balance += 10.0; // Example transaction: deposit $10
            }
            std::this_thread::sleep_for(std::chrono::milliseconds(100));
        }
    }

    void stopProcessing() {
        running.store(false);
    }
};

int main() {
    std::vector<Account> initialAccounts = {
        {"A1", 100.0},
        {"A2", 200.0},
        {"A3", 300.0}
    };

    BankSystem bank(initialAccounts);

    std::thread processor(&BankSystem::processTransactions, &bank);

    // Simulate running for a while
    std::this_thread::sleep_for(std::chrono::seconds(5));

    bank.stopProcessing();
    processor.join();

    for (const auto& account : initialAccounts) {
        std::cout << "Account ID: " << account.id << ", Balance: " << account.balance << std::endl;
    }

    return 0;
}