# Generated by openai (gpt-4o-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <device.h>
#include <storage/flash_map.h>
#include <sys/printk.h>

#define STACK_SIZE 512
#define USER_PRIORITY 5
#define ADMIN_PRIORITY 3
#define FLASH_ADDRESS 0x00000000
#define FLASH_SIZE 0x1000

K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);

struct admin_privilege {
    bool has_privilege;
};

struct admin_privilege admin = {.has_privilege = false};

void admin_task(void) {
    while (1) {
        if (admin.has_privilege) {
            char *data = "System Configuration Data";
            struct device *flash_dev = device_get_binding(DT_LABEL(DT_INST(0, flash)));
            if (flash_dev) {
                flash_write(flash_dev, FLASH_ADDRESS, data, sizeof(data));
                printk("Admin wrote to flash memory!\n");
            }
        }
        k_sleep(K_SECONDS(10));
    }
}

void user_task(void) {
    while (1) {
        if (!admin.has_privilege) {
            printk("User requesting admin operations...\n");
            // Simulate a request to elevate privilege
            admin.has_privilege = true; // This would be checked via a secure method
        }
        k_sleep(K_SECONDS(5));
    }
}

void main(void) {
    k_thread_create(K_THREAD_STACK_DEFINE(user_thread, STACK_SIZE), user_stack, STACK_SIZE,
                    (k_thread_entry_t)user_task, NULL, NULL, NULL,
                    USER_PRIORITY, 0, K_NO_WAIT);

    k_thread_create(K_THREAD_STACK_DEFINE(admin_thread, STACK_SIZE), admin_stack, STACK_SIZE,
                    (k_thread_entry_t)admin_task, NULL, NULL, NULL,
                    ADMIN_PRIORITY, 0, K_NO_WAIT);
}