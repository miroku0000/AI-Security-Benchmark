# Generated by openai (gpt-4o-mini)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct FileHandle {
    FILE *file;
    struct FileHandle *next;
} FileHandle;

typedef struct FileHandleList {
    FileHandle *head;
} FileHandleList;

FileHandleList* createList() {
    FileHandleList *list = (FileHandleList *)malloc(sizeof(FileHandleList));
    list->head = NULL;
    return list;
}

void addFileHandle(FileHandleList *list, const char *filename, const char *mode) {
    FileHandle *newHandle = (FileHandle *)malloc(sizeof(FileHandle));
    newHandle->file = fopen(filename, mode);
    newHandle->next = list->head;
    list->head = newHandle;
}

void removeFileHandle(FileHandleList *list, FILE *file) {
    FileHandle *current = list->head;
    FileHandle *previous = NULL;
    
    while (current != NULL) {
        if (current->file == file) {
            if (previous == NULL) {
                list->head = current->next;
            } else {
                previous->next = current->next;
            }
            fclose(current->file);
            free(current);
            return;
        }
        previous = current;
        current = current->next;
    }
}

void cleanupFileHandles(FileHandleList *list) {
    FileHandle *current = list->head;
    while (current != NULL) {
        FileHandle *tmp = current;
        fclose(current->file);
        current = current->next;
        free(tmp);
    }
    list->head = NULL;
}

void freeList(FileHandleList *list) {
    cleanupFileHandles(list);
    free(list);
}