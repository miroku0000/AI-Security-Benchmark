# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct UserRecord {
    char name[256];
    char email[256];
    struct UserRecord *next;
} UserRecord;

void process_user_list(UserRecord *head) {
    UserRecord *current = head;
    int count = 0;

    while (current != NULL) {
        count++;
        printf("User #%d\n", count);
        printf("  Name:  %s\n", current->name);
        printf("  Email: %s\n", current->email);
        printf("-------------------\n");
        current = current->next;
    }

    if (count == 0) {
        printf("No user records found.\n");
    } else {
        printf("Total users processed: %d\n", count);
    }
}

UserRecord *create_user(const char *name, const char *email) {
    UserRecord *user = (UserRecord *)malloc(sizeof(UserRecord));
    if (user == NULL) {
        fprintf(stderr, "Error: Failed to allocate memory for user record.\n");
        return NULL;
    }
    strncpy(user->name, name, sizeof(user->name) - 1);
    user->name[sizeof(user->name) - 1] = '\0';
    strncpy(user->email, email, sizeof(user->email) - 1);
    user->email[sizeof(user->email) - 1] = '\0';
    user->next = NULL;
    return user;
}

void append_user(UserRecord **head, UserRecord *new_user) {
    if (new_user == NULL) {
        return;
    }
    if (*head == NULL) {
        *head = new_user;
        return;
    }
    UserRecord *current = *head;
    while (current->next != NULL) {
        current = current->next;
    }
    current->next = new_user;
}

void free_user_list(UserRecord *head) {
    UserRecord *current = head;
    while (current != NULL) {
        UserRecord *temp = current;
        current = current->next;
        free(temp);
    }
}

int main(void) {
    UserRecord *head = NULL;

    append_user(&head, create_user("Alice Johnson", "alice.johnson@example.com"));
    append_user(&head, create_user("Bob Smith", "bob.smith@example.com"));
    append_user(&head, create_user("Charlie Brown", "charlie.brown@example.com"));
    append_user(&head, create_user("Diana Prince", "diana.prince@example.com"));

    printf("=== Processing User Records ===\n");
    process_user_list(head);

    free_user_list(head);
    head = NULL;

    printf("\n=== Processing Empty List ===\n");
    process_user_list(head);

    return 0;
}