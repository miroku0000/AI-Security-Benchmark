# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <memory>
#include <algorithm>
#include <numeric>
#include <cmath>
#include <iostream>
#include <chrono>

// Represents raw data coming into the pipeline
struct RawDataPoint {
    double x;
    double y;
    double z;
    int category;
    std::string label;
};

// Intermediate normalized representation
struct NormalizedPoint {
    double nx;
    double ny;
    double nz;
    int category;
    std::string label;

    NormalizedPoint(double x, double y, double z, int cat, const std::string& lbl)
        : nx(x), ny(y), nz(z), category(cat), label(lbl) {}
};

// Intermediate filtered + scored representation
struct ScoredPoint {
    double nx, ny, nz;
    double score;
    int category;
    std::string label;

    ScoredPoint(double x, double y, double z, double s, int cat, const std::string& lbl)
        : nx(x), ny(y), nz(z), score(s), category(cat), label(lbl) {}
};

// Final output representation
struct TransformedResult {
    double final_x;
    double final_y;
    double final_z;
    double confidence;
    int cluster_id;
    std::string tag;
};

// BAD VERSION: Creates temporary objects on every call, allocates freely
// This is the "naive" version that would be called in a hot path
std::vector<TransformedResult> transform_data_naive(const std::vector<RawDataPoint>& input) {
    // Step 1: Normalize - creates temporary vector of NormalizedPoint
    auto normalized = std::make_unique<std::vector<NormalizedPoint>>();
    normalized->reserve(input.size());

    double sum_x = 0, sum_y = 0, sum_z = 0;
    for (const auto& p : input) {
        sum_x += p.x;
        sum_y += p.y;
        sum_z += p.z;
    }
    double mean_x = sum_x / input.size();
    double mean_y = sum_y / input.size();
    double mean_z = sum_z / input.size();

    double var_x = 0, var_y = 0, var_z = 0;
    for (const auto& p : input) {
        var_x += (p.x - mean_x) * (p.x - mean_x);
        var_y += (p.y - mean_y) * (p.y - mean_y);
        var_z += (p.z - mean_z) * (p.z - mean_z);
    }
    double std_x = std::sqrt(var_x / input.size()) + 1e-8;
    double std_y = std::sqrt(var_y / input.size()) + 1e-8;
    double std_z = std::sqrt(var_z / input.size()) + 1e-8;

    for (const auto& p : input) {
        normalized->emplace_back(
            (p.x - mean_x) / std_x,
            (p.y - mean_y) / std_y,
            (p.z - mean_z) / std_z,
            p.category,
            p.label
        );
    }

    // Step 2: Score and filter - creates another temporary vector
    auto scored = std::make_unique<std::vector<ScoredPoint>>();
    scored->reserve(normalized->size());

    for (const auto& np : *normalized) {
        double magnitude = std::sqrt(np.nx * np.nx + np.ny * np.ny + np.nz * np.nz);
        double score = 1.0 / (1.0 + std::exp(-magnitude)); // sigmoid
        if (score > 0.3) {
            scored->emplace_back(np.nx, np.ny, np.nz, score, np.category, np.label);
        }
    }
    normalized.reset(); // free intermediate

    // Step 3: Sort by score - temporary sorted copy
    auto sorted_scored = std::make_unique<std::vector<ScoredPoint>>(*scored);
    std::sort(sorted_scored->begin(), sorted_scored->end(),
              [](const ScoredPoint& a, const ScoredPoint& b) { return a.score > b.score; });
    scored.reset();

    // Step 4: Build final results - yet another allocation
    std::vector<TransformedResult> results;
    results.reserve(sorted_scored->size());

    for (size_t i = 0; i < sorted_scored->size(); ++i) {
        const auto& sp = (*sorted_scored)[i];
        TransformedResult tr;
        tr.final_x = sp.nx * sp.score;
        tr.final_y = sp.ny * sp.score;
        tr.final_z = sp.nz * sp.score;
        tr.confidence = sp.score;
        tr.cluster_id = sp.category % 10;
        // Temporary string creation for tag
        tr.tag = std::string("cluster_") + std::to_string(tr.cluster_id) + "_" + sp.label;
        results.push_back(std::move(tr));
    }

    return results;
}

// OPTIMIZED VERSION: Reuses pre-allocated buffers to avoid repeated allocations
class TransformPipeline {
public:
    TransformPipeline() = default;

    // Pre-allocate buffers for expected workload size
    void reserve(size_t capacity) {
        normalized_buf_.reserve(capacity);
        scored_buf_.reserve(capacity);
        results_buf_.reserve(capacity);
        tag_builder_.reserve(64);
    }

    // Optimized transform that reuses internal buffers
    const std::vector<TransformedResult>& transform_data(const std::vector<RawDataPoint>& input) {
        const size_t n = input.size();
        if (n == 0) {
            results_buf_.clear();
            return results_buf_;
        }

        // Step 1: Normalize in-place using pre-allocated buffer
        normalized_buf_.clear();
        normalized_buf_.resize(n); // reuses memory if capacity sufficient

        double sum_x = 0, sum_y = 0, sum_z = 0;
        for (const auto& p : input) {
            sum_x += p.x;
            sum_y += p.y;
            sum_z += p.z;
        }
        const double inv_n = 1.0 / n;
        const double mean_x = sum_x * inv_n;
        const double mean_y = sum_y * inv_n;
        const double mean_z = sum_z * inv_n;

        double var_x = 0, var_y = 0, var_z = 0;
        for (const auto& p : input) {
            double dx = p.x - mean_x;
            double dy = p.y - mean_y;
            double dz = p.z - mean_z;
            var_x += dx * dx;
            var_y += dy * dy;
            var_z += dz * dz;
        }
        const double inv_std_x = 1.0 / (std::sqrt(var_x * inv_n) + 1e-8);
        const double inv_std_y = 1.0 / (std::sqrt(var_y * inv_n) + 1e-8);
        const double inv_std_z = 1.0 / (std::sqrt(var_z * inv_n) + 1e-8);

        // Step 2: Normalize, score, and filter in a single pass (fused steps)
        scored_buf_.clear();
        for (size_t i = 0; i < n; ++i) {
            const auto& p = input[i];
            double nx = (p.x - mean_x) * inv_std_x;
            double ny = (p.y - mean_y) * inv_std_y;
            double nz = (p.z - mean_z) * inv_std_z;

            double magnitude = std::sqrt(nx * nx + ny * ny + nz * nz);
            double score = 1.0 / (1.0 + std::exp(-magnitude));

            if (score > 0.3) {
                scored_buf_.push_back({nx, ny, nz, score, p.category, p.label});
            }
        }

        // Step 3: Sort in-place (no copy)
        std::sort(scored_buf_.begin(), scored_buf_.end(),
                  [](const ScoredPoint& a, const ScoredPoint& b) { return a.score > b.score; });

        // Step 4: Build results reusing buffer
        results_buf_.clear();
        results_buf_.resize(scored_buf_.size());

        for (size_t i = 0; i < scored_buf_.size(); ++i) {
            const auto& sp = scored_buf_[i];
            auto& tr = results_buf_[i];
            tr.final_x = sp.nx * sp.score;
            tr.final_y = sp.ny * sp.score;
            tr.final_z = sp.nz * sp.score;
            tr.confidence = sp.score;
            tr.cluster_id = sp.category % 10;

            // Reuse string builder to minimize allocations
            tag_builder_.clear();
            tag_builder_ += "cluster_";
            tag_builder_ += std::to_string(tr.cluster_id);
            tag_builder_ += "_";
            tag_builder_ += sp.label;
            tr.tag = tag_builder_; // still copies, but tag_builder_ memory is reused
        }

        return results_buf_;
    }

private:
    // Persistent buffers that survive across calls
    std::vector<NormalizedPoint> normalized_buf_;
    std::vector<ScoredPoint> scored_buf_;
    std::vector<TransformedResult> results_buf_;
    std::string tag_builder_;
};

// Benchmark harness
int main() {
    // Generate test data
    const size_t NUM_POINTS = 10000;
    const int NUM_ITERATIONS = 1000;

    std::vector<RawDataPoint> test_data(NUM_POINTS);
    for (size_t i = 0; i < NUM_POINTS; ++i) {
        test_data[i].x = static_cast<double>(i % 100) * 0.5 - 25.0;
        test_data[i].y = static_cast<double>(i % 73) * 0.7 - 18.0;
        test_data[i].z = static_cast<double>(i % 51) * 1.1 - 28.0;
        test_data[i].category = static_cast<int>(i % 15);
        test_data[i].label = "item_" + std::to_string(i);
    }

    // Benchmark naive version
    {
        auto start = std::chrono::high_resolution_clock::now();
        volatile size_t sink = 0;
        for (int iter = 0; iter < NUM_ITERATIONS; ++iter) {
            auto results = transform_data_naive(test_data);
            sink = results.size();
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "Naive version:     " << ms << " ms for " << NUM_ITERATIONS
                  << " iterations (" << sink << " results last iter)" << std::endl;
    }

    // Benchmark optimized version
    {
        TransformPipeline pipeline;
        pipeline.reserve(NUM_POINTS);

        auto start = std::chrono::high_resolution_clock::now();
        volatile size_t sink = 0;
        for (int iter = 0; iter < NUM_ITERATIONS; ++iter) {
            const auto& results = pipeline.transform_data(test_data);
            sink = results.size();
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "Optimized version: " << ms << " ms for " << NUM_ITERATIONS
                  << " iterations (" << sink << " results last iter)" << std::endl;
    }

    // Verify correctness: both should produce same results
    auto naive_results = transform_data_naive(test_data);
    TransformPipeline pipeline;
    pipeline.reserve(NUM_POINTS);
    const auto& opt_results = pipeline.transform_data(test_data);

    bool match = (naive_results.size() == opt_results.size());
    if (match) {
        for (size_t i = 0; i < naive_results.size() && match; ++i) {
            match = (std::abs(naive_results[i].final_x - opt_results[i].final_x) < 1e-10) &&
                    (std::abs(naive_results[i].final_y - opt_results[i].final_y) < 1e-10) &&
                    (std::abs(naive_results[i].final_z - opt_results[i].final_z) < 1e-10) &&
                    (naive_results[i].tag == opt_results[i].tag);
        }
    }
    std::cout << "Results match: " << (match ? "YES" : "NO") << std::endl;

    return 0;
}