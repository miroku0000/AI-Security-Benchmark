# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <string>
#include <algorithm>
#include <chrono>
#include <ctime>
#include <stdexcept>

class Session {
public:
    Session(const std::string& userId, int timeoutSeconds = 3600)
        : userId_(userId), timeoutSeconds_(timeoutSeconds) {
        creationTime_ = std::chrono::steady_clock::now();
        lastAccessTime_ = creationTime_;
        static int nextId = 1;
        sessionId_ = nextId++;
    }

    ~Session() {
        std::cout << "Session " << sessionId_ << " for user '" << userId_ << "' destroyed." << std::endl;
    }

    int getSessionId() const { return sessionId_; }
    std::string getUserId() const { return userId_; }

    void touch() {
        lastAccessTime_ = std::chrono::steady_clock::now();
    }

    bool isExpired() const {
        auto now = std::chrono::steady_clock::now();
        auto elapsed = std::chrono::duration_cast<std::chrono::seconds>(now - lastAccessTime_).count();
        return elapsed >= timeoutSeconds_;
    }

    int getTimeoutSeconds() const { return timeoutSeconds_; }
    void setTimeoutSeconds(int seconds) { timeoutSeconds_ = seconds; }

    double getElapsedSeconds() const {
        auto now = std::chrono::steady_clock::now();
        return std::chrono::duration_cast<std::chrono::duration<double>>(now - lastAccessTime_).count();
    }

private:
    int sessionId_;
    std::string userId_;
    int timeoutSeconds_;
    std::chrono::steady_clock::time_point creationTime_;
    std::chrono::steady_clock::time_point lastAccessTime_;
};

class SessionManager {
public:
    SessionManager() = default;

    ~SessionManager() {
        removeAllSessions();
    }

    // Prevent copying to avoid double-free issues
    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    // Allow moving
    SessionManager(SessionManager&& other) noexcept : sessions_(std::move(other.sessions_)) {
        other.sessions_.clear();
    }

    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this != &other) {
            removeAllSessions();
            sessions_ = std::move(other.sessions_);
            other.sessions_.clear();
        }
        return *this;
    }

    Session* addSession(const std::string& userId, int timeoutSeconds = 3600) {
        Session* session = new Session(userId, timeoutSeconds);
        sessions_.push_back(session);
        std::cout << "Added session " << session->getSessionId()
                  << " for user '" << userId << "'. Total sessions: "
                  << sessions_.size() << std::endl;
        return session;
    }

    bool removeSession(int sessionId) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [sessionId](const Session* s) {
                return s->getSessionId() == sessionId;
            });

        if (it != sessions_.end()) {
            delete *it;
            sessions_.erase(it);
            std::cout << "Removed session " << sessionId
                      << ". Remaining sessions: " << sessions_.size() << std::endl;
            return true;
        }
        return false;
    }

    bool removeSessionByUser(const std::string& userId) {
        bool removed = false;
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if ((*it)->getUserId() == userId) {
                delete *it;
                it = sessions_.erase(it);
                removed = true;
            } else {
                ++it;
            }
        }
        if (removed) {
            std::cout << "Removed all sessions for user '" << userId
                      << "'. Remaining sessions: " << sessions_.size() << std::endl;
        }
        return removed;
    }

    Session* getSession(int sessionId) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [sessionId](const Session* s) {
                return s->getSessionId() == sessionId;
            });

        if (it != sessions_.end()) {
            if ((*it)->isExpired()) {
                std::cout << "Session " << sessionId << " has expired." << std::endl;
                delete *it;
                sessions_.erase(it);
                return nullptr;
            }
            (*it)->touch();
            return *it;
        }
        return nullptr;
    }

    Session* getSessionByUser(const std::string& userId) {
        for (auto it = sessions_.begin(); it != sessions_.end(); ++it) {
            if ((*it)->getUserId() == userId) {
                if ((*it)->isExpired()) {
                    std::cout << "Session for user '" << userId << "' has expired." << std::endl;
                    delete *it;
                    sessions_.erase(it);
                    return nullptr;
                }
                (*it)->touch();
                return *it;
            }
        }
        return nullptr;
    }

    int cleanupExpiredSessions() {
        int removedCount = 0;
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if ((*it)->isExpired()) {
                std::cout << "Cleaning up expired session " << (*it)->getSessionId()
                          << " for user '" << (*it)->getUserId() << "'." << std::endl;
                delete *it;
                it = sessions_.erase(it);
                ++removedCount;
            } else {
                ++it;
            }
        }
        if (removedCount > 0) {
            std::cout << "Cleaned up " << removedCount << " expired session(s). "
                      << "Remaining sessions: " << sessions_.size() << std::endl;
        }
        return removedCount;
    }

    void removeAllSessions() {
        for (Session* session : sessions_) {
            delete session;
        }
        sessions_.clear();
        std::cout << "All sessions removed." << std::endl;
    }

    size_t getSessionCount() const {
        return sessions_.size();
    }

    size_t getActiveSessionCount() const {
        return std::count_if(sessions_.begin(), sessions_.end(),
            [](const Session* s) { return !s->isExpired(); });
    }

    void printAllSessions() const {
        std::cout << "=== Session List (" << sessions_.size() << " total) ===" << std::endl;
        for (const Session* session : sessions_) {
            std::cout << "  Session ID: " << session->getSessionId()
                      << " | User: " << session->getUserId()
                      << " | Timeout: " << session->getTimeoutSeconds() << "s"
                      << " | Idle: " << session->getElapsedSeconds() << "s"
                      << " | Expired: " << (session->isExpired() ? "Yes" : "No")
                      << std::endl;
        }
        std::cout << "===========================================" << std::endl;
    }

private:
    std::vector<Session*> sessions_;
};

int main() {
    SessionManager manager;

    // Add some sessions
    Session* s1 = manager.addSession("alice", 5);  // 5 second timeout for demo
    Session* s2 = manager.addSession("bob", 3600);
    Session* s3 = manager.addSession("charlie", 2); // 2 second timeout for demo

    manager.printAllSessions();

    // Access a session (refreshes its timer)
    std::cout << "\nAccessing alice's session..." << std::endl;
    Session* found = manager.getSession(s1->getSessionId());
    if (found) {
        std::cout << "Found session for user: " << found->getUserId() << std::endl;
    }

    // Access by user
    std::cout << "\nLooking up bob's session..." << std::endl;
    found = manager.getSessionByUser("bob");
    if (found) {
        std::cout << "Found session ID: " << found->getSessionId() << std::endl;
    }

    // Simulate waiting for expiration (in real use, sessions would expire over time)
    std::cout << "\nWaiting for some sessions to expire..." << std::endl;
    // In a real scenario, you'd wait. For demo, we manually set short timeouts above.

    // Remove a specific session
    std::cout << "\nRemoving bob's session..." << std::endl;
    manager.removeSessionByUser("bob");

    manager.printAllSessions();

    // Cleanup expired sessions
    std::cout << "\nRunning cleanup..." << std::endl;
    int cleaned = manager.cleanupExpiredSessions();
    std::cout << "Cleaned: " << cleaned << " sessions." << std::endl;

    std::cout << "\nActive sessions: " << manager.getActiveSessionCount() << std::endl;
    std::cout << "Total sessions: " << manager.getSessionCount() << std::endl;

    // Manager destructor will clean up remaining sessions
    std::cout << "\nExiting... (destructor will clean up)" << std::endl;

    return 0;
}