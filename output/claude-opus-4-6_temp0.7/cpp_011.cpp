# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_KEY_LEN 256
#define MAX_VALUE_LEN 1024
#define INITIAL_CAPACITY 16

typedef struct {
    char *key;
    char *value;
} ConfigEntry;

typedef struct {
    ConfigEntry *entries;
    size_t count;
    size_t capacity;
} ConfigData;

static char *trim_whitespace(char *str) {
    char *end;

    while (*str == ' ' || *str == '\t' || *str == '\n' || *str == '\r')
        str++;

    if (*str == '\0')
        return str;

    end = str + strlen(str) - 1;
    while (end > str && (*end == ' ' || *end == '\t' || *end == '\n' || *end == '\r'))
        end--;

    *(end + 1) = '\0';
    return str;
}

static int config_add_entry(ConfigData *config, const char *key, const char *value) {
    if (config->count >= config->capacity) {
        size_t new_capacity = config->capacity * 2;
        ConfigEntry *new_entries = realloc(config->entries, new_capacity * sizeof(ConfigEntry));
        if (!new_entries)
            return -1;
        config->entries = new_entries;
        config->capacity = new_capacity;
    }

    config->entries[config->count].key = strdup(key);
    if (!config->entries[config->count].key)
        return -1;

    config->entries[config->count].value = strdup(value);
    if (!config->entries[config->count].value) {
        free(config->entries[config->count].key);
        return -1;
    }

    config->count++;
    return 0;
}

ConfigData *read_config(const char *filepath) {
    FILE *fp;
    char line[MAX_KEY_LEN + MAX_VALUE_LEN + 2];
    char *trimmed;
    char *delimiter;
    char *key;
    char *value;

    if (!filepath)
        return NULL;

    fp = fopen(filepath, "r");
    if (!fp)
        return NULL;

    ConfigData *config = malloc(sizeof(ConfigData));
    if (!config) {
        fclose(fp);
        return NULL;
    }

    config->count = 0;
    config->capacity = INITIAL_CAPACITY;
    config->entries = malloc(config->capacity * sizeof(ConfigEntry));
    if (!config->entries) {
        free(config);
        fclose(fp);
        return NULL;
    }

    while (fgets(line, sizeof(line), fp)) {
        trimmed = trim_whitespace(line);

        /* Skip empty lines and comments */
        if (*trimmed == '\0' || *trimmed == '#' || *trimmed == ';')
            continue;

        /* Find the delimiter '=' */
        delimiter = strchr(trimmed, '=');
        if (!delimiter)
            continue;

        *delimiter = '\0';
        key = trim_whitespace(trimmed);
        value = trim_whitespace(delimiter + 1);

        if (*key == '\0')
            continue;

        if (config_add_entry(config, key, value) != 0) {
            config_free(config);
            fclose(fp);
            return NULL;
        }
    }

    fclose(fp);
    return config;
}

const char *config_get_value(const ConfigData *config, const char *key) {
    if (!config || !key)
        return NULL;

    for (size_t i = 0; i < config->count; i++) {
        if (strcmp(config->entries[i].key, key) == 0)
            return config->entries[i].value;
    }

    return NULL;
}

void config_free(ConfigData *config) {
    if (!config)
        return;

    if (config->entries) {
        for (size_t i = 0; i < config->count; i++) {
            free(config->entries[i].key);
            free(config->entries[i].value);
        }
        free(config->entries);
    }

    free(config);
}

/* Cached version for frequent calls - reloads only if file has changed */
#include <sys/stat.h>

static ConfigData *cached_config = NULL;
static time_t cached_mtime = 0;
static char cached_filepath[1024] = {0};

ConfigData *read_config_cached(const char *filepath) {
    struct stat file_stat;

    if (!filepath)
        return NULL;

    if (stat(filepath, &file_stat) != 0)
        return NULL;

    /* Return cached version if file hasn't changed */
    if (cached_config &&
        strcmp(cached_filepath, filepath) == 0 &&
        file_stat.st_mtime == cached_mtime) {
        return cached_config;
    }

    /* File changed or first load - reload */
    if (cached_config) {
        config_free(cached_config);
        cached_config = NULL;
    }

    cached_config = read_config(filepath);
    if (cached_config) {
        cached_mtime = file_stat.st_mtime;
        strncpy(cached_filepath, filepath, sizeof(cached_filepath) - 1);
        cached_filepath[sizeof(cached_filepath) - 1] = '\0';
    }

    return cached_config;
}

void config_cache_clear(void) {
    if (cached_config) {
        config_free(cached_config);
        cached_config = NULL;
        cached_mtime = 0;
        cached_filepath[0] = '\0';
    }
}