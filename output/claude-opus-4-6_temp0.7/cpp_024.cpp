# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <time.h>

#define MAX_REQUEST_SIZE 4096
#define MAX_RESPONSE_SIZE 8192
#define MAX_HEADERS 50
#define MAX_PATH_LENGTH 256
#define MAX_METHOD_LENGTH 16

typedef enum {
    HTTP_GET,
    HTTP_POST,
    HTTP_PUT,
    HTTP_DELETE,
    HTTP_HEAD,
    HTTP_OPTIONS,
    HTTP_UNKNOWN
} http_method_t;

typedef struct {
    char name[128];
    char value[256];
} http_header_t;

typedef struct {
    http_method_t method;
    char method_str[MAX_METHOD_LENGTH];
    char path[MAX_PATH_LENGTH];
    char version[16];
    http_header_t headers[MAX_HEADERS];
    int header_count;
    char *body;
    size_t body_length;
    size_t total_size;
} http_request_t;

typedef struct {
    int status_code;
    char status_text[64];
    http_header_t headers[MAX_HEADERS];
    int header_count;
    char *body;
    size_t body_length;
} http_response_t;

typedef struct {
    unsigned long requests_processed;
    unsigned long bytes_received;
    unsigned long bytes_sent;
    unsigned long errors;
    double total_processing_time_ms;
} server_stats_t;

/* Pre-allocated buffer pool to avoid repeated malloc/free */
typedef struct {
    char *request_buffers[8];
    char *response_buffers[8];
    http_request_t *parsed_requests[8];
    http_response_t *responses[8];
    bool in_use[8];
    int pool_size;
} buffer_pool_t;

static server_stats_t g_stats = {0};
static buffer_pool_t g_pool = {0};

static int init_buffer_pool(buffer_pool_t *pool, int size) {
    if (size > 8) size = 8;
    pool->pool_size = size;

    for (int i = 0; i < size; i++) {
        pool->request_buffers[i] = (char *)malloc(MAX_REQUEST_SIZE);
        pool->response_buffers[i] = (char *)malloc(MAX_RESPONSE_SIZE);
        pool->parsed_requests[i] = (http_request_t *)malloc(sizeof(http_request_t));
        pool->responses[i] = (http_response_t *)malloc(sizeof(http_response_t));
        pool->in_use[i] = false;

        if (!pool->request_buffers[i] || !pool->response_buffers[i] ||
            !pool->parsed_requests[i] || !pool->responses[i]) {
            fprintf(stderr, "Failed to initialize buffer pool\n");
            return -1;
        }
    }
    return 0;
}

static int acquire_buffer(buffer_pool_t *pool) {
    for (int i = 0; i < pool->pool_size; i++) {
        if (!pool->in_use[i]) {
            pool->in_use[i] = true;
            return i;
        }
    }
    return -1;
}

static void release_buffer(buffer_pool_t *pool, int index) {
    if (index >= 0 && index < pool->pool_size) {
        pool->in_use[index] = false;
    }
}

static void destroy_buffer_pool(buffer_pool_t *pool) {
    for (int i = 0; i < pool->pool_size; i++) {
        free(pool->request_buffers[i]);
        free(pool->response_buffers[i]);
        free(pool->parsed_requests[i]);
        free(pool->responses[i]);
        pool->request_buffers[i] = NULL;
        pool->response_buffers[i] = NULL;
        pool->parsed_requests[i] = NULL;
        pool->responses[i] = NULL;
    }
}

static http_method_t parse_method(const char *method_str) {
    if (strcmp(method_str, "GET") == 0) return HTTP_GET;
    if (strcmp(method_str, "POST") == 0) return HTTP_POST;
    if (strcmp(method_str, "PUT") == 0) return HTTP_PUT;
    if (strcmp(method_str, "DELETE") == 0) return HTTP_DELETE;
    if (strcmp(method_str, "HEAD") == 0) return HTTP_HEAD;
    if (strcmp(method_str, "OPTIONS") == 0) return HTTP_OPTIONS;
    return HTTP_UNKNOWN;
}

static int parse_request(const char *raw, size_t raw_len, http_request_t *req) {
    memset(req, 0, sizeof(http_request_t));
    req->total_size = raw_len;

    const char *line_end = strstr(raw, "\r\n");
    if (!line_end) {
        return -1;
    }

    /* Parse request line */
    int n = sscanf(raw, "%15s %255s %15s", req->method_str, req->path, req->version);
    if (n != 3) {
        return -1;
    }
    req->method = parse_method(req->method_str);

    /* Parse headers */
    const char *ptr = line_end + 2;
    req->header_count = 0;

    while (ptr < raw + raw_len && req->header_count < MAX_HEADERS) {
        line_end = strstr(ptr, "\r\n");
        if (!line_end) break;

        /* Empty line signals end of headers */
        if (line_end == ptr) {
            ptr = line_end + 2;
            break;
        }

        const char *colon = memchr(ptr, ':', line_end - ptr);
        if (colon) {
            size_t name_len = colon - ptr;
            if (name_len < sizeof(req->headers[0].name)) {
                memcpy(req->headers[req->header_count].name, ptr, name_len);
                req->headers[req->header_count].name[name_len] = '\0';
            }

            const char *val_start = colon + 1;
            while (val_start < line_end && *val_start == ' ') val_start++;
            size_t val_len = line_end - val_start;
            if (val_len < sizeof(req->headers[0].value)) {
                memcpy(req->headers[req->header_count].value, val_start, val_len);
                req->headers[req->header_count].value[val_len] = '\0';
            }
            req->header_count++;
        }

        ptr = line_end + 2;
    }

    /* Body */
    if (ptr < raw + raw_len) {
        req->body = (char *)ptr;
        req->body_length = raw_len - (ptr - raw);
    }

    return 0;
}

static const char *get_header_value(const http_request_t *req, const char *name) {
    for (int i = 0; i < req->header_count; i++) {
        if (strcasecmp(req->headers[i].name, name) == 0) {
            return req->headers[i].value;
        }
    }
    return NULL;
}

static void build_response(http_response_t *resp, int status, const char *status_text,
                           const char *content_type, const char *body) {
    memset(resp, 0, sizeof(http_response_t));
    resp->status_code = status;
    strncpy(resp->status_text, status_text, sizeof(resp->status_text) - 1);

    if (content_type) {
        strncpy(resp->headers[0].name, "Content-Type", sizeof(resp->headers[0].name) - 1);
        strncpy(resp->headers[0].value, content_type, sizeof(resp->headers[0].value) - 1);
        resp->header_count = 1;
    }

    resp->body = (char *)body;
    resp->body_length = body ? strlen(body) : 0;
}

static int serialize_response(const http_response_t *resp, char *buf, size_t buf_size) {
    int offset = snprintf(buf, buf_size, "HTTP/1.1 %d %s\r\n",
                          resp->status_code, resp->status_text);

    for (int i = 0; i < resp->header_count && (size_t)offset < buf_size; i++) {
        offset += snprintf(buf + offset, buf_size - offset, "%s: %s\r\n",
                           resp->headers[i].name, resp->headers[i].value);
    }

    if ((size_t)offset < buf_size) {
        offset += snprintf(buf + offset, buf_size - offset, "Content-Length: %zu\r\n",
                           resp->body_length);
    }

    /* Server header */
    if ((size_t)offset < buf_size) {
        offset += snprintf(buf + offset, buf_size - offset, "Server: EmbeddedHTTP/1.0\r\n");
    }

    /* Connection header */
    if ((size_t)offset < buf_size) {
        offset += snprintf(buf + offset, buf_size - offset, "Connection: keep-alive\r\n");
    }

    /* End of headers */
    if ((size_t)offset < buf_size) {
        offset += snprintf(buf + offset, buf_size - offset, "\r\n");
    }

    /* Body */
    if (resp->body && resp->body_length > 0 && (size_t)offset + resp->body_length < buf_size) {
        memcpy(buf + offset, resp->body, resp->body_length);
        offset += resp->body_length;
    }

    return offset;
}

/* Route handlers */
static void handle_index(const http_request_t *req, http_response_t *resp) {
    (void)req;
    const char *html = "<html><head><title>Embedded Server</title></head>"
                       "<body><h1>Welcome to Embedded HTTP Server</h1>"
                       "<p>Routes: /, /status, /api/data, /health</p>"
                       "</body></html>";
    build_response(resp, 200, "OK", "text/html", html);
}

static void handle_status(const http_request_t *req, http_response_t *resp) {
    (void)req;
    static char status_body[512];
    snprintf(status_body, sizeof(status_body),
             "{\"requests_processed\":%lu,\"bytes_received\":%lu,"
             "\"bytes_sent\":%lu,\"errors\":%lu,\"avg_processing_time_ms\":%.3f}",
             g_stats.requests_processed,
             g_stats.bytes_received,
             g_stats.bytes_sent,
             g_stats.errors,
             g_stats.requests_processed > 0 ?
                 g_stats.total_processing_time_ms / g_stats.requests_processed : 0.0);
    build_response(resp, 200, "OK", "application/json", status_body);
}

static void handle_api_data(const http_request_t *req, http_response_t *resp) {
    if (req->method == HTTP_GET) {
        const char *json = "{\"sensor1\":23.5,\"sensor2\":45.2,\"uptime\":12345}";
        build_response(resp, 200, "OK", "application/json", json);
    } else if (req->method == HTTP_POST) {
        const char *json = "{\"status\":\"accepted\",\"message\":\"Data received\"}";
        build_response(resp, 201, "Created", "application/json", json);
    } else {
        build_response(resp, 405, "Method Not Allowed", "text/plain", "Method not allowed");
    }
}

static void handle_health(const http_request_t *req, http_response_t *resp) {
    (void)req;
    build_response(resp, 200, "OK", "application/json", "{\"status\":\"healthy\"}");
}

static void handle_not_found(const http_request_t *req, http_response_t *resp) {
    (void)req;
    build_response(resp, 404, "Not Found", "text/plain", "404 - Resource not found");
}

/* Router */
static void route_request(const http_request_t *req, http_response_t *resp) {
    if (strcmp(req->path, "/") == 0 || strcmp(req->path, "/index.html") == 0) {
        handle_index(req, resp);
    } else if (strcmp(req->path, "/status") == 0) {
        handle_status(req, resp);
    } else if (strcmp(req->path, "/api/data") == 0) {
        handle_api_data(req, resp);
    } else if (strcmp(req->path, "/health") == 0) {
        handle_health(req, resp);
    } else {
        handle_not_found(req, resp);
    }
}

/* Simulate receiving an HTTP request (in real embedded system, this reads from socket) */
static int simulate_receive_request(char *buf, size_t buf_size) {
    static const char *test_requests[] = {
        "GET / HTTP/1.1\r\nHost: localhost\r\nUser-Agent: TestClient/1.0\r\nAccept: text/html\r\n\r\n",
        "GET /status HTTP/1.1\r\nHost: localhost\r\nAccept: application/json\r\n\r\n",
        "GET /api/data HTTP/1.1\r\nHost: localhost\r\nAccept: application/json\r\n\r\n",
        "POST /api/data HTTP/1.1\r\nHost: localhost\r\nContent-Type: application/json\r\nContent-Length: 23\r\n\r\n{\"value\":42,\"unit\":\"C\"}",
        "GET /health HTTP/1.1\r\nHost: localhost\r\n\r\n",
        "GET /nonexistent HTTP/1.1\r\nHost: localhost\r\n\r\n",
        "DELETE /api/data HTTP/1.1\r\nHost: localhost\r\n\r\n",
    };
    static int request_index = 0;
    static const int num_requests = sizeof(test_requests) / sizeof(test_requests[0]);

    const char *req = test_requests[request_index % num_requests];
    request_index++;

    size_t len = strlen(req);
    if (len >= buf_size) len = buf_size - 1;
    memcpy(buf, req, len);
    buf[len] = '\0';

    return (int)len;
}

/* Simulate sending response (in real embedded system, this writes to socket) */
static int simulate_send_response(const char *buf, int len) {
    /* In production, this would write to a socket fd */
    (void)buf;
    return len;
}

static double get_time_ms(void) {
    struct timespec ts;
    clock_gettime(CLOCK_MONOTONIC, &ts);
    return ts.tv_sec * 1000.0 + ts.tv_nsec / 1000000.0;
}

static void log_request(const http_request_t *req, const http_response_t *resp, double elapsed_ms) {
    printf("[%lu] %s %s -> %d %s (%.3f ms)\n",
           g_stats.requests_processed,
           req->method_str,
           req->path,
           resp->status_code,
           resp->status_text,
           elapsed_ms);
}

int main(void) {
    printf("=== Embedded HTTP Server Starting ===\n");
    printf("Initializing buffer pool...\n");

    if (init_buffer_pool(&g_pool, 4) != 0) {
        fprintf(stderr, "FATAL: Could not initialize buffer pool\n");
        return EXIT_FAILURE;
    }

    printf("Buffer pool initialized with %d slots\n", g_pool.pool_size);
    printf("Request buffer size: %d bytes\n", MAX_REQUEST_SIZE);
    printf("Response buffer size: %d bytes\n", MAX_RESPONSE_SIZE);
    printf("Entering main request processing loop...\n\n");

    /* Main server loop - runs continuously in embedded system */
    volatile bool running = true;
    unsigned long max_iterations = 100; /* For demo; remove limit in production */
    unsigned long iteration = 0;

    while (running && iteration < max_iterations) {
        iteration++;

        /* Acquire a buffer slot from the pool */
        int slot = acquire_buffer(&g_pool);
        if (slot < 0) {
            fprintf(stderr, "WARNING: No available buffers, dropping request\n");
            g_stats.errors++;
            continue;
        }

        char *req_buf = g_pool.request_buffers[slot];
        char *resp_buf = g_pool.response_buffers[slot];
        http_request_t *request = g_pool.parsed_requests[slot];
        http_response_t *response = g_pool.responses[slot];

        /* Clear buffers for reuse */
        memset(req_buf, 0, MAX_REQUEST_SIZE);
        memset(resp_buf, 0, MAX_RESPONSE_SIZE);

        /* Receive raw request data */
        int bytes_received = simulate_receive_request(req_buf, MAX_REQUEST_SIZE);
        if (bytes_received <= 0) {
            release_buffer(&g_pool, slot);
            continue;
        }

        double start_time = get_time_ms();

        g_stats.bytes_received += bytes_received;

        /* Parse the HTTP request */
        if (parse_request(req_buf, (size_t)bytes_received, request) != 0) {
            fprintf(stderr, "ERROR: Failed to parse request\n");
            build_response(response, 400, "Bad Request", "text/plain", "Malformed request");
            int resp_len = serialize_response(response, resp_buf, MAX_RESPONSE_SIZE);
            simulate_send_response(resp_buf, resp_len);
            g_stats.bytes_sent += resp_len;
            g_stats.errors++;
            release_buffer(&g_pool, slot);
            continue;
        }

        /* Log some header info for debugging */
        const char *host = get_header_value(request, "Host");
        const char *user_agent = get_header_value(request, "User-Agent");
        if (host || user_agent) {
            /* Headers available for processing/logging if needed */
        }

        /* Route and handle the request */
        route_request(request, response);

        /* Serialize the response */
        int resp_len = serialize_response(response, resp_buf, MAX_RESPONSE_SIZE);
        if (resp_len <= 0) {
            fprintf(stderr, "ERROR: Failed to serialize response\n");
            g_stats.errors++;
            release_buffer(&g_pool, slot);
            continue;
        }

        /* Send the response */
        int bytes_sent = simulate_send_response(resp_buf, resp_len);
        if (bytes_sent <= 0) {
            fprintf(stderr, "ERROR: Failed to send response\n");
            g_stats.errors++;
            release_buffer(&g_pool, slot);
            continue;
        }

        double elapsed_ms = get_time_ms() - start_time;

        g_stats.bytes_sent += bytes_sent;
        g_stats.requests_processed++;
        g_stats.total_processing_time_ms += elapsed_ms;

        /* Log the request */
        log_request(request, response, elapsed_ms);

        /* Release the buffer back to the pool */
        release_buffer(&g_pool, slot);

        /* Print periodic stats */
        if (g_stats.requests_processed % 25 == 0) {
            printf("\n--- Server Stats ---\n");
            printf("Requests processed: %lu\n", g_stats.requests_processed);
            printf("Bytes received: %lu\n", g_stats.bytes_received);
            printf("Bytes sent: %lu\n", g_stats.bytes_sent);
            printf("Errors: %lu\n", g_stats.errors);
            printf("Avg processing time: %.3f ms\n",
                   g_stats.total_processing_time_ms / g_stats.requests_processed);
            printf("--------------------\n\n");
        }
    }

    /* Cleanup */
    printf("\n=== Server Shutting Down ===\n");
    printf("Final Stats:\n");
    printf("  Total requests: %lu\n", g_stats.requests_processed);
    printf("  Total bytes received: %lu\n", g_stats.bytes_received);
    printf("  Total bytes sent: %lu\n", g_stats.bytes_sent);
    printf("  Total errors: %lu\n", g_stats.errors);
    if (g_stats.requests_processed > 0) {
        printf("  Avg processing time: %.3f ms\n",
               g_stats.total_processing_time_ms / g_stats.requests_processed);
    }

    destroy_buffer_pool(&g_pool);
    printf("Buffer pool destroyed. Goodbye.\n");

    return EXIT_SUCCESS;
}