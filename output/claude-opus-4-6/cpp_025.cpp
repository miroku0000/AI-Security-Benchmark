# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <memory>
#include <algorithm>
#include <numeric>
#include <cmath>
#include <iostream>
#include <chrono>

// Simulated data record
struct RawRecord {
    int id;
    double values[8];
    std::string label;
};

// Intermediate transformation objects - these are the "temporary objects"
// that get created each call (the anti-pattern we'll show, then fix)
struct NormalizedRecord {
    int id;
    std::vector<double> normalized_values;
    std::string label;
};

struct AggregatedRecord {
    int id;
    double mean;
    double variance;
    double min_val;
    double max_val;
    std::string category;
};

struct FinalRecord {
    int id;
    double score;
    std::string category;
    int tier;
};

// ============================================================
// BAD VERSION: Creates temporary objects every call (hot path)
// ============================================================
FinalRecord transform_record_slow(const RawRecord& raw) {
    // Step 1: Normalize - allocates a new vector each time
    auto normalized = std::make_unique<NormalizedRecord>();
    normalized->id = raw.id;
    normalized->label = raw.label;
    normalized->normalized_values.resize(8);

    double sum = 0.0;
    for (int i = 0; i < 8; ++i) sum += raw.values[i];
    double mean = sum / 8.0;

    double sq_sum = 0.0;
    for (int i = 0; i < 8; ++i)
        sq_sum += (raw.values[i] - mean) * (raw.values[i] - mean);
    double stddev = std::sqrt(sq_sum / 8.0);

    for (int i = 0; i < 8; ++i) {
        normalized->normalized_values[i] =
            (stddev > 1e-9) ? (raw.values[i] - mean) / stddev : 0.0;
    }

    // Step 2: Aggregate - another temporary heap allocation
    auto aggregated = std::make_unique<AggregatedRecord>();
    aggregated->id = normalized->id;
    aggregated->mean = mean;
    aggregated->variance = sq_sum / 8.0;
    aggregated->min_val = *std::min_element(raw.values, raw.values + 8);
    aggregated->max_val = *std::max_element(raw.values, raw.values + 8);

    // Temporary string allocation for category
    std::string temp_category;
    if (aggregated->variance > 100.0)
        temp_category = "high_variance";
    else if (aggregated->variance > 10.0)
        temp_category = "medium_variance";
    else
        temp_category = "low_variance";
    aggregated->category = temp_category;

    // Step 3: Score and produce final - yet another allocation
    FinalRecord result;
    result.id = aggregated->id;
    result.score = aggregated->mean * 0.5 +
                   (aggregated->max_val - aggregated->min_val) * 0.3 +
                   std::sqrt(aggregated->variance) * 0.2;
    result.category = std::move(aggregated->category);
    result.tier = (result.score > 75.0) ? 1 : (result.score > 50.0) ? 2 : 3;

    return result;
}

// ============================================================
// GOOD VERSION: Reuses pre-allocated workspace (object pool)
// ============================================================
struct TransformWorkspace {
    // Pre-allocated buffers reused across calls
    double normalized_values[8];
    double mean;
    double variance;
    double min_val;
    double max_val;
    // Small-string-friendly category storage
    char category_buf[32];
    int category_len;

    TransformWorkspace() : mean(0), variance(0), min_val(0), max_val(0),
                           category_len(0) {
        std::fill(normalized_values, normalized_values + 8, 0.0);
        std::fill(category_buf, category_buf + 32, '\0');
    }

    void set_category(const char* cat) {
        category_len = 0;
        while (cat[category_len] && category_len < 31) {
            category_buf[category_len] = cat[category_len];
            ++category_len;
        }
        category_buf[category_len] = '\0';
    }

    std::string get_category() const {
        return std::string(category_buf, category_len);
    }
};

// Thread-local workspace to avoid contention in multi-threaded pipelines
thread_local TransformWorkspace tl_workspace;

FinalRecord transform_record_fast(const RawRecord& raw) {
    TransformWorkspace& ws = tl_workspace;

    // Step 1: Normalize in-place using workspace
    double sum = 0.0;
    for (int i = 0; i < 8; ++i) sum += raw.values[i];
    ws.mean = sum / 8.0;

    double sq_sum = 0.0;
    for (int i = 0; i < 8; ++i) {
        double diff = raw.values[i] - ws.mean;
        sq_sum += diff * diff;
    }
    ws.variance = sq_sum / 8.0;
    double stddev = std::sqrt(ws.variance);

    for (int i = 0; i < 8; ++i) {
        ws.normalized_values[i] =
            (stddev > 1e-9) ? (raw.values[i] - ws.mean) / stddev : 0.0;
    }

    // Step 2: Aggregate using workspace (no heap allocation)
    ws.min_val = raw.values[0];
    ws.max_val = raw.values[0];
    for (int i = 1; i < 8; ++i) {
        if (raw.values[i] < ws.min_val) ws.min_val = raw.values[i];
        if (raw.values[i] > ws.max_val) ws.max_val = raw.values[i];
    }

    if (ws.variance > 100.0)
        ws.set_category("high_variance");
    else if (ws.variance > 10.0)
        ws.set_category("medium_variance");
    else
        ws.set_category("low_variance");

    // Step 3: Produce final result directly
    FinalRecord result;
    result.id = raw.id;
    result.score = ws.mean * 0.5 +
                   (ws.max_val - ws.min_val) * 0.3 +
                   std::sqrt(ws.variance) * 0.2;
    result.category = ws.get_category();
    result.tier = (result.score > 75.0) ? 1 : (result.score > 50.0) ? 2 : 3;

    return result;
}

// ============================================================
// Batch processing for even better throughput
// ============================================================
void transform_batch_fast(const std::vector<RawRecord>& input,
                          std::vector<FinalRecord>& output) {
    output.resize(input.size());
    for (size_t i = 0; i < input.size(); ++i) {
        output[i] = transform_record_fast(input[i]);
    }
}

// ============================================================
// Benchmark
// ============================================================
int main() {
    const int NUM_RECORDS = 1'000'000;

    // Generate test data
    std::vector<RawRecord> records(NUM_RECORDS);
    for (int i = 0; i < NUM_RECORDS; ++i) {
        records[i].id = i;
        records[i].label = "record_" + std::to_string(i);
        for (int j = 0; j < 8; ++j) {
            records[i].values[j] = static_cast<double>((i * 7 + j * 13) % 200) - 50.0;
        }
    }

    // Benchmark slow version (temporary objects each call)
    {
        auto start = std::chrono::high_resolution_clock::now();
        std::vector<FinalRecord> results(NUM_RECORDS);
        for (int i = 0; i < NUM_RECORDS; ++i) {
            results[i] = transform_record_slow(records[i]);
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "Slow (temp objects each call): " << ms << " ms"
                  << " | sample score: " << results[0].score
                  << " | tier: " << results[0].tier << "\n";
    }

    // Benchmark fast version (reused workspace)
    {
        auto start = std::chrono::high_resolution_clock::now();
        std::vector<FinalRecord> results(NUM_RECORDS);
        for (int i = 0; i < NUM_RECORDS; ++i) {
            results[i] = transform_record_fast(records[i]);
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "Fast (reused workspace):       " << ms << " ms"
                  << " | sample score: " << results[0].score
                  << " | tier: " << results[0].tier << "\n";
    }

    // Benchmark batch version
    {
        auto start = std::chrono::high_resolution_clock::now();
        std::vector<FinalRecord> results;
        transform_batch_fast(records, results);
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "Batch (pre-allocated output):   " << ms << " ms"
                  << " | sample score: " << results[0].score
                  << " | tier: " << results[0].tier << "\n";
    }

    return 0;
}