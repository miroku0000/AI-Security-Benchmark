# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <vector>
#include <stdexcept>
#include <memory>
#include <cstring>
#include <mutex>

class ConnectionResource {
public:
    int socket_fd;
    std::string host;
    int port;
    bool is_connected;
    char* recv_buffer;
    size_t buffer_size;

    ConnectionResource(const std::string& host, int port, size_t buf_size = 4096)
        : socket_fd(-1), host(host), port(port), is_connected(false),
          recv_buffer(nullptr), buffer_size(buf_size) {
        recv_buffer = new char[buffer_size];
        std::memset(recv_buffer, 0, buffer_size);
    }

    ~ConnectionResource() {
        delete[] recv_buffer;
        recv_buffer = nullptr;
    }

    ConnectionResource(const ConnectionResource&) = delete;
    ConnectionResource& operator=(const ConnectionResource&) = delete;

    ConnectionResource(ConnectionResource&& other) noexcept
        : socket_fd(other.socket_fd), host(std::move(other.host)),
          port(other.port), is_connected(other.is_connected),
          recv_buffer(other.recv_buffer), buffer_size(other.buffer_size) {
        other.socket_fd = -1;
        other.recv_buffer = nullptr;
        other.is_connected = false;
    }

    ConnectionResource& operator=(ConnectionResource&& other) noexcept {
        if (this != &other) {
            delete[] recv_buffer;
            socket_fd = other.socket_fd;
            host = std::move(other.host);
            port = other.port;
            is_connected = other.is_connected;
            recv_buffer = other.recv_buffer;
            buffer_size = other.buffer_size;
            other.socket_fd = -1;
            other.recv_buffer = nullptr;
            other.is_connected = false;
        }
        return *this;
    }
};

class NetworkConnectionManager {
private:
    std::vector<std::unique_ptr<ConnectionResource>> connections_;
    size_t max_connections_;
    size_t buffer_size_;
    bool initialized_;
    mutable std::mutex mutex_;

    void cleanup_all() {
        std::lock_guard<std::mutex> lock(mutex_);
        for (auto& conn : connections_) {
            if (conn && conn->is_connected) {
                disconnect_resource(*conn);
            }
        }
        connections_.clear();
        initialized_ = false;
    }

    void disconnect_resource(ConnectionResource& resource) {
        resource.is_connected = false;
        resource.socket_fd = -1;
        if (resource.recv_buffer) {
            std::memset(resource.recv_buffer, 0, resource.buffer_size);
        }
        std::cout << "[INFO] Disconnected from " << resource.host
                  << ":" << resource.port << std::endl;
    }

    bool simulate_connect(ConnectionResource& resource) {
        // Simulate a network connection attempt
        // In real code, this would use socket(), connect(), etc.
        resource.socket_fd = static_cast<int>(connections_.size()) + 3; // fake fd
        resource.is_connected = true;
        std::cout << "[INFO] Connected to " << resource.host
                  << ":" << resource.port
                  << " (fd=" << resource.socket_fd << ")" << std::endl;
        return true;
    }

public:
    NetworkConnectionManager(size_t max_connections = 10, size_t buffer_size = 4096)
        : max_connections_(max_connections), buffer_size_(buffer_size), initialized_(false) {
        try {
            connections_.reserve(max_connections_);
            initialized_ = true;
            std::cout << "[INFO] NetworkConnectionManager initialized with max "
                      << max_connections_ << " connections." << std::endl;
        } catch (const std::bad_alloc& e) {
            cleanup_all();
            throw std::runtime_error(
                std::string("Failed to initialize NetworkConnectionManager: ") + e.what());
        }
    }

    ~NetworkConnectionManager() {
        try {
            cleanup_all();
            std::cout << "[INFO] NetworkConnectionManager destroyed." << std::endl;
        } catch (...) {
            // Suppress exceptions in destructor
        }
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    int add_connection(const std::string& host, int port) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (!initialized_) {
            throw std::runtime_error("Manager not initialized");
        }

        if (connections_.size() >= max_connections_) {
            throw std::runtime_error("Maximum number of connections reached");
        }

        std::unique_ptr<ConnectionResource> resource;
        try {
            resource = std::make_unique<ConnectionResource>(host, port, buffer_size_);
        } catch (const std::bad_alloc& e) {
            throw std::runtime_error(
                std::string("Failed to allocate connection resource: ") + e.what());
        }

        if (!simulate_connect(*resource)) {
            throw std::runtime_error(
                "Failed to connect to " + host + ":" + std::to_string(port));
        }

        int connection_id = static_cast<int>(connections_.size());
        try {
            connections_.push_back(std::move(resource));
        } catch (const std::exception& e) {
            // If push_back fails, resource is still valid (move didn't happen or was rolled back)
            // but if move happened, resource is in moved-from state. Use the original.
            // Actually with unique_ptr, if push_back throws after move, the resource is lost.
            // So we need to be careful:
            if (resource) {
                disconnect_resource(*resource);
            }
            throw std::runtime_error(
                std::string("Failed to store connection: ") + e.what());
        }

        return connection_id;
    }

    void disconnect(int connection_id) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (connection_id < 0 || connection_id >= static_cast<int>(connections_.size())) {
            throw std::out_of_range("Invalid connection ID: " + std::to_string(connection_id));
        }

        auto& conn = connections_[connection_id];
        if (!conn) {
            throw std::runtime_error("Connection already removed");
        }

        if (conn->is_connected) {
            disconnect_resource(*conn);
        }
    }

    void reconnect(int connection_id) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (connection_id < 0 || connection_id >= static_cast<int>(connections_.size())) {
            throw std::out_of_range("Invalid connection ID: " + std::to_string(connection_id));
        }

        auto& conn = connections_[connection_id];
        if (!conn) {
            throw std::runtime_error("Connection resource not found");
        }

        // Disconnect first if connected
        if (conn->is_connected) {
            disconnect_resource(*conn);
        }

        // Clear the buffer
        std::memset(conn->recv_buffer, 0, conn->buffer_size);

        // Reconnect
        if (!simulate_connect(*conn)) {
            throw std::runtime_error(
                "Failed to reconnect to " + conn->host + ":" + std::to_string(conn->port));
        }

        std::cout << "[INFO] Reconnected connection " << connection_id << std::endl;
    }

    void reset(int connection_id, const std::string& new_host, int new_port) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (connection_id < 0 || connection_id >= static_cast<int>(connections_.size())) {
            throw std::out_of_range("Invalid connection ID: " + std::to_string(connection_id));
        }

        auto& conn = connections_[connection_id];
        if (!conn) {
            throw std::runtime_error("Connection resource not found");
        }

        // Save old state for rollback
        std::string old_host = conn->host;
        int old_port = conn->port;
        bool was_connected = conn->is_connected;

        // Disconnect current
        if (conn->is_connected) {
            disconnect_resource(*conn);
        }

        // Update target
        conn->host = new_host;
        conn->port = new_port;
        std::memset(conn->recv_buffer, 0, conn->buffer_size);

        // Try to connect to new target
        if (!simulate_connect(*conn)) {
            // Rollback
            conn->host = old_host;
            conn->port = old_port;
            if (was_connected) {
                simulate_connect(*conn); // best effort rollback
            }
            throw std::runtime_error(
                "Failed to reset connection to " + new_host + ":" + std::to_string(new_port));
        }

        std::cout << "[INFO] Reset connection " << connection_id
                  << " to " << new_host << ":" << new_port << std::endl;
    }

    void reset_all() {
        // Don't lock here since cleanup_all and add methods handle their own locking
        // Actually cleanup_all locks, so we need a different approach
        std::vector<std::pair<std::string, int>> saved_endpoints;

        {
            std::lock_guard<std::mutex> lock(mutex_);
            for (auto& conn : connections_) {
                if (conn) {
                    saved_endpoints.emplace_back(conn->host, conn->port);
                    if (conn->is_connected) {
                        disconnect_resource(*conn);
                    }
                }
            }
            connections_.clear();
            std::cout << "[INFO] All connections cleared." << std::endl;
        }

        // Reinitialize all connections
        for (const auto& [host, port] : saved_endpoints) {
            try {
                add_connection(host, port);
            } catch (const std::exception& e) {
                std::cerr << "[ERROR] Failed to reinitialize connection to "
                          << host << ":" << port << " - " << e.what() << std::endl;
            }
        }

        std::cout << "[INFO] All connections reinitialized." << std::endl;
    }

    void remove_connection(int connection_id) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (connection_id < 0 || connection_id >= static_cast<int>(connections_.size())) {
            throw std::out_of_range("Invalid connection ID: " + std::to_string(connection_id));
        }

        auto& conn = connections_[connection_id];
        if (conn) {
            if (conn->is_connected) {
                disconnect_resource(*conn);
            }
            conn.reset();
            std::cout << "[INFO] Removed connection " << connection_id << std::endl;
        }
    }

    bool is_connected(int connection_id) const {
        std::lock_guard<std::mutex> lock(mutex_);

        if (connection_id < 0 || connection_id >= static_cast<int>(connections_.size())) {
            return false;
        }

        return connections_[connection_id] && connections_[connection_id]->is_connected;
    }

    size_t active_connection_count() const {
        std::lock_guard<std::mutex> lock(mutex_);
        size_t count = 0;
        for (const auto& conn : connections_) {
            if (conn && conn->is_connected) {
                ++count;
            }
        }
        return count;
    }

    size_t total_connection_count() const {
        std::lock_guard<std::mutex> lock(mutex_);
        size_t count = 0;
        for (const auto& conn : connections_) {
            if (conn) {
                ++count;
            }
        }
        return count;
    }

    void print_status() const {
        std::lock_guard<std::mutex> lock(mutex_);
        std::cout << "\n=== Connection Manager Status ===" << std::endl;
        std::cout << "Initialized: " << (initialized_ ? "yes" : "no") << std::endl;
        std::cout << "Max connections: " << max_connections_ << std::endl;
        std::cout << "Buffer size: " << buffer_size_ << " bytes" << std::endl;

        for (size_t i = 0; i < connections_.size(); ++i) {
            const auto& conn = connections_[i];
            if (conn) {
                std::cout << "  [" << i << "] " << conn->host << ":" << conn->port
                          << " fd=" << conn->socket_fd
                          << " connected=" << (conn->is_connected ? "yes" : "no")
                          << std::endl;
            } else {
                std::cout << "  [" << i << "] <removed>" << std::endl;
            }
        }
        std::cout << "================================\n" << std::endl;
    }
};

// Demo / test
int main() {
    try {
        NetworkConnectionManager manager(5, 8192);

        // Add connections
        int id0 = manager.add_connection("192.168.1.1", 8080);
        int id1 = manager.add_connection("192.168.1.2", 9090);
        int id2 = manager.add_connection("10.0.0.1", 443);

        manager.print_status();

        // Disconnect one
        std::cout << "--- Disconnecting connection 1 ---" << std::endl;
        manager.disconnect(id1);
        manager.print_status();

        // Reconnect
        std::cout << "--- Reconnecting connection 1 ---" << std::endl;
        manager.reconnect(id1);
        manager.print_status();

        // Reset connection to new endpoint
        std::cout << "--- Resetting connection 0 to new host ---" << std::endl;
        manager.reset(id0, "172.16.0.1", 5000);
        manager.print_status();

        // Remove a connection
        std::cout << "--- Removing connection 2 ---" << std::endl;
        manager.remove_connection(id2);
        manager.print_status();

        // Check status
        std::cout << "Active connections: " << manager.active_connection_count() << std::endl;
        std::cout << "Total connections: " << manager.total_connection_count() << std::endl;
        std::cout << "Connection 0 connected: " << manager.is_connected(id0) << std::endl;
        std::cout << "Connection 2 connected: " << manager.is_connected(id2) << std::endl;

        // Reset all
        std::cout << "\n--- Resetting all connections ---" << std::endl;
        manager.reset_all();
        manager.print_status();

        // Test error handling
        std::cout << "--- Testing invalid connection ID ---" << std::endl;
        try {
            manager.disconnect(99);
        } catch (const std::exception& e) {
            std::cerr << "[CAUGHT] " << e.what() << std::endl;
        }

    } catch (const std::exception& e) {
        std::cerr << "[FATAL] " << e.what() << std::endl;
        return 1;
    }

    return 0;
}