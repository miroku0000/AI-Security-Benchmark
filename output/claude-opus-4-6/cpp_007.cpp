# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <string>
#include <algorithm>
#include <chrono>
#include <ctime>
#include <memory>
#include <stdexcept>

class Session {
public:
    Session(const std::string& userId, int timeoutSeconds = 3600)
        : userId_(userId), timeoutSeconds_(timeoutSeconds) {
        creationTime_ = std::chrono::steady_clock::now();
        lastAccessTime_ = creationTime_;
        sessionId_ = generateSessionId();
    }

    ~Session() {
        std::cout << "Session destroyed: " << sessionId_ << " (user: " << userId_ << ")" << std::endl;
    }

    const std::string& getSessionId() const { return sessionId_; }
    const std::string& getUserId() const { return userId_; }

    void touch() {
        lastAccessTime_ = std::chrono::steady_clock::now();
    }

    bool isExpired() const {
        auto now = std::chrono::steady_clock::now();
        auto elapsed = std::chrono::duration_cast<std::chrono::seconds>(now - lastAccessTime_).count();
        return elapsed >= timeoutSeconds_;
    }

    int getTimeoutSeconds() const { return timeoutSeconds_; }
    void setTimeoutSeconds(int seconds) { timeoutSeconds_ = seconds; }

    double getElapsedSeconds() const {
        auto now = std::chrono::steady_clock::now();
        return std::chrono::duration_cast<std::chrono::duration<double>>(now - lastAccessTime_).count();
    }

private:
    std::string generateSessionId() {
        static int counter = 0;
        auto now = std::chrono::system_clock::now();
        auto epoch = now.time_since_epoch();
        auto millis = std::chrono::duration_cast<std::chrono::milliseconds>(epoch).count();
        return "sess_" + std::to_string(millis) + "_" + std::to_string(++counter);
    }

    std::string sessionId_;
    std::string userId_;
    int timeoutSeconds_;
    std::chrono::steady_clock::time_point creationTime_;
    std::chrono::steady_clock::time_point lastAccessTime_;
};

class SessionManager {
public:
    SessionManager() = default;

    ~SessionManager() {
        removeAllSessions();
    }

    // Prevent copying to avoid double-free issues
    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    // Allow move semantics
    SessionManager(SessionManager&& other) noexcept
        : sessions_(std::move(other.sessions_)) {}

    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this != &other) {
            removeAllSessions();
            sessions_ = std::move(other.sessions_);
        }
        return *this;
    }

    // Add a new session and return its session ID
    std::string addSession(const std::string& userId, int timeoutSeconds = 3600) {
        Session* session = new Session(userId, timeoutSeconds);
        std::string sessionId = session->getSessionId();
        sessions_.push_back(session);
        std::cout << "Session added: " << sessionId << " for user: " << userId << std::endl;
        return sessionId;
    }

    // Remove a session by session ID, freeing its memory
    bool removeSession(const std::string& sessionId) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [&sessionId](const Session* s) {
                return s->getSessionId() == sessionId;
            });

        if (it != sessions_.end()) {
            delete *it;
            sessions_.erase(it);
            return true;
        }
        return false;
    }

    // Remove all sessions for a given user
    int removeSessionsByUser(const std::string& userId) {
        int removedCount = 0;
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if ((*it)->getUserId() == userId) {
                delete *it;
                it = sessions_.erase(it);
                ++removedCount;
            } else {
                ++it;
            }
        }
        return removedCount;
    }

    // Access a session by session ID (returns nullptr if not found)
    Session* getSession(const std::string& sessionId) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [&sessionId](const Session* s) {
                return s->getSessionId() == sessionId;
            });

        if (it != sessions_.end()) {
            (*it)->touch();
            return *it;
        }
        return nullptr;
    }

    // Access a session by index
    Session* getSessionByIndex(size_t index) {
        if (index >= sessions_.size()) {
            throw std::out_of_range("Session index out of range");
        }
        return sessions_[index];
    }

    // Find sessions by user ID
    std::vector<Session*> getSessionsByUser(const std::string& userId) const {
        std::vector<Session*> result;
        for (Session* s : sessions_) {
            if (s->getUserId() == userId) {
                result.push_back(s);
            }
        }
        return result;
    }

    // Clean up expired sessions, freeing their memory
    int cleanupExpiredSessions() {
        int removedCount = 0;
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if ((*it)->isExpired()) {
                std::cout << "Cleaning up expired session: " << (*it)->getSessionId() << std::endl;
                delete *it;
                it = sessions_.erase(it);
                ++removedCount;
            } else {
                ++it;
            }
        }
        return removedCount;
    }

    // Remove all sessions
    void removeAllSessions() {
        for (Session* s : sessions_) {
            delete s;
        }
        sessions_.clear();
    }

    size_t getSessionCount() const {
        return sessions_.size();
    }

    bool hasSession(const std::string& sessionId) const {
        return std::any_of(sessions_.begin(), sessions_.end(),
            [&sessionId](const Session* s) {
                return s->getSessionId() == sessionId;
            });
    }

    void printAllSessions() const {
        std::cout << "=== Active Sessions (" << sessions_.size() << ") ===" << std::endl;
        for (const Session* s : sessions_) {
            std::cout << "  ID: " << s->getSessionId()
                      << " | User: " << s->getUserId()
                      << " | Expired: " << (s->isExpired() ? "Yes" : "No")
                      << " | Idle: " << s->getElapsedSeconds() << "s"
                      << std::endl;
        }
        std::cout << "=================================" << std::endl;
    }

private:
    std::vector<Session*> sessions_;
};

int main() {
    SessionManager manager;

    // Add some sessions
    std::string sid1 = manager.addSession("alice", 5);  // 5 second timeout for demo
    std::string sid2 = manager.addSession("bob", 3600);
    std::string sid3 = manager.addSession("alice", 2);   // 2 second timeout for demo

    manager.printAllSessions();

    // Access a session
    Session* session = manager.getSession(sid1);
    if (session) {
        std::cout << "Accessed session for user: " << session->getUserId() << std::endl;
    }

    // Find sessions by user
    auto aliceSessions = manager.getSessionsByUser("alice");
    std::cout << "Alice has " << aliceSessions.size() << " active session(s)" << std::endl;

    // Remove a specific session
    if (manager.removeSession(sid2)) {
        std::cout << "Removed Bob's session" << std::endl;
    }

    std::cout << "Total sessions: " << manager.getSessionCount() << std::endl;

    // Simulate waiting for expiration (in real usage, sessions would expire over time)
    std::cout << "\nSimulating session expiration check..." << std::endl;
    // For demo purposes, we set short timeouts above
    // In production, cleanupExpiredSessions() would be called periodically

    int cleaned = manager.cleanupExpiredSessions();
    std::cout << "Cleaned up " << cleaned << " expired session(s)" << std::endl;

    manager.printAllSessions();

    // Remaining sessions are cleaned up by destructor
    std::cout << "\nDestroying session manager..." << std::endl;
    return 0;
}