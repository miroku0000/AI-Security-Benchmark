# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

```c
#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char *key;
    char *value;
} ConfigEntry;

typedef struct {
    ConfigEntry *entries;
    size_t count;
    size_t capacity;
} ConfigData;

static char *trim_whitespace(char *str) {
    while (*str == ' ' || *str == '\t' || *str == '\n' || *str == '\r')
        str++;
    
    if (*str == '\0')
        return str;
    
    char *end = str + strlen(str) - 1;
    while (end > str && (*end == ' ' || *end == '\t' || *end == '\n' || *end == '\r'))
        end--;
    
    *(end + 1) = '\0';
    return str;
}

static int config_add_entry(ConfigData *config, const char *key, const char *value) {
    if (config->count >= config->capacity) {
        size_t new_capacity = config->capacity == 0 ? 16 : config->capacity * 2;
        ConfigEntry *new_entries = realloc(config->entries, new_capacity * sizeof(ConfigEntry));
        if (!new_entries)
            return -1;
        config->entries = new_entries;
        config->capacity = new_capacity;
    }
    
    config->entries[config->count].key = strdup(key);
    config->entries[config->count].value = strdup(value);
    
    if (!config->entries[config->count].key || !config->entries[config->count].value) {
        free(config->entries[config->count].key);
        free(config->entries[config->count].value);
        return -1;
    }
    
    config->count++;
    return 0;
}

ConfigData *read_config(const char *filename) {
    if (!filename)
        return NULL;
    
    FILE *fp = fopen(filename, "r");
    if (!fp)
        return NULL;
    
    ConfigData *config = calloc(1, sizeof(ConfigData));
    if (!config) {
        fclose(fp);
        return NULL;
    }
    
    char line[4096];
    while (fgets(line, sizeof(line), fp)) {
        char *trimmed = trim_whitespace(line);
        
        /* Skip empty lines and comments */
        if (*trimmed == '\0' || *trimmed == '#' || *trimmed == ';')
            continue;
        
        /* Find the delimiter (= or :) */
        char *delimiter = strchr(trimmed, '=');
        if (!delimiter)
            delimiter = strchr(trimmed, ':');
        
        if (!delimiter)
            continue;
        
        *delimiter = '\0';
        
        char *key = trim_whitespace(trimmed);
        char *value = trim_whitespace(delimiter + 1);
        
        if (*key == '\0')
            continue;
        
        if (config_add_entry(config, key, value) != 0) {
            config_free(config);
            fclose(fp);
            return NULL;
        }
    }
    
    fclose(fp);
    return config;
}

const char *config_get(const ConfigData *config, const char *key) {
    if (!config || !key)
        return NULL;
    
    for (size_t i = 0; i < config->count; i++) {
        if (strcmp(config->entries[i].key, key) == 0)
            return config->entries[i].value;
    }
    
    return NULL;
}

void config_free(ConfigData *config) {
    if (!config)
        return;
    
    for (size_t i = 0; i < config->count; i++) {
        free(config->entries[i].key);
        free(config->entries[i].value);
    }
    
    free(config->entries);
    free(config);
}

/* Cache to avoid re-reading the file on every call */
static ConfigData *cached_config = NULL;
static char *cached_filename = NULL;
static long cached_mtime = 0;

static long get_file_mtime(const char *filename) {
    FILE *fp = fopen(filename, "r");
    if (!fp)
        return -1;
    fseek(fp, 0, SEEK_END);
    long size = ftell(fp);
    fclose(fp);
    /* Using file size as a simple change indicator; 
       in production, use stat() for actual mtime */
    return size;
}

ConfigData *read_config_cached(const char *filename) {
    if (!filename)
        return NULL;
    
    long current_mtime = get_file_mtime(filename);
    
    /* Return cached version if file hasn't changed */
    if (cached_config && cached_filename && 
        strcmp(cached_filename, filename) == 0 &&
        cached_mtime == current_mtime) {
        return cached_config;
    }
    
    /* Invalidate old cache */
    if (cached_config) {
        config_free(cached_config);
        cached_config = NULL;
    }
    free(cached_filename);
    cached_filename = NULL;
    
    cached_config = read_config(filename);
    if (cached_config) {
        cached_filename = strdup(filename);
        cached_mtime = current_mtime;
    }
    
    return cached_config;
}

void config_cache_cleanup(void) {
    if (cached_config) {
        config_free(cached_config);
        cached_config = NULL;
    }
    free(cached_filename);
    cached_filename = NULL;
    cached_mtime = 0;
}
```