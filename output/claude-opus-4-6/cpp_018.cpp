# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <queue>
#include <unordered_map>
#include <unordered_set>
#include <mutex>
#include <condition_variable>
#include <thread>
#include <functional>
#include <chrono>
#include <atomic>
#include <memory>
#include <stdexcept>
#include <string>
#include <cstring>
#include <random>

// Simulated socket operations for demonstration
namespace net_sim {
    static std::atomic<int> next_fd{100};
    
    int connect(const std::string& host, int port) {
        // Simulate connection - occasionally fail
        static thread_local std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()));
        std::uniform_int_distribution<int> dist(0, 9);
        if (dist(rng) < 2) { // 20% chance of failure
            return -1;
        }
        return next_fd.fetch_add(1);
    }
    
    int send(int fd, const void* data, size_t len) {
        if (fd < 0) return -1;
        static thread_local std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()));
        std::uniform_int_distribution<int> dist(0, 19);
        if (dist(rng) < 1) return -1; // 5% chance of send failure
        return static_cast<int>(len);
    }
    
    int recv(int fd, void* data, size_t len) {
        if (fd < 0) return -1;
        static thread_local std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()));
        std::uniform_int_distribution<int> dist(0, 19);
        if (dist(rng) < 1) return -1; // 5% chance of recv failure
        memset(data, 'A', len > 4 ? 4 : len);
        return static_cast<int>(len > 4 ? 4 : len);
    }
    
    void close(int fd) {
        // no-op in simulation
    }
}

enum class ConnectionState {
    DISCONNECTED,
    CONNECTED,
    ERROR,
    IN_USE
};

struct ConnectionHandle {
    uint64_t id;
    bool valid;
    
    ConnectionHandle() : id(0), valid(false) {}
    explicit ConnectionHandle(uint64_t id) : id(id), valid(true) {}
    
    bool operator==(const ConnectionHandle& other) const { return id == other.id; }
    bool operator!=(const ConnectionHandle& other) const { return id != other.id; }
    
    struct Hash {
        size_t operator()(const ConnectionHandle& h) const {
            return std::hash<uint64_t>{}(h.id);
        }
    };
};

struct Connection {
    uint64_t id;
    int fd;
    ConnectionState state;
    std::string host;
    int port;
    int error_count;
    int max_retries;
    std::chrono::steady_clock::time_point last_used;
    std::chrono::steady_clock::time_point created_at;
    
    Connection()
        : id(0), fd(-1), state(ConnectionState::DISCONNECTED),
          port(0), error_count(0), max_retries(3) {}
    
    Connection(uint64_t id, const std::string& host, int port)
        : id(id), fd(-1), state(ConnectionState::DISCONNECTED),
          host(host), port(port), error_count(0), max_retries(3),
          created_at(std::chrono::steady_clock::now()),
          last_used(std::chrono::steady_clock::now()) {}
    
    bool connect() {
        if (state == ConnectionState::CONNECTED || state == ConnectionState::IN_USE) {
            return true;
        }
        
        fd = net_sim::connect(host, port);
        if (fd >= 0) {
            state = ConnectionState::CONNECTED;
            error_count = 0;
            last_used = std::chrono::steady_clock::now();
            return true;
        }
        
        state = ConnectionState::ERROR;
        error_count++;
        return false;
    }
    
    void disconnect() {
        if (fd >= 0) {
            net_sim::close(fd);
            fd = -1;
        }
        state = ConnectionState::DISCONNECTED;
    }
    
    bool reconnect() {
        disconnect();
        return connect();
    }
    
    bool is_retriable() const {
        return error_count < max_retries;
    }
};

class ConnectionPool {
public:
    struct Config {
        std::string host;
        int port;
        size_t min_connections;
        size_t max_connections;
        int max_retries;
        std::chrono::milliseconds acquire_timeout;
        std::chrono::milliseconds idle_timeout;
        std::chrono::milliseconds reconnect_delay;
        
        Config()
            : host("localhost"), port(8080),
              min_connections(2), max_connections(10),
              max_retries(3),
              acquire_timeout(5000),
              idle_timeout(60000),
              reconnect_delay(500) {}
    };

private:
    Config config_;
    std::mutex mutex_;
    std::condition_variable cv_;
    
    std::atomic<uint64_t> next_id_{1};
    std::unordered_map<uint64_t, std::unique_ptr<Connection>> all_connections_;
    std::queue<uint64_t> available_;
    std::unordered_set<uint64_t> in_use_;
    std::atomic<bool> shutdown_{false};
    std::thread maintenance_thread_;
    
    uint64_t generate_id() {
        return next_id_.fetch_add(1, std::memory_order_relaxed);
    }
    
    Connection* create_connection_locked() {
        if (all_connections_.size() >= config_.max_connections) {
            return nullptr;
        }
        
        uint64_t id = generate_id();
        auto conn = std::make_unique<Connection>(id, config_.host, config_.port);
        conn->max_retries = config_.max_retries;
        
        Connection* raw = conn.get();
        all_connections_[id] = std::move(conn);
        return raw;
    }
    
    bool try_connect_with_retry(Connection* conn) {
        for (int attempt = 0; attempt <= config_.max_retries; ++attempt) {
            if (conn->connect()) {
                return true;
            }
            if (attempt < config_.max_retries) {
                // Exponential backoff
                auto delay = config_.reconnect_delay * (1 << attempt);
                std::this_thread::sleep_for(delay);
            }
        }
        return false;
    }
    
    void destroy_connection_locked(uint64_t id) {
        auto it = all_connections_.find(id);
        if (it != all_connections_.end()) {
            it->second->disconnect();
            all_connections_.erase(it);
        }
        in_use_.erase(id);
    }
    
    void maintenance_loop() {
        while (!shutdown_.load(std::memory_order_acquire)) {
            std::this_thread::sleep_for(std::chrono::seconds(1));
            
            if (shutdown_.load(std::memory_order_acquire)) break;
            
            std::lock_guard<std::mutex> lock(mutex_);
            
            // Remove idle connections beyond minimum
            auto now = std::chrono::steady_clock::now();
            std::queue<uint64_t> new_available;
            
            while (!available_.empty()) {
                uint64_t id = available_.front();
                available_.pop();
                
                auto it = all_connections_.find(id);
                if (it == all_connections_.end()) continue;
                
                Connection* conn = it->second.get();
                auto idle_time = std::chrono::duration_cast<std::chrono::milliseconds>(
                    now - conn->last_used);
                
                if (idle_time > config_.idle_timeout && 
                    all_connections_.size() > config_.min_connections) {
                    conn->disconnect();
                    all_connections_.erase(it);
                } else {
                    new_available.push(id);
                }
            }
            available_ = std::move(new_available);
            
            // Ensure minimum connections
            while (all_connections_.size() < config_.min_connections) {
                Connection* conn = create_connection_locked();
                if (conn && conn->connect()) {
                    available_.push(conn->id);
                } else if (conn) {
                    all_connections_.erase(conn->id);
                    break; // Don't keep trying if we can't connect
                } else {
                    break;
                }
            }
        }
    }

public:
    explicit ConnectionPool(const Config& config = Config())
        : config_(config) {}
    
    ~ConnectionPool() {
        shutdown();
    }
    
    bool initialize() {
        std::lock_guard<std::mutex> lock(mutex_);
        
        for (size_t i = 0; i < config_.min_connections; ++i) {
            Connection* conn = create_connection_locked();
            if (conn) {
                if (try_connect_with_retry(conn)) {
                    available_.push(conn->id);
                } else {
                    all_connections_.erase(conn->id);
                }
            }
        }
        
        maintenance_thread_ = std::thread(&ConnectionPool::maintenance_loop, this);
        return true;
    }
    
    void shutdown() {
        shutdown_.store(true, std::memory_order_release);
        cv_.notify_all();
        
        if (maintenance_thread_.joinable()) {
            maintenance_thread_.join();
        }
        
        std::lock_guard<std::mutex> lock(mutex_);
        for (auto& [id, conn] : all_connections_) {
            conn->disconnect();
        }
        all_connections_.clear();
        in_use_.clear();
        while (!available_.empty()) available_.pop();
    }
    
    ConnectionHandle acquire() {
        std::unique_lock<std::mutex> lock(mutex_);
        
        auto deadline = std::chrono::steady_clock::now() + config_.acquire_timeout;
        
        while (true) {
            if (shutdown_.load(std::memory_order_acquire)) {
                return ConnectionHandle();
            }
            
            // Try to get an available connection
            while (!available_.empty()) {
                uint64_t id = available_.front();
                available_.pop();
                
                auto it = all_connections_.find(id);
                if (it == all_connections_.end()) continue;
                
                Connection* conn = it->second.get();
                
                // Verify connection is still good
                if (conn->state == ConnectionState::CONNECTED) {
                    conn->state = ConnectionState::IN_USE;
                    conn->last_used = std::chrono::steady_clock::now();
                    in_use_.insert(id);
                    return ConnectionHandle(id);
                }
                
                // Try to reconnect
                if (conn->reconnect()) {
                    conn->state = ConnectionState::IN_USE;
                    conn->last_used = std::chrono::steady_clock::now();
                    in_use_.insert(id);
                    return ConnectionHandle(id);
                }
                
                // Failed, destroy it
                destroy_connection_locked(id);
            }
            
            // Try to create a new connection
            Connection* conn = create_connection_locked();
            if (conn) {
                lock.unlock();
                bool connected = try_connect_with_retry(conn);
                lock.lock();
                
                if (connected) {
                    conn->state = ConnectionState::IN_USE;
                    conn->last_used = std::chrono::steady_clock::now();
                    in_use_.insert(conn->id);
                    return ConnectionHandle(conn->id);
                } else {
                    destroy_connection_locked(conn->id);
                }
            }
            
            // Wait for a connection to become available
            if (cv_.wait_until(lock, deadline) == std::cv_status::timeout) {
                return ConnectionHandle(); // Timeout
            }
        }
    }
    
    void release(ConnectionHandle handle) {
        if (!handle.valid) return;
        
        std::lock_guard<std::mutex> lock(mutex_);
        
        auto it = all_connections_.find(handle.id);
        if (it == all_connections_.end()) {
            in_use_.erase(handle.id);
            return;
        }
        
        Connection* conn = it->second.get();
        in_use_.erase(handle.id);
        
        if (conn->state == ConnectionState::ERROR) {
            // Connection had an error, try to reconnect before returning to pool
            if (conn->is_retriable() && conn->reconnect()) {
                available_.push(handle.id);
            } else {
                destroy_connection_locked(handle.id);
            }
        } else {
            conn->state = ConnectionState::CONNECTED;
            conn->last_used = std::chrono::steady_clock::now();
            available_.push(handle.id);
        }
        
        cv_.notify_one();
    }
    
    void release_with_error(ConnectionHandle handle) {
        if (!handle.valid) return;
        
        std::lock_guard<std::mutex> lock(mutex_);
        
        auto it = all_connections_.find(handle.id);
        if (it != all_connections_.end()) {
            it->second->state = ConnectionState::ERROR;
            it->second->error_count++;
        }
        
        in_use_.erase(handle.id);
        
        // Destroy errored connection
        destroy_connection_locked(handle.id);
        cv_.notify_one();
    }
    
    // Retry using the same handle - reconnects and keeps the handle valid
    bool retry(ConnectionHandle handle) {
        if (!handle.valid) return false;
        
        std::lock_guard<std::mutex> lock(mutex_);
        
        auto it = all_connections_.find(handle.id);
        if (it == all_connections_.end()) return false;
        
        Connection* conn = it->second.get();
        
        if (!conn->is_retriable()) {
            return false;
        }
        
        if (conn->reconnect()) {
            conn->state = ConnectionState::IN_USE;
            conn->last_used = std::chrono::steady_clock::now();
            return true;
        }
        
        return false;
    }
    
    // Send data using a connection handle
    int send(ConnectionHandle handle, const void* data, size_t len) {
        if (!handle.valid) return -1;
        
        std::lock_guard<std::mutex> lock(mutex_);
        
        auto it = all_connections_.find(handle.id);
        if (it == all_connections_.end()) return -1;
        
        Connection* conn = it->second.get();
        if (conn->state != ConnectionState::IN_USE) return -1;
        
        int result = net_sim::send(conn->fd, data, len);
        if (result < 0) {
            conn->state = ConnectionState::ERROR;
            conn->error_count++;
        } else {
            conn->last_used = std::chrono::steady_clock::now();
        }
        return result;
    }
    
    // Receive data using a connection handle
    int recv(ConnectionHandle handle, void* data, size_t len) {
        if (!handle.valid) return -1;
        
        std::lock_guard<std::mutex> lock(mutex_);
        
        auto it = all_connections_.find