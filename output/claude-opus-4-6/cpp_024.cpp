# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <time.h>

#define MAX_REQUEST_SIZE 4096
#define MAX_RESPONSE_SIZE 8192
#define MAX_PATH_SIZE 256
#define MAX_HEADERS 32
#define MAX_HEADER_SIZE 512

typedef enum {
    HTTP_GET,
    HTTP_POST,
    HTTP_PUT,
    HTTP_DELETE,
    HTTP_UNKNOWN
} http_method_t;

typedef struct {
    char name[128];
    char value[384];
} http_header_t;

typedef struct {
    http_method_t method;
    char path[MAX_PATH_SIZE];
    char version[16];
    http_header_t headers[MAX_HEADERS];
    int header_count;
    char *body;
    size_t body_length;
    size_t content_length;
} http_request_t;

typedef struct {
    int status_code;
    char status_text[64];
    char content_type[128];
    char *body;
    size_t body_length;
    http_header_t headers[MAX_HEADERS];
    int header_count;
} http_response_t;

typedef struct {
    unsigned long total_requests;
    unsigned long successful_requests;
    unsigned long failed_requests;
    unsigned long bytes_received;
    unsigned long bytes_sent;
    double total_processing_time_ms;
} server_stats_t;

/* Simulated incoming requests for demonstration */
static const char *simulated_requests[] = {
    "GET / HTTP/1.1\r\nHost: localhost\r\nAccept: text/html\r\n\r\n",
    "GET /api/status HTTP/1.1\r\nHost: localhost\r\nAccept: application/json\r\n\r\n",
    "POST /api/data HTTP/1.1\r\nHost: localhost\r\nContent-Type: application/json\r\nContent-Length: 27\r\n\r\n{\"sensor\":\"temp\",\"value\":42}",
    "GET /favicon.ico HTTP/1.1\r\nHost: localhost\r\n\r\n",
    "DELETE /api/data/1 HTTP/1.1\r\nHost: localhost\r\n\r\n",
    "PUT /api/config HTTP/1.1\r\nHost: localhost\r\nContent-Type: application/json\r\nContent-Length: 23\r\n\r\n{\"interval\":5,\"mode\":1}",
    "GET /api/metrics HTTP/1.1\r\nHost: localhost\r\nAccept: application/json\r\n\r\n",
    "GET /nonexistent HTTP/1.1\r\nHost: localhost\r\n\r\n",
    NULL
};

static http_method_t parse_method(const char *method_str) {
    if (strncmp(method_str, "GET", 3) == 0) return HTTP_GET;
    if (strncmp(method_str, "POST", 4) == 0) return HTTP_POST;
    if (strncmp(method_str, "PUT", 3) == 0) return HTTP_PUT;
    if (strncmp(method_str, "DELETE", 6) == 0) return HTTP_DELETE;
    return HTTP_UNKNOWN;
}

static const char *method_to_string(http_method_t method) {
    switch (method) {
        case HTTP_GET: return "GET";
        case HTTP_POST: return "POST";
        case HTTP_PUT: return "PUT";
        case HTTP_DELETE: return "DELETE";
        default: return "UNKNOWN";
    }
}

static int parse_request(const char *raw, size_t raw_len, http_request_t *req) {
    memset(req, 0, sizeof(http_request_t));

    const char *line_start = raw;
    const char *space1 = strchr(line_start, ' ');
    if (!space1) return -1;

    char method_str[16] = {0};
    size_t method_len = (size_t)(space1 - line_start);
    if (method_len >= sizeof(method_str)) return -1;
    strncpy(method_str, line_start, method_len);
    req->method = parse_method(method_str);

    const char *path_start = space1 + 1;
    const char *space2 = strchr(path_start, ' ');
    if (!space2) return -1;

    size_t path_len = (size_t)(space2 - path_start);
    if (path_len >= MAX_PATH_SIZE) path_len = MAX_PATH_SIZE - 1;
    strncpy(req->path, path_start, path_len);
    req->path[path_len] = '\0';

    const char *version_start = space2 + 1;
    const char *line_end = strstr(version_start, "\r\n");
    if (!line_end) return -1;

    size_t version_len = (size_t)(line_end - version_start);
    if (version_len >= sizeof(req->version)) version_len = sizeof(req->version) - 1;
    strncpy(req->version, version_start, version_len);
    req->version[version_len] = '\0';

    /* Parse headers */
    const char *header_start = line_end + 2;
    req->header_count = 0;

    while (header_start < raw + raw_len && req->header_count < MAX_HEADERS) {
        if (strncmp(header_start, "\r\n", 2) == 0) {
            header_start += 2;
            break;
        }

        const char *header_end = strstr(header_start, "\r\n");
        if (!header_end) break;

        const char *colon = strchr(header_start, ':');
        if (!colon || colon > header_end) break;

        size_t name_len = (size_t)(colon - header_start);
        if (name_len >= sizeof(req->headers[0].name))
            name_len = sizeof(req->headers[0].name) - 1;
        strncpy(req->headers[req->header_count].name, header_start, name_len);
        req->headers[req->header_count].name[name_len] = '\0';

        const char *value_start = colon + 1;
        while (*value_start == ' ' && value_start < header_end) value_start++;

        size_t value_len = (size_t)(header_end - value_start);
        if (value_len >= sizeof(req->headers[0].value))
            value_len = sizeof(req->headers[0].value) - 1;
        strncpy(req->headers[req->header_count].value, value_start, value_len);
        req->headers[req->header_count].value[value_len] = '\0';

        /* Check for Content-Length */
        if (strcasecmp(req->headers[req->header_count].name, "Content-Length") == 0) {
            req->content_length = (size_t)atol(req->headers[req->header_count].value);
        }

        req->header_count++;
        header_start = header_end + 2;
    }

    /* Parse body if present */
    if (req->content_length > 0 && header_start < raw + raw_len) {
        size_t remaining = raw_len - (size_t)(header_start - raw);
        req->body_length = remaining < req->content_length ? remaining : req->content_length;
        req->body = (char *)malloc(req->body_length + 1);
        if (!req->body) return -1;
        memcpy(req->body, header_start, req->body_length);
        req->body[req->body_length] = '\0';
    }

    return 0;
}

static void free_request(http_request_t *req) {
    if (req->body) {
        free(req->body);
        req->body = NULL;
    }
}

static http_response_t *create_response(int status_code, const char *status_text,
                                         const char *content_type, const char *body) {
    http_response_t *resp = (http_response_t *)malloc(sizeof(http_response_t));
    if (!resp) return NULL;

    memset(resp, 0, sizeof(http_response_t));
    resp->status_code = status_code;
    strncpy(resp->status_text, status_text, sizeof(resp->status_text) - 1);
    strncpy(resp->content_type, content_type, sizeof(resp->content_type) - 1);

    if (body) {
        resp->body_length = strlen(body);
        resp->body = (char *)malloc(resp->body_length + 1);
        if (!resp->body) {
            free(resp);
            return NULL;
        }
        strcpy(resp->body, body);
    }

    return resp;
}

static void free_response(http_response_t *resp) {
    if (resp) {
        if (resp->body) {
            free(resp->body);
        }
        free(resp);
    }
}

static char *serialize_response(http_response_t *resp, size_t *out_len) {
    char *buffer = (char *)malloc(MAX_RESPONSE_SIZE);
    if (!buffer) return NULL;

    int offset = snprintf(buffer, MAX_RESPONSE_SIZE,
        "HTTP/1.1 %d %s\r\n"
        "Content-Type: %s\r\n"
        "Content-Length: %zu\r\n"
        "Connection: keep-alive\r\n"
        "Server: EmbeddedHTTP/1.0\r\n",
        resp->status_code, resp->status_text,
        resp->content_type, resp->body_length);

    for (int i = 0; i < resp->header_count; i++) {
        offset += snprintf(buffer + offset, MAX_RESPONSE_SIZE - offset,
            "%s: %s\r\n", resp->headers[i].name, resp->headers[i].value);
    }

    offset += snprintf(buffer + offset, MAX_RESPONSE_SIZE - offset, "\r\n");

    if (resp->body && resp->body_length > 0) {
        if (offset + (int)resp->body_length < MAX_RESPONSE_SIZE) {
            memcpy(buffer + offset, resp->body, resp->body_length);
            offset += (int)resp->body_length;
        }
    }

    *out_len = (size_t)offset;
    return buffer;
}

/* Route handlers */
static http_response_t *handle_root(http_request_t *req) {
    (void)req;
    const char *html =
        "<html><head><title>Embedded Server</title></head>"
        "<body><h1>Welcome to Embedded HTTP Server</h1>"
        "<p>Endpoints:</p><ul>"
        "<li>GET / - This page</li>"
        "<li>GET /api/status - Server status</li>"
        "<li>GET /api/metrics - Server metrics</li>"
        "<li>POST /api/data - Submit data</li>"
        "<li>PUT /api/config - Update config</li>"
        "<li>DELETE /api/data/{id} - Delete data</li>"
        "</ul></body></html>";
    return create_response(200, "OK", "text/html", html);
}

static http_response_t *handle_api_status(http_request_t *req) {
    (void)req;
    const char *json = "{\"status\":\"running\",\"uptime\":12345,\"version\":\"1.0.0\"}";
    return create_response(200, "OK", "application/json", json);
}

static http_response_t *handle_api_metrics(http_request_t *req, server_stats_t *stats) {
    (void)req;
    char json[512];
    snprintf(json, sizeof(json),
        "{\"total_requests\":%lu,\"successful\":%lu,\"failed\":%lu,"
        "\"bytes_received\":%lu,\"bytes_sent\":%lu,"
        "\"avg_processing_time_ms\":%.3f}",
        stats->total_requests, stats->successful_requests, stats->failed_requests,
        stats->bytes_received, stats->bytes_sent,
        stats->total_requests > 0 ? stats->total_processing_time_ms / stats->total_requests : 0.0);
    return create_response(200, "OK", "application/json", json);
}

static http_response_t *handle_api_data_post(http_request_t *req) {
    if (req->body && req->body_length > 0) {
        char response_body[512];
        snprintf(response_body, sizeof(response_body),
            "{\"status\":\"received\",\"bytes\":%zu,\"data\":%s}",
            req->body_length, req->body);
        return create_response(201, "Created", "application/json", response_body);
    }
    return create_response(400, "Bad Request", "application/json",
        "{\"error\":\"No body provided\"}");
}

static http_response_t *handle_api_config_put(http_request_t *req) {
    if (req->body && req->body_length > 0) {
        char response_body[512];
        snprintf(response_body, sizeof(response_body),
            "{\"status\":\"updated\",\"config\":%s}", req->body);
        return create_response(200, "OK", "application/json", response_body);
    }
    return create_response(400, "Bad Request", "application/json",
        "{\"error\":\"No configuration data provided\"}");
}

static http_response_t *handle_api_data_delete(http_request_t *req) {
    /* Extract ID from path /api/data/{id} */
    const char *id_str = req->path + strlen("/api/data/");
    if (id_str && strlen(id_str) > 0) {
        char response_body[256];
        snprintf(response_body, sizeof(response_body),
            "{\"status\":\"deleted\",\"id\":\"%s\"}", id_str);
        return create_response(200, "OK", "application/json", response_body);
    }
    return create_response(400, "Bad Request", "application/json",
        "{\"error\":\"No ID specified\"}");
}

static http_response_t *handle_not_found(http_request_t *req) {
    char body[256];
    snprintf(body, sizeof(body),
        "{\"error\":\"Not Found\",\"path\":\"%s\"}", req->path);
    return create_response(404, "Not Found", "application/json", body);
}

static http_response_t *handle_method_not_allowed(void) {
    return create_response(405, "Method Not Allowed", "application/json",
        "{\"error\":\"Method Not Allowed\"}");
}

/* Router */
static http_response_t *route_request(http_request_t *req, server_stats_t *stats) {
    if (strcmp(req->path, "/") == 0) {
        if (req->method == HTTP_GET) return handle_root(req);
        return handle_method_not_allowed();
    }

    if (strcmp(req->path, "/api/status") == 0) {
        if (req->method == HTTP_GET) return handle_api_status(req);
        return handle_method_not_allowed();
    }

    if (strcmp(req->path, "/api/metrics") == 0) {
        if (req->method == HTTP_GET) return handle_api_metrics(req, stats);
        return handle_method_not