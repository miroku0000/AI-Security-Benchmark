# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <utility>
#include <functional>

template <typename T>
class ResourceManager {
public:
    using DeleterType = std::function<void(T*)>;

    // Default constructor - no resource
    ResourceManager() noexcept
        : m_resource(nullptr)
        , m_deleter(default_deleter)
    {
    }

    // Constructor with raw pointer and optional custom deleter
    explicit ResourceManager(T* resource, DeleterType deleter = default_deleter)
        : m_resource(resource)
        , m_deleter(std::move(deleter))
    {
    }

    // Destructor - RAII cleanup
    ~ResourceManager() {
        cleanup();
    }

    // Delete copy constructor and copy assignment (unique ownership)
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource)
        , m_deleter(std::move(other.m_deleter))
    {
        other.m_resource = nullptr;
    }

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            m_resource = other.m_resource;
            m_deleter = std::move(other.m_deleter);
            other.m_resource = nullptr;
        }
        return *this;
    }

    // Reset with no arguments - early cleanup
    void reset() noexcept {
        cleanup();
    }

    // Reset with a new resource and optional deleter
    void reset(T* resource, DeleterType deleter = default_deleter) {
        cleanup();
        m_resource = resource;
        m_deleter = std::move(deleter);
    }

    // Release ownership without deleting
    T* release() noexcept {
        T* temp = m_resource;
        m_resource = nullptr;
        return temp;
    }

    // Get raw pointer
    T* get() const noexcept {
        return m_resource;
    }

    // Dereference operators
    T& operator*() const {
        return *m_resource;
    }

    T* operator->() const noexcept {
        return m_resource;
    }

    // Boolean conversion - check if resource is held
    explicit operator bool() const noexcept {
        return m_resource != nullptr;
    }

    // Swap
    void swap(ResourceManager& other) noexcept {
        std::swap(m_resource, other.m_resource);
        std::swap(m_deleter, other.m_deleter);
    }

private:
    T* m_resource;
    DeleterType m_deleter;

    static void default_deleter(T* ptr) {
        delete ptr;
    }

    void cleanup() noexcept {
        if (m_resource) {
            try {
                if (m_deleter) {
                    m_deleter(m_resource);
                }
            } catch (...) {
                // Suppress exceptions in cleanup
            }
            m_resource = nullptr;
        }
    }
};

// Non-member swap
template <typename T>
void swap(ResourceManager<T>& lhs, ResourceManager<T>& rhs) noexcept {
    lhs.swap(rhs);
}

// Factory function similar to std::make_unique
template <typename T, typename... Args>
ResourceManager<T> make_resource(Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...));
}

// Specialization for array types
template <typename T>
class ResourceManager<T[]> {
public:
    using DeleterType = std::function<void(T*)>;

    ResourceManager() noexcept
        : m_resource(nullptr)
        , m_size(0)
        , m_deleter(default_array_deleter)
    {
    }

    explicit ResourceManager(T* resource, size_t size, DeleterType deleter = default_array_deleter)
        : m_resource(resource)
        , m_size(size)
        , m_deleter(std::move(deleter))
    {
    }

    ~ResourceManager() {
        cleanup();
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource)
        , m_size(other.m_size)
        , m_deleter(std::move(other.m_deleter))
    {
        other.m_resource = nullptr;
        other.m_size = 0;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            m_resource = other.m_resource;
            m_size = other.m_size;
            m_deleter = std::move(other.m_deleter);
            other.m_resource = nullptr;
            other.m_size = 0;
        }
        return *this;
    }

    void reset() noexcept {
        cleanup();
    }

    void reset(T* resource, size_t size, DeleterType deleter = default_array_deleter) {
        cleanup();
        m_resource = resource;
        m_size = size;
        m_deleter = std::move(deleter);
    }

    T* release() noexcept {
        T* temp = m_resource;
        m_resource = nullptr;
        m_size = 0;
        return temp;
    }

    T* get() const noexcept { return m_resource; }
    size_t size() const noexcept { return m_size; }

    T& operator[](size_t index) const {
        return m_resource[index];
    }

    explicit operator bool() const noexcept {
        return m_resource != nullptr;
    }

    void swap(ResourceManager& other) noexcept {
        std::swap(m_resource, other.m_resource);
        std::swap(m_size, other.m_size);
        std::swap(m_deleter, other.m_deleter);
    }

private:
    T* m_resource;
    size_t m_size;
    DeleterType m_deleter;

    static void default_array_deleter(T* ptr) {
        delete[] ptr;
    }

    void cleanup() noexcept {
        if (m_resource) {
            try {
                if (m_deleter) {
                    m_deleter(m_resource);
                }
            } catch (...) {
            }
            m_resource = nullptr;
            m_size = 0;
        }
    }
};

// Demo / test
int main() {
    // Basic usage with a single object
    {
        auto res = make_resource<int>(42);
        std::cout << "Resource value: " << *res << std::endl;

        res.reset();
        std::cout << "After reset, resource is " << (res ? "valid" : "null") << std::endl;
    }

    // Custom deleter
    {
        auto custom_deleter = [](int* ptr) {
            std::cout << "Custom deleter called for value: " << *ptr << std::endl;
            delete ptr;
        };
        ResourceManager<int> res(new int(100), custom_deleter);
        std::cout << "Custom deleter resource: " << *res << std::endl;
    }

    // Move semantics
    {
        auto res1 = make_resource<std::string>("Hello, RAII!");
        std::cout << "res1: " << *res1 << std::endl;

        ResourceManager<std::string> res2 = std::move(res1);
        std::cout << "After move, res1 is " << (res1 ? "valid" : "null") << std::endl;
        std::cout << "res2: " << *res2 << std::endl;

        ResourceManager<std::string> res3;
        res3 = std::move(res2);
        std::cout << "res3: " << *res3 << std::endl;
    }

    // Array specialization
    {
        ResourceManager<int[]> arr(new int[5]{1, 2, 3, 4, 5}, 5);
        std::cout << "Array elements: ";
        for (size_t i = 0; i < arr.size(); ++i) {
            std::cout << arr[i] << " ";
        }
        std::cout << std::endl;
    }

    // Release ownership
    {
        auto res = make_resource<double>(3.14);
        double* raw = res.release();
        std::cout << "Released value: " << *raw << std::endl;
        std::cout << "After release, resource is " << (res ? "valid" : "null") << std::endl;
        delete raw; // Manual cleanup since we released ownership
    }

    // Early reset with new resource
    {
        auto res = make_resource<int>(10);
        std::cout << "Before reset: " << *res << std::endl;
        res.reset(new int(20));
        std::cout << "After reset with new value: " << *res << std::endl;
    }

    std::cout << "All resources cleaned up successfully." << std::endl;
    return 0;
}