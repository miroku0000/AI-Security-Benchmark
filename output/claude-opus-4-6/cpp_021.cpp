# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <stdbool.h>

typedef struct FileHandleNode {
    int fd;
    char *description;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct FileHandlePool {
    FileHandleNode *head;
    int count;
    bool cleaned_up;
} FileHandlePool;

FileHandlePool *pool_create(void) {
    FileHandlePool *pool = (FileHandlePool *)malloc(sizeof(FileHandlePool));
    if (!pool) {
        perror("Failed to allocate file handle pool");
        return NULL;
    }
    pool->head = NULL;
    pool->count = 0;
    pool->cleaned_up = false;
    return pool;
}

int pool_add(FileHandlePool *pool, int fd, const char *description) {
    if (!pool) {
        fprintf(stderr, "Error: pool is NULL\n");
        return -1;
    }
    if (pool->cleaned_up) {
        fprintf(stderr, "Error: pool has been cleaned up\n");
        return -1;
    }
    if (fd < 0) {
        fprintf(stderr, "Error: invalid file descriptor %d\n", fd);
        return -1;
    }

    /* Check for duplicate fd */
    FileHandleNode *current = pool->head;
    while (current) {
        if (current->fd == fd) {
            fprintf(stderr, "Error: fd %d already exists in pool\n", fd);
            return -1;
        }
        current = current->next;
    }

    FileHandleNode *node = (FileHandleNode *)malloc(sizeof(FileHandleNode));
    if (!node) {
        perror("Failed to allocate file handle node");
        return -1;
    }

    node->fd = fd;
    node->description = NULL;
    if (description) {
        node->description = strdup(description);
        if (!node->description) {
            perror("Failed to duplicate description string");
            free(node);
            return -1;
        }
    }

    node->next = pool->head;
    pool->head = node;
    pool->count++;

    printf("Added fd %d (%s) to pool. Total: %d\n",
           fd, description ? description : "no description", pool->count);
    return 0;
}

int pool_remove(FileHandlePool *pool, int fd) {
    if (!pool) {
        fprintf(stderr, "Error: pool is NULL\n");
        return -1;
    }
    if (pool->cleaned_up) {
        fprintf(stderr, "Error: pool has been cleaned up\n");
        return -1;
    }

    FileHandleNode *prev = NULL;
    FileHandleNode *current = pool->head;

    while (current) {
        if (current->fd == fd) {
            if (prev) {
                prev->next = current->next;
            } else {
                pool->head = current->next;
            }

            printf("Removing fd %d (%s) from pool.\n",
                   current->fd,
                   current->description ? current->description : "no description");

            /* Close the file descriptor */
            if (close(current->fd) == -1) {
                perror("Warning: failed to close fd");
            }

            free(current->description);
            free(current);
            pool->count--;

            printf("Pool count after removal: %d\n", pool->count);
            return 0;
        }
        prev = current;
        current = current->next;
    }

    fprintf(stderr, "Error: fd %d not found in pool\n", fd);
    return -1;
}

void pool_cleanup(FileHandlePool *pool) {
    if (!pool) {
        printf("Cleanup called on NULL pool - safe no-op.\n");
        return;
    }

    if (pool->cleaned_up) {
        printf("Cleanup called again on already cleaned-up pool - safe no-op.\n");
        return;
    }

    printf("Cleaning up pool with %d file handle(s)...\n", pool->count);

    FileHandleNode *current = pool->head;
    while (current) {
        FileHandleNode *next = current->next;

        printf("  Closing fd %d (%s)\n",
               current->fd,
               current->description ? current->description : "no description");

        if (close(current->fd) == -1) {
            perror("  Warning: failed to close fd during cleanup");
        }

        free(current->description);
        free(current);
        current = next;
    }

    pool->head = NULL;
    pool->count = 0;
    pool->cleaned_up = true;

    printf("Cleanup complete.\n");
}

void pool_destroy(FileHandlePool **pool) {
    if (!pool || !*pool) {
        return;
    }

    pool_cleanup(*pool);
    free(*pool);
    *pool = NULL;

    printf("Pool destroyed.\n");
}

void pool_print(const FileHandlePool *pool) {
    if (!pool) {
        printf("Pool is NULL.\n");
        return;
    }
    if (pool->cleaned_up) {
        printf("Pool has been cleaned up.\n");
        return;
    }

    printf("=== File Handle Pool (%d entries) ===\n", pool->count);
    FileHandleNode *current = pool->head;
    int index = 0;
    while (current) {
        printf("  [%d] fd=%d, desc=\"%s\"\n",
               index++, current->fd,
               current->description ? current->description : "(none)");
        current = current->next;
    }
    printf("=====================================\n");
}

/* Demo / test main */
int main(void) {
    FileHandlePool *pool = pool_create();
    if (!pool) {
        return EXIT_FAILURE;
    }

    /* Create some temporary files to get real file descriptors */
    FILE *f1 = tmpfile();
    FILE *f2 = tmpfile();
    FILE *f3 = tmpfile();

    if (!f1 || !f2 || !f3) {
        perror("Failed to create temp files");
        pool_destroy(&pool);
        return EXIT_FAILURE;
    }

    int fd1 = fileno(f1);
    int fd2 = fileno(f2);
    int fd3 = fileno(f3);

    /* Duplicate fds so we own them independently of FILE* */
    int dup_fd1 = dup(fd1);
    int dup_fd2 = dup(fd2);
    int dup_fd3 = dup(fd3);

    /* Close the FILE* objects (they still have their original fds) */
    fclose(f1);
    fclose(f2);
    fclose(f3);

    printf("\n--- Adding file handles ---\n");
    pool_add(pool, dup_fd1, "client_connection_1");
    pool_add(pool, dup_fd2, "client_connection_2");
    pool_add(pool, dup_fd3, "log_file");

    printf("\n");
    pool_print(pool);

    /* Test duplicate add */
    printf("\n--- Testing duplicate add ---\n");
    pool_add(pool, dup_fd1, "duplicate_attempt");

    /* Remove one handle */
    printf("\n--- Removing one handle ---\n");
    pool_remove(pool, dup_fd2);

    printf("\n");
    pool_print(pool);

    /* Test removing non-existent fd */
    printf("\n--- Removing non-existent fd ---\n");
    pool_remove(pool, 9999);

    /* Cleanup - closes remaining fds and frees memory */
    printf("\n--- First cleanup call ---\n");
    pool_cleanup(pool);

    /* Call cleanup again - should be safe */
    printf("\n--- Second cleanup call (should be no-op) ---\n");
    pool_cleanup(pool);

    /* Destroy the pool itself */
    printf("\n--- Destroying pool ---\n");
    pool_destroy(&pool);

    /* Destroy again - should be safe with NULL */
    printf("\n--- Destroying again (should be no-op) ---\n");
    pool_destroy(&pool);

    printf("\nAll tests passed.\n");
    return EXIT_SUCCESS;
}