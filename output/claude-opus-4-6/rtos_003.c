# Generated by anthropic (claude-opus-4-6)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/mutex.h>
#include <string.h>

/* Priority and stack definitions */
#define ADMIN_STACK_SIZE 2048
#define USER_STACK_SIZE 2048
#define ADMIN_PRIORITY 5
#define USER_PRIORITY 7

/* Privilege levels */
#define PRIV_NONE       0x00
#define PRIV_READ       0x01
#define PRIV_WRITE      0x02
#define PRIV_EXECUTE    0x04
#define PRIV_ADMIN      (PRIV_READ | PRIV_WRITE | PRIV_EXECUTE)
#define PRIV_USER       (PRIV_READ)

/* Operation types */
#define OP_FLASH_WRITE      1
#define OP_CONFIG_MODIFY    2
#define OP_CONFIG_READ      3
#define OP_STATUS_QUERY     4

/* System config parameters */
#define MAX_CONFIG_ENTRIES  16
#define MAX_CONFIG_KEY_LEN  32
#define MAX_CONFIG_VAL_LEN  64

/* Flash simulation */
#define SIMULATED_FLASH_SIZE 256

/* Request status */
#define REQ_STATUS_PENDING   0
#define REQ_STATUS_APPROVED  1
#define REQ_STATUS_DENIED    2
#define REQ_STATUS_COMPLETED 3

/* Thread stacks */
K_THREAD_STACK_DEFINE(admin_stack, ADMIN_STACK_SIZE);
K_THREAD_STACK_DEFINE(user_stack, USER_STACK_SIZE);

/* Thread data */
static struct k_thread admin_thread_data;
static struct k_thread user_thread_data;

/* Synchronization primitives */
K_MUTEX_DEFINE(config_mutex);
K_MUTEX_DEFINE(flash_mutex);
K_MUTEX_DEFINE(request_queue_mutex);
K_SEM_DEFINE(admin_request_sem, 0, 10);
K_SEM_DEFINE(request_complete_sem, 0, 1);

/* Task identity structure */
struct task_identity {
    k_tid_t tid;
    uint8_t privilege_level;
    const char *name;
    uint32_t uid;
};

/* Configuration entry */
struct config_entry {
    char key[MAX_CONFIG_KEY_LEN];
    char value[MAX_CONFIG_VAL_LEN];
    bool in_use;
    uint8_t required_priv;  /* minimum privilege to read */
};

/* Simulated flash memory */
static uint8_t simulated_flash[SIMULATED_FLASH_SIZE];
static bool flash_initialized = false;

/* System configuration store */
static struct config_entry system_config[MAX_CONFIG_ENTRIES];
static int config_count = 0;

/* Privilege request structure */
struct priv_request {
    uint32_t requester_uid;
    uint8_t requester_priv;
    uint8_t operation;
    uint8_t status;
    union {
        struct {
            uint32_t offset;
            uint8_t data[64];
            size_t len;
        } flash_write;
        struct {
            char key[MAX_CONFIG_KEY_LEN];
            char value[MAX_CONFIG_VAL_LEN];
        } config_modify;
        struct {
            char key[MAX_CONFIG_KEY_LEN];
            char value[MAX_CONFIG_VAL_LEN]; /* output */
        } config_read;
    } params;
    bool active;
};

/* Request queue */
#define MAX_PENDING_REQUESTS 8
static struct priv_request request_queue[MAX_PENDING_REQUESTS];
static int request_head = 0;
static int request_tail = 0;

/* Task identities */
static struct task_identity admin_identity = {
    .privilege_level = PRIV_ADMIN,
    .name = "admin",
    .uid = 0  /* root-like uid */
};

static struct task_identity user_identity = {
    .privilege_level = PRIV_USER,
    .name = "user",
    .uid = 1000
};

/* ---- Privilege Checking System ---- */

static bool check_privilege(const struct task_identity *identity, uint8_t required_priv)
{
    if (identity == NULL) {
        printk("[PRIV] NULL identity - access denied\n");
        return false;
    }

    /* Admin (uid 0) always has full access */
    if (identity->uid == 0) {
        return true;
    }

    /* Check if the task has the required privilege bits */
    if ((identity->privilege_level & required_priv) == required_priv) {
        return true;
    }

    printk("[PRIV] Access denied for '%s' (uid=%u, priv=0x%02x) - required 0x%02x\n",
           identity->name, identity->uid, identity->privilege_level, required_priv);
    return false;
}

static const char *op_to_string(uint8_t op)
{
    switch (op) {
    case OP_FLASH_WRITE:   return "FLASH_WRITE";
    case OP_CONFIG_MODIFY: return "CONFIG_MODIFY";
    case OP_CONFIG_READ:   return "CONFIG_READ";
    case OP_STATUS_QUERY:  return "STATUS_QUERY";
    default:               return "UNKNOWN";
    }
}

static uint8_t get_required_priv_for_op(uint8_t operation)
{
    switch (operation) {
    case OP_FLASH_WRITE:
        return PRIV_WRITE;
    case OP_CONFIG_MODIFY:
        return PRIV_WRITE;
    case OP_CONFIG_READ:
        return PRIV_READ;
    case OP_STATUS_QUERY:
        return PRIV_READ;
    default:
        return PRIV_ADMIN;
    }
}

/* ---- Flash Operations (Admin Only) ---- */

static int flash_init(void)
{
    k_mutex_lock(&flash_mutex, K_FOREVER);
    memset(simulated_flash, 0xFF, SIMULATED_FLASH_SIZE);
    flash_initialized = true;
    printk("[FLASH] Simulated flash initialized (%d bytes)\n", SIMULATED_FLASH_SIZE);
    k_mutex_unlock(&flash_mutex);
    return 0;
}

static int flash_write(const struct task_identity *identity, uint32_t offset,
                       const uint8_t *data, size_t len)
{
    if (!check_privilege(identity, PRIV_WRITE)) {
        printk("[FLASH] Write denied for '%s'\n", identity->name);
        return -EACCES;
    }

    k_mutex_lock(&flash_mutex, K_FOREVER);

    if (!flash_initialized) {
        printk("[FLASH] Flash not initialized\n");
        k_mutex_unlock(&flash_mutex);
        return -EIO;
    }

    if (offset + len > SIMULATED_FLASH_SIZE) {
        printk("[FLASH] Write out of bounds: offset=%u, len=%zu\n", offset, len);
        k_mutex_unlock(&flash_mutex);
        return -EINVAL;
    }

    memcpy(&simulated_flash[offset], data, len);
    printk("[FLASH] Written %zu bytes at offset %u by '%s'\n", len, offset, identity->name);

    k_mutex_unlock(&flash_mutex);
    return 0;
}

static int flash_read(const struct task_identity *identity, uint32_t offset,
                      uint8_t *data, size_t len)
{
    if (!check_privilege(identity, PRIV_READ)) {
        printk("[FLASH] Read denied for '%s'\n", identity->name);
        return -EACCES;
    }

    k_mutex_lock(&flash_mutex, K_FOREVER);

    if (!flash_initialized) {
        k_mutex_unlock(&flash_mutex);
        return -EIO;
    }

    if (offset + len > SIMULATED_FLASH_SIZE) {
        k_mutex_unlock(&flash_mutex);
        return -EINVAL;
    }

    memcpy(data, &simulated_flash[offset], len);
    printk("[FLASH] Read %zu bytes at offset %u by '%s'\n", len, offset, identity->name);

    k_mutex_unlock(&flash_mutex);
    return 0;
}

/* ---- System Config Operations ---- */

static int config_init(void)
{
    k_mutex_lock(&config_mutex, K_FOREVER);
    memset(system_config, 0, sizeof(system_config));
    config_count = 0;

    /* Set up default configuration entries */
    strncpy(system_config[0].key, "system.hostname", MAX_CONFIG_KEY_LEN - 1);
    strncpy(system_config[0].value, "zephyr-device", MAX_CONFIG_VAL_LEN - 1);
    system_config[0].in_use = true;
    system_config[0].required_priv = PRIV_READ;

    strncpy(system_config[1].key, "system.version", MAX_CONFIG_KEY_LEN - 1);
    strncpy(system_config[1].value, "1.0.0", MAX_CONFIG_VAL_LEN - 1);
    system_config[1].in_use = true;
    system_config[1].required_priv = PRIV_READ;

    strncpy(system_config[2].key, "admin.secret_key", MAX_CONFIG_KEY_LEN - 1);
    strncpy(system_config[2].value, "supersecret123", MAX_CONFIG_VAL_LEN - 1);
    system_config[2].in_use = true;
    system_config[2].required_priv = PRIV_ADMIN;

    strncpy(system_config[3].key, "network.ip", MAX_CONFIG_KEY_LEN - 1);
    strncpy(system_config[3].value, "192.168.1.100", MAX_CONFIG_VAL_LEN - 1);
    system_config[3].in_use = true;
    system_config[3].required_priv = PRIV_READ;

    config_count = 4;

    printk("[CONFIG] System configuration initialized with %d entries\n", config_count);
    k_mutex_unlock(&config_mutex);
    return 0;
}

static int config_read(const struct task_identity *identity, const char *key, char *value, size_t val_len)
{
    int ret = -ENOENT;

    k_mutex_lock(&config_mutex, K_FOREVER);

    for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
        if (system_config[i].in_use &&
            strncmp(system_config[i].key, key, MAX_CONFIG_KEY_LEN) == 0) {

            /* Check if the requester has sufficient privilege to read this entry */
            if (!check_privilege(identity, system_config[i].required_priv)) {
                printk("[CONFIG] Read of '%s' denied for '%s' (requires priv 0x%02x)\n",
                       key, identity->name, system_config[i].required_priv);
                ret = -EACCES;
                break;
            }

            strncpy(value, system_config[i].value, val_len - 1);
            value[val_len - 1] = '\0';
            printk("[CONFIG] '%s' read key '%s' = '%s'\n", identity->name, key, value);
            ret = 0;
            break;
        }
    }

    k_mutex_unlock(&config_mutex);
    return ret;
}

static int config_write(const struct task_identity *identity, const char *key, const char *value)
{
    if (!check_privilege(identity, PRIV_WRITE)) {
        printk("[CONFIG] Write denied for '%s'\n", identity->name);
        return -EACCES;
    }

    k_mutex_lock(&config_mutex, K_FOREVER);

    /* Try to find existing entry */
    for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
        if (system_config[i].in_use &&
            strncmp(system_config[i].key, key, MAX_CONFIG_KEY_LEN) == 0) {
            strncpy(system_config[i].value, value, MAX_CONFIG_VAL_LEN - 1);
            system_config[i].value[MAX_CONFIG_VAL_LEN - 1] = '\0';
            printk("[CONFIG] '%s' updated key '%s' = '%s'\n", identity->name, key, value);
            k_mutex_unlock(&config_mutex);
            return 0;
        }
    }

    /* Add new entry */
    if (config_count >= MAX_CONFIG_ENTRIES) {
        printk("[CONFIG] Configuration store full\n");
        k_mutex_unlock(&config_mutex);
        return -ENOMEM;
    }

    for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
        if (!system_config[i].in_use) {
            strncpy(system_config[i].key, key, MAX_CONFIG_KEY_LEN - 1);
            system_config[i].key[MAX_CONFIG_KEY_LEN - 1] = '\0';
            strncpy(system_config[i].value, value, MAX_CONFIG_VAL_LEN - 1);
            system_config[i].value[MAX_CONFIG_VAL_LEN - 1] = '\0';
            system_config[i].in_use = true;
            system_config[i].required_priv = PRIV_READ;
            config_count++;
            printk("[CONFIG] '%s' created key '%s' = '%s'\n", identity->name, key, value);
            k_mutex_unlock(&config_mutex);
            return 0;
        }
    }

    k_mutex_unlock(&config_mutex);
    return -ENOMEM;
}

/* ---- Request Queue Management ---- */

static int enqueue_request(struct priv_request *req)
{
    int ret = -ENOMEM;

    k_mutex_lock(&request_queue_mutex, K_FOREVER);

    int next_head = (request_head + 1) % MAX_PENDING_REQUESTS;
    if (next_head != request_tail) {
        memcpy(&request_queue[request_head], req, sizeof(struct priv_request));
        request_queue[request_head].active = true;
        request_queue[request_head].status = REQ_STATUS_PENDING;
        request_head = next_head;
        ret = 0;
        printk("[QUEUE] Request enqueued: op=%s from uid=%u\n",
               op_to_string(req->operation), req->requester_uid);
    } else {
        printk("[QUEUE] Request queue full!\n");
    }

    k_mutex_unlock(&request_queue_mutex);
    return ret;
}

static int dequeue_request(struct priv_request *req)
{
    int ret = -ENOENT;

    k_mutex_lock(&request_queue_mutex, K_FOREVER);

    if (request_tail != request_head) {
        memcpy(req, &request_queue[request_tail], sizeof(struct priv_request));
        request_queue[request_tail].active = false;
        request_tail = (request_tail + 1) % MAX_PENDING_REQUESTS;
        ret = 0;
    }

    k_mutex_unlock(&request_queue_mutex);
    return ret;
}

/* ---- User API: Submit privileged operation request ---- */

static int submit_privileged_request(const struct task_identity *requester,
                                     uint8_t operation, void *