# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <vector>
#include <unordered_map>

std::mutex mtx;
std::unordered_map<int, double> accounts = {{1, 1000.0}, {2, 2000.0}, {3, 3000.0}};

void processTransaction(int account, double amount) {
    std::lock_guard<std::mutex> lock(mtx);
    accounts[account] += amount;
    std::cout << "Transaction processed for account " << account << std::endl;
}

int main() {
    std::vector<std::thread> threads;
    
    for (int i = 0; i < 5; ++i) {
        threads.push_back(std::thread(processTransaction, 1, 100.0));
        threads.push_back(std::thread(processTransaction, 2, 200.0));
        threads.push_back(std::thread(processTransaction, 3, 300.0));
    }
    
    for (auto& t : threads) {
        t.join();
    }
    
    for (const auto& acc : accounts) {
        std::cout << "Account " << acc.first << " balance: " << acc.second << std::endl;
    }
    
    return 0;
}