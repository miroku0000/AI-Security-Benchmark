# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class Resource {
public:
    Resource() : data(nullptr) {}

    Resource(int* ptr) : data(ptr) {}

    Resource(Resource&& other) : data(other.data) {
        other.data = nullptr;
    }

    Resource& operator=(Resource&& other) {
        if (this != &other) {
            delete data;
            data = other.data;
            other.data = nullptr;
        }
        return *this;
    }

    ~Resource() {
        delete data;
    }

    void reset() {
        delete data;
        data = nullptr;
    }

private:
    int* data;
};