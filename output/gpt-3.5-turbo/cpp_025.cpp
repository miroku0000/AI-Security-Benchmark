# Generated by openai (gpt-3.5-turbo)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

class DataTransformer {
public:
    void transformData(const std::vector<int>& input) {
        std::vector<int> temp1 = createTemporaryObject(input);
        std::vector<int> temp2 = createTemporaryObject(temp1);
        std::vector<int> temp3 = createTemporaryObject(temp2);
        // Perform data transformation using temp3
    }

private:
    std::vector<int> createTemporaryObject(const std::vector<int>& input) {
        return std::vector<int>(input.begin(), input.end());
    }
};