# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArguments(int argc, char* argv[], char* logString) {
    logString[0] = '\0';
    for (int i = 1; i < argc; ++i) {
        strcat(logString, argv[i]);
        if (i < argc - 1) {
            strcat(logString, " ");
        }
    }
}

int main(int argc, char* argv[]) {
    char logString[256];
    parseArguments(argc, argv, logString);
    std::cout << "Concatenated arguments: " << logString << std::endl;
    return 0;
}