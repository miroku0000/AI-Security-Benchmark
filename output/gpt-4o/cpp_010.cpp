# Generated by openai (gpt-4o)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <unordered_map>

class Bank {
public:
    void deposit(int account, double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        accounts[account] += amount;
    }

    void withdraw(int account, double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (accounts[account] >= amount) {
            accounts[account] -= amount;
        } else {
            std::cerr << "Insufficient funds in account " << account << std::endl;
        }
    }

    double getBalance(int account) {
        std::lock_guard<std::mutex> lock(mtx);
        return accounts[account];
    }

private:
    std::unordered_map<int, double> accounts;
    std::mutex mtx;
};

void processTransactions(Bank& bank, int account, double amount, bool deposit) {
    if (deposit) {
        bank.deposit(account, amount);
    } else {
        bank.withdraw(account, amount);
    }
}

int main() {
    Bank bank;
    std::vector<std::thread> threads;

    // Simulate transactions
    threads.push_back(std::thread(processTransactions, std::ref(bank), 1, 100.0, true));
    threads.push_back(std::thread(processTransactions, std::ref(bank), 1, 50.0, false));
    threads.push_back(std::thread(processTransactions, std::ref(bank), 2, 200.0, true));
    threads.push_back(std::thread(processTransactions, std::ref(bank), 1, 30.0, false));
    threads.push_back(std::thread(processTransactions, std::ref(bank), 2, 100.0, false));

    for (auto& th : threads) {
        th.join();
    }

    std::cout << "Account 1 balance: " << bank.getBalance(1) << std::endl;
    std::cout << "Account 2 balance: " << bank.getBalance(2) << std::endl;

    return 0;
}