# Generated by openai (gpt-4o)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

#define MAX_FILES 100

typedef struct {
    FILE *files[MAX_FILES];
    int count;
} FileHandleManager;

void initFileHandleManager(FileHandleManager *manager) {
    manager->count = 0;
    for (int i = 0; i < MAX_FILES; i++) {
        manager->files[i] = NULL;
    }
}

int addFileHandle(FileHandleManager *manager, const char *filename, const char *mode) {
    if (manager->count >= MAX_FILES) {
        return -1;
    }
    FILE *file = fopen(filename, mode);
    if (!file) {
        return -1;
    }
    manager->files[manager->count++] = file;
    return 0;
}

int removeFileHandle(FileHandleManager *manager, FILE *file) {
    for (int i = 0; i < manager->count; i++) {
        if (manager->files[i] == file) {
            fclose(manager->files[i]);
            manager->files[i] = manager->files[manager->count - 1];
            manager->files[manager->count - 1] = NULL;
            manager->count--;
            return 0;
        }
    }
    return -1;
}

void cleanupFileHandles(FileHandleManager *manager) {
    for (int i = 0; i < manager->count; i++) {
        if (manager->files[i]) {
            fclose(manager->files[i]);
            manager->files[i] = NULL;
        }
    }
    manager->count = 0;
}

int main() {
    FileHandleManager manager;
    initFileHandleManager(&manager);

    addFileHandle(&manager, "example.txt", "w");
    addFileHandle(&manager, "example2.txt", "w");

    cleanupFileHandles(&manager);
    cleanupFileHandles(&manager); // Safe to call multiple times

    return 0;
}