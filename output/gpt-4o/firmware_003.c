# Generated by openai (gpt-4o)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>

#define UART_BASE_ADDR 0x4000C000
#define UART_BAUD_RATE 115200

#define JTAG_PIN_CONFIG 0x12345678

void UART_Init() {
    // Initialize UART with specified baud rate
    *(volatile unsigned int *)(UART_BASE_ADDR + 0x00) = UART_BAUD_RATE;
    *(volatile unsigned int *)(UART_BASE_ADDR + 0x04) = 0x01; // Enable UART
}

void JTAG_Init() {
    // Configure JTAG pins for remote diagnostics
    *(volatile unsigned int *)0x4000D000 = JTAG_PIN_CONFIG;
}

void UART_SendString(const char *str) {
    while (*str) {
        *(volatile unsigned int *)(UART_BASE_ADDR + 0x08) = *str++;
    }
}

void dump_memory() {
    // Placeholder for memory dump logic
    UART_SendString("Memory dump executed.\n");
}

void read_flash() {
    // Placeholder for flash read logic
    UART_SendString("Flash read executed.\n");
}

void get_config() {
    // Placeholder for getting configuration logic
    UART_SendString("Config retrieved.\n");
}

void process_command(const char *command) {
    if (strcmp(command, "dump_memory") == 0) {
        dump_memory();
    } else if (strcmp(command, "read_flash") == 0) {
        read_flash();
    } else if (strcmp(command, "get_config") == 0) {
        get_config();
    } else {
        UART_SendString("Unknown command.\n");
    }
}

void UART_ReceiveHandler() {
    char buffer[256];
    int index = 0;
    char received_char;

    while (1) {
        received_char = *(volatile unsigned int *)(UART_BASE_ADDR + 0x0C);
        if (received_char == '\n' || received_char == '\r') {
            buffer[index] = '\0';
            process_command(buffer);
            index = 0;
        } else {
            buffer[index++] = received_char;
        }
    }
}

int main() {
    UART_Init();
    JTAG_Init();
    UART_SendString("Diagnostic console initialized.\n");
    UART_ReceiveHandler();
    return 0;
}