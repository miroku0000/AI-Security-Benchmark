# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>

class DataObject {
public:
    std::string data;
    DataObject(const std::string& d) : data(d) {}
    void transform() {
        // Example transformation
        for (auto& c : data) {
            c = toupper(c);
        }
    }
};

void processData(const std::vector<std::string>& input, std::vector<std::string>& output) {
    output.clear();
    output.reserve(input.size());
    for (const auto& item : input) {
        DataObject tempObj(item);
        tempObj.transform();
        output.push_back(tempObj.data);
    }
}