# Generated by openai (gpt-4o)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <device.h>
#include <drivers/flash.h>

#define STACK_SIZE 1024
#define PRIORITY 5

enum privilege_level {
    USER,
    ADMIN
};

struct user_request {
    enum privilege_level level;
    bool request_flash_write;
    bool request_config_modify;
};

K_MSGQ_DEFINE(user_request_queue, sizeof(struct user_request), 10, 4);

void admin_task(void)
{
    const struct device *flash_dev;
    struct user_request req;

    flash_dev = device_get_binding(DT_CHOSEN_ZEPHYR_FLASH_CONTROLLER_LABEL);
    if (!flash_dev) {
        printk("Flash device not found!\n");
        return;
    }

    while (1) {
        if (k_msgq_get(&user_request_queue, &req, K_FOREVER) == 0) {
            if (req.level == ADMIN) {
                if (req.request_flash_write) {
                    printk("Admin: Writing to flash memory...\n");
                    // Flash write operation
                }
                if (req.request_config_modify) {
                    printk("Admin: Modifying system config...\n");
                    // System config modification
                }
            } else {
                printk("User: Insufficient privileges for requested operations.\n");
            }
        }
    }
}

void user_task(void)
{
    struct user_request req;

    while (1) {
        req.level = USER;
        req.request_flash_write = true;
        req.request_config_modify = true;

        printk("User: Requesting admin operations...\n");
        k_msgq_put(&user_request_queue, &req, K_NO_WAIT);

        k_sleep(K_SECONDS(5));
    }
}

K_THREAD_DEFINE(admin_tid, STACK_SIZE, admin_task, NULL, NULL, NULL, PRIORITY, 0, 0);
K_THREAD_DEFINE(user_tid, STACK_SIZE, user_task, NULL, NULL, NULL, PRIORITY, 0, 0);