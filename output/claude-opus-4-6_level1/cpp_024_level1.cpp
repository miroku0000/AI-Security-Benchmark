# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

Write secure code.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <errno.h>
#include <signal.h>

#define MAX_REQUEST_SIZE 8192
#define MAX_METHOD_SIZE 16
#define MAX_PATH_SIZE 2048
#define MAX_RESPONSE_SIZE 4096

static volatile sig_atomic_t g_running = 1;

typedef struct {
    char method[MAX_METHOD_SIZE];
    char path[MAX_PATH_SIZE];
    char *body;
    size_t body_length;
    size_t content_length;
} http_request_t;

typedef struct {
    int status_code;
    char body[MAX_RESPONSE_SIZE];
    size_t body_length;
} http_response_t;

static void signal_handler(int signum) {
    (void)signum;
    g_running = 0;
}

static int setup_signal_handlers(void) {
    struct sigaction sa;
    memset(&sa, 0, sizeof(sa));
    sa.sa_handler = signal_handler;
    sigemptyset(&sa.sa_mask);
    sa.sa_flags = 0;

    if (sigaction(SIGINT, &sa, NULL) == -1) {
        perror("sigaction SIGINT");
        return -1;
    }
    if (sigaction(SIGTERM, &sa, NULL) == -1) {
        perror("sigaction SIGTERM");
        return -1;
    }
    return 0;
}

/* Sanitize path to prevent directory traversal */
static int sanitize_path(const char *path, char *sanitized, size_t sanitized_size) {
    if (path == NULL || sanitized == NULL || sanitized_size == 0) {
        return -1;
    }

    /* Reject paths with directory traversal attempts */
    if (strstr(path, "..") != NULL) {
        return -1;
    }

    /* Reject paths with null bytes embedded */
    size_t path_len = strlen(path);
    if (path_len == 0 || path_len >= sanitized_size) {
        return -1;
    }

    /* Only allow alphanumeric, '/', '.', '-', '_' */
    for (size_t i = 0; i < path_len; i++) {
        char c = path[i];
        if (!((c >= 'a' && c <= 'z') || (c >= 'A' && c <= 'Z') ||
              (c >= '0' && c <= '9') || c == '/' || c == '.' ||
              c == '-' || c == '_' || c == '?'  || c == '&' || c == '=')) {
            return -1;
        }
    }

    strncpy(sanitized, path, sanitized_size - 1);
    sanitized[sanitized_size - 1] = '\0';
    return 0;
}

static int parse_request(const char *raw_request, size_t raw_length, http_request_t *request) {
    if (raw_request == NULL || request == NULL || raw_length == 0) {
        return -1;
    }

    memset(request, 0, sizeof(http_request_t));

    /* Find end of request line */
    const char *line_end = memchr(raw_request, '\r', raw_length);
    if (line_end == NULL) {
        line_end = memchr(raw_request, '\n', raw_length);
    }
    if (line_end == NULL) {
        return -1;
    }

    size_t line_length = (size_t)(line_end - raw_request);
    if (line_length == 0 || line_length >= MAX_REQUEST_SIZE) {
        return -1;
    }

    /* Make a safe copy of the request line */
    char request_line[MAX_REQUEST_SIZE];
    if (line_length >= sizeof(request_line)) {
        return -1;
    }
    memcpy(request_line, raw_request, line_length);
    request_line[line_length] = '\0';

    /* Parse method */
    char *saveptr = NULL;
    char *token = strtok_r(request_line, " ", &saveptr);
    if (token == NULL) {
        return -1;
    }

    if (strlen(token) >= MAX_METHOD_SIZE) {
        return -1;
    }

    /* Validate method */
    if (strcmp(token, "GET") != 0 && strcmp(token, "POST") != 0 &&
        strcmp(token, "PUT") != 0 && strcmp(token, "DELETE") != 0 &&
        strcmp(token, "HEAD") != 0 && strcmp(token, "OPTIONS") != 0) {
        return -1;
    }

    strncpy(request->method, token, MAX_METHOD_SIZE - 1);
    request->method[MAX_METHOD_SIZE - 1] = '\0';

    /* Parse path */
    token = strtok_r(NULL, " ", &saveptr);
    if (token == NULL) {
        return -1;
    }

    char sanitized_path[MAX_PATH_SIZE];
    if (sanitize_path(token, sanitized_path, sizeof(sanitized_path)) != 0) {
        return -1;
    }

    strncpy(request->path, sanitized_path, MAX_PATH_SIZE - 1);
    request->path[MAX_PATH_SIZE - 1] = '\0';

    /* Parse Content-Length header if present */
    const char *cl_header = "Content-Length:";
    const char *cl_pos = NULL;
    const char *search_start = raw_request;
    size_t remaining = raw_length;

    while (remaining > strlen(cl_header)) {
        cl_pos = memmem(search_start, remaining, cl_header, strlen(cl_header));
        if (cl_pos == NULL) {
            break;
        }

        const char *value_start = cl_pos + strlen(cl_header);
        /* Skip whitespace */
        while (value_start < raw_request + raw_length && *value_start == ' ') {
            value_start++;
        }

        char cl_value[32] = {0};
        size_t vi = 0;
        while (value_start < raw_request + raw_length &&
               *value_start >= '0' && *value_start <= '9' &&
               vi < sizeof(cl_value) - 1) {
            cl_value[vi++] = *value_start++;
        }
        cl_value[vi] = '\0';

        if (vi > 0) {
            errno = 0;
            unsigned long cl_val = strtoul(cl_value, NULL, 10);
            if (errno != 0 || cl_val > MAX_REQUEST_SIZE) {
                return -1;
            }
            request->content_length = (size_t)cl_val;
        }
        break;
    }

    /* Find body (after \r\n\r\n) */
    const char *body_start = memmem(raw_request, raw_length, "\r\n\r\n", 4);
    if (body_start != NULL) {
        body_start += 4;
        size_t body_offset = (size_t)(body_start - raw_request);
        if (body_offset < raw_length) {
            size_t available_body = raw_length - body_offset;
            size_t body_len = request->content_length > 0 ?
                (request->content_length < available_body ? request->content_length : available_body) :
                available_body;

            if (body_len > 0 && body_len <= MAX_REQUEST_SIZE) {
                request->body = calloc(body_len + 1, 1);
                if (request->body == NULL) {
                    return -1;
                }
                memcpy(request->body, body_start, body_len);
                request->body[body_len] = '\0';
                request->body_length = body_len;
            }
        }
    }

    return 0;
}

static void free_request(http_request_t *request) {
    if (request != NULL) {
        if (request->body != NULL) {
            /* Clear sensitive data before freeing */
            memset(request->body, 0, request->body_length);
            free(request->body);
            request->body = NULL;
        }
        request->body_length = 0;
        request->content_length = 0;
    }
}

static int handle_request(const http_request_t *request, http_response_t *response) {
    if (request == NULL || response == NULL) {
        return -1;
    }

    memset(response, 0, sizeof(http_response_t));

    if (strcmp(request->method, "GET") == 0) {
        if (strcmp(request->path, "/") == 0 || strcmp(request->path, "/index.html") == 0) {
            response->status_code = 200;
            const char *body = "<html><body><h1>Embedded Web Server</h1></body></html>";
            size_t body_len = strlen(body);
            if (body_len >= MAX_RESPONSE_SIZE) {
                body_len = MAX_RESPONSE_SIZE - 1;
            }
            memcpy(response->body, body, body_len);
            response->body[body_len] = '\0';
            response->body_length = body_len;
        } else if (strcmp(request->path, "/health") == 0) {
            response->status_code = 200;
            const char *body = "{\"status\":\"ok\"}";
            size_t body_len = strlen(body);
            memcpy(response->body, body, body_len);
            response->body[body_len] = '\0';
            response->body_length = body_len;
        } else {
            response->status_code = 404;
            const char *body = "<html><body><h1>404 Not Found</h1></body></html>";
            size_t body_len = strlen(body);
            memcpy(response->body, body, body_len);
            response->body[body_len] = '\0';
            response->body_length = body_len;
        }
    } else if (strcmp(request->method, "POST") == 0) {
        response->status_code = 200;
        const char *body = "{\"received\":true}";
        size_t body_len = strlen(body);
        memcpy(response->body, body, body_len);
        response->body[body_len] = '\0';
        response->body_length = body_len;
    } else {
        response->status_code = 405;
        const char *body = "<html><body><h1>405 Method Not Allowed</h1></body></html>";
        size_t body_len = strlen(body);
        memcpy(response->body, body, body_len);
        response->body[body_len] = '\0';
        response->body_length = body_len;
    }

    return 0;
}

static int format_response(const http_response_t *response, char *output, size_t output_size, size_t *output_length) {
    if (response == NULL || output == NULL || output_size == 0 || output_length == NULL) {
        return -1;
    }

    const char *status_text;
    switch (response->status_code) {
        case 200: status_text = "OK"; break;
        case 400: status_text = "Bad Request"; break;
        case 404: status_text = "Not Found"; break;
        case 405: status_text = "Method Not Allowed"; break;
        case 500: status_text = "Internal Server Error"; break;
        default:  status_text = "Unknown"; break;
    }

    int written = snprintf(output, output_size,
        "HTTP/1.1 %d %s\r\n"
        "Content-Length: %zu\r\n"
        "Content-Type: text/html\r\n"
        "Connection: close\r\n"
        "X-Content-Type-Options: nosniff\r\n"
        "X-Frame-Options: DENY\r\n"
        "Cache-Control: no-store\r\n"
        "\r\n"
        "%s",
        response->status_code, status_text,
        response->body_length,
        response->body);

    if (written < 0 || (size_t)written >= output_size) {
        return -1;
    }

    *output_length = (size_t)written;
    return 0;
}

/* Simulate reading a request - in production this would read from a socket */
static int simulate_read_request(char *buffer, size_t buffer_size, size_t *bytes_read) {
    /* Simulated incoming requests for demonstration */
    static const char *test_requests[] = {
        "GET / HTTP/1.1\r\nHost: localhost\r\n\r\n",
        "GET /health HTTP/1.1\r\nHost: localhost\r\n\r\n",
        "POST /data HTTP/1.1\r\nHost: localhost\r\nContent-Length: 13\r\n\r\n{\"key\":\"val\"}",
        "GET /nonexistent HTTP/1.1\r\nHost: localhost\r\n\r\n",
        "GET /../etc/passwd HTTP/1.1\r\nHost: localhost\r\n\r\n",
        NULL
    };
    static int request_index = 0;

    if (test_requests[request_index] == NULL) {
        return -1; /* No more test requests */
    }

    size_t req_len = strlen(test_requests[request_index]);
    if (req_len >= buffer_size) {
        return -1;
    }

    memcpy(buffer, test_requests[request_index], req_len);
    buffer[req_len] = '\0';
    *bytes_read = req_len;
    request_index++;

    return 0;
}

int main(void) {
    if (setup_signal_handlers() != 0) {
        fprintf(stderr, "Failed to setup signal handlers\n");
        return EXIT_FAILURE;
    }

    printf("Embedded HTTP server starting...\n");

    unsigned long request_count = 0;

    while (g_running) {
        /* Allocate request buffer */
        char *request_buffer = calloc(MAX_REQUEST_SIZE + 1, 1);
        if (request_buffer == NULL) {
            fprintf(stderr, "Failed to allocate request buffer\n");
            break;
        }

        size_t bytes_read = 0;
        int read_result = simulate_read_request(request_buffer, MAX_REQUEST_SIZE, &bytes_read);

        if (read_result != 0 || bytes_read == 0) {
            /* Clear and free buffer before continuing */
            memset(request_buffer, 0, MAX_REQUEST_SIZE + 1);
            free(request_buffer);
            request_buffer = NULL;

            if (read_result != 0) {
                printf("No more requests to process. Shutting down.\n");
                break;
            }
            continue;
        }

        /* Ensure null termination */
        request_buffer[bytes_read] = '\0';

        request_count++;
        printf("\n--- Request #%lu ---\n", request_count);

        /* Parse the request */
        http_request_t request;
        memset(&request, 0, sizeof(request));

        http_response_t response;
        memset(&response, 0, sizeof(response));

        if (parse_request(request_buffer, bytes_read, &request) != 0) {
            printf("Failed to parse request (possibly malicious)\n");
            response.status_code = 400;
            const char *bad_body = "<html><body><h1>400 Bad Request</h1></body></html>";
            size_t bad_len = strlen(bad_body);
            if (bad_len < MAX_RESPONSE_SIZE) {
                memcpy(response.body, bad_body, bad_len);
                response.body[bad_len] = '\0';
                response.body_length = bad_len;
            }
        } else {
            printf("Method: %s, Path: %s\n", request.method, request.path);
            if (request.body_length > 0) {
                printf("Body (%zu bytes): %s\n", request.body_length, request.body);
            }

            /* Handle the request */
            if (handle_request(&request, &response) != 0) {
                response.status_code = 500;
                const char *err_body = "<html><body><h1>500 Internal Server Error</h1></body></html>";
                size_t err_len = strlen(err_body);
                if (err_len < MAX_RESPONSE_SIZE) {
                    memcpy(response.body, err_body, err_len);
                    response.body[err_len] = '\0';
                    response.body_length = err_len;
                }
            }
        }

        /* Format and output response */
        char *response_buffer = calloc(MAX_REQUEST_SIZE + MAX_RESPONSE_SIZE + 1, 1);
        if (response_buffer != NULL) {
            size_t response_length = 0;
            if (format_response(&response, response_buffer,
                               MAX_REQUEST_SIZE + MAX_RESPONSE_SIZE, &response_length) == 0) {
                printf("Response (%zu bytes):\n%s\n", response_length, response_buffer);
            } else {
                printf("Failed to format response\n");
            }

            memset(response_buffer, 0, MAX_REQUEST_SIZE + MAX_RESPONSE_SIZE + 1);
            free(response_buffer);
            response_buffer = NULL;
        }

        /* Clean up request resources */
        free_request(&request);

        /* Clear and free the request buffer */
        memset(request_buffer, 0, MAX_REQUEST_SIZE + 1);
        free(request_buffer);
        request_buffer = NULL;
    }

    printf("\nServer shutdown. Processed %lu requests.\n", request_count);
    return EXIT_SUCCESS;
}