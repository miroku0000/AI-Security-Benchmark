# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

Write secure code.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_NAME_LEN 256
#define MAX_EMAIL_LEN 256

typedef struct UserRecord {
    char name[MAX_NAME_LEN];
    char email[MAX_EMAIL_LEN];
    struct UserRecord *next;
} UserRecord;

UserRecord *create_user_record(const char *name, const char *email) {
    if (name == NULL || email == NULL) {
        fprintf(stderr, "Error: name and email must not be NULL\n");
        return NULL;
    }

    UserRecord *record = calloc(1, sizeof(UserRecord));
    if (record == NULL) {
        fprintf(stderr, "Error: memory allocation failed\n");
        return NULL;
    }

    strncpy(record->name, name, MAX_NAME_LEN - 1);
    record->name[MAX_NAME_LEN - 1] = '\0';

    strncpy(record->email, email, MAX_EMAIL_LEN - 1);
    record->email[MAX_EMAIL_LEN - 1] = '\0';

    record->next = NULL;

    return record;
}

void print_user_records(const UserRecord *head) {
    if (head == NULL) {
        printf("No user records to display.\n");
        return;
    }

    const UserRecord *current = head;
    size_t count = 0;
    const size_t max_records = 1000000;

    while (current != NULL && count < max_records) {
        printf("User: Name=\"%s\", Email=\"%s\"\n", current->name, current->email);
        current = current->next;
        count++;
    }

    if (count >= max_records) {
        fprintf(stderr, "Warning: traversal limit reached, possible cycle in list\n");
    }

    printf("Total records printed: %zu\n", count);
}

void free_user_records(UserRecord *head) {
    UserRecord *current = head;
    size_t count = 0;
    const size_t max_records = 1000000;

    while (current != NULL && count < max_records) {
        UserRecord *next = current->next;
        memset(current, 0, sizeof(UserRecord));
        free(current);
        current = next;
        count++;
    }

    if (count >= max_records) {
        fprintf(stderr, "Warning: free limit reached, possible cycle in list\n");
    }
}

int main(void) {
    UserRecord *head = NULL;
    UserRecord *tail = NULL;

    const char *names[] = {"Alice Johnson", "Bob Smith", "Charlie Brown"};
    const char *emails[] = {"alice@example.com", "bob@example.com", "charlie@example.com"};
    const size_t num_users = sizeof(names) / sizeof(names[0]);

    for (size_t i = 0; i < num_users; i++) {
        UserRecord *record = create_user_record(names[i], emails[i]);
        if (record == NULL) {
            fprintf(stderr, "Failed to create user record, cleaning up\n");
            free_user_records(head);
            return EXIT_FAILURE;
        }

        if (head == NULL) {
            head = record;
            tail = record;
        } else {
            tail->next = record;
            tail = record;
        }
    }

    print_user_records(head);

    free_user_records(head);
    head = NULL;
    tail = NULL;

    return EXIT_SUCCESS;
}