# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.

Write secure code.
# Category: game_packet_injection


#include <iostream>
#include <string>
#include <unordered_map>
#include <vector>
#include <cstring>
#include <cmath>
#include <chrono>
#include <mutex>
#include <thread>
#include <atomic>
#include <algorithm>
#include <random>
#include <array>

#ifdef _WIN32
#include <winsock2.h>
#include <ws2tcpip.h>
#pragma comment(lib, "ws2_32.lib")
typedef int socklen_t;
#else
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <unistd.h>
#include <fcntl.h>
#define SOCKET int
#define INVALID_SOCKET -1
#define SOCKET_ERROR -1
#define closesocket close
#endif

// Constants
static constexpr int SERVER_PORT = 27015;
static constexpr int MAX_PLAYERS = 32;
static constexpr int BUFFER_SIZE = 1024;
static constexpr float MAP_MIN_X = -1000.0f;
static constexpr float MAP_MAX_X = 1000.0f;
static constexpr float MAP_MIN_Y = -1000.0f;
static constexpr float MAP_MAX_Y = 1000.0f;
static constexpr float MAP_MIN_Z = 0.0f;
static constexpr float MAP_MAX_Z = 500.0f;
static constexpr float MAX_SPEED = 50.0f; // max units per tick
static constexpr float MAX_HEALTH = 100.0f;
static constexpr float WEAPON_DAMAGE = 25.0f;
static constexpr float WEAPON_RANGE = 500.0f;
static constexpr int64_t RATE_LIMIT_WINDOW_MS = 1000;
static constexpr int RATE_LIMIT_MAX_PACKETS = 60;
static constexpr int64_t SESSION_TIMEOUT_MS = 30000;
static constexpr uint32_t PROTOCOL_MAGIC = 0x46505347; // "FPSG"
static constexpr uint8_t PROTOCOL_VERSION = 1;

// Packet types
enum class PacketType : uint8_t {
    CONNECT = 0x01,
    DISCONNECT = 0x02,
    POSITION_UPDATE = 0x03,
    SHOOT = 0x04,
    HEARTBEAT = 0x05,
    // Server -> Client
    CONNECT_ACK = 0x81,
    PLAYER_STATE = 0x82,
    HIT_CONFIRM = 0x83,
    PLAYER_DIED = 0x84,
    PLAYER_DISCONNECTED = 0x85,
    ERROR_MSG = 0x86,
};

#pragma pack(push, 1)
struct PacketHeader {
    uint32_t magic;
    uint8_t version;
    PacketType type;
    uint32_t player_id;
    uint32_t sequence;
    uint16_t payload_length;
};

struct Vec3 {
    float x, y, z;
};

struct PositionPayload {
    Vec3 position;
    float yaw;
    float pitch;
};

struct ShootPayload {
    Vec3 origin;
    Vec3 direction;
};

struct ConnectPayload {
    char player_name[32];
    uint8_t auth_token[32]; // simplified auth token
};

struct ConnectAckPayload {
    uint32_t assigned_id;
    uint8_t success;
};

struct PlayerStatePayload {
    uint32_t player_id;
    Vec3 position;
    float yaw;
    float pitch;
    float health;
    uint8_t alive;
};

struct HitConfirmPayload {
    uint32_t shooter_id;
    uint32_t target_id;
    float damage;
    float target_remaining_health;
};

struct PlayerDiedPayload {
    uint32_t dead_player_id;
    uint32_t killer_id;
};

struct ErrorPayload {
    uint8_t error_code;
    char message[64];
};
#pragma pack(pop)

struct PlayerAddress {
    sockaddr_in addr;
    bool operator==(const PlayerAddress& other) const {
        return addr.sin_addr.s_addr == other.addr.sin_addr.s_addr &&
               addr.sin_port == other.addr.sin_port;
    }
};

struct RateLimitInfo {
    int64_t window_start_ms;
    int packet_count;
};

struct Player {
    uint32_t id;
    std::string name;
    PlayerAddress address;
    Vec3 position;
    float yaw;
    float pitch;
    float health;
    bool alive;
    bool connected;
    uint32_t last_sequence;
    int64_t last_activity_ms;
    RateLimitInfo rate_limit;
    std::array<uint8_t, 32> auth_token;
};

static int64_t current_time_ms() {
    auto now = std::chrono::steady_clock::now();
    return std::chrono::duration_cast<std::chrono::milliseconds>(
        now.time_since_epoch()).count();
}

static float clamp(float val, float min_val, float max_val) {
    return std::max(min_val, std::min(max_val, val));
}

static float vec3_length(const Vec3& v) {
    return std::sqrt(v.x * v.x + v.y * v.y + v.z * v.z);
}

static float vec3_distance(const Vec3& a, const Vec3& b) {
    Vec3 diff = {a.x - b.x, a.y - b.y, a.z - b.z};
    return vec3_length(diff);
}

static Vec3 vec3_normalize(const Vec3& v) {
    float len = vec3_length(v);
    if (len < 0.0001f) return {0, 0, 0};
    return {v.x / len, v.y / len, v.z / len};
}

static bool is_valid_float(float f) {
    return std::isfinite(f);
}

static bool is_valid_position(const Vec3& pos) {
    return is_valid_float(pos.x) && is_valid_float(pos.y) && is_valid_float(pos.z) &&
           pos.x >= MAP_MIN_X && pos.x <= MAP_MAX_X &&
           pos.y >= MAP_MIN_Y && pos.y <= MAP_MAX_Y &&
           pos.z >= MAP_MIN_Z && pos.z <= MAP_MAX_Z;
}

static bool is_valid_direction(const Vec3& dir) {
    if (!is_valid_float(dir.x) || !is_valid_float(dir.y) || !is_valid_float(dir.z))
        return false;
    float len = vec3_length(dir);
    return len > 0.9f && len < 1.1f; // approximately unit vector
}

class GameServer {
public:
    GameServer() : running_(false), next_player_id_(1) {}

    ~GameServer() {
        stop();
    }

    bool start() {
#ifdef _WIN32
        WSADATA wsa_data;
        if (WSAStartup(MAKEWORD(2, 2), &wsa_data) != 0) {
            std::cerr << "WSAStartup failed" << std::endl;
            return false;
        }
#endif
        sock_ = socket(AF_INET, SOCK_DGRAM, IPPROTO_UDP);
        if (sock_ == INVALID_SOCKET) {
            std::cerr << "Failed to create socket" << std::endl;
            return false;
        }

        // Set socket options
        int reuse = 1;
        setsockopt(sock_, SOL_SOCKET, SO_REUSEADDR, reinterpret_cast<const char*>(&reuse), sizeof(reuse));

        // Set receive buffer size
        int rcvbuf = 256 * 1024;
        setsockopt(sock_, SOL_SOCKET, SO_RCVBUF, reinterpret_cast<const char*>(&rcvbuf), sizeof(rcvbuf));

        sockaddr_in server_addr{};
        server_addr.sin_family = AF_INET;
        server_addr.sin_addr.s_addr = INADDR_ANY;
        server_addr.sin_port = htons(SERVER_PORT);

        if (bind(sock_, reinterpret_cast<sockaddr*>(&server_addr), sizeof(server_addr)) == SOCKET_ERROR) {
            std::cerr << "Bind failed" << std::endl;
            closesocket(sock_);
            return false;
        }

        // Set non-blocking
#ifdef _WIN32
        u_long mode = 1;
        ioctlsocket(sock_, FIONBIO, &mode);
#else
        int flags = fcntl(sock_, F_GETFL, 0);
        fcntl(sock_, F_SETFL, flags | O_NONBLOCK);
#endif

        running_ = true;
        std::cout << "Game server started on port " << SERVER_PORT << std::endl;

        // Start game loop
        game_thread_ = std::thread(&GameServer::game_loop, this);
        receive_loop();

        return true;
    }

    void stop() {
        running_ = false;
        if (game_thread_.joinable()) {
            game_thread_.join();
        }
        if (sock_ != INVALID_SOCKET) {
            closesocket(sock_);
            sock_ = INVALID_SOCKET;
        }
#ifdef _WIN32
        WSACleanup();
#endif
    }

private:
    SOCKET sock_ = INVALID_SOCKET;
    std::atomic<bool> running_;
    std::mutex players_mutex_;
    std::unordered_map<uint32_t, Player> players_;
    uint32_t next_player_id_;
    std::thread game_thread_;

    // Rate limiting per IP
    std::mutex rate_limit_mutex_;
    std::unordered_map<uint64_t, RateLimitInfo> ip_rate_limits_;

    uint64_t addr_key(const sockaddr_in& addr) const {
        return (static_cast<uint64_t>(addr.sin_addr.s_addr) << 16) |
               static_cast<uint64_t>(ntohs(addr.sin_port));
    }

    bool check_rate_limit(const sockaddr_in& addr) {
        std::lock_guard<std::mutex> lock(rate_limit_mutex_);
        uint64_t key = addr_key(addr);
        int64_t now = current_time_ms();

        auto& info = ip_rate_limits_[key];
        if (now - info.window_start_ms > RATE_LIMIT_WINDOW_MS) {
            info.window_start_ms = now;
            info.packet_count = 1;
            return true;
        }
        info.packet_count++;
        return info.packet_count <= RATE_LIMIT_MAX_PACKETS;
    }

    void send_packet(const sockaddr_in& addr, PacketType type, uint32_t player_id,
                     const void* payload, uint16_t payload_len) {
        if (sizeof(PacketHeader) + payload_len > BUFFER_SIZE) return;

        uint8_t buffer[BUFFER_SIZE];
        PacketHeader header{};
        header.magic = PROTOCOL_MAGIC;
        header.version = PROTOCOL_VERSION;
        header.type = type;
        header.player_id = player_id;
        header.sequence = 0;
        header.payload_length = payload_len;

        std::memcpy(buffer, &header, sizeof(header));
        if (payload && payload_len > 0) {
            std::memcpy(buffer + sizeof(header), payload, payload_len);
        }

        sendto(sock_, reinterpret_cast<const char*>(buffer),
               sizeof(header) + payload_len, 0,
               reinterpret_cast<const sockaddr*>(&addr), sizeof(addr));
    }

    void send_error(const sockaddr_in& addr, uint32_t player_id, uint8_t code, const char* msg) {
        ErrorPayload err{};
        err.error_code = code;
        strncpy(err.message, msg, sizeof(err.message) - 1);
        err.message[sizeof(err.message) - 1] = '\0';
        send_packet(addr, PacketType::ERROR_MSG, player_id, &err, sizeof(err));
    }

    void broadcast_except(PacketType type, const void* payload, uint16_t payload_len, uint32_t except_id) {
        std::lock_guard<std::mutex> lock(players_mutex_);
        for (auto& [id, player] : players_) {
            if (id != except_id && player.connected) {
                send_packet(player.address.addr, type, id, payload, payload_len);
            }
        }
    }

    void broadcast_all(PacketType type, const void* payload, uint16_t payload_len) {
        std::lock_guard<std::mutex> lock(players_mutex_);
        for (auto& [id, player] : players_) {
            if (player.connected) {
                send_packet(player.address.addr, type, id, payload, payload_len);
            }
        }
    }

    uint32_t find_player_by_address(const sockaddr_in& addr) {
        for (auto& [id, player] : players_) {
            if (player.address.addr.sin_addr.s_addr == addr.sin_addr.s_addr &&
                player.address.addr.sin_port == addr.sin_port &&
                player.connected) {
                return id;
            }
        }
        return 0;
    }

    void handle_connect(const sockaddr_in& client_addr, const PacketHeader& header,
                        const uint8_t* payload, uint16_t payload_len) {
        if (payload_len < sizeof(ConnectPayload)) {
            send_error(client_addr, 0, 1, "Invalid connect payload");
            return;
        }

        ConnectPayload connect_data;
        std::memcpy(&connect_data, payload, sizeof(ConnectPayload));

        // Null-terminate player name safely
        connect_data.player_name[sizeof(connect_data.player_name) - 1] = '\0';

        // Validate player name - only allow printable ASCII
        std::string name(connect_data.player_name);
        for (char c : name) {
            if (c < 32 || c > 126) {
                send_error(client_addr, 0, 2, "Invalid player name");
                return;
            }
        }
        if (name.empty() || name.length() > 31) {
            send_error(client_addr, 0, 2, "Invalid player name length");
            return;
        }

        std::lock_guard<std::mutex> lock(players_mutex_);

        // Check if already connected from this address
        uint32_t existing = find_player_by_address(client_addr);
        if (existing != 0) {
            // Already connected, send ack again
            ConnectAckPayload ack{};
            ack.assigned_id = existing;
            ack.success = 1;
            send_packet(client_addr, PacketType::CONNECT_ACK, existing, &ack, sizeof(ack));
            return;
        }

        // Check max players
        int connected_count = 0;
        for (auto& [id, p] : players_) {
            if (p.connected) connected_count++;
        }
        if (connected_count >= MAX_PLAYERS) {
            ConnectAckPayload ack{};
            ack.assigned_id = 0;
            ack.success = 0;
            send_packet(client_addr, PacketType::CONNECT_ACK, 0, &ack, sizeof(ack));
            return;
        }

        // Create new player
        uint32_t new_id = next_player_id_++;
        Player player{};
        player.id = new_id;
        player.name = name;
        player.address.addr = client_addr;
        // Spawn at random position
        std::random_device rd;
        std::mt19937 gen(rd());
        std::uniform_real_distribution<float> dist_x(MAP_MIN_X * 0.5f, MAP_MAX_X * 0.5f);
        std::uniform_real_distribution<float> dist_y(MAP_MIN_Y * 0.5f, MAP_MAX_Y * 0.5f);
        player.position = {dist_x(gen), dist_y(gen), 0.0f};
        player.yaw = 0.0f;
        player.pitch = 0.0f;
        player.health = MAX_HEALTH;
        player.alive = true;
        player.connected = true;
        player.last_sequence = 0;
        player.last_activity_ms = current_time_ms();
        player.rate_limit = {current_time_ms(), 0};
        std::memcpy(player.auth_token.data(), connect_data.auth_token, 32);

        players_[new_id] = player;

        std::cout << "Player '" << name << "' connected with ID " << new_id << std::endl;

        // Send ack
        ConnectAckPayload ack{};
        ack.assigned_id = new_id;
        ack.success = 1;
        send_packet(client_addr, PacketType::CONNECT_ACK, new_id, &ack, sizeof(ack));

        // Send existing player states to new player
        for (auto& [id, p] : players_) {
            if (id != new_id && p.connected) {
                PlayerStatePayload state{};
                state.player_id = p.id;
                state.position = p.position;
                state.yaw = p.yaw;
                state.pitch = p.pitch;
                state.health = p.health;
                state.alive = p.alive ? 1 : 0;
                send_packet(client_addr, PacketType::PLAYER_STATE, new_id, &state, sizeof(state));
            }
        }
    }

    void handle_disconnect(const sockaddr_in& client_addr, const PacketHeader& header) {
        std::lock_guard<std::mutex> lock(players_mutex_);

        auto it = players_.find(header.player_id);
        if (it == players_.end() || !it->second.connected) return;

        // Verify address matches
        if (it->second.address.addr.sin_addr.s_addr != client_addr.sin_addr.s_addr ||
            it->second.address.addr.sin_port != client_addr.sin_port) {
            return; // Address mismatch - potential spoofing
        }

        std::cout << "Player '" << it->second.name << "' (ID " << it->second.id << ") disconnected" << std::endl;
        it->second.connected = false;

        // Notify others
        PlayerDiedPayload notify{};
        notify.dead_player_id = header.player_id;
        notify.killer_id = 0;

        for (auto& [id, p] : players_) {
            if (id != header.player_id && p.connected) {
                uint32_t disc_id = header.player_id;
                send_packet(p.address.addr, PacketType::PLAYER_DISCONNECTED, id, &disc_id, sizeof(disc_id));
            }
        }

        players_.erase(it);
    }

    void handle_position_update(const sockaddr_in& client_addr, const PacketHeader& header,
                                 const uint8_t* payload, uint16_t payload_len) {
        if (payload_len < sizeof(PositionPayload)) return;

        PositionPayload pos_data;
        std::memcpy(&pos_data, payload, sizeof(PositionPayload));

        std::lock_guard<std::mutex> lock(players_mutex_);

        auto it = players_.find(header.player_id);
        if (it == players_.end() || !it->second.connected) return;

        // Verify address matches
        if (it->second.address.addr.sin_addr.s_addr != client_addr.sin_addr.s_addr ||
            it->second.address.addr.sin_port != client_addr.sin_port) {
            return;
        }

        // Validate sequence number (must be newer)
        if (header.sequence <= it->second.last_sequence && it->second.last_sequence != 0) {
            return; // Old or duplicate packet
        }

        Player& player = it->second;

        if (!player.alive) return;

        // Validate position values
        if (!is_valid_position(pos_data.position)) {
            send_error(client_addr, player.id, 3, "Invalid position");
            return;
        }

        // Validate angles
        if (!is_valid_float(pos_data.yaw) || !is_valid_float(pos_data.pitch)) {
            return;
        }

        // Clamp angles
        pos_data.yaw = std::fmod(pos_data.yaw, 360.0f);
        pos_data.pitch = clamp(pos_data.pitch, -90.0f, 90.0f);

        // Speed hack detection
        float distance = vec3_distance(player.position, pos_data.position);
        if (distance > MAX_SPEED) {
            // Reject the movement - potential speed hack
            send_error(client_addr, player.id, 4, "Movement too fast");
            // Send corrected position back
            PlayerStatePayload state{};
            state.player_id = player.id;
            state.position = player.position;
            state.yaw = player.yaw;
            state.pitch = player.pitch;
            state.health = player.health;
            state.alive = player.alive ? 1 : 0;
            send_packet(client_addr, PacketType::PLAYER_STATE, player.id, &state, sizeof(state));
            return;
        }

        // Update player state
        player.position = pos_data.position;
        player.yaw = pos_data.yaw;
        player.pitch = pos_data.pitch;
        player.last_sequence = header.sequence;
        player.last_activity_ms = current_time_ms();

        // Broadcast to other players
        PlayerStatePayload state{};
        state.player_id = player.id;
        state.position = player.position;
        state.yaw = player.yaw;
        state.pitch = player.pitch;
        state.health = player.health;
        state.alive = player.alive ? 1 : 0;

        for (auto& [id, p] : players_) {
            if (id != player.id && p.connected) {
                send_packet(p.address.addr, PacketType::PLAYER_STATE, id, &state, sizeof(state));
            }
        }
    }

    void handle_shoot(const sockaddr_in& client_addr, const PacketHeader& header,
                      const uint8_t* payload, uint16_t payload_len) {
        if (payload_len < sizeof(ShootPayload)) return;

        ShootPayload shoot_data;
        std::memcpy(&shoot_data, payload, sizeof(ShootPayload));

        std::lock_guard<std::mutex> lock(players_mutex_);

        auto it = players_.find(header.player_id);
        if (it == players_.end() || !it->second.connected) return;

        // Verify address matches
        if (it->second.address.addr.sin_addr.s_addr != client_addr.sin_addr.s_addr ||
            it->second.address.addr.sin_port != client_addr.sin_port) {
            return;
        }

        Player& shooter = it->second;
        if (!shooter.alive) return;

        // Validate shoot origin is near player position (anti-cheat)
        if (!is_valid_position(shoot_data.origin)) return;
        float origin_dist = vec3_distance(shooter.position, shoot_data.origin);
        if (origin_dist > 5.0f) {
            // Shoot origin too far from player - potential cheat
            return;
        }

        // Validate direction
        if (!is_valid_direction(shoot_data.direction)) return;

        Vec3 dir = vec3_normalize(shoot_data.direction);

        shooter.last_activity_ms = current_time_ms();

        // Simple ray-cast hit detection against all other players
        // Using a simple sphere intersection (player hitbox radius)
        constexpr float HITBOX_RADIUS = 2.0f;

        uint32_t hit_player_id = 0;
        float closest_hit_dist = WEAPON_RANGE;

        for (auto& [id, target] : players_) {
            if (id == shooter.id || !target.connected || !target.alive) continue;

            // Ray-sphere intersection
            Vec3 oc = {shoot_data.origin.x - target.position.x,
                       shoot_data.origin.y - target.position.y,
                       shoot_data.origin.z - target.position.z};

            float a = dir.x * dir.x + dir.y * dir.y + dir.z * dir.z;
            float b = 2.0f * (oc.x * dir.x + oc.y * dir.y + oc.z * dir.z);
            float c = oc.x * oc.x + oc.y * oc.y + oc.z * oc.z - HITBOX_RADIUS * HITBOX_RADIUS;

            float discriminant = b * b - 4.0f * a * c;
            if (discriminant >= 0) {
                float t = (-b - std::sqrt(discriminant)) / (2.0f * a);
                if (t > 0 && t < closest_hit_dist) {
                    closest_hit_dist = t;
                    hit_player_id = id;
                }
            }
        }

        if (hit_player_id != 0) {
            auto target_it = players_.find(hit_player_id);
            if (target_it != players_.end()) {
                Player& target = target_it->second;
                target.health -= WEAPON_DAMAGE;
                target.health = std::max(0.0f, target.health);

                // Send hit confirmation to shooter
                HitConfirmPayload hit{};
                hit.shooter_id = shooter.id;
                hit.target_id = target.id;
                hit.damage = WEAPON_DAMAGE;
                hit.target_remaining_health = target.health;
                send_packet(shooter.address.addr, PacketType::HIT_CONFIRM, shooter.id, &hit, sizeof(hit));

                // Send updated state to target
                PlayerStatePayload state{};
                state.player_id = target.id;
                state.position = target.position;
                state.yaw = target.yaw;
                state.pitch = target.pitch;
                state.health = target.health;
                state.alive = target.alive ? 1 : 0;
                send_packet(target.address.addr, PacketType::PLAYER_STATE, target.id, &state, sizeof(state));

                if (target.health <= 0.0f) {
                    target.alive = false;
                    std::cout << "Player '" << shooter.name << "' killed '" << target.name << "'" << std::endl;

                    // Broadcast death
                    PlayerDiedPayload death{};
                    death.dead_player_id = target.id;
                    death.killer_id = shooter.id;

                    for (auto& [id, p] : players_) {
                        if (p.connected) {
                            send_packet(p.address.addr, PacketType::PLAYER_DIED, id, &death, sizeof(death));
                        }
                    }

                    // Respawn after delay (simplified: immediate respawn)
                    std::random_device rd;
                    std::mt19937 gen(rd());
                    std::uniform_real_distribution<float> dist_x(MAP_MIN_X * 0.5f, MAP_MAX_X * 0.5f);
                    std::uniform_real_distribution<float> dist_y(MAP_MIN_Y * 0.5f, MAP_MAX_Y * 0.5f);
                    target.position = {dist_x(gen), dist_y(gen), 0.0f};
                    target.health = MAX_HEALTH;
                    target.alive = true;

                    // Broadcast respawn state
                    PlayerStatePayload respawn_state{};
                    respawn_state.player_id = target.id;
                    respawn_state.position = target.position;
                    respawn_state.yaw = target.yaw;
                    respawn_state.pitch = target.pitch;
                    respawn_state.health = target.health;
                    respawn_state.alive = 1;

                    for (auto& [id, p] : players_) {
                        if (p.connected) {
                            send_packet(p.address.addr, PacketType::PLAYER_STATE, id,
                                       &respawn_state, sizeof(respawn_state));
                        }
                    }
                }
            }
        }
    }

    void handle_heartbeat(const sockaddr_in& client_addr, const PacketHeader& header) {
        std::lock_guard<std::mutex> lock(players_mutex_);
        auto it = players_.find(header.player_id);
        if (it == players_.end() || !it->second.connected) return;

        if (it->second.address.addr.sin_addr.s_addr != client_addr.sin_addr.s_addr ||
            it->second.address.addr.sin_port != client_addr.sin_port) {
            return;
        }

        it->second.last_activity_ms = current_time_ms();
    }

    void process_packet(const uint8_t* buffer, int bytes_received, const sockaddr_in& client_addr) {
        // Rate limit check
        if (!check_rate_limit(client_addr)) {
            return; // Drop packet - rate limited
        }

        // Minimum packet size check
        if (bytes_received < static_cast<int>(sizeof(PacketHeader))) {
            return;
        }

        // Parse header
        PacketHeader header;
        std::memcpy(&header, buffer, sizeof(PacketHeader));

        // Validate magic and version
        if (header.magic != PROTOCOL_MAGIC) {
            return;
        }
        if (header.version != PROTOCOL_VERSION) {
            return;
        }

        // Validate payload length
        if (header.payload_length > BUFFER_SIZE - sizeof(PacketHeader)) {
            return;
        }
        if (bytes_received < static_cast<int>(sizeof(PacketHeader) + header.payload_length)) {
            return;
        }

        // Only allow client packet types
        if (static_cast<uint8_t>(header.type) >= 0x80) {
            return; // Server-only packet type from client
        }

        const uint8_t* payload = buffer + sizeof(PacketHeader);

        switch (header.type) {
            case PacketType::CONNECT:
                handle_connect(client_addr, header, payload, header.payload_length);
                break;
            case PacketType::DISCONNECT:
                handle_disconnect(client_addr, header);
                break;
            case PacketType::POSITION_UPDATE:
                handle_position_update(client_addr, header, payload, header.payload_length);
                break;
            case PacketType::SHOOT:
                handle_shoot(client_addr, header, payload, header.payload_length);
                break;
            case PacketType::HEARTBEAT:
                handle_heartbeat(client_addr, header);
                break;
            default:
                break;
        }
    }

    void receive_loop() {
        uint8_t buffer[BUFFER_SIZE];
        sockaddr_in client_addr{};
        socklen_t addr_len = sizeof(client_addr);

        while (running_) {
            std::memset(buffer, 0, BUFFER_SIZE);
            addr_len = sizeof(client_addr);

            int bytes_received = recvfrom(sock_, reinterpret_cast<char*>(buffer), BUFFER_SIZE, 0,
                                          reinterpret_cast<sockaddr*>(&client_addr), &addr_len);

            if (bytes_received > 0) {
                process_packet(buffer, bytes_received, client_addr);
            } else {
                // No data available, sleep briefly
                std::this_thread::sleep_for(std::chrono::milliseconds(1));
            }
        }
    }

    void check_timeouts() {
        std::lock_guard<std::mutex> lock(players_mutex_);
        int64_t now = current_time_ms();

        std::vector<uint32_t> timed_out;
        for (auto& [id, player] : players_) {
            if (player.connected && (now - player.last_activity_ms > SESSION_TIMEOUT_MS)) {
                timed_out.push_back(id);
            }
        }

        for (uint32_t id : timed_out) {
            auto it = players_.find(id);
            if (it != players_.end()) {
                std::cout << "Player '" << it->second.name << "' timed out" << std::endl;
                it->second.connected = false;

                // Notify others
                for (auto& [oid, p] : players_) {
                    if (oid != id && p.connected) {
                        uint32_t disc_id = id;
                        send_packet(p.address.addr, PacketType::PLAYER_DISCONNECTED, oid,
                                   &disc_id, sizeof(disc_id));
                    }
                }

                players_.erase(it);
            }
        }

        // Clean up old rate limit entries
        {
            std::lock_guard<std::mutex> rl_lock(rate_limit_mutex_);
            std::vector<uint64_t> old_entries;
            for (auto& [key, info] : ip_rate_limits_) {
                if (now - info.window_start_ms > RATE_LIMIT_WINDOW_MS * 10) {
                    old_entries.push_back(key);
                }
            }
            for (uint64_t key : old_entries) {
                ip_rate_limits_.erase(key);
            }
        }
    }

    void game_loop() {
        auto last_tick = std::chrono::steady_clock::now();
        constexpr auto tick_rate = std::chrono::milliseconds(16); // ~60 ticks/sec

        while (running_) {
            auto now = std::chrono::steady_clock::now();
            auto elapsed = std::chrono::duration_cast<std::chrono::milliseconds>(now - last_tick);

            if (elapsed >= tick_rate) {
                last_tick = now;
                check_timeouts();
            }

            std::this_thread::sleep_for(std::chrono::milliseconds(1));
        }
    }
};

int main() {
    GameServer server;
    if (!server.start()) {
        std::cerr << "Failed to start server" << std::endl;
        return 1;
    }
    return 0;
}