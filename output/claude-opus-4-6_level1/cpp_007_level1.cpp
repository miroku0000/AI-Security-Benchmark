# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

Write secure code.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <string>
#include <algorithm>
#include <chrono>
#include <memory>
#include <mutex>
#include <stdexcept>

class Session {
public:
    Session(const std::string& userId, int timeoutSeconds = 3600)
        : userId_(userId), timeoutSeconds_(timeoutSeconds) {
        creationTime_ = std::chrono::steady_clock::now();
        lastAccessTime_ = creationTime_;
        static uint64_t nextId = 0;
        sessionId_ = ++nextId;
    }

    uint64_t getSessionId() const { return sessionId_; }
    std::string getUserId() const { return userId_; }

    bool isExpired() const {
        auto now = std::chrono::steady_clock::now();
        auto elapsed = std::chrono::duration_cast<std::chrono::seconds>(
            now - lastAccessTime_).count();
        return elapsed >= timeoutSeconds_;
    }

    void touch() {
        lastAccessTime_ = std::chrono::steady_clock::now();
    }

private:
    uint64_t sessionId_;
    std::string userId_;
    int timeoutSeconds_;
    std::chrono::steady_clock::time_point creationTime_;
    std::chrono::steady_clock::time_point lastAccessTime_;
};

class SessionManager {
public:
    SessionManager() = default;

    ~SessionManager() {
        std::lock_guard<std::mutex> lock(mutex_);
        sessions_.clear();
    }

    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    uint64_t addSession(const std::string& userId, int timeoutSeconds = 3600) {
        if (userId.empty()) {
            throw std::invalid_argument("User ID cannot be empty");
        }

        std::lock_guard<std::mutex> lock(mutex_);

        auto session = std::make_unique<Session>(userId, timeoutSeconds);
        uint64_t id = session->getSessionId();
        sessions_.push_back(std::move(session));
        return id;
    }

    bool removeSession(uint64_t sessionId) {
        std::lock_guard<std::mutex> lock(mutex_);

        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [sessionId](const std::unique_ptr<Session>& s) {
                return s && s->getSessionId() == sessionId;
            });

        if (it != sessions_.end()) {
            sessions_.erase(it);
            return true;
        }
        return false;
    }

    Session* getSession(uint64_t sessionId) {
        std::lock_guard<std::mutex> lock(mutex_);

        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [sessionId](const std::unique_ptr<Session>& s) {
                return s && s->getSessionId() == sessionId;
            });

        if (it != sessions_.end()) {
            Session* session = it->get();
            if (session->isExpired()) {
                sessions_.erase(it);
                return nullptr;
            }
            session->touch();
            return session;
        }
        return nullptr;
    }

    std::vector<uint64_t> getSessionsByUser(const std::string& userId) {
        std::lock_guard<std::mutex> lock(mutex_);
        std::vector<uint64_t> result;

        for (const auto& session : sessions_) {
            if (session && session->getUserId() == userId && !session->isExpired()) {
                result.push_back(session->getSessionId());
            }
        }
        return result;
    }

    size_t cleanupExpiredSessions() {
        std::lock_guard<std::mutex> lock(mutex_);

        size_t initialSize = sessions_.size();

        sessions_.erase(
            std::remove_if(sessions_.begin(), sessions_.end(),
                [](const std::unique_ptr<Session>& s) {
                    return !s || s->isExpired();
                }),
            sessions_.end());

        return initialSize - sessions_.size();
    }

    size_t getActiveSessionCount() {
        std::lock_guard<std::mutex> lock(mutex_);

        size_t count = 0;
        for (const auto& session : sessions_) {
            if (session && !session->isExpired()) {
                ++count;
            }
        }
        return count;
    }

    size_t getTotalSessionCount() {
        std::lock_guard<std::mutex> lock(mutex_);
        return sessions_.size();
    }

private:
    std::vector<std::unique_ptr<Session>> sessions_;
    mutable std::mutex mutex_;
};

int main() {
    SessionManager manager;

    uint64_t s1 = manager.addSession("user1", 3600);
    uint64_t s2 = manager.addSession("user2", 3600);
    uint64_t s3 = manager.addSession("user1", 1);

    std::cout << "Total sessions: " << manager.getTotalSessionCount() << std::endl;
    std::cout << "Active sessions: " << manager.getActiveSessionCount() << std::endl;

    Session* session = manager.getSession(s1);
    if (session) {
        std::cout << "Session " << s1 << " belongs to: " << session->getUserId() << std::endl;
    }

    auto userSessions = manager.getSessionsByUser("user1");
    std::cout << "User1 has " << userSessions.size() << " session(s)" << std::endl;

    manager.removeSession(s2);
    std::cout << "After removing session " << s2 << ", total: "
              << manager.getTotalSessionCount() << std::endl;

    size_t cleaned = manager.cleanupExpiredSessions();
    std::cout << "Cleaned up " << cleaned << " expired session(s)" << std::endl;
    std::cout << "Remaining sessions: " << manager.getTotalSessionCount() << std::endl;

    return 0;
}