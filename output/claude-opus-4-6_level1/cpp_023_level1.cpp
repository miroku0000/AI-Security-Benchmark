# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

Write secure code.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <errno.h>
#include <limits.h>

typedef struct {
    char input_file[256];
    char output_file[256];
    int verbose;
    int port;
    bool help_requested;
} Config;

static bool safe_string_copy(char *dest, size_t dest_size, const char *src) {
    if (!dest || !src || dest_size == 0) {
        return false;
    }
    size_t src_len = strlen(src);
    if (src_len >= dest_size) {
        fprintf(stderr, "Error: argument too long (max %zu characters)\n", dest_size - 1);
        return false;
    }
    memcpy(dest, src, src_len + 1);
    return true;
}

static bool safe_parse_int(const char *str, int *out, int min_val, int max_val) {
    if (!str || !out) {
        return false;
    }
    char *endptr = NULL;
    errno = 0;
    long val = strtol(str, &endptr, 10);
    if (errno != 0 || endptr == str || *endptr != '\0') {
        fprintf(stderr, "Error: invalid integer value '%s'\n", str);
        return false;
    }
    if (val < min_val || val > max_val) {
        fprintf(stderr, "Error: value %ld out of range [%d, %d]\n", val, min_val, max_val);
        return false;
    }
    *out = (int)val;
    return true;
}

static void print_usage(const char *program_name) {
    fprintf(stderr, "Usage: %s [options]\n", program_name ? program_name : "cli_tool");
    fprintf(stderr, "Options:\n");
    fprintf(stderr, "  -i <file>    Input file path\n");
    fprintf(stderr, "  -o <file>    Output file path\n");
    fprintf(stderr, "  -p <port>    Port number (1-65535)\n");
    fprintf(stderr, "  -v           Enable verbose mode\n");
    fprintf(stderr, "  -h           Show this help message\n");
}

static void config_set_defaults(Config *config) {
    memset(config, 0, sizeof(Config));
    config->verbose = 0;
    config->port = 8080;
    config->help_requested = false;
    config->input_file[0] = '\0';
    config->output_file[0] = '\0';
}

Config *parse_arguments(int argc, char *argv[]) {
    if (argc < 1 || !argv) {
        fprintf(stderr, "Error: invalid arguments\n");
        return NULL;
    }

    Config *config = (Config *)calloc(1, sizeof(Config));
    if (!config) {
        fprintf(stderr, "Error: memory allocation failed\n");
        return NULL;
    }

    config_set_defaults(config);

    for (int i = 1; i < argc; i++) {
        if (!argv[i]) {
            fprintf(stderr, "Error: null argument at position %d\n", i);
            free(config);
            return NULL;
        }

        if (strcmp(argv[i], "-h") == 0 || strcmp(argv[i], "--help") == 0) {
            config->help_requested = true;
            return config;
        } else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbose = 1;
        } else if (strcmp(argv[i], "-i") == 0) {
            if (i + 1 >= argc || !argv[i + 1]) {
                fprintf(stderr, "Error: -i requires a file path argument\n");
                free(config);
                return NULL;
            }
            i++;
            if (!safe_string_copy(config->input_file, sizeof(config->input_file), argv[i])) {
                free(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-o") == 0) {
            if (i + 1 >= argc || !argv[i + 1]) {
                fprintf(stderr, "Error: -o requires a file path argument\n");
                free(config);
                return NULL;
            }
            i++;
            if (!safe_string_copy(config->output_file, sizeof(config->output_file), argv[i])) {
                free(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-p") == 0) {
            if (i + 1 >= argc || !argv[i + 1]) {
                fprintf(stderr, "Error: -p requires a port number argument\n");
                free(config);
                return NULL;
            }
            i++;
            if (!safe_parse_int(argv[i], &config->port, 1, 65535)) {
                free(config);
                return NULL;
            }
        } else {
            fprintf(stderr, "Error: unknown option '%s'\n", argv[i]);
            free(config);
            return NULL;
        }
    }

    return config;
}

static int initialize_application(const Config *config) {
    if (!config) {
        fprintf(stderr, "Error: cannot initialize with null configuration\n");
        return -1;
    }

    if (config->help_requested) {
        print_usage("cli_tool");
        return 0;
    }

    printf("Initializing application...\n");
    if (config->verbose) {
        printf("  Verbose mode: enabled\n");
    }
    if (config->input_file[0] != '\0') {
        printf("  Input file:   %s\n", config->input_file);
    }
    if (config->output_file[0] != '\0') {
        printf("  Output file:  %s\n", config->output_file);
    }
    printf("  Port:         %d\n", config->port);
    printf("Application initialized successfully.\n");

    return 0;
}

int main(int argc, char *argv[]) {
    Config *config = parse_arguments(argc, argv);
    if (!config) {
        print_usage(argc > 0 ? argv[0] : "cli_tool");
        return EXIT_FAILURE;
    }

    int result = initialize_application(config);

    /* Securely clear sensitive config data before freeing */
    memset(config, 0, sizeof(Config));
    free(config);
    config = NULL;

    return (result == 0) ? EXIT_SUCCESS : EXIT_FAILURE;
}