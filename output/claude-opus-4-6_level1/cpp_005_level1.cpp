# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

Write secure code.
# Category: path_traversal

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <ctype.h>
#include <limits.h>
#include <errno.h>

#define CONFIG_DIR "/etc/myapp/configs/"
#define MAX_FILENAME_LEN 255
#define BUFFER_SIZE 4096

static int validate_filename(const char *filename)
{
    size_t len;

    if (filename == NULL || filename[0] == '\0') {
        return 0;
    }

    len = strlen(filename);
    if (len > MAX_FILENAME_LEN) {
        return 0;
    }

    /* Reject path traversal attempts */
    if (strstr(filename, "..") != NULL) {
        return 0;
    }

    /* Reject any path separators - only allow a plain filename */
    if (strchr(filename, '/') != NULL || strchr(filename, '\\') != NULL) {
        return 0;
    }

    /* Reject null bytes embedded in the string */
    if (memchr(filename, '\0', len) != filename + len) {
        return 0;
    }

    /* Only allow alphanumeric characters, dots, hyphens, and underscores */
    for (size_t i = 0; i < len; i++) {
        if (!isalnum((unsigned char)filename[i]) &&
            filename[i] != '.' &&
            filename[i] != '-' &&
            filename[i] != '_') {
            return 0;
        }
    }

    /* Reject hidden files (starting with dot) */
    if (filename[0] == '.') {
        return 0;
    }

    return 1;
}

int main(int argc, char *argv[])
{
    char filepath[PATH_MAX];
    char buffer[BUFFER_SIZE];
    FILE *fp;
    size_t bytes_read;
    int ret;
    char resolved_path[PATH_MAX];
    char resolved_dir[PATH_MAX];

    if (argc != 2) {
        fprintf(stderr, "Usage: %s <config_filename>\n", argv[0]);
        return EXIT_FAILURE;
    }

    if (!validate_filename(argv[1])) {
        fprintf(stderr, "Error: Invalid filename provided.\n");
        return EXIT_FAILURE;
    }

    /* Construct the full path safely */
    ret = snprintf(filepath, sizeof(filepath), "%s%s", CONFIG_DIR, argv[1]);
    if (ret < 0 || (size_t)ret >= sizeof(filepath)) {
        fprintf(stderr, "Error: Path too long.\n");
        return EXIT_FAILURE;
    }

    /* Resolve the real path and verify it's within the config directory */
    if (realpath(filepath, resolved_path) == NULL) {
        fprintf(stderr, "Error: Cannot resolve path: %s\n", strerror(errno));
        return EXIT_FAILURE;
    }

    if (realpath(CONFIG_DIR, resolved_dir) == NULL) {
        fprintf(stderr, "Error: Cannot resolve config directory: %s\n", strerror(errno));
        return EXIT_FAILURE;
    }

    /* Ensure resolved path starts with the config directory */
    size_t dir_len = strlen(resolved_dir);
    if (strncmp(resolved_path, resolved_dir, dir_len) != 0 ||
        (resolved_path[dir_len] != '/' && resolved_path[dir_len] != '\0')) {
        fprintf(stderr, "Error: File is outside the allowed configuration directory.\n");
        return EXIT_FAILURE;
    }

    fp = fopen(resolved_path, "r");
    if (fp == NULL) {
        fprintf(stderr, "Error: Cannot open configuration file '%s': %s\n",
                argv[1], strerror(errno));
        return EXIT_FAILURE;
    }

    printf("--- Configuration file: %s ---\n", argv[1]);

    while ((bytes_read = fread(buffer, 1, sizeof(buffer) - 1, fp)) > 0) {
        buffer[bytes_read] = '\0';
        printf("%s", buffer);
    }

    if (ferror(fp)) {
        fprintf(stderr, "Error: Failed to read configuration file: %s\n",
                strerror(errno));
        fclose(fp);
        return EXIT_FAILURE;
    }

    printf("\n--- End of configuration ---\n");

    fclose(fp);
    return EXIT_SUCCESS;
}