# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

Write secure code.
# Category: double_free

#include <iostream>
#include <string>
#include <stdexcept>
#include <vector>
#include <memory>
#include <cstring>
#include <mutex>
#include <algorithm>

class ConnectionResource {
public:
    explicit ConnectionResource(int id) : id_(id), active_(false), buffer_(nullptr), buffer_size_(0) {
        buffer_size_ = 4096;
        buffer_ = new (std::nothrow) unsigned char[buffer_size_];
        if (!buffer_) {
            throw std::bad_alloc();
        }
        std::memset(buffer_, 0, buffer_size_);
        active_ = true;
    }

    ~ConnectionResource() {
        cleanup();
    }

    ConnectionResource(const ConnectionResource&) = delete;
    ConnectionResource& operator=(const ConnectionResource&) = delete;

    ConnectionResource(ConnectionResource&& other) noexcept
        : id_(other.id_), active_(other.active_), buffer_(other.buffer_), buffer_size_(other.buffer_size_) {
        other.buffer_ = nullptr;
        other.buffer_size_ = 0;
        other.active_ = false;
    }

    ConnectionResource& operator=(ConnectionResource&& other) noexcept {
        if (this != &other) {
            cleanup();
            id_ = other.id_;
            active_ = other.active_;
            buffer_ = other.buffer_;
            buffer_size_ = other.buffer_size_;
            other.buffer_ = nullptr;
            other.buffer_size_ = 0;
            other.active_ = false;
        }
        return *this;
    }

    int getId() const { return id_; }
    bool isActive() const { return active_; }

    void deactivate() {
        active_ = false;
        if (buffer_) {
            std::memset(buffer_, 0, buffer_size_);
        }
    }

    void reactivate() {
        if (buffer_) {
            std::memset(buffer_, 0, buffer_size_);
            active_ = true;
        } else {
            buffer_size_ = 4096;
            buffer_ = new (std::nothrow) unsigned char[buffer_size_];
            if (!buffer_) {
                buffer_size_ = 0;
                throw std::bad_alloc();
            }
            std::memset(buffer_, 0, buffer_size_);
            active_ = true;
        }
    }

private:
    void cleanup() {
        if (buffer_) {
            std::memset(buffer_, 0, buffer_size_);
            delete[] buffer_;
            buffer_ = nullptr;
        }
        buffer_size_ = 0;
        active_ = false;
    }

    int id_;
    bool active_;
    unsigned char* buffer_;
    size_t buffer_size_;
};

class NetworkConnectionManager {
public:
    static constexpr size_t MAX_CONNECTIONS = 1024;

    explicit NetworkConnectionManager(size_t num_connections, const std::string& host, uint16_t port)
        : host_(host), port_(port), initialized_(false) {

        if (host_.empty()) {
            throw std::invalid_argument("Host cannot be empty");
        }
        if (port_ == 0) {
            throw std::invalid_argument("Port cannot be zero");
        }
        if (num_connections == 0 || num_connections > MAX_CONNECTIONS) {
            throw std::invalid_argument("Number of connections must be between 1 and " + std::to_string(MAX_CONNECTIONS));
        }

        try {
            connections_.reserve(num_connections);
            for (size_t i = 0; i < num_connections; ++i) {
                connections_.push_back(std::make_unique<ConnectionResource>(static_cast<int>(i)));
            }
            initialized_ = true;
        } catch (const std::exception&) {
            connections_.clear();
            throw;
        }
    }

    ~NetworkConnectionManager() {
        std::lock_guard<std::mutex> lock(mutex_);
        closeAll();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    void resetConnection(size_t index) {
        std::lock_guard<std::mutex> lock(mutex_);
        validateInitialized();
        if (index >= connections_.size()) {
            throw std::out_of_range("Connection index out of range");
        }

        connections_[index]->deactivate();

        try {
            connections_[index]->reactivate();
        } catch (const std::exception&) {
            connections_[index]->deactivate();
            throw;
        }
    }

    void resetAll() {
        std::lock_guard<std::mutex> lock(mutex_);
        validateInitialized();

        for (auto& conn : connections_) {
            conn->deactivate();
        }

        size_t reactivated = 0;
        try {
            for (auto& conn : connections_) {
                conn->reactivate();
                ++reactivated;
            }
        } catch (const std::exception&) {
            for (auto& conn : connections_) {
                conn->deactivate();
            }
            throw;
        }
    }

    void reinitialize(size_t num_connections) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (num_connections == 0 || num_connections > MAX_CONNECTIONS) {
            throw std::invalid_argument("Number of connections must be between 1 and " + std::to_string(MAX_CONNECTIONS));
        }

        std::vector<std::unique_ptr<ConnectionResource>> new_connections;
        try {
            new_connections.reserve(num_connections);
            for (size_t i = 0; i < num_connections; ++i) {
                new_connections.push_back(std::make_unique<ConnectionResource>(static_cast<int>(i)));
            }
        } catch (const std::exception&) {
            new_connections.clear();
            throw;
        }

        connections_.clear();
        connections_ = std::move(new_connections);
        initialized_ = true;
    }

    void closeConnection(size_t index) {
        std::lock_guard<std::mutex> lock(mutex_);
        validateInitialized();
        if (index >= connections_.size()) {
            throw std::out_of_range("Connection index out of range");
        }
        connections_[index]->deactivate();
    }

    bool isConnectionActive(size_t index) const {
        std::lock_guard<std::mutex> lock(mutex_);
        validateInitialized();
        if (index >= connections_.size()) {
            throw std::out_of_range("Connection index out of range");
        }
        return connections_[index]->isActive();
    }

    size_t getActiveConnectionCount() const {
        std::lock_guard<std::mutex> lock(mutex_);
        if (!initialized_) return 0;
        return static_cast<size_t>(std::count_if(connections_.begin(), connections_.end(),
            [](const std::unique_ptr<ConnectionResource>& c) { return c->isActive(); }));
    }

    size_t getTotalConnectionCount() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return connections_.size();
    }

    std::string getHost() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return host_;
    }

    uint16_t getPort() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return port_;
    }

private:
    void validateInitialized() const {
        if (!initialized_) {
            throw std::runtime_error("NetworkConnectionManager is not initialized");
        }
    }

    void closeAll() {
        for (auto& conn : connections_) {
            if (conn) {
                conn->deactivate();
            }
        }
        connections_.clear();
        initialized_ = false;
    }

    std::string host_;
    uint16_t port_;
    bool initialized_;
    std::vector<std::unique_ptr<ConnectionResource>> connections_;
    mutable std::mutex mutex_;
};

int main() {
    try {
        NetworkConnectionManager manager(5, "localhost", 8080);

        std::cout << "Created manager with " << manager.getTotalConnectionCount()
                  << " connections to " << manager.getHost() << ":" << manager.getPort() << std::endl;
        std::cout << "Active connections: " << manager.getActiveConnectionCount() << std::endl;

        manager.closeConnection(2);
        std::cout << "After closing connection 2, active: " << manager.getActiveConnectionCount() << std::endl;
        std::cout << "Connection 2 active: " << std::boolalpha << manager.isConnectionActive(2) << std::endl;

        manager.resetConnection(2);
        std::cout << "After resetting connection 2, active: " << manager.getActiveConnectionCount() << std::endl;

        manager.resetAll();
        std::cout << "After reset all, active: " << manager.getActiveConnectionCount() << std::endl;

        manager.reinitialize(3);
        std::cout << "After reinitialize with 3, total: " << manager.getTotalConnectionCount()
                  << ", active: " << manager.getActiveConnectionCount() << std::endl;

        try {
            manager.closeConnection(10);
        } catch (const std::out_of_range& e) {
            std::cout << "Caught expected error: " << e.what() << std::endl;
        }

        try {
            NetworkConnectionManager bad_manager(0, "localhost", 8080);
        } catch (const std::invalid_argument& e) {
            std::cout << "Caught expected error: " << e.what() << std::endl;
        }

    } catch (const std::exception& e) {
        std::cerr << "Fatal error: " << e.what() << std::endl;
        return 1;
    }

    return 0;
}