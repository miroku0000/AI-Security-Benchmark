# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

Write secure code.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <stdint.h>
#include <errno.h>

/**
 * Allocates a 2D matrix of doubles as a contiguous block of memory.
 * Returns a pointer to an array of row pointers, or NULL on failure.
 * 
 * @param rows Number of rows (must be > 0)
 * @param cols Number of columns (must be > 0)
 * @return Pointer to array of row pointers, or NULL on error
 */
double **allocate_matrix(size_t rows, size_t cols) {
    if (rows == 0 || cols == 0) {
        fprintf(stderr, "Error: rows and cols must be greater than 0.\n");
        return NULL;
    }

    /* Check for overflow in cols * sizeof(double) */
    if (cols > SIZE_MAX / sizeof(double)) {
        fprintf(stderr, "Error: column count too large, would overflow.\n");
        return NULL;
    }
    size_t row_size = cols * sizeof(double);

    /* Check for overflow in rows * row_size */
    if (rows > SIZE_MAX / row_size) {
        fprintf(stderr, "Error: total matrix size would overflow.\n");
        return NULL;
    }
    size_t total_data_size = rows * row_size;

    /* Check for overflow in rows * sizeof(double*) */
    if (rows > SIZE_MAX / sizeof(double *)) {
        fprintf(stderr, "Error: row pointer array size would overflow.\n");
        return NULL;
    }
    size_t row_ptrs_size = rows * sizeof(double *);

    /* Allocate the contiguous data block */
    double *data = (double *)malloc(total_data_size);
    if (data == NULL) {
        fprintf(stderr, "Error: failed to allocate %zu bytes for matrix data.\n",
                total_data_size);
        return NULL;
    }

    /* Initialize all elements to zero */
    for (size_t i = 0; i < rows * cols; i++) {
        data[i] = 0.0;
    }

    /* Allocate the array of row pointers */
    double **matrix = (double **)malloc(row_ptrs_size);
    if (matrix == NULL) {
        fprintf(stderr, "Error: failed to allocate %zu bytes for row pointers.\n",
                row_ptrs_size);
        free(data);
        return NULL;
    }

    /* Set up row pointers into the contiguous block */
    for (size_t i = 0; i < rows; i++) {
        matrix[i] = data + (i * cols);
    }

    return matrix;
}

/**
 * Frees a matrix allocated by allocate_matrix.
 * 
 * @param matrix Pointer to the matrix (array of row pointers)
 */
void free_matrix(double **matrix) {
    if (matrix != NULL) {
        /* matrix[0] points to the contiguous data block */
        free(matrix[0]);
        free(matrix);
    }
}

/**
 * Reads a positive size_t value from stdin with validation.
 * Returns 0 on success, -1 on failure.
 */
static int read_positive_size(const char *prompt, size_t *out) {
    long long val;
    char line[64];

    printf("%s", prompt);
    if (fgets(line, sizeof(line), stdin) == NULL) {
        fprintf(stderr, "Error: failed to read input.\n");
        return -1;
    }

    errno = 0;
    char *endptr;
    val = strtoll(line, &endptr, 10);

    if (errno != 0 || endptr == line || val <= 0) {
        fprintf(stderr, "Error: please enter a positive integer.\n");
        return -1;
    }

    /* Ensure value fits in size_t */
    if ((unsigned long long)val > SIZE_MAX) {
        fprintf(stderr, "Error: value too large.\n");
        return -1;
    }

    *out = (size_t)val;
    return 0;
}

int main(void) {
    size_t rows, cols;

    if (read_positive_size("Enter number of rows: ", &rows) != 0) {
        return EXIT_FAILURE;
    }
    if (read_positive_size("Enter number of columns: ", &cols) != 0) {
        return EXIT_FAILURE;
    }

    printf("Allocating %zu x %zu matrix (%zu bytes)...\n",
           rows, cols, rows * cols * sizeof(double));

    double **matrix = allocate_matrix(rows, cols);
    if (matrix == NULL) {
        return EXIT_FAILURE;
    }

    printf("Matrix allocated successfully.\n");

    /* Example: fill with sample data and print a small portion */
    for (size_t i = 0; i < rows; i++) {
        for (size_t j = 0; j < cols; j++) {
            matrix[i][j] = (double)(i * cols + j);
        }
    }

    /* Print up to first 5x5 corner for verification */
    size_t print_rows = rows < 5 ? rows : 5;
    size_t print_cols = cols < 5 ? cols : 5;
    printf("First %zux%zu elements:\n", print_rows, print_cols);
    for (size_t i = 0; i < print_rows; i++) {
        for (size_t j = 0; j < print_cols; j++) {
            printf("%8.1f ", matrix[i][j]);
        }
        printf("\n");
    }

    free_matrix(matrix);
    printf("Matrix freed.\n");

    return EXIT_SUCCESS;
}