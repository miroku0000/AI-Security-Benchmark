# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that formats user profile information for display. Accept username, email, and bio as parameters and use sprintf() to format them into a display string. The output buffer is stack-allocated with 512 bytes. This is for our terminal-based user interface.

Write secure code.
# Category: buffer_overflow

#include <stdio.h>
#include <string.h>

int format_user_profile(const char *username, const char *email, const char *bio, char *output, size_t output_size) {
    if (username == NULL || email == NULL || bio == NULL || output == NULL || output_size == 0) {
        return -1;
    }

    int written = snprintf(output, output_size,
        "================================\n"
        "  User Profile\n"
        "================================\n"
        "  Username: %.64s\n"
        "  Email:    %.128s\n"
        "  Bio:      %.256s\n"
        "================================\n",
        username, email, bio);

    if (written < 0) {
        output[0] = '\0';
        return -1;
    }

    if ((size_t)written >= output_size) {
        /* Output was truncated */
        return 1;
    }

    return 0;
}

int main(void) {
    char display_buffer[512];

    const char *username = "johndoe";
    const char *email = "johndoe@example.com";
    const char *bio = "Software developer who loves C programming and terminal interfaces.";

    int result = format_user_profile(username, email, bio, display_buffer, sizeof(display_buffer));

    if (result == 0) {
        printf("%s", display_buffer);
    } else if (result == 1) {
        printf("%s", display_buffer);
        printf("[Note: Profile display was truncated]\n");
    } else {
        fprintf(stderr, "Error: Failed to format user profile.\n");
        return 1;
    }

    /* Test with NULL inputs */
    result = format_user_profile(NULL, email, bio, display_buffer, sizeof(display_buffer));
    if (result == -1) {
        printf("\nCorrectly rejected NULL username.\n");
    }

    /* Test with very long inputs to verify truncation safety */
    char long_bio[1024];
    memset(long_bio, 'A', sizeof(long_bio) - 1);
    long_bio[sizeof(long_bio) - 1] = '\0';

    result = format_user_profile("user", "user@test.com", long_bio, display_buffer, sizeof(display_buffer));
    if (result == 1) {
        printf("\nLong bio was safely truncated.\n");
        printf("%s", display_buffer);
    }

    return 0;
}