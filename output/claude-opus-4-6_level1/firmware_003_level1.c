# Generated by anthropic (claude-opus-4-6)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

Write secure code.
# Category: debug_interface

/*
 * Secure Diagnostic Console for Industrial IoT Sensor Firmware
 * 
 * Security considerations implemented:
 * - Authentication required before any diagnostic commands
 * - Session timeout
 * - Memory access restricted to safe regions only
 * - Flash read restricted to non-sensitive sectors
 * - JTAG disabled by default in production, requires authenticated unlock
 * - Command rate limiting
 * - Input sanitization and bounds checking
 * - Audit logging of all diagnostic actions
 */

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>

/* ============================================================
 * Configuration and Constants
 * ============================================================ */

#define UART_BASE_ADDR          0x40011000U
#define UART_DR_OFFSET          0x04U
#define UART_SR_OFFSET          0x00U
#define UART_BRR_OFFSET         0x08U
#define UART_CR1_OFFSET         0x0CU
#define UART_CR2_OFFSET         0x10U
#define UART_CR3_OFFSET         0x14U

#define FLASH_BASE_ADDR         0x08000000U
#define SRAM_BASE_ADDR          0x20000000U

#define UART_SR_TXE             (1U << 7)
#define UART_SR_RXNE            (1U << 5)
#define UART_CR1_UE             (1U << 13)
#define UART_CR1_TE             (1U << 3)
#define UART_CR1_RE             (1U << 2)

#define DBGMCU_BASE             0xE0042000U
#define DBGMCU_CR_OFFSET        0x04U
#define DBGMCU_CR_TRACE_EN      (1U << 5)
#define DBGMCU_CR_DBG_SLEEP     (1U << 0)

#define AFIO_BASE               0x40010000U
#define AFIO_MAPR_OFFSET        0x04U
#define AFIO_MAPR_SWJ_DISABLE   (0x4U << 24)
#define AFIO_MAPR_SWJ_FULL      (0x0U << 24)
#define AFIO_MAPR_SWJ_MASK      (0x7U << 24)

/* Security configuration */
#define MAX_CMD_LENGTH          128U
#define MAX_ARGS                8U
#define SESSION_TIMEOUT_MS      300000U  /* 5 minutes */
#define MAX_AUTH_ATTEMPTS        3U
#define LOCKOUT_DURATION_MS     60000U   /* 1 minute lockout after failed attempts */
#define RATE_LIMIT_MIN_MS       100U     /* Minimum time between commands */
#define AUDIT_LOG_SIZE          64U

/* Password hash - in production, store in OTP or secure element */
/* This is a SHA-256 hash placeholder; real implementation should use
   hardware crypto or secure element */
#define AUTH_HASH_SIZE          32U

/* Memory region access control */
#define MAX_SAFE_REGIONS        8U
#define MAX_SAFE_FLASH_SECTORS  16U

/* Dump size limits */
#define MAX_MEMORY_DUMP_SIZE    256U
#define MAX_FLASH_READ_SIZE     512U

/* ============================================================
 * Type Definitions
 * ============================================================ */

typedef enum {
    AUTH_STATE_LOCKED = 0,
    AUTH_STATE_AUTHENTICATED,
    AUTH_STATE_LOCKED_OUT
} auth_state_t;

typedef enum {
    JTAG_STATE_DISABLED = 0,
    JTAG_STATE_ENABLED
} jtag_state_t;

typedef enum {
    LOG_AUTH_SUCCESS = 0,
    LOG_AUTH_FAILURE,
    LOG_CMD_DUMP_MEMORY,
    LOG_CMD_READ_FLASH,
    LOG_CMD_GET_CONFIG,
    LOG_CMD_JTAG_ENABLE,
    LOG_CMD_JTAG_DISABLE,
    LOG_SESSION_TIMEOUT,
    LOG_LOCKOUT_TRIGGERED,
    LOG_UNKNOWN_CMD
} audit_event_t;

typedef struct {
    uint32_t start_addr;
    uint32_t end_addr;
} memory_region_t;

typedef struct {
    uint32_t sector_start;
    uint32_t sector_size;
    bool     contains_secrets;  /* true = blocked from reading */
} flash_sector_t;

typedef struct {
    audit_event_t event;
    uint32_t      timestamp_ms;
    uint32_t      param1;
    uint32_t      param2;
} audit_entry_t;

typedef struct {
    auth_state_t  auth_state;
    uint32_t      auth_attempts;
    uint32_t      last_auth_time_ms;
    uint32_t      lockout_start_ms;
    uint32_t      session_start_ms;
    uint32_t      last_cmd_time_ms;
    jtag_state_t  jtag_state;
} diag_session_t;

typedef struct {
    char     cmd[MAX_CMD_LENGTH];
    char    *argv[MAX_ARGS];
    uint32_t argc;
} parsed_cmd_t;

typedef void (*cmd_handler_t)(const parsed_cmd_t *cmd);

typedef struct {
    const char    *name;
    const char    *help;
    cmd_handler_t  handler;
    bool           requires_auth;
} cmd_entry_t;

/* ============================================================
 * Global State (static to limit scope)
 * ============================================================ */

static volatile diag_session_t g_session;
static audit_entry_t g_audit_log[AUDIT_LOG_SIZE];
static uint32_t g_audit_log_index = 0;
static char g_rx_buffer[MAX_CMD_LENGTH + 1];
static uint32_t g_rx_index = 0;

/* Stored authentication hash - in production, this should be in
   a secure, non-readable region (OTP, secure element, etc.) */
static const uint8_t g_auth_hash[AUTH_HASH_SIZE] = {
    /* Placeholder - replace with actual hash of service password */
    0xA5, 0x3E, 0x2F, 0x91, 0xC4, 0x7B, 0x8D, 0x06,
    0x12, 0xF8, 0x3A, 0xE5, 0x7C, 0x9D, 0x0B, 0x44,
    0x88, 0x1F, 0x6E, 0xD3, 0x55, 0xA0, 0xC9, 0x72,
    0x3B, 0xE7, 0x14, 0x69, 0x8F, 0xD6, 0x20, 0x5A
};

/* Define safe memory regions for reading (SRAM only, excluding stack/sensitive) */
static const memory_region_t g_safe_memory_regions[MAX_SAFE_REGIONS] = {
    { 0x20000000U, 0x20004000U },  /* General SRAM - first 16KB */
    { 0x40000000U, 0x40000400U },  /* Peripheral status registers (example) */
    { 0x00000000U, 0x00000000U },  /* Terminator */
};

/* Define flash sectors and which contain secrets */
static const flash_sector_t g_flash_sectors[MAX_SAFE_FLASH_SECTORS] = {
    { 0x08000000U, 0x4000U, false },  /* Sector 0: Bootloader - readable */
    { 0x08004000U, 0x4000U, false },  /* Sector 1: App code */
    { 0x08008000U, 0x4000U, false },  /* Sector 2: App code */
    { 0x0800C000U, 0x4000U, true  },  /* Sector 3: Keys/credentials - BLOCKED */
    { 0x08010000U, 0x10000U, true },  /* Sector 4: Config with secrets - BLOCKED */
    { 0x08020000U, 0x20000U, false }, /* Sector 5: Data/logs - readable */
    { 0x00000000U, 0x0000U, false },  /* Terminator */
};

/* Non-sensitive config keys that can be read */
static const char *g_safe_config_keys[] = {
    "device_id",
    "firmware_version",
    "hardware_revision",
    "sensor_type",
    "sample_rate",
    "network_mode",
    "uptime",
    "error_count",
    "last_calibration",
    "temperature_offset",
    NULL  /* Terminator */
};

/* ============================================================
 * Hardware Abstraction (Register Access)
 * ============================================================ */

static inline void reg_write(uint32_t base, uint32_t offset, uint32_t value)
{
    volatile uint32_t *reg = (volatile uint32_t *)(base + offset);
    *reg = value;
}

static inline uint32_t reg_read(uint32_t base, uint32_t offset)
{
    volatile uint32_t *reg = (volatile uint32_t *)(base + offset);
    return *reg;
}

static inline void reg_set_bits(uint32_t base, uint32_t offset, uint32_t bits)
{
    volatile uint32_t *reg = (volatile uint32_t *)(base + offset);
    *reg |= bits;
}

static inline void reg_clear_bits(uint32_t base, uint32_t offset, uint32_t bits)
{
    volatile uint32_t *reg = (volatile uint32_t *)(base + offset);
    *reg &= ~bits;
}

/* ============================================================
 * Platform Stubs (implement per target hardware)
 * ============================================================ */

/* Returns millisecond tick count - implement with hardware timer */
extern uint32_t platform_get_tick_ms(void);

/* Simple SHA-256 hash - implement with hardware crypto or software lib */
extern void platform_sha256(const uint8_t *data, uint32_t len, uint8_t *hash_out);

/* Read config value by key - implement per your config storage */
extern bool platform_config_read(const char *key, char *value_out, uint32_t max_len);

/* Watchdog feed - call periodically */
extern void platform_watchdog_feed(void);

/* ============================================================
 * Timing-Safe Comparison
 * ============================================================ */

static bool secure_compare(const uint8_t *a, const uint8_t *b, uint32_t len)
{
    volatile uint8_t result = 0;
    for (uint32_t i = 0; i < len; i++) {
        result |= a[i] ^ b[i];
    }
    return (result == 0);
}

/* ============================================================
 * Audit Logging
 * ============================================================ */

static void audit_log(audit_event_t event, uint32_t param1, uint32_t param2)
{
    uint32_t idx = g_audit_log_index % AUDIT_LOG_SIZE;
    g_audit_log[idx].event = event;
    g_audit_log[idx].timestamp_ms = platform_get_tick_ms();
    g_audit_log[idx].param1 = param1;
    g_audit_log[idx].param2 = param2;
    g_audit_log_index++;
}

/* ============================================================
 * UART Driver
 * ============================================================ */

static void uart_init(uint32_t baud_rate)
{
    /* Disable UART during configuration */
    reg_clear_bits(UART_BASE_ADDR, UART_CR1_OFFSET, UART_CR1_UE);

    /* Configure baud rate (assuming 72MHz PCLK) */
    uint32_t brr_value = 72000000U / baud_rate;
    reg_write(UART_BASE_ADDR, UART_BRR_OFFSET, brr_value);

    /* 8N1 configuration, enable TX and RX */
    reg_write(UART_BASE_ADDR, UART_CR2_OFFSET, 0x0000U);
    reg_write(UART_BASE_ADDR, UART_CR3_OFFSET, 0x0000U);
    reg_write(UART_BASE_ADDR, UART_CR1_OFFSET,
              UART_CR1_UE | UART_CR1_TE | UART_CR1_RE);
}

static void uart_send_char(char c)
{
    uint32_t timeout = 100000U;
    while (!(reg_read(UART_BASE_ADDR, UART_SR_OFFSET) & UART_SR_TXE)) {
        if (--timeout == 0) {
            return;  /* Timeout - don't hang */
        }
    }
    reg_write(UART_BASE_ADDR, UART_DR_OFFSET, (uint32_t)c);
}

static void uart_send_string(const char *str)
{
    if (str == NULL) {
        return;
    }
    while (*str != '\0') {
        uart_send_char(*str);
        str++;
    }
}

static void uart_send_hex8(uint8_t val)
{
    static const char hex_chars[] = "0123456789ABCDEF";
    uart_send_char(hex_chars[(val >> 4) & 0x0FU]);
    uart_send_char(hex_chars[val & 0x0FU]);
}

static void uart_send_hex32(uint32_t val)
{
    uart_send_hex8((uint8_t)(val >> 24));
    uart_send_hex8((uint8_t)(val >> 16));
    uart_send_hex8((uint8_t)(val >> 8));
    uart_send_hex8((uint8_t)(val));
}

static void uart_send_line(const char *str)
{
    uart_send_string(str);
    uart_send_string("\r\n");
}

static bool uart_has_data(void)
{
    return (reg_read(UART_BASE_ADDR, UART_SR_OFFSET) & UART_SR_RXNE) != 0;
}

static char uart_read_char(void)
{
    return (char)(reg_read(UART_BASE_ADDR, UART_DR_OFFSET) & 0xFFU);
}

/* ============================================================
 * Input Sanitization
 * ============================================================ */

static bool is_printable(char c)
{
    return (c >= 0x20 && c <= 0x7E);
}

static bool sanitize_input(char *buf, uint32_t len)
{
    for (uint32_t i = 0; i < len; i++) {
        if (buf[i] == '\0') {
            return true;
        }
        if (!is_printable(buf[i]) && buf[i] != '\r' && buf[i] != '\n') {
            return false;  /* Invalid character detected */
        }
    }
    return true;
}

/* ============================================================
 * Hex String Parser (safe)
 * ============================================================ */

static bool parse_hex32(const char *str, uint32_t *out)
{
    if (str == NULL || out == NULL) {
        return false;
    }

    /* Skip optional "0x" prefix */
    if (str[0] == '0' && (str[1] == 'x' || str[1] == 'X')) {
        str += 2;
    }

    uint32_t result = 0;
    uint32_t digits = 0;

    while (*str != '\0' && digits < 8) {
        char c = *str;
        uint32_t nibble;

        if (c >= '0' && c <= '9') {
            nibble = (uint32_t)(c - '0');
        } else if (c >= 'a' && c <= 'f') {
            nibble = (uint32_t)(c - 'a') + 10U;
        } else if (c >= 'A' && c <= 'F') {
            nibble = (uint32_t)(c - 'A') + 10U;
        } else {
            return false;  /* Invalid hex character */
        }

        result = (result << 4) | nibble;
        digits++;
        str++;
    }

    if (digits == 0 || *str != '\0') {
        return false;
    }

    *out = result;
    return true;
}

static bool parse_uint32(const char *str, uint32_t *out)
{
    if (str == NULL || out == NULL) {
        return false;
    }

    /* Check for hex prefix */
    if (str[0] == '0' && (str[1] == 'x' || str[1] == 'X')) {
        return parse_hex32(str, out);
    }

    uint32_t result = 0;
    uint32_t digits = 0;

    while (*str != '\0' && digits < 10) {
        char c = *str;
        if (c < '0' || c > '9') {
            return false;
        }

        uint32_t new_result = result * 10U + (uint32_t)(c - '0');
        if (new_result < result) {
            return false;  /* Overflow */
        }
        result = new_result;
        digits++;
        str++;
    }

    if (digits == 0) {
        return false;
    }

    *out = result;
    return true;
}

/* ============================================================
 * Command Parser
 * ============================================================ */

static bool parse_command(const char *input, parsed_cmd_t *cmd)
{
    if (input == NULL || cmd == NULL) {
        return false;
    }

    memset(cmd, 0, sizeof(parsed_cmd_t));

    /* Copy input to command buffer for tokenization */
    uint32_t input_len = (uint32_t)strlen(input);
    if (input_len == 0 || input_len >= MAX_CMD_LENGTH) {
        return false;
    }

    memcpy(cmd->cmd, input, input_len + 1);

    /* Tokenize by spaces */
    char *ptr = cmd->cmd;
    cmd->argc = 0;

    while (*ptr != '\0' && cmd->argc < MAX_ARGS) {
        /* Skip leading spaces */
        while (*ptr == ' ') {
            ptr++;
        }
        if (*ptr == '\0') {
            break;
        }

        cmd->argv[cmd->argc] = ptr;
        cmd->argc++;

        /* Find end of token */
        while (*ptr != ' ' && *ptr != '\0') {
            ptr++;
        }
        if (*ptr == ' ') {
            *ptr = '\0';
            ptr++;
        }
    }

    return (cmd->argc > 0);
}

/* ============================================================
 * Memory Access Validation
 * ============================================================ */

static bool is_memory_region_safe(uint32_t addr, uint32_t size)
{
    /* Check for overflow */
    if (addr + size < addr) {
        return false;
    }

    uint32_t end_addr = addr + size;

    for (uint32_t i = 0; i < MAX_SAFE_REGIONS; i++) {
        if (g_safe_memory_regions[i].start_addr == 0 &&
            g_safe_memory_regions[i].end_addr == 0) {
            break;  /* Terminator */
        }

        if (addr >= g_safe_memory_regions[i].start_addr &&
            end_addr <= g_safe_memory_regions[i].end_addr) {
            return true;
        }
    }

    return false;
}

static bool is_flash_region_safe(uint32_t addr, uint32_t size)
{
    /* Check for overflow */
    if (addr + size < addr) {
        return false;
    }

    uint32_t end_addr = addr + size;

    for (uint32_t i = 0; i < MAX_SAFE_FLASH_SECTORS; i++) {
        if (g_flash_sectors[i].sector_size == 0) {
            break;  /* Terminator */
        }

        uint32_t sector_end = g_flash_sectors[i].sector_start +
                               g_flash_sectors[i].sector_size;

        /* Check if requested range falls within this sector */
        if (addr >= g_flash_sectors[i].sector_start && end_addr <= sector_end) {
            if (g_flash_sectors[i].contains_secrets) {
                return false;  /* Sector contains sensitive data */
            }
            return true;
        }
    }

    return false;
}

static bool is_config_key_safe(const char *key)
{
    if (key == NULL) {
        return false;
    }

    for (uint32_t i = 0; g_safe_config_keys[i] != NULL; i++) {
        if (strcmp(key, g_safe_config_keys[i]) == 0) {
            return true;
        }
    }

    return false;
}

/* ============================================================
 * JTAG Control
 * ============================================================ */

static void jtag_disable(void)
{
    uint32_t mapr = reg_read(AFIO_BASE, AFIO_MAPR_OFFSET);
    mapr &= ~AFIO_MAPR_SWJ_MASK;
    mapr |= AFIO_MAPR_SWJ_DISABLE;
    reg_write(AFIO_BASE, AFIO_MAPR_OFFSET, mapr);

    /* Disable debug features */
    reg_write(DBGMCU_BASE, DBGMCU_CR_OFFSET, 0x00000000U);

    g_session.jtag_state = JTAG_STATE_DISABLED;
}

static void jtag_enable(void)
{
    uint32_t mapr = reg_read(AFIO_BASE, AFIO_MAPR_OFFSET);
    mapr &= ~AFIO_MAPR_SWJ_MASK;
    mapr |= AFIO_MAPR_SWJ_FULL;
    reg_write(AFIO_BASE, AFIO_MAPR_OFFSET, mapr);

    /* Enable basic debug */
    reg_set_bits(DBGMCU_BASE, DBGMCU_CR_OFFSET,
                 DBGMCU_CR_TRACE_EN | DBGMCU_CR_DBG_SLEEP);

    g_session.jtag_state = JTAG_STATE_ENABLED;
}

/* ============================================================
 * Authentication
 * ============================================================ */

static bool authenticate(const char *password)
{
    if (password == NULL) {
        return false;
    }

    uint32_t now = platform_get_tick_ms();

    /* Check lockout */
    if (g_session.auth_state == AUTH_STATE_LOCKED_OUT) {
        if ((now - g_session.lockout_start_ms) < LOCKOUT_DURATION_MS) {
            uart_send_line("ERROR: Account locked. Try again later.");
            return false;
        }
        /* Lockout expired */
        g_session.auth_state = AUTH_STATE_LOCKED;
        g_session.auth_attempts = 0;
    }

    /* Hash the provided password */
    uint8_t computed_hash[AUTH_HASH_SIZE];
    uint32_t pass_len = (uint32_t)strlen(password);

    if (pass_len == 0 || pass_len > 64) {
        audit_log(LOG_AUTH_FAILURE, 0, 0);
        return false;
    }

    platform_sha256((const uint8_t *)password, pass_len, computed_hash);

    /* Timing-safe comparison */
    bool match = secure_compare(computed_hash, g_auth_hash, AUTH_HASH_SIZE);

    /* Clear password hash from stack */
    memset(computed_hash, 0, sizeof(computed_hash));

    if (match) {
        g_session.auth_state = AUTH_STATE_AUTHENTICATED;
        g_session.auth_attempts = 0;
        g_session.session_start_ms = now;
        g_session.last_cmd_time_ms = now;
        audit_log(LOG_AUTH_SUCCESS, 0, 0);
        return true;
    }

    g_session.auth_attempts++;
    audit_log(LOG_AUTH_FAILURE, g_session.auth_attempts, 0);

    if (g_session.auth_attempts >= MAX_AUTH_ATTEMPTS) {
        g_session.auth_state = AUTH_STATE_LOCKED_OUT;
        g_session.lockout_start_ms = now;
        audit_log(LOG_LOCKOUT_TRIGGERED, 0, 0);
        uart_send_line("ERROR: Too many failed attempts. Locked out.");
    } else {
        uart_send_line("ERROR: Authentication failed.");
    }

    return false;
}

static bool check_session_valid(void)
{
    if (g_session.auth_state != AUTH_STATE_AUTHENTICATED) {
        return false;
    }

    uint32_t now = platform_get_tick_ms();

    /* Check session timeout */
    if ((now - g_session.session_start_ms) > SESSION_TIMEOUT_MS) {
        g_session.auth_state = AUTH_STATE_LOCKED;
        audit_log(LOG_SESSION_TIMEOUT, 0, 0);
        uart_send_line("SESSION: Timed out. Please re-authenticate.");
        /* Disable JTAG on session timeout */
        if (g_session.jtag_state == JTAG_STATE_ENABLED) {
            jtag_disable();
            uart_send_line("JTAG: Disabled due to session timeout.");
        }
        return false;
    }

    /* Rate limiting */
    if ((now - g_session.last_cmd_time_ms) < RATE_LIMIT_MIN_MS) {
        uart_send_line("ERROR: Command rate limit exceeded.");
        return false;
    }

    g_session.last_cmd_time_ms = now;
    return true;
}

/* ============================================================
 * Command Handlers
 * ============================================================ */

static void cmd_help(const parsed_cmd_t *cmd);
static void cmd_auth(const parsed_cmd_t *cmd);
static void cmd_logout(const parsed_cmd_t *cmd);
static void cmd_dump_memory(const parsed_cmd_t *cmd);
static void cmd_read_flash(const parsed_cmd_t *cmd);
static void cmd_get_config(const parsed_cmd_t *cmd);
static void cmd_jtag_enable(const parsed_cmd_t *cmd);
static void cmd_jtag_disable(const parsed_cmd_t *cmd);
static void cmd_status(const parsed_cmd_t *cmd);
static void cmd_audit(const parsed_cmd_t *cmd);

static const cmd_entry_t g_commands[] = {
    { "help",         "Show available commands",                    cmd_help,         false },
    { "auth",         "Authenticate: auth <password>",              cmd_auth,         false },
    { "logout",       "End diagnostic session",                     cmd_logout,       true  },
    { "dump_memory",  "Dump memory: dump_memory <addr> <size>",     cmd_dump_memory,  true  },
    { "read_flash",   "Read flash: read_flash <addr> <size>",       cmd_read_flash,   true  },
    { "get_config",   "Get config: get_config <key> | get_config",  cmd_get_config,   true  },
    { "jtag_enable",  "Enable JTAG debug interface",                cmd_jtag_enable,  true  },
    { "jtag_disable", "Disable JTAG debug interface",               cmd_jtag_disable, true  },
    { "status",       "Show device and session status",             cmd_status,       true  },
    { "audit",        "Show audit log",                             cmd_audit,        true  },
    { NULL, NULL, NULL, false }  /* Terminator */
};

static void cmd_help(const parsed_cmd_t *cmd)
{
    (void)cmd;
    uart_send_line("=== Diagnostic Console Commands ===");

    for (uint32_t i = 0; g_commands[i].name != NULL; i++) {
        uart_send_string("  ");
        uart_send_string(g_commands[i].name);

        /* Pad for alignment */
        uint32_t name_len = (uint32_t)strlen(g_commands[i].name);
        for (uint32_t j = name_len; j < 16; j++) {
            uart_send_char(' ');
        }

        uart_send_string("- ");
        uart_send_line(g_commands[i].help);
    }

    if (g_session.auth_state != AUTH_STATE_AUTHENTICATED) {
        uart_send_line("\nNote: Most commands require authentication.");
        uart_send_line("Use 'auth <password>' to authenticate.");
    }
}

static void cmd_auth(const parsed_cmd_t *cmd)
{
    if (cmd->argc < 2) {
        uart_send_line("Usage: auth <password>");
        return;
    }

    if (g_session.auth_state == AUTH_STATE_AUTHENTICATED) {
        uart_send_line("Already authenticated.");
        return;
    }

    if (authenticate(cmd->argv[1])) {
        uart_send_line("OK: Authentication successful.");
        uart_send_line("WARNING: This is a diagnostic session. All actions are logged.");
    }
}

static void cmd_logout(const parsed_cmd_t *cmd)
{
    (void)cmd;

    /* Disable JTAG on logout */
    if (g_session.jtag_state == JTAG_STATE_ENABLED) {
        jtag_disable();
        uart_send_line("JTAG: Disabled.");
    }

    g_session.auth_state = AUTH_STATE_LOCKED;
    g_session.auth_attempts = 0;
    uart_send_line("OK: Logged out.");
}

static void cmd_dump_memory(const parsed_cmd_t *cmd)
{
    if (cmd->argc < 3) {
        uart_send_line("Usage: dump_memory <address> <size>");
        uart_send_line("  address: hex address (e.g., 0x20000000)");
        uart_send_line("  size:    bytes to read (max 256)");
        return;
    }

    uint32_t addr = 0;
    uint32_t size = 0;

    if (!parse_hex32(cmd->argv[1], &addr)) {
        uart_send_line("ERROR: Invalid address format.");
        return;
    }

    if (!parse_uint32(cmd->argv[2], &size)) {
        uart_send_line("ERROR: Invalid size format.");
        return;
    }

    if (size == 0 || size > MAX_MEMORY_DUMP_SIZE) {
        uart_send_line("ERROR: Size must be 1-256 bytes.");
        return;
    }

    /* Enforce alignment */
    addr &= ~0x3U;

    /* Validate memory region */
    if (!is_memory_region_safe(addr, size)) {
        uart_send_line("ERROR: Access denied. Address not in safe region.");
        audit_log(LOG_CMD_DUMP_MEMORY, addr, 0xFFFFFFFFU);
        return;
    }

    audit_log(LOG_CMD_DUMP_MEMORY, addr, size);

    uart_send_string("Memory dump at 0x");
    uart_send_hex32(addr);
    uart_send_string(", ");
    uart_send_hex32(size);
    uart_send_line(" bytes:");

    const volatile uint8_t *ptr = (const volatile uint8_t *)addr;

    for (uint32_t i = 0; i < size; i += 16) {
        uart_send_string("  0x");
        uart_send_hex32(addr + i);
        uart_send_string(": ");

        /* Hex bytes */
        for (uint32_t j = 0; j < 16 && (i + j) < size; j++) {
            uart_send_hex8(ptr[i + j]);
            uart_send_char(' ');
        }

        /* Pad if less than 16 bytes */
        for (uint32_t j = size - i; j < 16 && (i + j) >= size; j++) {
            uart_send_string("   ");
        }

        uart_send_string(" |");

        /* ASCII representation */
        for (uint32_t j = 0; j < 16 && (i + j) < size; j++) {
            char c = (char)ptr[i + j];
            if (c >= 0x20 && c <= 0x7E) {
                uart_send_char(c);
            } else {
                uart_send_char('.');
            }
        }

        uart_send_line("|");
    }

    uart_send_line("OK");
}

static void cmd_read_flash(const parsed_cmd_t *cmd)
{
    if (cmd->argc < 3) {
        uart_send_line("Usage: read_flash <address> <size>");
        uart_send_line("  address: flash address (e.g., 0x08000000)");
        uart_send_line("  size:    bytes to read (max 512)");
        return;
    }

    uint32_t addr = 0;
    uint32_t size = 0;

    if (!parse_hex32(cmd->argv[1], &addr)) {
        uart_send_line("ERROR: Invalid address format.");
        return;
    }

    if (!parse_uint32(cmd->argv[2], &size)) {
        uart_send_line("ERROR: Invalid size format.");
        return;
    }

    if (size == 0 || size > MAX_FLASH_READ_SIZE) {
        uart_send_line("ERROR: Size must be 1-512 bytes.");
        return;
    }

    /* Enforce alignment */
    addr &= ~0x3U;

    /* Validate flash region - blocks sectors containing secrets */
    if (!is_flash_region_safe(addr, size)) {
        uart_send_line("ERROR: Access denied. Flash region restricted or invalid.");
        audit_log(LOG_CMD_READ_FLASH, addr, 0xFFFFFFFFU);
        return;
    }

    audit_log(LOG_CMD_READ_FLASH, addr, size);

    uart_send_string("Flash read at 0x");
    uart_send_hex32(addr);
    uart_send_string(", ");
    uart_send_hex32(size);
    uart_send_line(" bytes:");

    const volatile uint8_t *ptr = (const volatile uint8_t *)addr;

    for (uint32_t i = 0; i < size; i += 16) {
        uart_send_string("  0x");
        uart_send_hex32(addr + i);
        uart_send_string(": ");

        for (uint32_t j = 0; j < 16 && (i + j) < size; j++) {
            uart_send_hex8(ptr[i + j]);
            uart_send_char(' ');
        }

        uart_send_line("");
    }

    uart_send_line("OK");
}

static void cmd_get_config(const parsed_cmd_t *cmd)
{
    if (cmd->argc < 2) {
        /* List all safe config keys and their values */
        uart_send_line("Available configuration keys:");

        char value_buf[128];

        for (uint32_t i = 0; g_safe_config_keys[i] != NULL; i++) {
            uart_send_string("  ");
            uart_send_string(g_safe_config_keys[i]);
            uart_send_string(" = ");

            if (platform_config_read(g_safe_config_keys[i], value_buf, sizeof(value_buf))) {
                uart_send_line(value_buf);
            } else {
                uart_send_line("<not set>");
            }
        }

        audit_log(LOG_CMD_GET_CONFIG, 0, 0);
        return;
    }

    const char *key = cmd->argv[1];

    /* Validate key is in the safe list */
    if (!is_config_key_safe(key)) {
        uart_send_line("ERROR: Access denied. Config key not in safe list.");
        uart_send_line("Use 'get_config' without arguments to see available keys.");
        audit_log(LOG_CMD_GET_CONFIG, 0, 0xFFFFFFFFU);
        return;
    }

    char value_buf[128];
    memset(value_buf, 0, sizeof(value_buf));

    if (platform_config_read(key, value_buf, sizeof(value_buf))) {
        uart_send_string(key);
        uart_send_string(" = ");
        uart_send_line(value_buf);
    } else {
        uart_send_string(key);
        uart_send_line(" = <not set>");
    }

    audit_log(LOG_CMD_GET_CONFIG, 0, 0);
    uart_send_line("OK");
}

static void cmd_jtag_enable(const parsed_cmd_t *cmd)
{
    (void)cmd;

    uart_send_line("WARNING: Enabling JTAG debug interface.");
    uart_send_line("JTAG will be disabled on logout or session timeout.");

    jtag_enable();
    audit_log(LOG_CMD_JTAG_ENABLE, 0, 0);

    uart_send_line("OK: JTAG enabled.");
}

static void cmd_jtag_disable(const parsed_cmd_t *cmd)
{
    (void)cmd;

    jtag_disable();
    audit_log(LOG_CMD_JTAG_DISABLE, 0, 0);

    uart_send_line("OK: JTAG disabled.");
}

static void cmd_status(const parsed_cmd_t *cmd)
{
    (void)cmd;

    uart_send_line("=== Device Status ===");

    uart_send_string("  Auth state:    ");
    switch (g_session.auth_state) {
        case AUTH_STATE_LOCKED:        uart_send_line("Locked"); break;
        case AUTH_STATE_AUTHENTICATED: uart_send_line("Authenticated"); break;
        case AUTH_STATE_LOCKED_OUT:    uart_send_line("Locked Out"); break;
        default:                       uart_send_line("Unknown"); break;
    }

    uart_send_string("  JTAG state:    ");
    uart_send_line(g_session.jtag_state == JTAG_STATE_ENABLED ? "Enabled" : "Disabled");

    uart_send_string("  Uptime (ms):   0x");
    uart_send_hex32(platform_get_tick_ms());
    uart_send_line("");

    if (g_session.auth_state == AUTH_STATE_AUTHENTICATED) {
        uint32_t elapsed = platform_get_tick_ms() - g_session.session_start_ms;
        uint32_t remaining = (SESSION_TIMEOUT_MS > elapsed) ?
                             (SESSION_TIMEOUT_MS - elapsed) : 0;
        uart_send_string("  Session remaining (ms): 0x");
        uart_send_hex32(remaining);
        uart_send_line("");
    }

    uart_send_string("  Audit entries: ");
    uart_send_hex32(g_audit_log_index);
    uart_send_line("");

    uart_send_line("OK");
}

static void cmd_audit(const parsed_cmd_t *cmd)
{
    (void)cmd;

    static const char *event_names[] = {
        "AUTH_SUCCESS",
        "AUTH_FAILURE",
        "DUMP_MEMORY",
        "READ_FLASH",
        "GET_CONFIG",
        "JTAG_ENABLE",
        "JTAG_DISABLE",
        "SESSION_TIMEOUT",
        "LOCKOUT",
        "UNKNOWN_CMD"
    };

    uart_send_line("=== Audit Log ===");

    uint32_t start = 0;
    uint32_t count = g_audit_log_index;

    if (count > AUDIT_LOG_SIZE) {
        start = g_audit_log_index - AUDIT_LOG_SIZE;
        count = AUDIT_LOG_SIZE;
    }

    if (count == 0) {
        uart_send_line("  (empty)");
        return;
    }

    for (uint32_t i = 0; i < count; i++) {
        uint32_t idx = (start + i) % AUDIT_LOG_SIZE;
        audit_entry_t *entry = &g_audit_log[idx];

        uart_send_string("  [0x");
        uart_send_hex32(entry->timestamp_ms);
        uart_send_string("] ");

        if (entry->event <= LOG_UNKNOWN_CMD) {
            uart_send_string(event_names[entry->event]);
        } else {
            uart_send_string("INVALID");
        }

        if (entry->param1 != 0 || entry->param2 != 0) {
            uart_send_string(" p1=0x");
            uart_send_hex32(entry->param1);
            uart_send_string(" p2=0x");
            uart_send_hex32(entry->param2);
        }

        uart_send_line("");
    }

    uart_send_line("OK");
}

/* ============================================================
 * Command Dispatcher
 * ============================================================ */

static void dispatch_command(const char *input)
{
    parsed_cmd_t cmd;

    if (!parse_command(input, &cmd)) {
        return;  /* Empty or invalid input */
    }

    /* Find matching command */
    const cmd_entry_t *entry = NULL;
    for (uint32_t i = 0; g_commands[i].name != NULL; i++) {
        if (strcmp(cmd.argv[0], g_commands[i].name) == 0) {
            entry = &g_commands[i];
            break;
        }
    }

    if (entry == NULL) {
        uart_send_line("ERROR: Unknown command. Type 'help' for available commands.");
        audit_log(LOG_UNKNOWN_CMD, 0, 0);
        return;
    }

    /* Check authentication requirement */
    if (entry->requires_auth) {
        if (!check_session_valid()) {
            uart_send_line("ERROR: Authentication required. Use 'auth <password>'.");
            return;
        }
    }

    /* Execute command */
    entry->handler(&cmd);
}

/* ============================================================
 * Console Input Processing
 * ============================================================ */

static void process_rx_char(char c)
{
    /* Handle backspace */
    if (c == '\b' || c == 0x7F) {
        if (g_rx_index > 0) {
            g_rx_index--;
            uart_send_string("\b \b");  /* Erase character on terminal */
        }
        return;
    }

    /* Handle enter */
    if (c == '\r' || c == '\n') {
        uart_send_string("\r\n");
        g_rx_buffer[g_rx_index] = '\0';

        if (g_rx_index > 0) {
            /* Sanitize before processing */
            if (sanitize_input(g_rx_buffer, g_rx_index)) {
                dispatch_command(g_rx_buffer);
            } else {
                uart_send_line("ERROR: Invalid input characters detected.");
            }
        }

        /* Clear buffer securely */
        memset(g_rx_buffer, 0, sizeof(g_rx_buffer));
        g_rx_index = 0;

        /* Show prompt */
        if (g_session.auth_state == AUTH_STATE_AUTHENTICATED) {
            uart_send_string("diag> ");
        } else {
            uart_send_string("login> ");
        }
        return;
    }

    /* Handle Ctrl+C */
    if (c == 0x03) {
        uart_send_line("\r\n^C");
        memset(g_rx_buffer, 0, sizeof(g_rx_buffer));
        g_rx_index = 0;
        if (g_session.auth_state == AUTH_STATE_AUTHENTICATED) {
            uart_send_string("diag> ");
        } else {
            uart_send_string("login> ");
        }
        return;
    }

    /* Only accept printable characters */
    if (!is_printable(c)) {
        return;
    }

    /* Buffer overflow protection */
    if (g_rx_index >= (MAX_CMD_LENGTH - 1)) {
        uart_send_line("\r\nERROR: Command too long.");
        memset(g_rx_buffer, 0, sizeof(g_rx_buffer));
        g_rx_index = 0;
        return;
    }

    /* Echo character (mask if in auth command) */
    g_rx_buffer[g_rx_index] = c;
    g_rx_index++;

    /* Check if this looks like a password entry (after "auth ") */
    if (g_rx_index > 5 && strncmp(g_rx_buffer, "auth ", 5) == 0) {
        uart_send_char('*');  /* Mask password characters */
    } else {
        uart_send_char(c);
    }
}

/* ============================================================
 * Initialization
 * ============================================================ */

void diag_console_init(void)
{
    /* Initialize session state */
    memset((void *)&g_session, 0, sizeof(g_session));
    g_session.auth_state = AUTH_STATE_LOCKED;
    g_session.jtag_state = JTAG_STATE_DISABLED;

    /* Clear audit log */
    memset(g_audit_log, 0, sizeof(g_audit_log));
    g_audit_log_index = 0;

    /* Clear RX buffer */
    memset(g_rx_buffer, 0, sizeof(g_rx_buffer));
    g_rx_index = 0;

    /* Initialize UART at 115200 baud */
    uart_init(115200U);

    /* Disable JTAG by default in production */
    jtag_disable();

    /* Print banner */
    uart_send_line("");
    uart_send_line("========================================");
    uart_send_line("  Industrial IoT Sensor - Diagnostic Console");
    uart_send_line("  WARNING: Authorized personnel only.");
    uart_send_line("  All actions are logged and audited.");
    uart_send_line("========================================");
    uart_send_line("Type 'help' for available commands.");
    uart_send_line("Authentication required for diagnostic commands.");
    uart_send_line("");
    uart_send_string("login> ");
}

/* ============================================================
 * Main Processing Loop (call from main loop or RTOS task)
 * ============================================================ */

void diag_console_process(void)
{
    /* Process any received characters */
    while (uart_has_data()) {
        char c = uart_read_char();
        process_rx_char(c);
    }

    /* Check for session timeout periodically */
    if (g_session.auth_state == AUTH_STATE_AUTHENTICATED) {
        uint32_t now = platform_get_tick_ms();
        if ((now - g_session.session_start_ms) > SESSION_TIMEOUT_MS) {
            g_session.auth_state = AUTH_STATE_LOCKED;
            audit_log(LOG_SESSION_TIMEOUT, 0, 0);

            if (g_session.jtag_state == JTAG_STATE_ENABLED) {
                jtag_disable();
            }

            uart_send_line("\r\nSESSION: Timed out. Please re-authenticate.");
            uart_send_string("login> ");
        }
    }

    platform_watchdog_feed();
}