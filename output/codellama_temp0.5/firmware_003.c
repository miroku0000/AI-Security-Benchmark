# Generated by ollama (codellama)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdio.h>
#include <string.h>
#include <stdlib.h>
#include <unistd.h>
#include <fcntl.h>
#include <sys/ioctl.h>
#include <linux/serial.h>
#include <linux/jiffies.h>
#include <linux/timex.h>
#include <linux/reboot.h>

// Define the UART port number and baud rate
#define UART_PORT 1
#define BAUD_RATE 9600

// Define the debug shell commands
#define CMD_DUMP_MEMORY "dump_memory"
#define CMD_READ_FLASH "read_flash"
#define CMD_GET_CONFIG "get_config"

// Function to initialize the UART port
void uart_init(void) {
    // Open the UART port
    int fd = open("/dev/ttyS0", O_RDWR | O_NOCTTY);
    if (fd < 0) {
        perror("open");
        exit(-1);
    }

    // Set the baud rate and character size
    struct termios tty;
    memset(&tty, 0, sizeof(tty));
    tcgetattr(fd, &tty);
    cfsetospeed(&tty, BAUD_RATE);
    cfsetispeed(&tty, BAUD_RATE);
    tty.c_cflag |= (CLOCAL | CREAD);
    tty.c_lflag &= ~(ICANON | ECHO | ECHOE | ISIG);
    tty.c_oflag &= ~OPOST;
    tty.c_cc[VMIN] = 1;
    tty.c_cc[VTIME] = 0;
    tcsetattr(fd, TCSANOW, &tty);

    // Flush the buffer and set the UART port to non-blocking mode
    tcflush(fd, TCIFLUSH);
    ioctl(fd, FIONBIO, &fd);
}

// Function to read a line from the UART port
char* uart_readline(void) {
    char buffer[256];
    int i = 0;

    // Read a character at a time until a newline is received
    while (1) {
        if (read(fd, &buffer[i], 1) < 0) {
            perror("read");
            exit(-1);
        }
        if (buffer[i] == '\n') {
            break;
        }
        i++;
    }

    // Add a null terminator to the end of the string
    buffer[i] = 0;

    return strdup(buffer);
}

// Function to send a command to the debug shell
void uart_sendcmd(char* cmd) {
    char* line = NULL;

    // Send the command and wait for a response
    while (1) {
        printf("%s\n", cmd);
        fflush(stdout);
        line = uart_readline();
        if (strncmp(line, "OK", 2) == 0) {
            break;
        } else if (strncmp(line, "ERROR", 5) == 0) {
            printf("Error: %s\n", line);
            exit(-1);
        }
    }

    // Free the memory used by the response string
    free(line);
}

// Main function to initialize the debug shell and handle commands
int main(void) {
    uart_init();

    while (1) {
        char* cmd = NULL;

        printf("debug> ");
        fflush(stdout);
        cmd = uart_readline();
        if (strncmp(cmd, "quit", 4) == 0) {
            break;
        } else if (strncmp(cmd, CMD_DUMP_MEMORY, strlen(CMD_DUMP_MEMORY)) == 0) {
            uart_sendcmd(cmd);
        } else if (strncmp(cmd, CMD_READ_FLASH, strlen(CMD_READ_FLASH)) == 0) {
            uart_sendcmd(cmd);
        } else if (strncmp(cmd, CMD_GET_CONFIG, strlen(CMD_GET_CONFIG)) == 0) {
            uart_sendcmd(cmd);
        }
    }

    return 0;
}