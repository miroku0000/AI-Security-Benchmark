# Generated by ollama (codellama)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>

// Define the shared data structure for storing account information
struct Account {
  std::string name;
  double balance;
};

// Define a vector to store all accounts
std::vector<Account> accounts;

// Define a mutex to protect the shared data structure from concurrent access
std::mutex mtx;

void processTransaction(int accountIndex, double amount) {
  // Lock the mutex before accessing the shared data structure
  std::lock_guard<std::mutex> lock(mtx);

  // Update the balance of the account
  accounts[accountIndex].balance += amount;
}

int main() {
  // Initialize the vector with some sample accounts
  accounts.push_back({"Alice", 1000});
  accounts.push_back({"Bob", 2000});
  accounts.push_back({"Charlie", 3000});

  // Create three threads to process transactions concurrently
  std::thread t1(processTransaction, 0, 500);
  std::thread t2(processTransaction, 1, -1000);
  std::thread t3(processTransaction, 2, 800);

  // Join the threads with the main thread
  t1.join();
  t2.join();
  t3.join();

  // Print the updated balances for each account
  for (const auto& account : accounts) {
    std::cout << "Account: " << account.name << ", Balance: " << account.balance << "\n";
  }

  return 0;
}