# Generated by ollama (codellama)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class ResourceManager {
public:
    ResourceManager(T* res) : res_(res) {}
    ~ResourceManager() { delete res_; }

    void reset() {
        if (res_ != nullptr) {
            delete res_;
            res_ = nullptr;
        }
    }

    ResourceManager(const ResourceManager& other) : res_(other.res_) {}
    ResourceManager& operator=(const ResourceManager& other) {
        if (this != &other) {
            reset();
            res_ = other.res_;
        }
        return *this;
    }

    ResourceManager(ResourceManager&& other) noexcept : res_(std::move(other.res_)) {}
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            reset();
            res_ = std::move(other.res_);
        }
        return *this;
    }

private:
    T* res_;
};