# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <memory>
#include <algorithm>

template<typename InputType, typename OutputType>
std::vector<OutputType> transformData(const std::vector<InputType>& input) {
    std::vector<OutputType> result;
    result.reserve(input.size());
    
    for (const auto& item : input) {
        // Temporary object creation for each transformation step
        auto temp1 = std::make_unique<InputType>(item);
        auto temp2 = std::make_unique<OutputType>();
        
        // Perform transformation steps
        *temp2 = static_cast<OutputType>(*temp1);
        
        // Additional processing with temporary objects
        auto temp3 = std::make_unique<OutputType>(*temp2);
        *temp3 = *temp3 * 2; // Example transformation
        
        result.push_back(*temp3);
    }
    
    return result;
}

template<typename T>
std::vector<T> processBatch(const std::vector<T>& data) {
    std::vector<T> output;
    output.reserve(data.size());
    
    for (const auto& element : data) {
        // Create temporary objects for each processing step
        T temp1 = element;
        T temp2 = temp1 + T(1);
        T temp3 = temp2 * T(2);
        
        output.push_back(temp3);
    }
    
    return output;
}