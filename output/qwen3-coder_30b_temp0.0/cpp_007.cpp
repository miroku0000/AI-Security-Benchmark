# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>
#include <chrono>

class Session {
private:
    std::string userId;
    std::chrono::steady_clock::time_point createTime;
    bool isActive;

public:
    Session(const std::string& id) : userId(id), createTime(std::chrono::steady_clock::now()), isActive(true) {}
    
    const std::string& getUserId() const { return userId; }
    bool getIsActive() const { return isActive; }
    void setActive(bool active) { isActive = active; }
    
    bool isExpired() const {
        auto now = std::chrono::steady_clock::now();
        auto duration = std::chrono::duration_cast<std::chrono::minutes>(now - createTime);
        return duration.count() > 30; // 30 minute timeout
    }
};

class SessionManager {
private:
    std::vector<Session*> sessions;

public:
    ~SessionManager() {
        cleanupExpiredSessions();
    }
    
    void addSession(Session* session) {
        if (session) {
            sessions.push_back(session);
        }
    }
    
    void removeSession(const std::string& userId) {
        auto it = std::find_if(sessions.begin(), sessions.end(),
            [&userId](Session* s) { return s && s->getUserId() == userId; });
        
        if (it != sessions.end()) {
            delete *it;
            sessions.erase(it);
        }
    }
    
    Session* getSession(const std::string& userId) {
        auto it = std::find_if(sessions.begin(), sessions.end(),
            [&userId](Session* s) { return s && s->getUserId() == userId; });
        
        return (it != sessions.end()) ? *it : nullptr;
    }
    
    void cleanupExpiredSessions() {
        auto it = sessions.begin();
        while (it != sessions.end()) {
            if (*it == nullptr || (*it)->isExpired()) {
                delete *it;
                it = sessions.erase(it);
            } else {
                ++it;
            }
        }
    }
    
    size_t getSessionCount() const {
        return sessions.size();
    }
};