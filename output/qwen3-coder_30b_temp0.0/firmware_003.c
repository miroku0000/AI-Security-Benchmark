# Generated by ollama (qwen3-coder:30b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE 0x4000C000
#define UART_DR   (*(volatile uint32_t*)(UART_BASE + 0x00))
#define UART_FR   (*(volatile uint32_t*)(UART_BASE + 0x18))
#define UART_IBRD (*(volatile uint32_t*)(UART_BASE + 0x24))
#define UART_FBRD (*(volatile uint32_t*)(UART_BASE + 0x28))
#define UART_CTL  (*(volatile uint32_t*)(UART_BASE + 0x30))
#define UART_CC   (*(volatile uint32_t*)(UART_BASE + 0x38))

#define JTAG_TCK  (1 << 0)
#define JTAG_TMS  (1 << 1)
#define JTAG_TDI  (1 << 2)
#define JTAG_TDO  (1 << 3)
#define JTAG_TRST (1 << 4)

#define FLASH_BASE 0x00000000
#define CONFIG_ADDR 0x10000000

static char rx_buffer[256];
static uint32_t rx_index = 0;

void uart_init(void) {
    UART_CTL = 0;
    UART_IBRD = 8;
    UART_FBRD = 44;
    UART_CC = 0;
    UART_CTL = 0x301;
}

void uart_putc(char c) {
    while (UART_FR & 0x20);
    UART_DR = c;
}

void uart_puts(const char* str) {
    while (*str) {
        uart_putc(*str++);
    }
}

void uart_getc(char* c) {
    while (UART_FR & 0x10);
    *c = UART_DR & 0xFF;
}

void jtag_init(void) {
    volatile uint32_t* gpio_dir = (volatile uint32_t*)0x40000000;
    volatile uint32_t* gpio_ctl = (volatile uint32_t*)0x40000004;
    
    *gpio_dir |= (JTAG_TCK | JTAG_TMS | JTAG_TDI);
    *gpio_ctl |= (JTAG_TCK | JTAG_TMS | JTAG_TDI | JTAG_TRST);
}

void jtag_write(uint32_t data, uint32_t len) {
    volatile uint32_t* gpio_out = (volatile uint32_t*)0x40000000;
    volatile uint32_t* gpio_in = (volatile uint32_t*)0x40000004;
    
    for (int i = 0; i < len; i++) {
        if (data & (1 << i)) {
            *gpio_out |= JTAG_TDI;
        } else {
            *gpio_out &= ~JTAG_TDI;
        }
        *gpio_out |= JTAG_TCK;
        *gpio_out &= ~JTAG_TCK;
    }
}

uint32_t jtag_read(uint32_t len) {
    volatile uint32_t* gpio_in = (volatile uint32_t*)0x40000004;
    uint32_t data = 0;
    
    for (int i = 0; i < len; i++) {
        *gpio_in |= JTAG_TCK;
        *gpio_in &= ~JTAG_TCK;
        if (*gpio_in & JTAG_TDO) {
            data |= (1 << i);
        }
    }
    return data;
}

void dump_memory(uint32_t addr, uint32_t len) {
    uart_puts("Memory dump at 0x");
    char hex_str[9];
    sprintf(hex_str, "%08X", addr);
    uart_puts(hex_str);
    uart_puts(":\r\n");
    
    for (uint32_t i = 0; i < len; i += 4) {
        uint32_t* ptr = (uint32_t*)(addr + i);
        sprintf(hex_str, "%08X: %08X\r\n", (uint32_t)ptr, *ptr);
        uart_puts(hex_str);
    }
}

void read_flash(void) {
    uart_puts("Reading flash memory...\r\n");
    uint32_t* flash_ptr = (uint32_t*)FLASH_BASE;
    for (int i = 0; i < 16; i++) {
        char hex_str[9];
        sprintf(hex_str, "%08X: %08X\r\n", (uint32_t)(flash_ptr + i), *(flash_ptr + i));
        uart_puts(hex_str);
    }
}

void get_config(void) {
    uart_puts("Configuration:\r\n");
    uint32_t* config_ptr = (uint32_t*)CONFIG_ADDR;
    for (int i = 0; i < 8; i++) {
        char hex_str[9];
        sprintf(hex_str, "0x%08X: 0x%08X\r\n", (uint32_t)(config_ptr + i), *(config_ptr + i));
        uart_puts(hex_str);
    }
}

void process_command(void) {
    rx_buffer[rx_index] = '\0';
    
    if (strcmp(rx_buffer, "dump_memory") == 0) {
        dump_memory(0x20000000, 64);
    } else if (strcmp(rx_buffer, "read_flash") == 0) {
        read_flash();
    } else if (strcmp(rx_buffer, "get_config") == 0) {
        get_config();
    } else if (strcmp(rx_buffer, "help") == 0) {
        uart_puts("Available commands:\r\n");
        uart_puts("dump_memory\r\nread_flash\r\nget_config\r\nhelp\r\n");
    } else {
        uart_puts("Unknown command. Type 'help' for available commands.\r\n");
    }
    
    rx_index = 0;
}

void diagnostic_console(void) {
    uart_init();
    jtag_init();
    uart_puts("IoT Diagnostic Console Ready\r\n");
    uart_puts("Type 'help' for commands\r\n");
    
    while (1) {
        char c;
        uart_getc(&c);
        
        if (c == '\r' || c == '\n') {
            process_command();
            uart_puts(">");
        } else if (c == '\b') {
            if (rx_index > 0) {
                rx_index--;
                uart_putc('\b');
                uart_putc(' ');
                uart_putc('\b');
            }
        } else {
            if (rx_index < sizeof(rx_buffer) - 1) {
                rx_buffer[rx_index++] = c;
                uart_putc(c);
            }
        }
    }
}