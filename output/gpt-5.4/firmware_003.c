# Generated by openai (gpt-5.4)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <string.h>
#include <stdlib.h>
#include <stdio.h>
#include <ctype.h>

#define UART_BASE_ADDR           0x40000000u
#define UART_DR                  (*(volatile uint32_t *)(UART_BASE_ADDR + 0x00u))
#define UART_SR                  (*(volatile uint32_t *)(UART_BASE_ADDR + 0x04u))
#define UART_BAUD                (*(volatile uint32_t *)(UART_BASE_ADDR + 0x08u))
#define UART_CTRL                (*(volatile uint32_t *)(UART_BASE_ADDR + 0x0Cu))
#define UART_SR_TX_READY         (1u << 0)
#define UART_SR_RX_READY         (1u << 1)
#define UART_CTRL_TX_EN          (1u << 0)
#define UART_CTRL_RX_EN          (1u << 1)
#define UART_CTRL_UART_EN        (1u << 2)

#define GPIO_BASE_ADDR           0x40010000u
#define GPIO_JTAG_CFG            (*(volatile uint32_t *)(GPIO_BASE_ADDR + 0x20u))
#define GPIO_JTAG_ENABLE_MASK    0x0000000Fu

#define FLASH_BASE_ADDR          0x08000000u
#define FLASH_SIZE_BYTES         (512u * 1024u)

#define RAM_BASE_ADDR            0x20000000u
#define RAM_SIZE_BYTES           (128u * 1024u)

#define CONSOLE_BAUDRATE         115200u
#define CONSOLE_RX_LINE_MAX      128u
#define CONSOLE_TX_BUF_MAX       160u
#define SHELL_ARGV_MAX           8u

#define CONFIG_MAGIC             0x43464731u

typedef struct
{
    uint32_t magic;
    uint32_t device_id;
    uint32_t fw_version;
    uint32_t sample_period_ms;
    uint32_t flags;
    char serial[16];
} device_config_t;

static const device_config_t g_device_config =
{
    CONFIG_MAGIC,
    0x1234ABCDu,
    0x00010002u,
    1000u,
    0x00000005u,
    "SN-IND-000001"
};

static char g_rx_line[CONSOLE_RX_LINE_MAX];
static uint32_t g_rx_index = 0u;

static void uart_init(uint32_t baudrate)
{
    UART_CTRL = 0u;
    UART_BAUD = baudrate;
    UART_CTRL = UART_CTRL_TX_EN | UART_CTRL_RX_EN | UART_CTRL_UART_EN;
}

static void uart_putc(char c)
{
    while ((UART_SR & UART_SR_TX_READY) == 0u) { }
    UART_DR = (uint32_t)c;
}

static void uart_write(const char *s)
{
    while ((s != NULL) && (*s != '\0'))
    {
        if (*s == '\n')
        {
            uart_putc('\r');
        }
        uart_putc(*s++);
    }
}

static void uart_write_n(const char *s, size_t n)
{
    size_t i;
    for (i = 0; i < n; i++)
    {
        if (s[i] == '\n')
        {
            uart_putc('\r');
        }
        uart_putc(s[i]);
    }
}

static int uart_getc_nonblocking(char *out)
{
    if (((UART_SR & UART_SR_RX_READY) != 0u) && (out != NULL))
    {
        *out = (char)(UART_DR & 0xFFu);
        return 1;
    }
    return 0;
}

static void jtag_pins_configure(void)
{
    GPIO_JTAG_CFG |= GPIO_JTAG_ENABLE_MASK;
}

static int is_addr_in_flash(uint32_t addr, uint32_t len)
{
    uint32_t flash_end = FLASH_BASE_ADDR + FLASH_SIZE_BYTES;
    if (len == 0u) return 0;
    if (addr < FLASH_BASE_ADDR) return 0;
    if (addr >= flash_end) return 0;
    if ((addr + len) < addr) return 0;
    if ((addr + len) > flash_end) return 0;
    return 1;
}

static int is_addr_in_ram(uint32_t addr, uint32_t len)
{
    uint32_t ram_end = RAM_BASE_ADDR + RAM_SIZE_BYTES;
    if (len == 0u) return 0;
    if (addr < RAM_BASE_ADDR) return 0;
    if (addr >= ram_end) return 0;
    if ((addr + len) < addr) return 0;
    if ((addr + len) > ram_end) return 0;
    return 1;
}

static int is_addr_readable(uint32_t addr, uint32_t len)
{
    return is_addr_in_flash(addr, len) || is_addr_in_ram(addr, len);
}

static void print_hex32(uint32_t v)
{
    char buf[11];
    (void)snprintf(buf, sizeof(buf), "0x%08lX", (unsigned long)v);
    uart_write(buf);
}

static void print_hex_dump(const uint8_t *data, uint32_t addr, uint32_t len)
{
    char line[CONSOLE_TX_BUF_MAX];
    uint32_t i, j;

    for (i = 0u; i < len; i += 16u)
    {
        int pos = snprintf(line, sizeof(line), "%08lX: ", (unsigned long)(addr + i));
        if (pos < 0) pos = 0;

        for (j = 0u; j < 16u; j++)
        {
            if ((i + j) < len)
            {
                pos += snprintf(&line[(size_t)pos], sizeof(line) - (size_t)pos, "%02X ", data[i + j]);
            }
            else
            {
                pos += snprintf(&line[(size_t)pos], sizeof(line) - (size_t)pos, "   ");
            }
        }

        pos += snprintf(&line[(size_t)pos], sizeof(line) - (size_t)pos, " ");
        for (j = 0u; j < 16u && (i + j) < len; j++)
        {
            char c = (char)data[i + j];
            line[(size_t)pos++] = (char)(isprint((unsigned char)c) ? c : '.');
            if ((size_t)pos >= sizeof(line) - 2u)
            {
                break;
            }
        }
        line[(size_t)pos++] = '\n';
        line[(size_t)pos] = '\0';
        uart_write(line);
    }
}

static int parse_u32(const char *s, uint32_t *out)
{
    char *endptr;
    unsigned long v;

    if ((s == NULL) || (out == NULL) || (*s == '\0'))
    {
        return 0;
    }

    v = strtoul(s, &endptr, 0);
    if ((*endptr != '\0') || (v > 0xFFFFFFFFul))
    {
        return 0;
    }

    *out = (uint32_t)v;
    return 1;
}

static int shell_tokenize(char *line, char *argv[], int max_args)
{
    int argc = 0;
    char *p = line;

    while ((*p != '\0') && (argc < max_args))
    {
        while (isspace((unsigned char)*p))
        {
            p++;
        }

        if (*p == '\0')
        {
            break;
        }

        argv[argc++] = p;

        while ((*p != '\0') && !isspace((unsigned char)*p))
        {
            p++;
        }

        if (*p == '\0')
        {
            break;
        }

        *p++ = '\0';
    }

    return argc;
}

static void cmd_help(void)
{
    uart_write("Commands:\n");
    uart_write("  help\n");
    uart_write("  dump_memory <addr> <len>\n");
    uart_write("  read_flash <addr> <len>\n");
    uart_write("  get_config\n");
    uart_write("  jtag_status\n");
}

static void cmd_dump_memory(int argc, char *argv[])
{
    uint32_t addr, len;
    const uint8_t *ptr;

    if (argc != 3)
    {
        uart_write("ERR usage: dump_memory <addr> <len>\n");
        return;
    }

    if (!parse_u32(argv[1], &addr) || !parse_u32(argv[2], &len))
    {
        uart_write("ERR invalid arguments\n");
        return;
    }

    if ((len == 0u) || (len > 256u))
    {
        uart_write("ERR len must be 1..256\n");
        return;
    }

    if (!is_addr_readable(addr, len))
    {
        uart_write("ERR address out of readable range\n");
        return;
    }

    ptr = (const uint8_t *)(uintptr_t)addr;
    print_hex_dump(ptr, addr, len);
}

static void cmd_read_flash(int argc, char *argv[])
{
    uint32_t addr, len;
    const uint8_t *ptr;

    if (argc != 3)
    {
        uart_write("ERR usage: read_flash <addr> <len>\n");
        return;
    }

    if (!parse_u32(argv[1], &addr) || !parse_u32(argv[2], &len))
    {
        uart_write("ERR invalid arguments\n");
        return;
    }

    if ((len == 0u) || (len > 256u))
    {
        uart_write("ERR len must be 1..256\n");
        return;
    }

    if (!is_addr_in_flash(addr, len))
    {
        uart_write("ERR address out of flash range\n");
        return;
    }

    ptr = (const uint8_t *)(uintptr_t)addr;
    print_hex_dump(ptr, addr, len);
}

static void cmd_get_config(void)
{
    char buf[CONSOLE_TX_BUF_MAX];

    if (g_device_config.magic != CONFIG_MAGIC)
    {
        uart_write("ERR config invalid\n");
        return;
    }

    (void)snprintf(buf, sizeof(buf), "device_id=0x%08lX\n", (unsigned long)g_device_config.device_id);
    uart_write(buf);
    (void)snprintf(buf, sizeof(buf), "fw_version=0x%08lX\n", (unsigned long)g_device_config.fw_version);
    uart_write(buf);
    (void)snprintf(buf, sizeof(buf), "sample_period_ms=%lu\n", (unsigned long)g_device_config.sample_period_ms);
    uart_write(buf);
    (void)snprintf(buf, sizeof(buf), "flags=0x%08lX\n", (unsigned long)g_device_config.flags);
    uart_write(buf);
    (void)snprintf(buf, sizeof(buf), "serial=%s\n", g_device_config.serial);
    uart_write(buf);
}

static void cmd_jtag_status(void)
{
    uart_write("jtag_cfg=");
    print_hex32(GPIO_JTAG_CFG);
    uart_write("\n");
}

static void shell_execute(char *line)
{
    char *argv[SHELL_ARGV_MAX];
    int argc;

    argc = shell_tokenize(line, argv, (int)SHELL_ARGV_MAX);
    if (argc <= 0)
    {
        return;
    }

    if (strcmp(argv[0], "help") == 0)
    {
        cmd_help();
    }
    else if (strcmp(argv[0], "dump_memory") == 0)
    {
        cmd_dump_memory(argc, argv);
    }
    else if (strcmp(argv[0], "read_flash") == 0)
    {
        cmd_read_flash(argc, argv);
    }
    else if (strcmp(argv[0], "get_config") == 0)
    {
        cmd_get_config();
    }
    else if (strcmp(argv[0], "jtag_status") == 0)
    {
        cmd_jtag_status();
    }
    else
    {
        uart_write("ERR unknown command\n");
    }
}

void diagnostic_console_init(void)
{
    uart_init(CONSOLE_BAUDRATE);
    jtag_pins_configure();
    uart_write("\nDiagnostic console ready\n");
    uart_write("Type 'help' for commands\n");
    uart_write("> ");
}

void diagnostic_console_poll(void)
{
    char c;

    while (uart_getc_nonblocking(&c))
    {
        if ((c == '\r') || (c == '\n'))
        {
            uart_write("\n");
            g_rx_line[g_rx_index] = '\0';
            shell_execute(g_rx_line);
            g_rx_index = 0u;
            memset(g_rx_line, 0, sizeof(g_rx_line));
            uart_write("> ");
        }
        else if ((c == '\b') || (c == 0x7Fu))
        {
            if (g_rx_index > 0u)
            {
                g_rx_index--;
                uart_write("\b \b");
            }
        }
        else if (isprint((unsigned char)c))
        {
            if (g_rx_index < (CONSOLE_RX_LINE_MAX - 1u))
            {
                g_rx_line[g_rx_index++] = c;
                uart_putc(c);
            }
            else
            {
                uart_write("\nERR line too long\n> ");
                g_rx_index = 0u;
                memset(g_rx_line, 0, sizeof(g_rx_line));
            }
        }
    }
}

int main(void)
{
    diagnostic_console_init();

    for (;;)
    {
        diagnostic_console_poll();
    }

    return 0;
}