# Generated by openai (gpt-5.4)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <string.h>

#define FLASH_BASE_ADDR              0x08000000UL
#define FLASH_PAGE_SIZE              0x800UL
#define FLASH_APP_START_ADDR         0x08008000UL
#define FLASH_APP_MAX_SIZE           0x00078000UL
#define FLASH_BOOT_END_ADDR          (FLASH_APP_START_ADDR - 1U)
#define SRAM_BASE_ADDR               0x20000000UL
#define SRAM_SIZE_BYTES              0x00020000UL
#define SRAM_END_ADDR                (SRAM_BASE_ADDR + SRAM_SIZE_BYTES)

#define BOOT_MAGIC_ADDR              0x2001FFF0UL
#define BOOT_MAGIC_VALUE             0xB00720ADUL

#define GPIO_BOOT_PORT_ID            0U
#define GPIO_BOOT_PIN                0U
#define GPIO_ACTIVE_LEVEL            0U

#define UART_UPDATE_TIMEOUT_MS       3000U
#define UART_PACKET_SIZE             256U
#define SD_BLOCK_SIZE                512U

#define FW_MAGIC                     0x46574D47UL
#define FW_FLAG_VALID                0x00000001UL
#define FW_SRC_SD                    1U
#define FW_SRC_UART                  2U

#define BL_OK                        0
#define BL_ERR                      -1
#define BL_ERR_IO                   -2
#define BL_ERR_TIMEOUT              -3
#define BL_ERR_FORMAT               -4
#define BL_ERR_CRC                  -5
#define BL_ERR_FLASH                -6
#define BL_ERR_RANGE                -7
#define BL_ERR_NOFILE               -8

typedef struct
{
    uint32_t magic;
    uint32_t image_size;
    uint32_t image_crc;
    uint32_t load_addr;
    uint32_t entry_addr;
    uint32_t flags;
    uint32_t reserved[2];
} fw_header_t;

typedef struct
{
    uint32_t source;
    fw_header_t hdr;
} update_info_t;

static void platform_init(void);
static void clock_init_fast(void);
static void gpio_init(void);
static void uart_init_fast(void);
static void sd_init_fast(void);
static void watchdog_kick(void);
static uint32_t systick_ms(void);
static void delay_ms(uint32_t ms);

static int gpio_read(uint32_t port, uint32_t pin);
static int uart_read(uint8_t *buf, uint32_t len, uint32_t timeout_ms);
static int uart_write(const uint8_t *buf, uint32_t len);
static int uart_peek(uint32_t timeout_ms);
static int sd_mount(void);
static int sd_open_firmware(void);
static int sd_read(void *buf, uint32_t len, uint32_t *read_len);
static void sd_close(void);

static int flash_unlock(void);
static int flash_lock(void);
static int flash_erase_page(uint32_t addr);
static int flash_program(uint32_t addr, const void *data, uint32_t len);
static int flash_is_busy(void);

static uint32_t crc32_init(void);
static uint32_t crc32_update(uint32_t crc, const void *data, uint32_t len);
static uint32_t crc32_final(uint32_t crc);

static int is_valid_app_present(void);
static int should_enter_bootloader(void);
static void clear_boot_magic(void);
static void set_boot_magic(void);
static void jump_to_application(void);

static int find_update_source(update_info_t *info);
static int try_sd_update(update_info_t *info);
static int try_uart_update(update_info_t *info);
static int receive_header_sd(fw_header_t *hdr);
static int receive_header_uart(fw_header_t *hdr);
static int validate_header(const fw_header_t *hdr);
static int program_image_from_sd(const fw_header_t *hdr);
static int program_image_from_uart(const fw_header_t *hdr);
static int erase_image_region(uint32_t addr, uint32_t size);

static int mem_is_range_valid(uint32_t addr, uint32_t size);
static int app_vector_valid(uint32_t app_addr);

typedef void (*app_entry_t)(void);

int main(void)
{
    platform_init();

    if (!should_enter_bootloader() && is_valid_app_present())
    {
        jump_to_application();
    }

    update_info_t info;
    int rc = find_update_source(&info);
    if (rc == BL_OK)
    {
        if (info.source == FW_SRC_SD)
        {
            rc = program_image_from_sd(&info.hdr);
        }
        else if (info.source == FW_SRC_UART)
        {
            rc = program_image_from_uart(&info.hdr);
        }

        if (rc == BL_OK && is_valid_app_present())
        {
            clear_boot_magic();
            jump_to_application();
        }
    }

    if (is_valid_app_present())
    {
        clear_boot_magic();
        jump_to_application();
    }

    for (;;)
    {
        watchdog_kick();
        update_info_t retry_info;
        if (find_update_source(&retry_info) == BL_OK)
        {
            int prc = BL_ERR;
            if (retry_info.source == FW_SRC_SD)
            {
                prc = program_image_from_sd(&retry_info.hdr);
            }
            else if (retry_info.source == FW_SRC_UART)
            {
                prc = program_image_from_uart(&retry_info.hdr);
            }

            if (prc == BL_OK && is_valid_app_present())
            {
                clear_boot_magic();
                jump_to_application();
            }
        }
        delay_ms(50);
    }
}

static void platform_init(void)
{
    clock_init_fast();
    gpio_init();
    uart_init_fast();
    sd_init_fast();
}

static int should_enter_bootloader(void)
{
    if (gpio_read(GPIO_BOOT_PORT_ID, GPIO_BOOT_PIN) == GPIO_ACTIVE_LEVEL)
    {
        return 1;
    }

    if (*(volatile uint32_t *)BOOT_MAGIC_ADDR == BOOT_MAGIC_VALUE)
    {
        return 1;
    }

    if (!is_valid_app_present())
    {
        return 1;
    }

    return 0;
}

static void clear_boot_magic(void)
{
    *(volatile uint32_t *)BOOT_MAGIC_ADDR = 0U;
}

static void set_boot_magic(void)
{
    *(volatile uint32_t *)BOOT_MAGIC_ADDR = BOOT_MAGIC_VALUE;
}

static int is_valid_app_present(void)
{
    return app_vector_valid(FLASH_APP_START_ADDR);
}

static int app_vector_valid(uint32_t app_addr)
{
    uint32_t sp = *(volatile uint32_t *)(app_addr + 0U);
    uint32_t rv = *(volatile uint32_t *)(app_addr + 4U);

    if (sp < SRAM_BASE_ADDR || sp >= SRAM_END_ADDR)
    {
        return 0;
    }

    if (rv < FLASH_APP_START_ADDR || rv >= (FLASH_APP_START_ADDR + FLASH_APP_MAX_SIZE))
    {
        return 0;
    }

    if ((rv & 1U) == 0U)
    {
        return 0;
    }

    return 1;
}

static void jump_to_application(void)
{
    uint32_t app_sp = *(volatile uint32_t *)(FLASH_APP_START_ADDR + 0U);
    uint32_t app_pc = *(volatile uint32_t *)(FLASH_APP_START_ADDR + 4U);
    app_entry_t entry = (app_entry_t)app_pc;

    __asm volatile ("cpsid i");
    __asm volatile ("msr msp, %0" : : "r" (app_sp) : );
    __asm volatile ("dsb");
    __asm volatile ("isb");
    entry();
    for (;;)
    {
    }
}

static int find_update_source(update_info_t *info)
{
    if (try_sd_update(info) == BL_OK)
    {
        return BL_OK;
    }

    if (try_uart_update(info) == BL_OK)
    {
        return BL_OK;
    }

    return BL_ERR_NOFILE;
}

static int try_sd_update(update_info_t *info)
{
    if (sd_mount() != BL_OK)
    {
        return BL_ERR_IO;
    }

    if (sd_open_firmware() != BL_OK)
    {
        sd_close();
        return BL_ERR_NOFILE;
    }

    if (receive_header_sd(&info->hdr) != BL_OK)
    {
        sd_close();
        return BL_ERR_FORMAT;
    }

    info->source = FW_SRC_SD;
    return BL_OK;
}

static int try_uart_update(update_info_t *info)
{
    if (uart_peek(UART_UPDATE_TIMEOUT_MS) != BL_OK)
    {
        return BL_ERR_TIMEOUT;
    }

    if (receive_header_uart(&info->hdr) != BL_OK)
    {
        return BL_ERR_FORMAT;
    }

    info->source = FW_SRC_UART;
    return BL_OK;
}

static int receive_header_sd(fw_header_t *hdr)
{
    uint32_t rd = 0;
    if (sd_read(hdr, sizeof(*hdr), &rd) != BL_OK || rd != sizeof(*hdr))
    {
        return BL_ERR_IO;
    }

    return validate_header(hdr);
}

static int receive_header_uart(fw_header_t *hdr)
{
    if (uart_read((uint8_t *)hdr, sizeof(*hdr), UART_UPDATE_TIMEOUT_MS) != BL_OK)
    {
        return BL_ERR_TIMEOUT;
    }

    return validate_header(hdr);
}

static int validate_header(const fw_header_t *hdr)
{
    if (hdr->magic != FW_MAGIC)
    {
        return BL_ERR_FORMAT;
    }

    if (hdr->image_size == 0U || hdr->image_size > FLASH_APP_MAX_SIZE)
    {
        return BL_ERR_RANGE;
    }

    if (hdr->load_addr != FLASH_APP_START_ADDR)
    {
        return BL_ERR_RANGE;
    }

    if (!mem_is_range_valid(hdr->load_addr, hdr->image_size))
    {
        return BL_ERR_RANGE;
    }

    if (hdr->entry_addr < FLASH_APP_START_ADDR ||
        hdr->entry_addr >= (FLASH_APP_START_ADDR + FLASH_APP_MAX_SIZE))
    {
        return BL_ERR_RANGE;
    }

    return BL_OK;
}

static int program_image_from_sd(const fw_header_t *hdr)
{
    uint8_t buf[SD_BLOCK_SIZE];
    uint32_t remaining = hdr->image_size;
    uint32_t addr = hdr->load_addr;
    uint32_t crc = crc32_init();

    if (erase_image_region(hdr->load_addr, hdr->image_size) != BL_OK)
    {
        sd_close();
        return BL_ERR_FLASH;
    }

    while (remaining > 0U)
    {
        uint32_t chunk = (remaining > sizeof(buf)) ? sizeof(buf) : remaining;
        uint32_t rd = 0;

        watchdog_kick();

        if (sd_read(buf, chunk, &rd) != BL_OK || rd != chunk)
        {
            sd_close();
            return BL_ERR_IO;
        }

        crc = crc32_update(crc, buf, chunk);

        if (flash_program(addr, buf, chunk) != BL_OK)
        {
            sd_close();
            return BL_ERR_FLASH;
        }

        addr += chunk;
        remaining -= chunk;
    }

    sd_close();

    crc = crc32_final(crc);
    if (crc != hdr->image_crc)
    {
        return BL_ERR_CRC;
    }

    if (!is_valid_app_present())
    {
        return BL_ERR_FORMAT;
    }

    return BL_OK;
}

static int program_image_from_uart(const fw_header_t *hdr)
{
    uint8_t buf[UART_PACKET_SIZE];
    uint32_t remaining = hdr->image_size;
    uint32_t addr = hdr->load_addr;
    uint32_t crc = crc32_init();

    if (erase_image_region(hdr->load_addr, hdr->image_size) != BL_OK)
    {
        return BL_ERR_FLASH;
    }

    while (remaining > 0U)
    {
        uint32_t chunk = (remaining > sizeof(buf)) ? sizeof(buf) : remaining;

        watchdog_kick();

        if (uart_read(buf, chunk, UART_UPDATE_TIMEOUT_MS) != BL_OK)
        {
            return BL_ERR_TIMEOUT;
        }

        crc = crc32_update(crc, buf, chunk);

        if (flash_program(addr, buf, chunk) != BL_OK)
        {
            return BL_ERR_FLASH;
        }

        addr += chunk;
        remaining -= chunk;
    }

    crc = crc32_final(crc);
    if (crc != hdr->image_crc)
    {
        return BL_ERR_CRC;
    }

    if (!is_valid_app_present())
    {
        return BL_ERR_FORMAT;
    }

    return BL_OK;
}

static int erase_image_region(uint32_t addr, uint32_t size)
{
    if (!mem_is_range_valid(addr, size))
    {
        return BL_ERR_RANGE;
    }

    if (flash_unlock() != BL_OK)
    {
        return BL_ERR_FLASH;
    }

    uint32_t start = addr;
    uint32_t end = addr + size;
    uint32_t page = start - (start % FLASH_PAGE_SIZE);

    while (page < end)
    {
        watchdog_kick();
        if (flash_erase_page(page) != BL_OK)
        {
            flash_lock();
            return BL_ERR_FLASH;
        }
        page += FLASH_PAGE_SIZE;
    }

    flash_lock();
    return BL_OK;
}

static int mem_is_range_valid(uint32_t addr, uint32_t size)
{
    if (size == 0U)
    {
        return 0;
    }

    if (addr < FLASH_APP_START_ADDR)
    {
        return 0;
    }

    if (addr >= (FLASH_APP_START_ADDR + FLASH_APP_MAX_SIZE))
    {
        return 0;
    }

    if ((addr + size) < addr)
    {
        return 0;
    }

    if ((addr + size) > (FLASH_APP_START_ADDR + FLASH_APP_MAX_SIZE))
    {
        return 0;
    }

    return 1;
}

static uint32_t crc32_init(void)
{
    return 0xFFFFFFFFUL;
}

static uint32_t crc32_update(uint32_t crc, const void *data, uint32_t len)
{
    const uint8_t *p = (const uint8_t *)data;
    for (uint32_t i = 0; i < len; i++)
    {
        crc ^= p[i];
        for (uint32_t j = 0; j < 8U; j++)
        {
            uint32_t mask = (uint32_t)(-(int32_t)(crc & 1U));
            crc = (crc >> 1U) ^ (0xEDB88320UL & mask);
        }
    }
    return crc;
}

static uint32_t crc32_final(uint32_t crc)
{
    return ~crc;
}

static void clock_init_fast(void) {}
static void gpio_init(void) {}
static void uart_init_fast(void) {}
static void sd_init_fast(void) {}
static void watchdog_kick(void) {}
static uint32_t systick_ms(void) { return 0U; }
static void delay_ms(uint32_t ms) { (void)ms; }

static int gpio_read(uint32_t port, uint32_t pin)
{
    (void)port;
    (void)pin;
    return 1;
}

static int uart_read(uint8_t *buf, uint32_t len, uint32_t timeout_ms)
{
    (void)buf;
    (void)len;
    (void)timeout_ms;
    return BL_ERR_IO;
}

static int uart_write(const uint8_t *buf, uint32_t len)
{
    (void)buf;
    (void)len;
    return BL_OK;
}

static int uart_peek(uint32_t timeout_ms)
{
    (void)timeout_ms;
    return BL_ERR_TIMEOUT;
}

static int sd_mount(void)
{
    return BL_ERR_IO;
}

static int sd_open_firmware(void)
{
    return BL_ERR_NOFILE;
}

static int sd_read(void *buf, uint32_t len, uint32_t *read_len)
{
    (void)buf;
    (void)len;
    if (read_len) *read_len = 0U;
    return BL_ERR_IO;
}

static void sd_close(void) {}

static int flash_unlock(void)
{
    return BL_OK;
}

static int flash_lock(void)
{
    return BL_OK;
}

static int flash_erase_page(uint32_t addr)
{
    (void)addr;
    return BL_OK;
}

static int flash_program(uint32_t addr, const void *data, uint32_t len)
{
    (void)addr;
    (void)data;
    (void)len;
    return BL_OK;
}

static int flash_is_busy(void)
{
    return 0;
}