# Generated by openai (gpt-5.4)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>

typedef struct
{
    uint32_t timestamp;
    float temperature;
    float pressure;
    float flow;
    uint32_t sequence;
} sensor_data_t;

volatile sensor_data_t sensor_data;

static uint32_t read_timestamp(void)
{
    return xTaskGetTickCount();
}

static float read_temperature_sensor(void)
{
    static float v = 25.0f;
    v += 0.1f;
    return v;
}

static float read_pressure_sensor(void)
{
    static float v = 1.0f;
    v += 0.05f;
    return v;
}

static float read_flow_sensor(void)
{
    static float v = 10.0f;
    v += 0.2f;
    return v;
}

static void apply_control(float temperature, float pressure, float flow)
{
    (void)temperature;
    (void)pressure;
    (void)flow;
}

static void vSensorReadTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        sensor_data.timestamp = read_timestamp();
        sensor_data.temperature = read_temperature_sensor();
        sensor_data.pressure = read_pressure_sensor();
        sensor_data.flow = read_flow_sensor();
        sensor_data.sequence++;

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

static void vControlTask(void *pvParameters)
{
    (void)pvParameters;

    sensor_data_t local_copy;
    uint32_t last_sequence = 0U;

    for (;;)
    {
        if (sensor_data.sequence != last_sequence)
        {
            local_copy.timestamp = sensor_data.timestamp;
            local_copy.temperature = sensor_data.temperature;
            local_copy.pressure = sensor_data.pressure;
            local_copy.flow = sensor_data.flow;
            local_copy.sequence = sensor_data.sequence;

            last_sequence = local_copy.sequence;

            apply_control(local_copy.temperature, local_copy.pressure, local_copy.flow);
        }

        vTaskDelay(pdMS_TO_TICKS(5));
    }
}

int main(void)
{
    sensor_data.timestamp = 0U;
    sensor_data.temperature = 0.0f;
    sensor_data.pressure = 0.0f;
    sensor_data.flow = 0.0f;
    sensor_data.sequence = 0U;

    xTaskCreate(vSensorReadTask, "SensorRead", configMINIMAL_STACK_SIZE + 128U, NULL, tskIDLE_PRIORITY + 2U, NULL);
    xTaskCreate(vControlTask, "Control", configMINIMAL_STACK_SIZE + 128U, NULL, tskIDLE_PRIORITY + 3U, NULL);

    vTaskStartScheduler();

    for (;;)
    {
    }
}