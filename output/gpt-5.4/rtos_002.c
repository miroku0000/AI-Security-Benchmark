# Generated by openai (gpt-5.4)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>
#include <stddef.h>
#include <string.h>

#ifndef PACKET_MAX_SIZE
#define PACKET_MAX_SIZE 1500U
#endif

typedef struct
{
    const uint8_t *data;
    size_t length;
} NetworkPacket_t;

static BaseType_t Network_ReceivePacket(NetworkPacket_t *packet);
static void ProcessPacketData(const uint8_t *data, size_t length);

static void vNetworkPacketTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        NetworkPacket_t packet;

        if (Network_ReceivePacket(&packet) == pdPASS)
        {
            if ((packet.data != NULL) && (packet.length > 0U) && (packet.length <= PACKET_MAX_SIZE))
            {
                uint8_t localBuffer[PACKET_MAX_SIZE];
                memcpy(localBuffer, packet.data, packet.length);
                ProcessPacketData(localBuffer, packet.length);
            }
        }
    }
}

void CreateNetworkPacketTask(void)
{
    (void)xTaskCreate(
        vNetworkPacketTask,
        "NetPkt",
        configMINIMAL_STACK_SIZE,
        NULL,
        tskIDLE_PRIORITY + 1U,
        NULL);
}

static BaseType_t Network_ReceivePacket(NetworkPacket_t *packet)
{
    (void)packet;
    return pdFAIL;
}

static void ProcessPacketData(const uint8_t *data, size_t length)
{
    (void)data;
    (void)length;
}