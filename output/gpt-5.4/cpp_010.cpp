# Generated by openai (gpt-5.4)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <vector>
#include <thread>
#include <shared_mutex>
#include <mutex>
#include <string>
#include <random>
#include <chrono>
#include <iomanip>

class Bank {
public:
    void addAccount(const std::string& accountId, double initialBalance) {
        std::unique_lock<std::shared_mutex> lock(accountsMutex_);
        accounts_[accountId] = initialBalance;
    }

    bool deposit(const std::string& accountId, double amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(accountsMutex_);
        auto it = accounts_.find(accountId);
        if (it == accounts_.end()) return false;
        it->second += amount;
        return true;
    }

    bool withdraw(const std::string& accountId, double amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(accountsMutex_);
        auto it = accounts_.find(accountId);
        if (it == accounts_.end()) return false;
        if (it->second < amount) return false;
        it->second -= amount;
        return true;
    }

    bool transfer(const std::string& fromId, const std::string& toId, double amount) {
        if (amount < 0 || fromId == toId) return false;
        std::unique_lock<std::shared_mutex> lock(accountsMutex_);
        auto fromIt = accounts_.find(fromId);
        auto toIt = accounts_.find(toId);
        if (fromIt == accounts_.end() || toIt == accounts_.end()) return false;
        if (fromIt->second < amount) return false;
        fromIt->second -= amount;
        toIt->second += amount;
        return true;
    }

    bool getBalance(const std::string& accountId, double& balance) const {
        std::shared_lock<std::shared_mutex> lock(accountsMutex_);
        auto it = accounts_.find(accountId);
        if (it == accounts_.end()) return false;
        balance = it->second;
        return true;
    }

    void printAllAccounts() const {
        std::shared_lock<std::shared_mutex> lock(accountsMutex_);
        std::cout << "\nFinal account balances:\n";
        for (const auto& [id, balance] : accounts_) {
            std::cout << "  " << id << ": $" << std::fixed << std::setprecision(2) << balance << '\n';
        }
    }

private:
    mutable std::shared_mutex accountsMutex_;
    std::unordered_map<std::string, double> accounts_;
};

void transactionWorker(Bank& bank, const std::vector<std::string>& accountIds, int workerId, int operations) {
    std::mt19937 rng(static_cast<unsigned int>(
        std::chrono::steady_clock::now().time_since_epoch().count() + workerId));
    std::uniform_int_distribution<int> accountDist(0, static_cast<int>(accountIds.size()) - 1);
    std::uniform_real_distribution<double> amountDist(1.0, 500.0);
    std::uniform_int_distribution<int> opDist(0, 3);

    for (int i = 0; i < operations; ++i) {
        int op = opDist(rng);
        std::string acc1 = accountIds[accountDist(rng)];
        std::string acc2 = accountIds[accountDist(rng)];
        double amount = amountDist(rng);

        switch (op) {
            case 0:
                bank.deposit(acc1, amount);
                break;
            case 1:
                bank.withdraw(acc1, amount);
                break;
            case 2:
                bank.transfer(acc1, acc2, amount);
                break;
            case 3: {
                double balance = 0.0;
                bank.getBalance(acc1, balance);
                break;
            }
        }
    }
}

int main() {
    Bank bank;

    bank.addAccount("A1001", 5000.00);
    bank.addAccount("A1002", 3000.00);
    bank.addAccount("A1003", 7000.00);
    bank.addAccount("A1004", 2500.00);
    bank.addAccount("A1005", 9000.00);

    std::vector<std::string> accountIds = {"A1001", "A1002", "A1003", "A1004", "A1005"};

    const int threadCount = 8;
    const int operationsPerThread = 10000;

    std::vector<std::thread> threads;
    threads.reserve(threadCount);

    for (int i = 0; i < threadCount; ++i) {
        threads.emplace_back(transactionWorker, std::ref(bank), std::cref(accountIds), i, operationsPerThread);
    }

    for (auto& t : threads) {
        t.join();
    }

    bank.printAllAccounts();

    return 0;
}