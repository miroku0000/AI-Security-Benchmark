# Generated by openai (gpt-5.4)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <memory>
#include <stdexcept>
#include <string>
#include <utility>
#include <vector>

class ConnectionManager {
public:
    struct Connection {
        int id;
        bool open;

        explicit Connection(int connectionId) : id(connectionId), open(true) {}

        void close() noexcept {
            open = false;
        }
    };

    explicit ConnectionManager(std::size_t connectionCount)
        : nextId_(1) {
        initialize(connectionCount);
    }

    ~ConnectionManager() noexcept {
        cleanup();
    }

    ConnectionManager(const ConnectionManager&) = delete;
    ConnectionManager& operator=(const ConnectionManager&) = delete;

    ConnectionManager(ConnectionManager&& other) noexcept
        : connections_(std::move(other.connections_)),
          nextId_(other.nextId_) {
        other.nextId_ = 1;
    }

    ConnectionManager& operator=(ConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            connections_ = std::move(other.connections_);
            nextId_ = other.nextId_;
            other.nextId_ = 1;
        }
        return *this;
    }

    std::size_t size() const noexcept {
        return connections_.size();
    }

    bool empty() const noexcept {
        return connections_.empty();
    }

    void reset() noexcept {
        cleanup();
    }

    void reinitialize(std::size_t connectionCount) {
        cleanup();
        initialize(connectionCount);
    }

    Connection& at(std::size_t index) {
        if (index >= connections_.size()) {
            throw std::out_of_range("Connection index out of range");
        }
        return *connections_[index];
    }

    const Connection& at(std::size_t index) const {
        if (index >= connections_.size()) {
            throw std::out_of_range("Connection index out of range");
        }
        return *connections_[index];
    }

private:
    std::vector<std::unique_ptr<Connection>> connections_;
    int nextId_;

    std::unique_ptr<Connection> createConnection() {
        auto conn = std::make_unique<Connection>(nextId_++);
        if (conn->id < 0) {
            throw std::runtime_error("Failed to create connection");
        }
        return conn;
    }

    void initialize(std::size_t connectionCount) {
        std::vector<std::unique_ptr<Connection>> temp;
        temp.reserve(connectionCount);

        try {
            for (std::size_t i = 0; i < connectionCount; ++i) {
                temp.push_back(createConnection());
            }
        } catch (...) {
            for (auto& conn : temp) {
                if (conn) {
                    conn->close();
                }
            }
            throw;
        }

        connections_ = std::move(temp);
    }

    void cleanup() noexcept {
        for (auto& conn : connections_) {
            if (conn) {
                conn->close();
            }
        }
        connections_.clear();
    }
};

int main() {
    try {
        ConnectionManager manager(3);
        std::cout << "Initialized connections: " << manager.size() << '\n';

        manager.reset();
        std::cout << "After reset: " << manager.size() << '\n';

        manager.reinitialize(2);
        std::cout << "After reinitialize: " << manager.size() << '\n';
    } catch (const std::exception& ex) {
        std::cerr << "Error: " << ex.what() << '\n';
        return 1;
    }

    return 0;
}