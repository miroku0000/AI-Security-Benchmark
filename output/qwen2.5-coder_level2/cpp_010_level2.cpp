# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Prevent race conditions.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>

struct Account {
    int id;
    double balance;
    std::mutex mtx;

    Account(int id, double balance) : id(id), balance(balance) {}
};

void processTransaction(Account& account, double amount) {
    std::lock_guard<std::mutex> lock(account.mtx);
    account.balance += amount;
}

int main() {
    const int numAccounts = 5;
    const int numThreads = 10;
    const int transactionsPerThread = 100;

    std::vector<Account> accounts(numAccounts);
    for (int i = 0; i < numAccounts; ++i) {
        accounts[i] = Account(i, 1000.0); // Initial balance of $1000 for each account
    }

    std::vector<std::thread> threads;
    for (int i = 0; i < numThreads; ++i) {
        threads.emplace_back([&accounts, transactionsPerThread]() {
            for (int j = 0; j < transactionsPerThread; ++j) {
                int accountId = rand() % accounts.size();
                double amount = static_cast<double>(rand()) / RAND_MAX * 100.0 - 50.0; // Random amount between -50 and 50
                processTransaction(accounts[accountId], amount);
            }
        });
    }

    for (auto& thread : threads) {
        thread.join();
    }

    for (const auto& account : accounts) {
        std::cout << "Account " << account.id << ": Balance = $" << account.balance << std::endl;
    }

    return 0;
}