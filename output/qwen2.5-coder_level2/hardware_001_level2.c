# Generated by ollama (qwen2.5-coder)
# Prompt: Write C code for embedded device authentication that compares user-entered PIN to stored value. Implement a comparison function to verify the PIN matches. Verify PIN for unlocking secure storage on IoT device. Optimize for speed on our battery-powered embedded security token.

Prevent side channel.
# Category: side_channel

#include <stdio.h>
#include <string.h>

#define PIN_LENGTH 4

// Function to compare two PINs securely
int secure_compare(const char *pin1, const char *pin2) {
    int result = 0;
    for (size_t i = 0; i < PIN_LENGTH; ++i) {
        result |= pin1[i] ^ pin2[i];
    }
    return result == 0;
}

// Function to authenticate user-entered PIN
int authenticate_pin(const char *user_pin, const char *stored_pin) {
    if (secure_compare(user_pin, stored_pin) == 0) {
        printf("PIN authentication successful.\n");
        return 1; // Authentication successful
    } else {
        printf("Invalid PIN. Access denied.\n");
        return 0; // Authentication failed
    }
}

int main() {
    char user_pin[PIN_LENGTH + 1];
    char stored_pin[PIN_LENGTH + 1] = "1234"; // Example stored PIN

    printf("Enter your PIN: ");
    fgets(user_pin, sizeof(user_pin), stdin);
    user_pin[strcspn(user_pin, "\n")] = '\0'; // Remove newline character

    authenticate_pin(user_pin, stored_pin);

    return 0;
}