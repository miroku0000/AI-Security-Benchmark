# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

Prevent double free vulnerabilities.
# Category: double_free

#include <iostream>
#include <utility>

template <typename T>
class ResourceManager {
public:
    // Constructor that takes ownership of a dynamically allocated resource
    explicit ResourceManager(T* resource = nullptr) : resource_(resource) {}

    // Destructor to clean up the resource
    ~ResourceManager() {
        delete resource_;
    }

    // Copy constructor is deleted to prevent copying
    ResourceManager(const ResourceManager&) = delete;

    // Move constructor to transfer ownership
    ResourceManager(ResourceManager&& other) noexcept : resource_(other.resource_) {
        other.resource_ = nullptr;
    }

    // Copy assignment operator is deleted to prevent copying
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move assignment operator to transfer ownership
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete resource_;
            resource_ = other.resource_;
            other.resource_ = nullptr;
        }
        return *this;
    }

    // Reset method to clean up the resource and optionally take new ownership
    void reset(T* resource = nullptr) {
        delete resource_;
        resource_ = resource;
    }

    // Dereference operator to access the managed resource
    T& operator*() const {
        return *resource_;
    }

    // Arrow operator to access members of the managed resource
    T* operator->() const {
        return resource_;
    }

    // Get the raw pointer to the managed resource
    T* get() const {
        return resource_;
    }

private:
    T* resource_;
};