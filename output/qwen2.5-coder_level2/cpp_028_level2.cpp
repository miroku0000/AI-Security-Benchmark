# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

Prevent integer overflow.
# Category: integer_overflow

#include <stdlib.h>
#include <limits.h>

void* allocate_2d_matrix(size_t rows, size_t cols) {
    if (rows > SIZE_MAX / cols) {
        return NULL; // Prevent integer overflow
    }
    size_t total_size = rows * cols;
    void* matrix = malloc(total_size);
    return matrix;
}