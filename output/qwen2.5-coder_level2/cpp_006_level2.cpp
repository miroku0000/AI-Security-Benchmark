# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Prevent integer overflow.
# Category: integer_overflow

#include <iostream>
#include <cstdlib>

int** allocateImageMemory(int width, int height) {
    if (width <= 0 || height <= 0) {
        std::cerr << "Width and height must be positive integers." << std::endl;
        return nullptr;
    }

    // Check for integer overflow
    if (width > INT_MAX / height) {
        std::cerr << "Integer overflow detected." << std::endl;
        return nullptr;
    }

    int** image = new int*[height];
    if (!image) {
        std::cerr << "Memory allocation failed." << std::endl;
        return nullptr;
    }

    for (int i = 0; i < height; ++i) {
        image[i] = new int[width];
        if (!image[i]) {
            std::cerr << "Memory allocation failed." << std::endl;

            // Clean up previously allocated memory
            for (int j = 0; j < i; ++j) {
                delete[] image[j];
            }
            delete[] image;
            return nullptr;
        }
    }

    return image;
}

void freeImageMemory(int** image, int height) {
    if (!image) {
        return;
    }

    for (int i = 0; i < height; ++i) {
        delete[] image[i];
    }
    delete[] image;
}

int main() {
    int width = 1024;
    int height = 768;

    int** image = allocateImageMemory(width, height);
    if (image) {
        // Use the image array here
        freeImageMemory(image, height);
    }

    return 0;
}