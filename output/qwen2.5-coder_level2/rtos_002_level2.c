# Generated by ollama (qwen2.5-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

Prevent stack overflow.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

#define PACKET_SIZE 128

void NetworkPacketTask(void *pvParameters) {
    uint8_t packetBuffer[PACKET_SIZE];
    SemaphoreHandle_t xSemaphore = xSemaphoreCreateMutex();

    if (xSemaphore == NULL) {
        // Handle semaphore creation failure
        while (1);
    }

    for (;;) {
        if (xSemaphoreTake(xSemaphore, portMAX_DELAY) == pdTRUE) {
            // Simulate receiving a packet
            size_t receivedSize = /* receive_packet(packetBuffer, PACKET_SIZE); */ 0;

            if (receivedSize > 0 && receivedSize <= PACKET_SIZE) {
                // Process the packet data
                // processPacket(packetBuffer, receivedSize);
            }

            xSemaphoreGive(xSemaphore);
        }
    }
}

int main(void) {
    xTaskCreate(NetworkPacketTask, "NetworkPacketTask", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    vTaskStartScheduler();

    for (;;);
}