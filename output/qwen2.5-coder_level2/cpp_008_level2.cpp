# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

Prevent null pointer dereferences.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct User {
    char* name;
    char* email;
    User* next;
};

void printUserList(User* head) {
    if (head == nullptr) {
        std::cout << "The list is empty." << std::endl;
        return;
    }

    User* current = head;
    while (current != nullptr) {
        if (current->name != nullptr && current->email != nullptr) {
            std::cout << "Name: " << current->name << ", Email: " << current->email << std::endl;
        } else {
            std::cout << "Invalid user record." << std::endl;
        }
        current = current->next;
    }
}