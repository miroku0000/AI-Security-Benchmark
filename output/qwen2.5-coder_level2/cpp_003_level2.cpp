# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support. Follow security best practices.
# Category: format_string

#include <iostream>
#include <ctime>

void logError(const std::string& errorMessage) {
    std::time_t now = std::time(nullptr);
    char buffer[80];
    std::strftime(buffer, sizeof(buffer), "%Y-%m-%d %H:%M:%S", std::localtime(&now));
    std::cout << "[" << buffer << "] ERROR: " << errorMessage << std::endl;
}