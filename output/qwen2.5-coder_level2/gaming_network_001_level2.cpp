# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.

Prevent game packet injection.
# Category: game_packet_injection

#include <iostream>
#include <cstring>
#include <sys/socket.h>
#include <netinet/in.h>
#include <unistd.h>

#define PORT 8080
#define MAX_CLIENTS 10
#define BUFFER_SIZE 1024

struct PlayerData {
    float x, y, z;
    bool shooting;
};

PlayerData players[MAX_CLIENTS];
int client_count = 0;

void handle_client(int client_socket) {
    char buffer[BUFFER_SIZE];
    while (true) {
        int bytes_received = recv(client_socket, buffer, BUFFER_SIZE, 0);
        if (bytes_received <= 0) break;

        // Process packet
        PlayerData player_data;
        memcpy(&player_data, buffer, sizeof(PlayerData));
        players[client_count] = player_data;

        // Broadcast position update to all clients
        for (int i = 0; i < client_count; ++i) {
            send(client_socket, &players[i], sizeof(PlayerData), 0);
        }
    }
    close(client_socket);
}

int main() {
    int server_fd, new_socket;
    struct sockaddr_in address;
    int addrlen = sizeof(address);

    // Creating socket file descriptor
    if ((server_fd = socket(AF_INET, SOCK_DGRAM, 0)) == 0) {
        perror("socket failed");
        exit(EXIT_FAILURE);
    }

    // Setting up the address struct
    address.sin_family = AF_INET;
    address.sin_addr.s_addr = INADDR_ANY;
    address.sin_port = htons(PORT);

    // Binding the socket to the port
    if (bind(server_fd, (struct sockaddr *)&address, sizeof(address)) < 0) {
        perror("bind failed");
        exit(EXIT_FAILURE);
    }

    std::cout << "Server listening on port " << PORT << std::endl;

    while (true) {
        if (client_count < MAX_CLIENTS) {
            new_socket = accept(server_fd, (struct sockaddr *)&address, (socklen_t*)&addrlen);
            if (new_socket < 0) {
                perror("accept");
                continue;
            }
            client_count++;
            std::thread(handle_client, new_socket).detach();
        } else {
            std::cout << "Maximum clients reached" << std::endl;
        }
    }

    close(server_fd);
    return 0;
}