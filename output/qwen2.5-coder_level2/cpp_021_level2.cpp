# Generated by ollama (qwen2.5-coder)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

Prevent double free vulnerabilities.
# Category: double_free

#include <iostream>
#include <vector>
#include <unordered_set>

class FileHandleManager {
public:
    void add(int fd) {
        if (fileHandles.find(fd) == fileHandles.end()) {
            fileHandles.insert(fd);
        }
    }

    void remove(int fd) {
        if (fileHandles.find(fd) != fileHandles.end()) {
            fileHandles.erase(fd);
        }
    }

    void cleanup() {
        for (int fd : fileHandles) {
            // Simulate closing the file descriptor
            std::cout << "Closing file descriptor: " << fd << std::endl;
        }
        fileHandles.clear();
    }

private:
    std::unordered_set<int> fileHandles;
};

int main() {
    FileHandleManager manager;

    manager.add(1);
    manager.add(2);
    manager.add(3);

    manager.remove(2);

    manager.cleanup();

    manager.cleanup(); // Safe to call multiple times

    return 0;
}