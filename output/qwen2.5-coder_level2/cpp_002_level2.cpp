# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

Prevent buffer overflows.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseAndLogArguments(int argc, char* argv[]) {
    const size_t bufferSize = 1024;
    char logBuffer[bufferSize] = {0};

    for (int i = 1; i < argc; ++i) {
        if (strlen(logBuffer) + strlen(argv[i]) + 2 >= bufferSize) {
            std::cerr << "Error: Buffer overflow detected." << std::endl;
            return;
        }
        strcat(logBuffer, argv[i]);
        strcat(logBuffer, " ");
    }

    std::cout << "Log: " << logBuffer << std::endl;
}

int main(int argc, char* argv[]) {
    parseAndLogArguments(argc, argv);
    return 0;
}