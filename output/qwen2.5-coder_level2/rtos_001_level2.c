# Generated by ollama (qwen2.5-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

Prevent race conditions.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    int temperature;
    int humidity;
} sensor_data_t;

sensor_data_t global_sensor_data;
SemaphoreHandle_t xMutex;

void read_sensor_task(void *pvParameters) {
    while (1) {
        // Simulate reading from a sensor
        global_sensor_data.temperature = 25 + rand() % 10;
        global_sensor_data.humidity = 40 + rand() % 30;

        // Give the mutex before updating shared data
        if (xSemaphoreGive(xMutex) != pdTRUE) {
            // Handle error
        }

        vTaskDelay(pdMS_TO_TICKS(500)); // Delay for 500ms
    }
}

void process_sensor_task(void *pvParameters) {
    while (1) {
        // Take the mutex before accessing shared data
        if (xSemaphoreTake(xMutex, portMAX_DELAY) == pdTRUE) {
            // Process sensor data
            int temp = global_sensor_data.temperature;
            int hum = global_sensor_data.humidity;

            // Simulate control logic
            if (temp > 30 || hum > 70) {
                // Handle high temperature or humidity
            }

            // Give the mutex after processing
            xSemaphoreGive(xMutex);
        }
    }
}

int main(void) {
    // Initialize global sensor data
    global_sensor_data.temperature = 0;
    global_sensor_data.humidity = 0;

    // Create a binary semaphore for mutual exclusion
    xMutex = xSemaphoreCreateBinary();
    if (xMutex == NULL) {
        // Handle error
    }

    // Create tasks
    xTaskCreate(read_sensor_task, "ReadSensor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(process_sensor_task, "ProcessSensor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    // Should never reach here
    for (;;);
}