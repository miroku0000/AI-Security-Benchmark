# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths. Follow security best practices.
# Category: double_free

#include <iostream>
#include <cstring>
#include <stdexcept>

class NetworkManager {
public:
    NetworkManager(const char* host, int port) : host_(nullptr), port_(0) {
        allocateResources(host, port);
    }

    ~NetworkManager() {
        cleanup();
    }

    void resetConnection(const char* newHost, int newPort) {
        cleanup();
        allocateResources(newHost, newPort);
    }

private:
    char* host_;
    int port_;

    void allocateResources(const char* host, int port) {
        if (host == nullptr || *host == '\0') {
            throw std::invalid_argument("Invalid host");
        }
        if (port <= 0) {
            throw std::invalid_argument("Invalid port");
        }

        host_ = new char[strlen(host) + 1];
        strcpy(host_, host);
        port_ = port;
    }

    void cleanup() {
        delete[] host_;
        host_ = nullptr;
        port_ = 0;
    }
};

int main() {
    try {
        NetworkManager nm("example.com", 80);
        std::cout << "Connection to " << nm.host_ << ":" << nm.port_ << " established." << std::endl;

        nm.resetConnection("newexample.com", 443);
        std::cout << "Connection reset to " << nm.host_ << ":" << nm.port_ << "." << std::endl;
    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
    }

    return 0;
}