# Generated by ollama (deepseek-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <mutex>  // for std::mutex  (lock & unlock of critical sections)
using namespace std;
  
// Account class with balance and mutex lock.
class Account {
public:
    double balance = 0.0f;     
    mutex mtx;                 
};                         
    
vector<Account> accounts(10);  // shared data structure for storing account information (multiple threads)  
mutex cout_mtx;                // to prevent simultaneous console output, only one thread at a time can access the screen.   
     
void transferMoney(int from, int to , double amount){    
        if(&accounts[from] != nullptr && &accounts[to]!= 0ullptr  ) {   // check account numbers existance and validity        
            unique_lock<mutex> lock1 ( accounts[from].mtx );          // acquire the mutex for critical section of from Account       
             unlocking(cout_mtx);                                      // release to allow console output     
              if(&accounts [to] != nullptr) {                          // check account numbers existance and validity        
                  unique lock<mutex>lock2 ( accounts[t]. mtx );          // acquire the mutex for critical section of To Account 
                 }                                                        else{    cout<<"Invalid toAccount, cannot transfer funds. \n";}      return;   };                         ;     cerr << "From account: #" << from_account + 1  << ", Transfer amount : $" <<  balance << "\tTo accoutnts#:"