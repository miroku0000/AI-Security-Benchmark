# Generated by ollama (deepseek-coder)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <stdlib.h>

// Function to dynamically create a multidimensional array in C based on user-specified dimensions and size of each element (in this case, int) 
int** allocateArray(const int width, const int height){   // Define the type as 'void*' if you need pointers for accessibility. It depends upon your program requirements whether void or pointer is more suitable in C language to use here   
     return (int**)malloc(height * sizeof(int*));        // Allocate memory dynamically, height times size of one int pointer and then each row's address 
}