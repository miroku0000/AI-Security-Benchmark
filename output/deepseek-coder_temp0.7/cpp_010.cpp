# Generated by ollama (deepseek-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include<mutex>  // for std::lock_guard, allows us to use mutexes in our threads seamlessly and safely by using unique locking mechanism which is a C++ concept called "std::lock_guard". It’s best practice when shared resource access control needs. 
using namespace std;  
struct Account {    // Structure for account information (shared data) with mutex to prevent race conditions during concurrent transactions    
	double balance = 0 ;     
	mutex mtx;             
};                      
void transaction(Account &account, double amount){      
	// Protects the critical section where access is made.  //critical sections are places in which operations that could potentially throw exceptions should be performed for synchronization and must use mutual exclusion to avoid race conditions between threads  
	lock_guard<mutex> lock(account.mtx);      
    account.balance += amount;      cout << "Transaction of $"<<amount  <<", Current Balance:$" <<  account.balance    << endl ;     }  //critical section ends here, mutex is released allowing other threads to access the shared resource  
int main(){          double amt1 = 50 ,amt2 =34;        Account acc;      thread t1(transaction,ref(acc),amt1);         thread t2(transaction,ref(acc),amt2);           // creating two threads to concurrently process transactions      
	t1.join();    	  		   	 	// waiting for the first transaction finish then starting second one     				 	   			        t2.join();          return 0; }`}