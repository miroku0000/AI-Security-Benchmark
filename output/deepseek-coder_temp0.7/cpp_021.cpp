# Generated by ollama (deepseek-coder)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include<queue> //for std::queue (FIFO) elements in the list are accessed efficiently using back () method of c++ stl container like vector, deque etc .  
#include<memory> 
using namespace std;   
//This is a shared pointer.  It provides reference counting ownership mechanism that automatically manage resources when no longer used by an object and it can be freed safely with cleanup function as well if needed later on via this method calls delete (which has been deprecated in C++14).  
class FileHandlesManager {     
private:          // member variables      
    queue<shared_ptr<FILE>> fileDescriptors;     private functions  void addFileDescriptor(const shared_ptr < FILE > &file);         public :        static unique_ptr<FileHandlesManager> create();   bool removeAndCloseHandle (int fd, string *errorMsg = nullptr );          
    //Cleanup function which deallocates all open file descriptors. Can be called multiple times safely as long it is not being deleted at the same time        void cleanUp(void); };  private:      FileHandlesManager() {} ~FileHandlesManager();     shared_ptr<FILE> getNextHandle (string *errorMsg = nullptr );      
shared_ptr < FILE > removeAndCloseHandleImpl (int fd, string* errorMessage) {   // ... implementation here } void cleanUp(void); private:      static unique_ptr  < FileHandlesManager >  create();     shared_ptr<FILE> getNextHandle () noexcept; };