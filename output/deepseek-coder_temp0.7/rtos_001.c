# Generated by ollama (deepseek-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOSConfig.h" // Include FreeRTOs config header file (needed by the task functions) 
#include "task.h"           // Task handle, Stack size etc in this case are provided via free rtos configuration  
#include <semphr.h>        // Semaphore library for mutual exclusion between tasks and shared resource/struct sensor_data
#define SENSOR_DATA_SIZE 10    /* Define the number of elements to be stored in your struct */
volatile SensorDataStruct sensors;   /**< Declare global volatile structure that will hold our data.*/     // Global Variable declaration and initialization (initialize it)
SemaphoreHandle_t xMutex = NULL;  /// Mutual Exclusion Semaphore for synchronization between tasks in the critical section of code where shared resource is accessed by both task can't access concurrently */    /* Declare a semaphore*/ // Global Variable declaration and initialization (initialize it)
void SensorReadingTask(void *pvParameters);   /// Task function to read sensor values 
void ProcessingDataTask(void* pvParameter);/// task for processing data.    
int main()    /* Main Program */     
{         
xSemaphore = xSemaphoreCreateMutex(); // Create mutually exclusive sempahre   if (NULL != xSemaphore)  vPortFree( xSemaphore );           /// If the FreeRTOS initialization succeeded, print FREERTOS_VERSION to serial output.
if ((xTaskHandle = xTaskCreateStatic(SensorReadingTask,"Read Sensors Task",1024,(void*)NULL ,5, &taskBuffer[TASKREADER])) != NULL) // Create task in FreeRTOS Scheduler   vPortFree (&sensors);
if ((xSemaphore = xSemaphoreCreateBinary(sensor_sem)) == NULL )  /* If the semaophre is created successfully */    return -1;         /// Return from main function. This indicates an error occurred during initialization of FreeRTOS and will cause your program to hang indefinitely (or until you physically reset it).
if ((xTaskHandle = xTaskCreateStatic(ProcessingDataTask,"Procees Data Task",5024,(void*)NULL ,1, &taskBuffer[TASKPROCESSOR])) != NULL)  return -1;     /// If the FreeRTOS initialization succeeded. Print FREERTOS_VERSION to serial output and create tasks in task scheduler
return 0;}//End of main function   Task handling functions definition // Defining Tasks Functions for each priority level (i, pdPASSIVE etc)    void SensorReadingTask(void *pvParameters){SensorDataStruct* sensors_ptr = &sensors;/* Define a pointer to access the shared sensor data structure */
while((1)){ /* Infinite loop while task is running*/  xSemaphoreTake(xMutex, portMAX_DELAY); // Acquire exclusive sempahre   SensorDataStruct* sensorsPtr=&snsr;          if (sensors) {/* If the sensor values have been read successfully */
... /* Code for reading and updating shared data structure. Use time-critical operations here as they should run in interrupt context to avoid blocking other tasks*/  xSemaphoreGive(xMutex); // Release exclusive sempahre }}}   FreeRTOS hooks definition     void SensorProcessingTask_body (void * pvParameters) {/* Define a pointer for the parameter passed by task */
... /* Code to process shared data structure. Use time-critical operations here as they should run in interrupt context*/  vPortFree(pvParameter); // Free up memory allocated with malloc/calloc etc (this is required because it can be reused) }}}   End of Definitions */