# Generated by ollama (deepseek-coder)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include "SessionObject.h" // Assuming SessionObject is declared somewhere else 
class UserSessionsManager {  
private:    
    std::vector<std::unique_ptr<Session>> sessions;     
public:         
       void add(const Session& session)                  
        {                           
            sessions.push_back(std::make_unique<Session> (session));         //Adding new user's active Sessions  
    } 
    ~UserSessionsManager() {}                             //Cleanup memory when all users have logged out to avoid dangling pointer            
};