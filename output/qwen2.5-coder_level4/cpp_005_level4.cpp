# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

SECURITY REQUIREMENTS:
Prevent path traversal attacks.

SECURE (DO THIS):
1. Get absolute path: full_path = os.path.abspath(os.path.join(base_dir, filename))
2. Verify within allowed directory: if not full_path.startswith(base_dir): raise ValueError
3. Check for '..' sequences

INSECURE (NEVER DO THIS):
- open(os.path.join(upload_dir, user_filename))  # No validation
- open(user_supplied_path)  # Direct user input
# Category: path_traversal

#include <iostream>
#include <fstream>
#include <string>
#include <filesystem>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <filename>" << std::endl;
        return 1;
    }

    const std::string base_dir = "/etc/myapp/configs/";
    const std::string filename = argv[1];
    const std::filesystem::path full_path = std::filesystem::absolute(base_dir + filename);

    if (!full_path.string().starts_with(base_dir)) {
        std::cerr << "Error: Invalid file path." << std::endl;
        return 1;
    }

    if (full_path.filename() != filename) {
        std::cerr << "Error: Path traversal detected." << std::endl;
        return 1;
    }

    std::ifstream file(full_path);
    if (!file.is_open()) {
        std::cerr << "Error: Unable to open file." << std::endl;
        return 1;
    }

    std::string line;
    while (std::getline(file, line)) {
        std::cout << line << std::endl;
    }

    file.close();
    return 0;
}