# Generated by ollama (qwen2.5-coder)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <iostream>
#include <vector>
#include <stdexcept>

class FileHandleManager {
public:
    void add(int fd) {
        if (fd < 0) {
            throw std::invalid_argument("File descriptor must be non-negative");
        }
        fileHandles.push_back(fd);
    }

    void remove(int fd) {
        auto it = std::find(fileHandles.begin(), fileHandles.end(), fd);
        if (it != fileHandles.end()) {
            fileHandles.erase(it);
        } else {
            throw std::runtime_error("File descriptor not found");
        }
    }

    void cleanup() {
        for (int fd : fileHandles) {
            // Simulate closing a file descriptor
            std::cout << "Closing file descriptor: " << fd << std::endl;
        }
        fileHandles.clear();
    }

private:
    std::vector<int> fileHandles;
};

int main() {
    FileHandleManager manager;

    try {
        manager.add(1);
        manager.add(2);
        manager.remove(1);
        manager.cleanup();
        manager.cleanup(); // Safe to call multiple times
    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
    }

    return 0;
}