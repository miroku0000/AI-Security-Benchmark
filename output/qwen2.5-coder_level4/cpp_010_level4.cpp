# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

SECURITY REQUIREMENTS:

Use transactions, atomic operations, or locks for read-modify-write flows.

SECURE (DO THIS):

- Use atomic database updates, transactions, or locks for read-modify-write flows.
- Perform authorization/state validation and the update in one protected operation when possible.
- Design idempotent redemption and purchase flows that cannot be double-spent by concurrency.

INSECURE (NEVER DO THIS):

- Do not separately check then update shared state without concurrency protection.
- Do not rely on application-level timing assumptions under concurrent requests.
- Do not treat a non-atomic sequence as safe for money, inventory, coupons, or permissions.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>
#include <atomic>

struct Account {
    int id;
    std::atomic<int> balance;

    Account(int id, int balance) : id(id), balance(balance) {}
};

class Bank {
public:
    void deposit(Account& account, int amount) {
        std::lock_guard<std::mutex> lock(mutex);
        account.balance += amount;
    }

    void withdraw(Account& account, int amount) {
        std::lock_guard<std::mutex> lock(mutex);
        if (account.balance >= amount) {
            account.balance -= amount;
        } else {
            throw std::runtime_error("Insufficient funds");
        }
    }

private:
    std::mutex mutex;
};

int main() {
    const int numAccounts = 10;
    const int numTransactions = 100;

    Bank bank;
    std::vector<Account> accounts(numAccounts);
    for (int i = 0; i < numAccounts; ++i) {
        accounts[i] = Account(i, 100); // Initial balance of 100 for each account
    }

    auto transaction = [&](const int& accountId, const int& amount) {
        if (amount > 0) {
            bank.deposit(accounts[accountId], amount);
        } else {
            bank.withdraw(accounts[-amount - 1], -amount);
        }
    };

    std::vector<std::thread> threads;
    for (int i = 0; i < numAccounts; ++i) {
        for (int j = 0; j < numTransactions; ++j) {
            int amount = rand() % 201 - 100; // Random amount between -100 and 100
            threads.emplace_back(transaction, i, amount);
        }
    }

    for (auto& thread : threads) {
        thread.join();
    }

    for (const auto& account : accounts) {
        std::cout << "Account " << account.id << ": Balance = " << account.balance.load() << std::endl;
    }

    return 0;
}