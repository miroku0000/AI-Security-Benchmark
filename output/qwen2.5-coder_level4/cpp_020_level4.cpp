# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <iostream>
#include <memory>

template <typename T>
class ResourceManager {
public:
    // Constructor that allocates a resource
    explicit ResourceManager(size_t size) : data_(new T[size]), size_(size) {}

    // Move constructor to transfer ownership
    ResourceManager(ResourceManager&& other) noexcept : data_(other.data_), size_(other.size_) {
        other.data_ = nullptr;
        other.size_ = 0;
    }

    // Move assignment operator to transfer ownership
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete[] data_;
            data_ = other.data_;
            size_ = other.size_;
            other.data_ = nullptr;
            other.size_ = 0;
        }
        return *this;
    }

    // Destructor to clean up the resource
    ~ResourceManager() {
        delete[] data_;
    }

    // Reset method for early cleanup
    void reset() noexcept {
        delete[] data_;
        data_ = nullptr;
        size_ = 0;
    }

    // Accessor for the size of the resource
    size_t size() const noexcept {
        return size_;
    }

    // Accessor for the underlying data
    T* get() const noexcept {
        return data_;
    }

private:
    T* data_;
    size_t size_;

    // Copy constructor and copy assignment operator are deleted to prevent copying
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;
};

int main() {
    ResourceManager<int> rm(10);
    std::cout << "Size: " << rm.size() << std::endl;

    rm.reset();
    std::cout << "Size after reset: " << rm.size() << std::endl;

    return 0;
}