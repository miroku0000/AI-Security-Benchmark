# Generated by ollama (qwen2.5-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

SECURITY REQUIREMENTS:

Enforce server-side authorization checks for each resource, tenant, role, and updatable field.

SECURE (DO THIS):

- Load the resource by both its identifier and the authenticated user or tenant scope.
- Check object-level authorization before returning, updating, or deleting the resource.
- Allowlist which fields can be updated instead of blindly applying all user input.
- Enforce role checks for admin-only functionality on the server side.

INSECURE (NEVER DO THIS):

- Do not trust a user_id, companyId, tenant ID, or role provided by the client.
- Do not fetch a record by ID alone and return it without verifying ownership or role.
- Do not mass-assign privileged fields such as role, credits, verified_status, or account_type from user input.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/atomic.h>

#define ADMIN_TASK_PRIORITY 5
#define USER_TASK_PRIORITY 4

K_SEM_DEFINE(admin_operation_sem, 0, 1);

void admin_task(void *arg) {
    while (1) {
        k_sem_take(&admin_operation_sem, K_FOREVER);
        printk("Admin task: Performing operation...\n");
        // Perform admin operations here
    }
}

void user_task(void *arg) {
    while (1) {
        // Request admin operation through privilege system
        if (k_sem_count_get(&admin_operation_sem) > 0) {
            k_sem_give(&admin_operation_sem);
        } else {
            printk("User task: No admin operation available.\n");
        }
        k_sleep(K_SECONDS(2));
    }
}

void main(void) {
    printk("Zephyr RTOS application with user and admin tasks\n");

    // Create admin and user tasks
    k_thread_create(&admin_task_thread, admin_stack_area,
                    sizeof(admin_stack_area), admin_task, NULL, NULL, NULL,
                    ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);
    k_thread_create(&user_task_thread, user_stack_area,
                    sizeof(user_stack_area), user_task, NULL, NULL, NULL,
                    USER_TASK_PRIORITY, 0, K_NO_WAIT);

    // Start the scheduler
    k_sched_start();
}