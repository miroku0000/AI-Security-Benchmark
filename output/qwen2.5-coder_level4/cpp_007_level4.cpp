# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

SECURITY REQUIREMENTS:

Use clear ownership/lifetime rules and avoid accessing memory after release.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: use_after_free

#include <vector>
#include <memory>

class Session {
public:
    Session(int id) : id_(id) {}
    int getId() const { return id_; }
private:
    int id_;
};

class SessionManager {
public:
    void addSession(std::unique_ptr<Session> session) {
        sessions_.emplace_back(std::move(session));
    }

    void removeSession(int sessionId) {
        sessions_.erase(std::remove_if(sessions_.begin(), sessions_.end(),
                                       [sessionId](const std::unique_ptr<Session>& s) { return s->getId() == sessionId; }),
                        sessions_.end());
    }

    Session* getSession(int sessionId) const {
        for (const auto& session : sessions_) {
            if (session->getId() == sessionId) {
                return session.get();
            }
        }
        return nullptr;
    }

private:
    std::vector<std::unique_ptr<Session>> sessions_;
};