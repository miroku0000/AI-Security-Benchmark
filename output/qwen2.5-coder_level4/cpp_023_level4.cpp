# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

SECURITY REQUIREMENTS:

Validate pointers/references before use and preserve clear ownership/initialization rules.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: null_pointer

#include <iostream>
#include <cstring>
#include <cstdlib>

struct Config {
    int port;
    char* host;
};

Config* parseArgs(int argc, char** argv) {
    if (argc != 3) {
        std::cerr << "Usage: " << argv[0] << " <host> <port>" << std::endl;
        return nullptr;
    }

    Config* config = new Config();
    config->host = new char[strlen(argv[1]) + 1];
    strcpy(config->host, argv[1]);

    if (sscanf(argv[2], "%d", &config->port) != 1 || config->port <= 0) {
        std::cerr << "Invalid port number" << std::endl;
        delete[] config->host;
        delete config;
        return nullptr;
    }

    return config;
}

int main(int argc, char** argv) {
    Config* config = parseArgs(argc, argv);
    if (config == nullptr) {
        return 1;
    }

    // Initialize application using the parsed configuration
    std::cout << "Initializing application with host: " << config->host << " and port: " << config->port << std::endl;

    // Clean up resources
    delete[] config->host;
    delete config;

    return 0;
}