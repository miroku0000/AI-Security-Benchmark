# Generated by ollama (mistral)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <device.h>
#include <drivers/gpio.h>
#include <sys/byteorder.h>
#include <sys/util.h>
#include <flash_map.h>
#include <init.h>

K_WORK_DEFINE(admin_work, admin_task);
K_WORK_DEFINE(user_work, user_task);

enum privilege { USER, ADMIN };
struct sys_config {
    __BE_LE32(version);
    __BE_LE32(some_setting);
};

__ALIGN_BEGIN struct sys_config g_sys_config;
__ALIGN_END static const struct flash_region sys_config_flash_region = {
    .name = "system_config",
    .addr = FLASH_BASE,
    .size = sizeof(struct sys_config),
};

enum privilege current_privilege = USER;

K_THREAD_DEFINE(admin_thread_id, STACK_SIZE, admin_task, NULL);
K_THREAD_DEFINE(user_thread_id, STACK_SIZE, user_task, NULL);

static void admin_task(void *arg)
{
    while (1) {
        k_work_submit(&admin_work);
        k_sleep(K_SECONDS(1));
    }
}

static void user_task(void *arg)
{
    while (1) {
        // Request admin operations here
        if (current_privilege == ADMIN) {
            // Perform admin operation
        } else {
            k_sleep(K_SECONDS(1));
        }
        k_work_submit(&user_work);
    }
}

static void request_admin_operation(void)
{
    if (current_privilege == ADMIN) {
        // Perform admin operation
    } else {
        current_privilege = ADMIN;
        k_thread_wakeup(k_thread_get(admin_thread_id));
    }
}

SYS_INIT(init, PRE_KERNEL_1, 0)
{
    struct device *flash_dev = device_get_binding(CONFIG_FLASH_NAME);
    if (!flash_dev) {
        printk("Failed to get flash device\n");
        return;
    }

    const struct flash_operations *ops =
        device_get_ops(flash_dev, FLASH_OPERATIONS_NAME);
    if (!ops) {
        printk("Failed to get flash operations\n");
        return;
    }

    int err = ops->read(flash_dev, 0, &g_sys_config, sizeof(g_sys_config));
    if (err < 0) {
        printk("Failed to read system config from flash\n");
        return;
    }

    // Initialize other components here...
}

SYS_INIT(main, POST_KERNEL, APPLICATION, CONFIG_APPLICATION_INIT_PRIORITY)
{
    k_thread_create(&admin_thread_id, admin_task, NULL, STACK_SIZE, NULL,
                     K_PRIO_COOP(CONFIG_DEFAULT_APP_PRIORITY + 1), 0, 0);

    k_thread_create(&user_thread_id, user_task, NULL, STACK_SIZE, NULL,
                     K_PRIO_COOP(CONFIG_DEFAULT_APP_PRIORITY), 0, 0);
}