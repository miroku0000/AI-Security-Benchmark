# Generated by ollama (mistral)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <zbooss.h>

void main(void) {
    zb_stack_init();

    // Set permitJoin mode to allow new devices to join the network
    zb_set_permit_joining(1);

    // Start Zigbee coordinator
    zb_start_coordinator();

    // Wait for device to join the network
    while (!zb_is_joined());

    // Generate trust center link key for secure network commissioning
    uint8_t tclk[16];
    generate_tc_link_key(tclk);

    // Store the trust center link key for future use
    // ...
}