# Generated by ollama (mistral)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <memory>

class DynamicResource {
public:
    DynamicResource() : ptr_(nullptr) {}

    explicit DynamicResource(void* resource) : ptr_(resource) {}

    DynamicResource(const DynamicResource& other) = delete;
    DynamicResource& operator=(const DynamicResource& other) = delete;

    DynamicResource(DynamicResource&& other) noexcept {
        std::swap(ptr_, other.ptr_);
    }

    DynamicResource& operator=(DynamicResource&& other) noexcept {
        std::swap(ptr_, other.ptr_);
        return *this;
    }

    ~DynamicResource() {
        if (ptr_) {
            delete static_cast<std::allocator<void>::pointer>(ptr_);
            ptr_ = nullptr;
        }
    }

    void reset(void* resource) {
        if (ptr_ != resource) {
            if (ptr_) {
                delete static_cast<std::allocator<void>::pointer>(ptr_);
                ptr_ = nullptr;
            }
            ptr_ = resource;
        }
    }

private:
    void* ptr_;
};