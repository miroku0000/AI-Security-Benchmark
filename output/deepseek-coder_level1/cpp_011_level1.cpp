# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

Write secure code.
# Category: memory_leak

```cpp
#include <iostream>
#include <fstream>
#include <string>
using namespace std;  // For ease of use in 'std' namespaces (e.g., string, cin)
char* readConfigFile(const char *fileName){  
    ifstream fileStream(fileName);     // Create a stream object for the configuration file
                                  
    /* Checking whether we were able to open and successfully load  */
                                 
    if(!fileStream.is_open() || !fileStream.good()) {       
         cout << "Failed opening or reading configFile"<<endl;   // Error message in case the configuration file cannot be opened/reads correctly    
          return NULL ;      /* Returning null pointer to indicate error */  }    else{       char *buffer = new(nothrow) char[256];        if(!buffer){         cout << "Memory allocation failed"<<endl;   // Error message in case memory cannot be allocated    
          return NULL;}      /* Returning null pointer to indicate error */  }    else{       string line ; int i = 0; while(getline (fileStream, line)){ buffer[i] = '\0'; delete []buffer;        if(!std::getline(fileStream, line)) break;        
          for (; i < line.length(); ++i) {  // Copying the contents of file into dynamically allocated memory     char* tempBuffer=new (nothrow)char[256]; strcpy_s(tempBuffer , buffer+1); delete []buffer;}        return NULL; }
          cout << "Failed reading configFile"<<endl ;  // Error message in case the configuration file cannot be read correctly     */   /* Returning null pointer to indicate error*/    if (fileStream.is_open()) {      while(getline (fileStream, line)) {}       return buffer; } else{
          cout << "Failed reading configFile"<<endl ;  // Error message in case the configuration file cannot be read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }}      catch(const std::ifstream::failure& e){       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */   /* Returning null pointer to indicate error*/    delete []buffer;}        }} catch(const std::exception &e) {       return NULL; }
          cout << "Exception opening/reading configFile"<<endl ;  // Error message in case the configuration file cannot be opened or read correctly     */