arm-none-eabi-gcc -mcpu=cortex-m4 -mthumb -nostdlib -T bootloader.ld bootloader.c -o bootloader.elf