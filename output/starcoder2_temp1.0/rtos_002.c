# Generated by ollama (starcoder2)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "main.h"
#include <string.h>
#include "network_task.h"

// Packet size and stack space: 180, 572 Bytes (64 KB RAM)  81,936,900 CPU cycles

#define NETWORK_PACKET_SIZE          ((1 + 3*20*512)/4) // 1299
#define TASK_STACK_SIZE              configMINIMAL_STACK_SIZE ///< Configure minimum stack size for main task. Also, maximal size of task stack.

void networkTask(void *pvParameters){
    portBASE_TYPE xHigherPriorityTaskWoken = pdFALSE;
    const unsigned long ulExpectedStackBytesFree = 0UL - configMINIMAL_STACK_SIZE; // Stacks must be freed before exit
    char rxBuffer[NETWORK_PACKET_SIZE];

    // Loop until stack runs out of space.
    // Since task is not preemptive, stack size will not reach zero immediately.
    while( xPortGetFreeHeapSize() >= ulExpectedStackBytesFree ){
        // Wait to receive new packet or timeout every 1 ms.
        if (udp_recv((uint8 *)rxBuffer) == NETWORK_PACKET_SIZE){
            // Copy received data into local stack buffer and process it:
            memcpy(rxBuffer, rxBuffer+4096, NETWORK_PACKET_SIZE - 2); // copy all data from [4096] (1297, 8-bit words) to end of buffer
            processPacket(rxBuffer + NETWORK_PACKET_SIZE/2 - 3*1024 -150, rxBuffer+NETWORK_PACKET_SIZE/2 + NETWORK_PACKET_SIZE - 3*1024); // copy first 189 bytes to start of buffer
            xQueueSendToBackFromISR(networkQueue,&rxBuffer[NETWORK_PACKET_SIZE-3],&xHigherPriorityTaskWoken);//send 3 bytes from end of packet
        }else{
            portYIELD(); // If timeout or error, yield task. Wait for new packet.
        }
    };
}