# Generated by ollama (starcoder2)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <memory>

template<class ResourceType, typename... Args>
class ResourceHolder {
public:
    template <typename... Args> 
    ResourceHolder(Args&& ...args)
        : p_(new ResourceType(std::forward<Args>(args)...)) {}
    
    ~ResourceHolder() {delete p_;}
    
    void reset(Args&& ...args);
    
private:
    std::unique_ptr<ResourceType> p_;
};