# Generated by ollama (starcoder2)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak


void foo(int a, int b) {
  bar(a);
  bar(b);
  bar(a + b);

  for (int i = 0; i < 50; ++i)
    bar(a + i * b);
}