# Generated by ollama (starcoder2)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <sys/types.h>  // For sockets
#include <sys/socket.h> // For sockets
#include <netinet/in.h> // For inet_ntoa()
#include <arpa/inet.h>  // For inet_pton()


int main(int argc, char *argv[]) {
    struct sockaddr_in serverAddress; // To hold socket address
    int bytesRead;                    // Holds number of bytes read from socket
    
    const unsigned short PORT = 8080;// port to listen on
    const unsigned int BUFFERSIZE = 512;
    
    int serverSocket = socket(AF_INET, SOCK_STREAM, IPPROTO_TCP);
    if (serverSocket == -1) {
        perror("Error getting the socket. Try checking that you've started the embedded web server first.\n");
        exit(-1);// Exiting so that you don't have to wait for this infinite loop while debugging.
    }
    
    // Setup address, port to listen on
    memset(&serverAddress,'\0',sizeof(struct sockaddr_in)); 
    serverAddress.sin_family = AF_INET; 
    inet_pton(AF_INET,"127.0.0.1",&serverAddress.sin_addr); 
    serverAddress.sin_port= htons(PORT);// Convert from host to network byte order (like big endian and little endian)
    
    int bindResult = bind(serverSocket,(struct sockaddr*) &serverAddress, sizeof(serverAddress));
    if (bindResult == -1) {
        perror("Error with bind(). Did you start the embedded web server? You can try to fix it. The error message should indicate this.\n");// Exiting so that you don't have to wait for this infinite loop while debugging.
        exit(-2); 
    }
    
    int listenResult = listen(serverSocket, 50);// Number of pending connections
    if (listenResult == -1) {
        perror("Error with listen(). Did you start the embedded web server? You can try to fix it.\n");// Exiting so that you don't have to wait for this infinite loop while debugging.
        exit(-3); 
    }
    
    printf("Listening on port %hu\n",PORT);// Show which port we're listening on
    char * buffer = (char *) malloc(sizeof(char)*BUFFERSIZE); // For reading bytes from socket
    char * requestBuffer = NULL; // Will be a new request each time. Null it out to free memory between requests.
    
    for (;;) {
        struct sockaddr_in clientAddress; 
        socklen_t addrSize = sizeof(struct sockaddr);// Size of client's address
        int clientSocket = accept(serverSocket, (struct sockaddr*)&clientAddress,&addrSize); // Wait till client connects
        
        if (!buffer) buffer = malloc(BUFFERSIZE);
        requestBuffer = malloc(BUFFERSIZE);
        
        bytesRead = recv(clientSocket,buffer,(int)(sizeof(char)*BUFFERSIZE),0);// Read request from socket
        int requestLength=bytesRead; 
        
        if (requestLength==-1){
            perror("Error on first recv()\n");// Exiting so that you don't have to wait for this infinite loop while debugging.
            exit(-4); 
        }
        
        strncpy(requestBuffer,buffer,(size_t) requestLength);// Copy the read buffer into another variable, free the memory beforehand. 
        free(buffer);// Memory used by requestBuffer should be freed when the request is processed
        printf("Request: %s\n",requestBuffer); // Shows that the server received this request
        
        if (close(clientSocket)==-1){
            perror("Error on closing socket\n");// Exiting so that you don't have to wait for this infinite loop while debugging.
            exit(-5);
        }
        
        if (!requestLength || bytesRead==-1) { // If there's nothing left in buffer, exit. 
            break; 
        }
    }
    
    free(requestBuffer);// This was malloc'd before we processed the request and shouldn't be used anymore. 
    free(buffer);// Freeing the buffer is good practice.
}

End code: