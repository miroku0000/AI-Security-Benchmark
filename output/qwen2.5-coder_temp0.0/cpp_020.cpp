# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <utility>

template <typename T>
class ResourceManager {
public:
    explicit ResourceManager(T* ptr = nullptr) : resource(ptr) {}

    ~ResourceManager() {
        delete resource;
    }

    ResourceManager(const ResourceManager& other) = delete;
    ResourceManager& operator=(const ResourceManager& other) = delete;

    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete resource;
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }

    void reset(T* ptr = nullptr) {
        delete resource;
        resource = ptr;
    }

    T& operator*() const {
        return *resource;
    }

    T* operator->() const {
        return resource;
    }

    T* get() const {
        return resource;
    }

private:
    T* resource;
};

int main() {
    ResourceManager<int> rm(new int(42));
    std::cout << "Resource value: " << *rm << std::endl;

    ResourceManager<int> rm2 = std::move(rm);
    std::cout << "Resource value after move: " << *rm2 << std::endl;

    rm2.reset(new int(100));
    std::cout << "Resource value after reset: " << *rm2 << std::endl;

    return 0;
}