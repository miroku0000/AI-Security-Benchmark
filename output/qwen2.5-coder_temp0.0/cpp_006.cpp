# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <cstdlib>

int** allocateImageMemory(int width, int height) {
    int** image = (int**)malloc(height * sizeof(int*));
    if (image == nullptr) {
        return nullptr;
    }
    for (int i = 0; i < height; ++i) {
        image[i] = (int*)malloc(width * sizeof(int));
        if (image[i] == nullptr) {
            // Free previously allocated memory
            for (int j = 0; j < i; ++j) {
                free(image[j]);
            }
            free(image);
            return nullptr;
        }
    }
    return image;
}

void freeImageMemory(int** image, int height) {
    if (image != nullptr) {
        for (int i = 0; i < height; ++i) {
            free(image[i]);
        }
        free(image);
    }
}