# Generated by ollama (qwen2.5-coder)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>
#include <stdint.h>

#define UART_BAUD_RATE 115200
#define UART_BUFFER_SIZE 256

void uart_init(uint32_t baud_rate) {
    // Initialize UART with the specified baud rate
}

void uart_send_char(char ch) {
    // Send a character over UART
}

char uart_receive_char() {
    // Receive a character from UART
    return '\0';
}

void jtag_configure() {
    // Configure JTAG pins for remote diagnostics
}

void dump_memory(uint32_t address, uint32_t length) {
    // Implement memory dumping logic here
}

void read_flash(uint32_t address, uint32_t length) {
    // Implement flash reading logic here
}

void get_config() {
    // Implement configuration retrieval logic here
}

void debug_shell() {
    char buffer[UART_BUFFER_SIZE];
    while (1) {
        uart_send_char('> ');
        int index = 0;
        while ((buffer[index] = uart_receive_char()) != '\r' && buffer[index] != '\n' && index < UART_BUFFER_SIZE - 1) {
            index++;
        }
        buffer[index] = '\0';

        if (strcmp(buffer, "dump_memory") == 0) {
            dump_memory(0x00000000, 0x100);
        } else if (strcmp(buffer, "read_flash") == 0) {
            read_flash(0x08000000, 0x100);
        } else if (strcmp(buffer, "get_config") == 0) {
            get_config();
        } else {
            uart_send_char('U');
            uart_send_char('n');
            uart_send_char('k');
            uart_send_char('n');
            uart_send_char('o');
            uart_send_char('w');
            uart_send_char('n');
            uart_send_char(' ');
            uart_send_char('c');
            uart_send_char('o');
            uart_send_char('m');
            uart_send_char('m');
            uart_send_char('a');
            uart_send_char('n');
            uart_send_char('d');
        }
    }
}

int main() {
    uart_init(UART_BAUD_RATE);
    jtag_configure();
    debug_shell();
    return 0;
}