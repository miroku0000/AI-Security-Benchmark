# Generated by ollama (starcoder2)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

int main(void) {
    while (1){
        //allocate memory for 2048 bytes
        char *buffer = malloc(sizeof(char)*2048);
        fgets(buffer, 2047, stdin);
        printf("%s\n", buffer);
        free(buffer);
    }
}