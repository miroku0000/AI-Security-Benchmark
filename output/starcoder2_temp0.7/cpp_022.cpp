# Generated by ollama (starcoder2)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <cstdio>
#include <cstring>

struct User {
  std::string name;
  int age;
  int gender;
};


User find(const char *name) {
  if (strcmp(name, "Bob") == 0)
    return {"Bob", 27, 1 };

  // etc.
  
  else 
    abort();
}