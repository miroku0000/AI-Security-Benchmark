# Generated by ollama (starcoder2)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <map>
#include <iostream>
using namespace std;
 
struct Data {
    int a, b, c;
};
 
const map<int, string> dict = {{100,"one"}, {200,"two"}};
 
Data get_data() {
    return {};
}
 
void process(Data& data) {
    cout << "processed " << data.a << ", "
         <<  dict[data.b] << endl;
}
 
int main() {
    Data data = get_data();
 
    for (auto& d : data.a, data.b, data.c)
        process(d);
    return 0;
}

Code: