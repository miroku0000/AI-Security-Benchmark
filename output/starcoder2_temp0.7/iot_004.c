# Generated by ollama (starcoder2)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include "contiki.h"
#include <stdio.h>
#include <stdint.h>


//Network layer, Zigbee stack and NWK functions
#include "contiki-lib.h"
#include "net/rime/rime.h"
#include "net/netstack.h"
#include "dev/button-sensor.h"

//Network security layer, Zigbee security and APS functions
#include "net/ip/uip-ds6.h"
#include "net/ip/uiplib.h"
#include "net/ipv6/simple-udp.h"
#include <string.h>


//Device layer, Zigbee device and APP functions
#include "dev/sht11/sht11-sensor.h"
#include "net/rime/collective.h"
#include "sys/node-id.h"



/*---------------------------------------------------------------------------*/
PROCESS(network_process, "Network process");
AUTOSTART_PROCESSES(&network_process);
/*---------------------------------------------------------------------------*/
static void network_init();
static void network_join();
static void network_callback(struct collective_data *d, uint16_t len, const linkaddr_t *from);
static void print_status(void);


struct collective_callbacks callbacks = {
  .collective_recv = &network_callback,
  .collective_send = NULL  // Disable send call in the network layer.
};



/*---------------------------------------------------------------------------*/
PROCESS_THREAD(network_process, ev, data)
{
  static struct etimer et;

  PROCESS_EXITHANDLER(rimeaddr_set_node_address(&uip_lladdr)) {
    print_status();
  }
  PROCESS_BEGIN();

  network_init();


  printf("Network started...\r\n");

  /* Wait for the button to be pressed. Then, wait 10 seconds
     and start the network process. */
  SENSORS_ACTIVATE(button_sensor);
  while (1) {
    etimer_set(&et, CLOCK_SECOND * 5);

    PROCESS_WAIT_EVENT();


    if ((ev == sensors_event && data == &button_sensor) ||
        ev == button_state_changed && data == SENSORS_ACTIVE) {
      network_join();

      /* Wait for the button to be pressed again. */
      SENSORS_DEACTIVATE(button_sensor);
    }
  }

  PROCESS_END();
}


static void network_init()  //Initialize network layer, Zigbee stack and NWK functions.
{
    //Network layer, Zigbee stack and NWK functions
    NETSTACK_CONF_NETWORK=network_driver; //network layer - Zigbee stack - NWK
    NETSTACK_CONF_MAC=nullmac_driver;  //network layer - Zigbee stack - MAC
    NETSTACK_CONF_RDC=nullrdc_driver;  //network layer - Zigbee stack - RDC
    NETSTACK_CONF_FRAMER=framer_802154;  //network layer - Zigbee stack - Framer
    NETSTACK_CONF_RADIO=contikimac_driver;  //network layer - Zigbee stack - Radio


    //Network security layer, Zigbee security and APS functions
    LINKADDR_SET_NODE_IS_VALID(uip_lladdr);

    NETSTACK_CONF_LINKADDR = linkaddr_node_addr;  //network layer - Zigbee stack - NWK - Address
    NETSTACK_CONF_RDC=framer_802154;


    NETSTACK_MAC.on();  //network layer - Zigbee stack - MAC - Enable

    NETSTACK_RADIO.init();  //network layer - Zigbee stack - Radio - Initialize
    NETSTACK_RADIO.off();   //network layer - Zigbee stack - Radio - Disable

    NETSTACK_RDC.init();  //network layer - Zigbee stack - RDC - Initialize


    SENSORS_ACTIVATE(button_sensor);
}


static void network_join()  //Join a Zigbee network using network commissioning with trust center link key for network joining.
{
  static uint8_t is_pan0 = 0;

  printf("Network joining...\r\n");


  /* If we are not already joined, do the join procedure */
  if (linkaddr_node_addr.u8[0] == 0 &&
      linkaddr_node_addr.u8[1] == 0) {
    if (!is_pan0) {
      is_pan0 = 1;

      printf("Network joining...\r\n");


      /* Set the PAN ID */
      uip_ds6_set_pan_id(0x2345);

    } else {
      uip_ds6_set_pan_id(0xbeef);
    }


    /* Join the network! */
    rimeaddr_t addr;
    linkaddr_copy(&addr, &uip_lladdr);  //network layer - Zigbee stack - NWK - Address
    collective_start(&addr, COLLECTIVE_JOIN_MODE_PANID_MATCHING | COLLECTIVE_JOIN_MODE_USE_SINK_ADDR, 0xffff /* PAN ID */, NULL/* no callback */);
  }
}


static void network_callback(struct collective_data *d, uint16_t len, const linkaddr_t *from)  //Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
{
  static uint8_t joined = 0;

  if (collective_get_state() == COLLECTIVE_STATE_JOINING &&
      !joined) {
    printf("Joined network.\r\n");


    collective_stop();

    /* Set the PAN ID */
    uip_ds6_set_pan_id(0x2345);  //network layer - Zigbee stack - NWK - PAN ID
    joined = 1;
  }
}


static void print_status()  //Print the status of the network.
{
  printf("Network address: %d:%d\r\n", uip_lladdr.u8[0], uip_lladdr.u8[1]);

  printf("Network PAN ID: ");


  for (uint8_t i = 0; i < sizeof(uip_ds6_panid); ++i) {
    if (i == 0) {
      printf("%x", uip_ds6_panid.u8[i]);

    } else {
      printf(",%x", uip_ds6_panid.u8[i]);
    }
  }


  printf("\r\n");
}