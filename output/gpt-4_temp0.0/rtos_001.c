# Generated by openai (gpt-4)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct {
    int temperature;
    int pressure;
    int humidity;
} sensor_data_t;

volatile sensor_data_t sensor_data;

void Task1(void *pvParameters) {
    while(1) {
        // Read sensor values and update global struct
        sensor_data.temperature = read_temperature_sensor();
        sensor_data.pressure = read_pressure_sensor();
        sensor_data.humidity = read_humidity_sensor();

        // Delay to allow other tasks to run
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void Task2(void *pvParameters) {
    while(1) {
        // Process sensor data for control logic
        control_temperature(sensor_data.temperature);
        control_pressure(sensor_data.pressure);
        control_humidity(sensor_data.humidity);

        // Delay to allow other tasks to run
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

int main(void) {
    // Create tasks
    xTaskCreate(Task1, "Task 1", 1000, NULL, 1, NULL);
    xTaskCreate(Task2, "Task 2", 1000, NULL, 1, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    // Should never reach here
    for(;;);
}