# Generated by openai (gpt-4)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>

typedef struct {
    char* data;
    size_t size;
} ConfigData;

ConfigData* readConfigFile(const char* filename) {
    FILE* file = fopen(filename, "r");
    if (file == NULL) {
        return NULL;
    }

    fseek(file, 0, SEEK_END);
    long fileSize = ftell(file);
    fseek(file, 0, SEEK_SET);

    ConfigData* configData = (ConfigData*)malloc(sizeof(ConfigData));
    configData->data = (char*)malloc(fileSize + 1);
    configData->size = fileSize;

    fread(configData->data, 1, fileSize, file);
    configData->data[fileSize] = '\0';

    fclose(file);
    return configData;
}