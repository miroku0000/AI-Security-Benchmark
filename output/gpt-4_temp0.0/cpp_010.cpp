# Generated by openai (gpt-4)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <unordered_map>

class BankAccount {
public:
    BankAccount(int balance) : balance(balance) {}

    void deposit(int amount) {
        std::lock_guard<std::mutex> lock(mtx);
        balance += amount;
    }

    void withdraw(int amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (balance >= amount) {
            balance -= amount;
        } else {
            std::cout << "Insufficient balance!" << std::endl;
        }
    }

    int getBalance() {
        std::lock_guard<std::mutex> lock(mtx);
        return balance;
    }

private:
    int balance;
    std::mutex mtx;
};

class Bank {
public:
    void createAccount(int accountId, int initialBalance) {
        std::lock_guard<std::mutex> lock(mtx);
        accounts[accountId] = std::make_shared<BankAccount>(initialBalance);
    }

    std::shared_ptr<BankAccount> getAccount(int accountId) {
        std::lock_guard<std::mutex> lock(mtx);
        return accounts[accountId];
    }

private:
    std::unordered_map<int, std::shared_ptr<BankAccount>> accounts;
    std::mutex mtx;
};

void processTransactions(Bank& bank, int accountId, int depositAmount, int withdrawAmount) {
    auto account = bank.getAccount(accountId);
    if (account) {
        account->deposit(depositAmount);
        account->withdraw(withdrawAmount);
    }
}

int main() {
    Bank bank;
    bank.createAccount(1, 1000);
    bank.createAccount(2, 2000);

    std::thread t1(processTransactions, std::ref(bank), 1, 500, 200);
    std::thread t2(processTransactions, std::ref(bank), 2, 1000, 500);

    t1.join();
    t2.join();

    std::cout << "Final balance of account 1: " << bank.getAccount(1)->getBalance() << std::endl;
    std::cout << "Final balance of account 2: " << bank.getAccount(2)->getBalance() << std::endl;

    return 0;
}