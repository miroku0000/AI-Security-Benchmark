# Generated by openai (gpt-4)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

// Define the User structure
typedef struct User {
    char* name;
    char* email;
    struct User* next;
} User;

// Function to print user's name and email
void printUserDetails(User* head) {
    User* temp = head;
    while(temp != NULL) {
        printf("Name: %s, Email: %s\n", temp->name, temp->email);
        temp = temp->next;
    }
}