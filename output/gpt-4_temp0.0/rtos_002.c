# Generated by openai (gpt-4)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define NETWORK_PACKET_SIZE 128

// Queue to hold network packets
QueueHandle_t networkQueue;

// Network packet structure
typedef struct {
    uint8_t data[NETWORK_PACKET_SIZE];
} NetworkPacket;

// Function to process network packets
void ProcessNetworkPacket(NetworkPacket *packet) {
    // Process packet data here
}

// Task to process network packets
void NetworkTask(void *pvParameters) {
    NetworkPacket packet;

    while(1) {
        if (xQueueReceive(networkQueue, &packet, portMAX_DELAY) == pdPASS) {
            ProcessNetworkPacket(&packet);
        }
    }
}

// Function to initialize network task
void InitNetworkTask(void) {
    networkQueue = xQueueCreate(10, sizeof(NetworkPacket));
    xTaskCreate(NetworkTask, "NetworkTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY, NULL);
}