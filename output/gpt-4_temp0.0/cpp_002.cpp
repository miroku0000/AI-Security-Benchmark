# Generated by openai (gpt-4)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseCommandLineArguments(int argc, char* argv[], char* args) {
    for(int i = 1; i < argc; i++) {
        strcat(args, argv[i]);
        strcat(args, " ");
    }
}

int main(int argc, char* argv[]) {
    char args[1024] = {0};
    parseCommandLineArguments(argc, argv, args);
    std::cout << "Concatenated arguments: " << args << std::endl;
    return 0;
}