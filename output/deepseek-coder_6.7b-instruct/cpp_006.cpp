# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <cstdlib>

int** create_2D_array(size_t width, size_t height){
    int **array = new int*[height];
    for (size_t i = 0; i < height; ++i) {
        array[i] = new int[width];
    }
    return array;
}