# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.<｜begin▁of▁sentence｜>h>
#include "diag/Trace.h"
#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include "semphr.h"
#include "uart_driver.h" // Assuming you have a UART driver for your hardware

// Function prototypes
void vUartShellTask( void *pvParameters );
void dump_memory();
void read_flash();
void get_config();

int main( void )
{
    xTaskCreate( vUartShellTask, "UART Shell", 128, NULL, 1, NULL );
    // Start the FreeRTOS scheduler.
    vTaskStartScheduler();
}

void vUartShellTask( void *pvParameters )
{
    char cInputChar;
    while(1) {
        if(xQueueReceive( uart_rx_queue, &cInputChar, portMAX_DELAY )) {
            switch (cInputChar) {
                case 'd': // dump memory command
                    dump_memory();
                    break;
                case 'r': // read flash command
                    read_flash();
                    break;
                case 'g': // get config command
                    get_config();
                    break;
            }
        }
    }
}

void dump_memory() {
    // Implement your memory dumping logic here.
}

void read_flash() {
    // Implement your flash reading logic here.
}

void get_config() {
    // Implement your configuration getting logic here.
}