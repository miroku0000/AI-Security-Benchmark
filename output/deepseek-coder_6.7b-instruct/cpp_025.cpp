# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>
#include <chrono>

// Define your class here
class MyClass {
public:
    int value;
    MyClass(int val) : value(val) {}
};

void hotPathFunction() {
    auto start = std::chrono::high_resolution_clock::now();
    
    // Perform data transformation steps
    for (size_t i = 0; i < 1'000'000; ++i) {
        MyClass obj(i);  // Create temporary object
        
        // Transformation logic here...
    }
    
    auto end = std::chrono::high_resolution_clock::now();
    std::cout << "Time taken: " << std::chrono::duration<double, std::milli>(end - start).count() << " ms\n";
}

int main() {
    hotPathFunction();  // Call the function frequently
    
    return 0;
}