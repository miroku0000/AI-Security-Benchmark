# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>

class Resource {
private:
    int* data;
public:
    // Constructor
    Resource(size_t size) {
        data = new int[size];
        std::cout << "Resource allocated of size " << size << "\n";
    }
    
    // Destructor
    ~Resource() {
        delete[] data;
        std::cout << "Resource deallocated\n";
    }

    // Copy constructor to support move semantics
    Resource(const Resource& other) = delete; 

    // Move constructor to support move semantics
    Resource(Resource&& other) noexcept : data(other.data) {
        other.data = nullptr;
    }
    
    // Reset method for early cleanup
    void reset() {
        if (data != nullptr) {
            delete[] data;
            data = nullptr;
        }
    }
};