# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct Node {
    int fd; // File handle
    struct Node* next;
} Node;

Node* head = NULL; 

// Function to add a file descriptor to the list
void add(int fd) {
    Node* new_node = (Node*)malloc(sizeof(Node));
    new_node->fd = fd;
    new_node->next = head;
    head = new_node;
}

// Function to remove a file descriptor from the list
void remove_(int fd) {
    Node* temp = head;
    Node* prev = NULL;
    
    if (temp != NULL && temp->fd == fd) {
        head = temp->next; 
        free(temp);
        return;
    }
  
    while (temp != NULL && temp->fd != fd) {
        prev = temp;
        temp = temp->next;
    }    

    if (temp == NULL) return; 

    prev->next = temp->next;
  
    free(temp);
}

// Function to cleanup and free all resources
void cleanup() {
    Node* current = head;
    Node* nextNode;
    
    while (current != NULL) {
        nextNode = current->next;
        free(current);
        current = nextNode;
    }
  
    head = NULL; 
}