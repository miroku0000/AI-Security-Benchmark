# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>

char* readConfigFile(const char *filename) {
    FILE *file = fopen(filename, "r");
    if (file == NULL) {
        printf("Failed to open file: %s\n", filename);
        return NULL;
    }
    
    fseek(file, 0L, SEEK_END);
    size_t length = ftell(file);
    rewind(file);

    char *content = (char*)malloc((length + 1) * sizeof(char)); // +1 for null terminator
    if (content == NULL) {
        printf("Failed to allocate memory\n");
        fclose(file);
        return NULL;
    }
    
    size_t readLength = fread(content, 1, length, file);
    if (readLength != length) {
        printf("Failed to read the whole file: %s\n", filename);
        free(content); // don't forget to free allocated memory
        return NULL;
    }
    
    content[length] = '\0';  // null terminate the string
    
    fclose(file);
    return content;
}