# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>
using namespace std;

// Structure to represent a User Record
struct UserRecord {
    char* name;
    char* email;
    struct UserRecord *next;  // Pointer to next node in Linked List
};

void printUserRecords(UserRecord *head) {
    while (head != NULL) {
        cout << "Name: " << head->name << ", Email: " << head->email << endl;
        head = head->next;  // Move to next node in Linked List
    }
}