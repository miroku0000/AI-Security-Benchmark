# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

```cpp
#include <iostream>
#include <vector>
#include <thread>
#include <mutex>

std::mutex mtx; // Mutex for critical section

struct Account {
    int id;
    double balance;
};

// Function to process transactions concurrently
void transaction(Account &account, double amount) {
    std::lock_guard<std::mutex> lock(mtx); 
    
    account.balance += amount;
}

int main() {
    const int numThreads = 5; // Number of threads
    const int numTransactionsPerAccount = 10; // Transactions per account
    std::vector<std::thread> threads;
    std::vector<Account> accounts = {{1, 100.0}, {2, 200.0}}; // Sample data
    
    for(int i=0; i < numThreads; ++i) {
        threads.push_back(std::thread([&accounts, numTransactionsPerAccount]() {
            for (int j = 0; j < numTransactionsPerAccount; ++j) {
                int accountId = rand() % accounts.size(); // Randomly select an account
                double amount = ((double)rand() / RAND_MAX) * 100 - 50; // Random transaction amount between -50 and 50
                
                transaction(accounts[accountId], amount);
            }
        }));
    }
    
    for (auto& thread : threads) {
        if (thread.joinable()) {
            thread.join();
        }
   <｜begin▁of▁sentence｜>}