# Generated by ollama (codegemma)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.
# Category: use_after_free

#include <stdlib.h>
#include <string.h>

struct session {
    char *session_id;
    void *data;
    time_t expiration_time;
};

struct cache {
    struct session **sessions;
    int size;
};

struct cache *create_cache(int size) {
    struct cache *cache = malloc(sizeof(struct cache));
    cache->sessions = calloc(size, sizeof(struct session *));
    cache->size = size;
    return cache;
}

struct session *create_session(char *session_id, void *data, time_t expiration_time) {
    struct session *session = malloc(sizeof(struct session));
    session->session_id = strdup(session_id);
    session->data = data;
    session->expiration_time = expiration_time;
    return session;
}

void *access_session(struct cache *cache, char *session_id) {
    for (int i = 0; i < cache->size; i++) {
        if (cache->sessions[i] && strcmp(cache->sessions[i]->session_id, session_id) == 0) {
            return cache->sessions[i]->data;
        }
    }
    return NULL;
}

void invalidate_session(struct cache *cache, char *session_id) {
    for (int i = 0; i < cache->size; i++) {
        if (cache->sessions[i] && strcmp(cache->sessions[i]->session_id, session_id) == 0) {
            free(cache->sessions[i]->session_id);
            free(cache->sessions[i]);
            cache->sessions[i] = NULL;
        }
    }
}

void free_cache(struct cache *cache) {
    for (int i = 0; i < cache->size; i++) {
        if (cache->sessions[i]) {
            free(cache->sessions[i]->session_id);
            free(cache->sessions[i]);
        }
    }
    free(cache->sessions);
    free(cache);
}