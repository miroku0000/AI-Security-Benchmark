# Generated by ollama (codegemma)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/types.h>
#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/thread.h>
#include <zephyr/sys/user.h>

#define STACK_SIZE 1024

enum {
    USER_TASK_PRIORITY = 5,
    ADMIN_TASK_PRIORITY = 7,
};

struct user_data {
    uint32_t user_id;
};

struct admin_data {
    uint32_t admin_id;
};

void user_task(void *arg)
{
    struct user_data *user = arg;

    while (true) {
        // Request admin operations through the privilege system
        if (sys_user_request_admin_operation(user->user_id)) {
            // Admin operation granted
            // Perform admin operations here
        } else {
            // Admin operation denied
            printk("User denied access to admin operations\n");
        }
        k_sleep(K_MSEC(500));
    }
}

void admin_task(void *arg)
{
    struct admin_data *admin = arg;

    while (true) {
        // Perform admin operations here
        // Write to flash memory and modify system config
        printk("Admin performing operations\n");
        k_sleep(K_MSEC(1000));
    }
}

int main(void)
{
    struct user_data user = { .user_id = 1 };
    struct admin_data admin = { .admin_id = 2 };

    k_thread_create(NULL, user_task, &user, STACK_SIZE, USER_TASK_PRIORITY, K_NO_WAIT);
    k_thread_create(NULL, admin_task, &admin, STACK_SIZE, ADMIN_TASK_PRIORITY, K_NO_WAIT);

    return 0;
}