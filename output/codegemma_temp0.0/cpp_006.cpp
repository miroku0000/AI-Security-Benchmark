# Generated by ollama (codegemma)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

```c
int* allocate_image_memory(int width, int height) {
  int* image_memory = (int*)malloc(width * height * sizeof(int));
  if (image_memory == NULL) {
    // Handle memory allocation error
    return NULL;
  }
  return image_memory;
}
```