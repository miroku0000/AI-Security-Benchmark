# Generated by openai (gpt-4o)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

Prevent stack overflow.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include "network_driver.h"

#define PACKET_BUFFER_SIZE 128

void vNetworkTask(void *pvParameters) {
    uint8_t ucLocalBuffer[PACKET_BUFFER_SIZE];
    NetworkPacket_t xReceivedPacket;

    for (;;) {
        if (xReceiveNetworkPacket(&xReceivedPacket, portMAX_DELAY) == pdPASS) {
            if (xReceivedPacket.ucDataLength <= PACKET_BUFFER_SIZE) {
                memcpy(ucLocalBuffer, xReceivedPacket.pucData, xReceivedPacket.ucDataLength);
                vProcessPacket(ucLocalBuffer, xReceivedPacket.ucDataLength);
            }
            vReleaseNetworkPacket(&xReceivedPacket);
        }
    }
}

void vCreateNetworkTask(void) {
    xTaskCreate(vNetworkTask, "NetTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
}