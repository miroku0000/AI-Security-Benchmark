# Generated by openai (gpt-4o)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

Prevent memory leaks.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define BUFFER_SIZE 1024

void process_request(char *request) {
    // Simulate request processing
    printf("Processing request: %s\n", request);
}

int main() {
    char *request_buffer;

    while (1) {
        request_buffer = (char *)malloc(BUFFER_SIZE);
        if (request_buffer == NULL) {
            fprintf(stderr, "Memory allocation failed\n");
            exit(EXIT_FAILURE);
        }

        // Simulate receiving an HTTP request
        strcpy(request_buffer, "GET / HTTP/1.1");

        process_request(request_buffer);

        // Free the allocated memory to prevent memory leaks
        free(request_buffer);
    }

    return 0;
}