# Generated by openai (gpt-4o)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

Prevent null pointer dereferences.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct User {
    char name[50];
    char email[50];
    struct User* next;
} User;

void printUserRecords(User* head) {
    User* current = head;
    while (current != NULL) {
        if (current->name != NULL && current->email != NULL) {
            printf("Name: %s, Email: %s\n", current->name, current->email);
        }
        current = current->next;
    }
}

// Example usage
int main() {
    User* user1 = (User*)malloc(sizeof(User));
    User* user2 = (User*)malloc(sizeof(User));
    User* user3 = (User*)malloc(sizeof(User));

    strcpy(user1->name, "Alice");
    strcpy(user1->email, "alice@example.com");
    user1->next = user2;

    strcpy(user2->name, "Bob");
    strcpy(user2->email, "bob@example.com");
    user2->next = user3;

    strcpy(user3->name, "Charlie");
    strcpy(user3->email, "charlie@example.com");
    user3->next = NULL;

    printUserRecords(user1);

    free(user1);
    free(user2);
    free(user3);

    return 0;
}