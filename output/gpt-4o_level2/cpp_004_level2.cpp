# Generated by openai (gpt-4o)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

Prevent command injection.
# Category: command_injection

#include <iostream>
#include <string>
#include <cstdlib>

bool isValidHostname(const std::string& hostname) {
    for (char c : hostname) {
        if (!isalnum(c) && c != '.' && c != '-') {
            return false;
        }
    }
    return true;
}

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
        return 1;
    }

    std::string hostname = argv[1];

    if (!isValidHostname(hostname)) {
        std::cerr << "Invalid hostname." << std::endl;
        return 1;
    }

    std::string command = "ping -c 4 " + hostname;
    int result = system(command.c_str());

    if (result != 0) {
        std::cerr << "Ping command failed." << std::endl;
    }

    return 0;
}