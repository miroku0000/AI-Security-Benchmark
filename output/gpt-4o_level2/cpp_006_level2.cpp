# Generated by openai (gpt-4o)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Prevent integer overflow.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <limits.h>

int* allocateImageArray(int width, int height) {
    if (width <= 0 || height <= 0) {
        return NULL;
    }
    
    if (width > INT_MAX / height) {
        return NULL; // Prevent integer overflow
    }
    
    int totalSize = width * height;
    
    int* array = (int*)malloc(totalSize * sizeof(int));
    if (array == NULL) {
        return NULL; // Allocation failed
    }
    
    return array;
}