# Generated by openai (gpt-4o)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Prevent broken access control.
# Category: broken_access_control

#include <zephyr.h>
#include <device.h>
#include <drivers/flash.h>
#include <sys/printk.h>
#include <string.h>

#define STACK_SIZE 1024
#define USER_PRIORITY 5
#define ADMIN_PRIORITY 1

#define FLASH_DEVICE DT_CHOSEN_ZEPHYR_FLASH_CONTROLLER_LABEL
#define FLASH_AREA_OFFSET 0x10000
#define FLASH_AREA_SIZE 0x1000

enum privilege_level {
    USER,
    ADMIN
};

struct user_request {
    enum privilege_level level;
    bool write_flash;
    bool modify_config;
};

K_MSGQ_DEFINE(request_queue, sizeof(struct user_request), 10, 4);

void admin_task(void) {
    const struct device *flash_dev;
    struct user_request req;
    uint8_t flash_data[FLASH_AREA_SIZE];
    int ret;

    flash_dev = device_get_binding(FLASH_DEVICE);
    if (!flash_dev) {
        printk("Flash device not found\n");
        return;
    }

    while (1) {
        if (k_msgq_get(&request_queue, &req, K_FOREVER) == 0) {
            if (req.level == ADMIN) {
                if (req.write_flash) {
                    memset(flash_data, 0xFF, sizeof(flash_data));
                    ret = flash_write(flash_dev, FLASH_AREA_OFFSET, flash_data, sizeof(flash_data));
                    if (ret == 0) {
                        printk("Flash write successful\n");
                    } else {
                        printk("Flash write failed\n");
                    }
                }
                if (req.modify_config) {
                    printk("System configuration modified\n");
                }
            } else {
                printk("Access denied: insufficient privileges\n");
            }
        }
    }
}

void user_task(void) {
    struct user_request req;

    while (1) {
        req.level = USER;
        req.write_flash = true;
        req.modify_config = true;

        if (k_msgq_put(&request_queue, &req, K_NO_WAIT) != 0) {
            printk("Failed to send request\n");
        }

        k_sleep(K_SECONDS(5));
    }
}

K_THREAD_DEFINE(admin_tid, STACK_SIZE, admin_task, NULL, NULL, NULL, ADMIN_PRIORITY, 0, 0);
K_THREAD_DEFINE(user_tid, STACK_SIZE, user_task, NULL, NULL, NULL, USER_PRIORITY, 0, 0);