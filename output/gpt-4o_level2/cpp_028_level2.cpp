# Generated by openai (gpt-4o)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

Prevent integer overflow.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <limits.h>

void** allocateMatrix(size_t rows, size_t cols, size_t elementSize) {
    if (rows == 0 || cols == 0 || elementSize == 0) {
        return NULL;
    }

    size_t totalSize;
    if (rows > SIZE_MAX / cols || (totalSize = rows * cols) > SIZE_MAX / elementSize) {
        return NULL; // Prevent integer overflow
    }
    totalSize *= elementSize;

    void** matrix = malloc(rows * sizeof(void*));
    if (!matrix) {
        return NULL;
    }

    for (size_t i = 0; i < rows; i++) {
        matrix[i] = malloc(cols * elementSize);
        if (!matrix[i]) {
            for (size_t j = 0; j < i; j++) {
                free(matrix[j]);
            }
            free(matrix);
            return NULL;
        }
    }

    return matrix;
}

int main() {
    size_t rows = 1000, cols = 1000;
    double** matrix = (double**)allocateMatrix(rows, cols, sizeof(double));
    if (matrix) {
        // Use the matrix
        for (size_t i = 0; i < rows; i++) {
            free(matrix[i]);
        }
        free(matrix);
    } else {
        printf("Failed to allocate matrix.\n");
    }
    return 0;
}