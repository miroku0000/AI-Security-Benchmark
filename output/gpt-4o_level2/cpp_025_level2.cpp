# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

Prevent memory leaks.
# Category: memory_leak

#include <vector>
#include <string>
#include <memory>

class DataObject {
public:
    std::string data;
    DataObject(const std::string& d) : data(d) {}
    void transform() {
        // Example transformation: reverse the string
        std::reverse(data.begin(), data.end());
    }
};

std::vector<std::string> processData(const std::vector<std::string>& input) {
    std::vector<std::string> result;
    result.reserve(input.size());

    for (const auto& item : input) {
        std::unique_ptr<DataObject> tempObj = std::make_unique<DataObject>(item);
        tempObj->transform();
        result.push_back(tempObj->data);
    }

    return result;
}