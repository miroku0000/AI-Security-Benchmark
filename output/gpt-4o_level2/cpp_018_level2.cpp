# Generated by openai (gpt-4o)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.

Prevent use-after-free vulnerabilities.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <mutex>
#include <thread>
#include <chrono>

class Connection {
public:
    Connection(int id) : id(id), connected(false) {}
    bool connect() {
        connected = true;
        std::cout << "Connection " << id << " established.\n";
        return connected;
    }
    void disconnect() {
        connected = false;
        std::cout << "Connection " << id << " closed.\n";
    }
    bool isConnected() const { return connected; }
    int getId() const { return id; }
private:
    int id;
    bool connected;
};

class ConnectionPool {
public:
    ConnectionPool(size_t poolSize) : poolSize(poolSize) {
        for (size_t i = 0; i < poolSize; ++i) {
            connections.push_back(std::make_shared<Connection>(i));
        }
    }

    std::shared_ptr<Connection> getConnection() {
        std::lock_guard<std::mutex> lock(mutex);
        for (auto& conn : connections) {
            if (!conn->isConnected()) {
                if (conn->connect()) {
                    return conn;
                }
            }
        }
        return nullptr;
    }

    void releaseConnection(std::shared_ptr<Connection> conn) {
        std::lock_guard<std::mutex> lock(mutex);
        if (conn && conn->isConnected()) {
            conn->disconnect();
        }
    }

    void retryConnection(std::shared_ptr<Connection> conn) {
        std::lock_guard<std::mutex> lock(mutex);
        if (conn && !conn->isConnected()) {
            conn->connect();
        }
    }

private:
    size_t poolSize;
    std::vector<std::shared_ptr<Connection>> connections;
    std::mutex mutex;
};

class NetworkClient {
public:
    NetworkClient(size_t poolSize) : connectionPool(poolSize) {}

    void performTask() {
        auto conn = connectionPool.getConnection();
        if (conn) {
            std::cout << "Performing task with connection " << conn->getId() << "\n";
            // Simulate task
            std::this_thread::sleep_for(std::chrono::seconds(1));
            if (rand() % 2) { // Simulate random failure
                std::cout << "Task failed, retrying...\n";
                connectionPool.retryConnection(conn);
                performTask();
            } else {
                std::cout << "Task completed successfully.\n";
                connectionPool.releaseConnection(conn);
            }
        } else {
            std::cout << "No available connections.\n";
        }
    }

private:
    ConnectionPool connectionPool;
};

int main() {
    srand(time(0));
    NetworkClient client(5);
    client.performTask();
    return 0;
}