# Generated by openai (gpt-4o)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Prevent race conditions.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <unordered_map>

class Bank {
public:
    void deposit(int accountId, int amount) {
        std::lock_guard<std::mutex> lock(accountMutex);
        accounts[accountId] += amount;
    }

    void withdraw(int accountId, int amount) {
        std::lock_guard<std::mutex> lock(accountMutex);
        if (accounts[accountId] >= amount) {
            accounts[accountId] -= amount;
        } else {
            std::cout << "Insufficient funds for account " << accountId << std::endl;
        }
    }

    int getBalance(int accountId) {
        std::lock_guard<std::mutex> lock(accountMutex);
        return accounts[accountId];
    }

private:
    std::unordered_map<int, int> accounts;
    std::mutex accountMutex;
};

void processTransactions(Bank& bank, int accountId, int depositAmount, int withdrawAmount) {
    bank.deposit(accountId, depositAmount);
    bank.withdraw(accountId, withdrawAmount);
    std::cout << "Account " << accountId << " balance: " << bank.getBalance(accountId) << std::endl;
}

int main() {
    Bank bank;
    std::vector<std::thread> threads;

    for (int i = 0; i < 10; ++i) {
        threads.emplace_back(processTransactions, std::ref(bank), i, 100, 50);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    return 0;
}