# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <cstddef>
#include <cstdint>
#include <cstring>
#include <memory>
#include <new>
#include <type_traits>
#include <utility>
#include <vector>

struct alignas(64) TransformScratch {
    std::byte* mem = nullptr;
    std::size_t cap = 0;
    std::size_t off = 0;

    TransformScratch() = default;
    explicit TransformScratch(std::size_t initialBytes) { reserve(initialBytes); }

    TransformScratch(const TransformScratch&) = delete;
    TransformScratch& operator=(const TransformScratch&) = delete;

    TransformScratch(TransformScratch&& other) noexcept
        : mem(other.mem), cap(other.cap), off(other.off) {
        other.mem = nullptr;
        other.cap = 0;
        other.off = 0;
    }

    TransformScratch& operator=(TransformScratch&& other) noexcept {
        if (this != &other) {
            ::operator delete(mem, std::align_val_t(64));
            mem = other.mem;
            cap = other.cap;
            off = other.off;
            other.mem = nullptr;
            other.cap = 0;
            other.off = 0;
        }
        return *this;
    }

    ~TransformScratch() { ::operator delete(mem, std::align_val_t(64)); }

    void reset() noexcept { off = 0; }

    void reserve(std::size_t bytes) {
        if (bytes <= cap) return;
        std::size_t newCap = cap ? cap : 4096;
        while (newCap < bytes) newCap *= 2;

        std::byte* newMem = static_cast<std::byte*>(::operator new(newCap, std::align_val_t(64)));
        if (mem) {
            std::memcpy(newMem, mem, off);
            ::operator delete(mem, std::align_val_t(64));
        }
        mem = newMem;
        cap = newCap;
    }

    void* allocate(std::size_t bytes, std::size_t align) {
        std::size_t p = off;
        std::size_t aligned = (p + (align - 1)) & ~(align - 1);
        std::size_t end = aligned + bytes;
        if (end > cap) reserve(end);
        void* ptr = mem + aligned;
        off = end;
        return ptr;
    }

    template <class T, class... Args>
    T* make(Args&&... args) {
        void* p = allocate(sizeof(T), alignof(T));
        return ::new (p) T(std::forward<Args>(args)...);
    }

    template <class T>
    T* make_array(std::size_t n) {
        if (n == 0) return nullptr;
        void* p = allocate(sizeof(T) * n, alignof(T));
        if constexpr (std::is_trivially_default_constructible_v<T>) {
            return static_cast<T*>(p);
        } else {
            T* arr = static_cast<T*>(p);
            for (std::size_t i = 0; i < n; ++i) ::new (arr + i) T();
            return arr;
        }
    }
};

struct InputRecord {
    const std::uint8_t* data = nullptr;
    std::size_t size = 0;
};

struct OutputRecord {
    const std::uint8_t* data = nullptr;
    std::size_t size = 0;
};

struct Stage1Buf {
    std::uint8_t* buf = nullptr;
    std::size_t len = 0;
};

struct Stage2Buf {
    std::uint8_t* buf = nullptr;
    std::size_t len = 0;
};

struct Stage3Buf {
    std::uint8_t* buf = nullptr;
    std::size_t len = 0;
};

static inline Stage1Buf step1_decode(const InputRecord& in, TransformScratch& scratch) {
    Stage1Buf s;
    s.len = in.size;
    s.buf = scratch.make_array<std::uint8_t>(s.len);
    if (s.len) std::memcpy(s.buf, in.data, s.len);
    return s;
}

static inline Stage2Buf step2_transform(const Stage1Buf& s1, TransformScratch& scratch) {
    Stage2Buf s;
    s.len = s1.len;
    s.buf = scratch.make_array<std::uint8_t>(s.len);
    for (std::size_t i = 0; i < s.len; ++i) s.buf[i] = static_cast<std::uint8_t>(s1.buf[i] ^ 0xA5u);
    return s;
}

static inline Stage3Buf step3_filter(const Stage2Buf& s2, TransformScratch& scratch) {
    Stage3Buf s;
    s.len = s2.len;
    s.buf = scratch.make_array<std::uint8_t>(s.len);
    for (std::size_t i = 0; i < s.len; ++i) s.buf[i] = static_cast<std::uint8_t>((s2.buf[i] + 17u) & 0xFFu);
    return s;
}

static inline OutputRecord transform_hotpath(const InputRecord& in, TransformScratch& scratch) {
    scratch.reset();

    Stage1Buf s1 = step1_decode(in, scratch);
    Stage2Buf s2 = step2_transform(s1, scratch);
    Stage3Buf s3 = step3_filter(s2, scratch);

    OutputRecord out;
    out.data = s3.buf;
    out.size = s3.len;
    return out;
}