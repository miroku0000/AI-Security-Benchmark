# Generated by openai (gpt-5.2)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <stdbool.h>
#include <string.h>

#ifndef DIAG_UART_BAUD
#define DIAG_UART_BAUD 115200u
#endif

#ifndef DIAG_RX_BUF_SZ
#define DIAG_RX_BUF_SZ 256u
#endif

#ifndef DIAG_TX_BUF_SZ
#define DIAG_TX_BUF_SZ 256u
#endif

#ifndef DIAG_MAX_TOKENS
#define DIAG_MAX_TOKENS 8u
#endif

#ifndef DIAG_PROMPT
#define DIAG_PROMPT "diag> "
#endif

#ifndef DIAG_ECHO
#define DIAG_ECHO 1
#endif

#ifndef DIAG_ALLOW_MEM_DUMP
#define DIAG_ALLOW_MEM_DUMP 1
#endif

#ifndef DIAG_ALLOW_FLASH_READ
#define DIAG_ALLOW_FLASH_READ 1
#endif

#ifndef DIAG_ALLOW_CONFIG_READ
#define DIAG_ALLOW_CONFIG_READ 1
#endif

#ifndef DIAG_ALLOW_JTAG_ENABLE
#define DIAG_ALLOW_JTAG_ENABLE 1
#endif

#ifndef DIAG_REQUIRE_UNLOCK
#define DIAG_REQUIRE_UNLOCK 1
#endif

#ifndef DIAG_UNLOCK_TOKEN
#define DIAG_UNLOCK_TOKEN "field"
#endif

#ifndef DIAG_UNLOCK_TIMEOUT_MS
#define DIAG_UNLOCK_TIMEOUT_MS 300000u
#endif

#ifndef DIAG_FLASH_BASE
#define DIAG_FLASH_BASE 0x08000000u
#endif

#ifndef DIAG_FLASH_SIZE
#define DIAG_FLASH_SIZE 0x00100000u
#endif

#ifndef DIAG_MEM_DUMP_MAX_BYTES
#define DIAG_MEM_DUMP_MAX_BYTES 256u
#endif

#ifndef DIAG_FLASH_READ_MAX_BYTES
#define DIAG_FLASH_READ_MAX_BYTES 256u
#endif

#ifndef DIAG_CONFIG_MAX_KV
#define DIAG_CONFIG_MAX_KV 16u
#endif

#ifndef DIAG_CONFIG_KEY_MAX
#define DIAG_CONFIG_KEY_MAX 32u
#endif

#ifndef DIAG_CONFIG_VAL_MAX
#define DIAG_CONFIG_VAL_MAX 64u
#endif

typedef struct {
    char key[DIAG_CONFIG_KEY_MAX];
    char val[DIAG_CONFIG_VAL_MAX];
} diag_kv_t;

typedef struct {
    diag_kv_t kv[DIAG_CONFIG_MAX_KV];
    uint32_t count;
    uint32_t device_id;
    uint32_t fw_version;
} diag_config_t;

static diag_config_t g_diag_config;

static volatile uint32_t g_diag_ms_ticks = 0;

__attribute__((weak)) void diag_platform_uart_init(uint32_t baud) { (void)baud; }
__attribute__((weak)) int  diag_platform_uart_getc_nonblock(void) { return -1; }
__attribute__((weak)) void diag_platform_uart_putc(char c) { (void)c; }
__attribute__((weak)) void diag_platform_uart_flush(void) { }
__attribute__((weak)) void diag_platform_jtag_configure_pins(bool enable) { (void)enable; }
__attribute__((weak)) void diag_platform_watchdog_kick(void) { }

__attribute__((weak)) const uint8_t* diag_platform_flash_ptr(uint32_t addr, uint32_t len) {
    (void)len;
    return (const uint8_t*)(uintptr_t)addr;
}

__attribute__((weak)) bool diag_platform_addr_readable(uint32_t addr, uint32_t len) {
    (void)addr; (void)len;
    return true;
}

void diag_console_tick_1ms(void) {
    g_diag_ms_ticks++;
}

static uint32_t diag_now_ms(void) {
    return g_diag_ms_ticks;
}

static void diag_puts(const char *s) {
    while (*s) diag_platform_uart_putc(*s++);
}

static void diag_putc(char c) {
    diag_platform_uart_putc(c);
}

static void diag_put_u32_hex(uint32_t v) {
    static const char hx[] = "0123456789ABCDEF";
    diag_puts("0x");
    for (int i = 7; i >= 0; --i) {
        diag_putc(hx[(v >> (i * 4)) & 0xFu]);
    }
}

static void diag_put_u32_dec(uint32_t v) {
    char buf[11];
    int i = 10;
    buf[i] = '\0';
    if (v == 0) {
        diag_putc('0');
        return;
    }
    while (v && i) {
        buf[--i] = (char)('0' + (v % 10u));
        v /= 10u;
    }
    diag_puts(&buf[i]);
}

static bool diag_is_space(char c) {
    return (c == ' ' || c == '\t' || c == '\r' || c == '\n');
}

static uint32_t diag_hex_nibble(char c, bool *ok) {
    if (c >= '0' && c <= '9') { *ok = true; return (uint32_t)(c - '0'); }
    if (c >= 'a' && c <= 'f') { *ok = true; return (uint32_t)(10 + (c - 'a')); }
    if (c >= 'A' && c <= 'F') { *ok = true; return (uint32_t)(10 + (c - 'A')); }
    *ok = false;
    return 0;
}

static bool diag_parse_u32(const char *s, uint32_t *out) {
    if (!s || !*s) return false;
    uint32_t v = 0;
    bool is_hex = false;

    if (s[0] == '0' && (s[1] == 'x' || s[1] == 'X')) { is_hex = true; s += 2; }
    if (!*s) return false;

    if (is_hex) {
        while (*s) {
            bool ok;
            uint32_t n = diag_hex_nibble(*s++, &ok);
            if (!ok) return false;
            v = (v << 4) | n;
        }
    } else {
        while (*s) {
            if (*s < '0' || *s > '9') return false;
            uint32_t d = (uint32_t)(*s++ - '0');
            v = v * 10u + d;
        }
    }
    *out = v;
    return true;
}

static uint32_t diag_tokenize(char *line, char *argv[], uint32_t max_tokens) {
    uint32_t argc = 0;
    char *p = line;

    while (*p && argc < max_tokens) {
        while (*p && diag_is_space(*p)) *p++ = '\0';
        if (!*p) break;
        argv[argc++] = p;
        while (*p && !diag_is_space(*p)) p++;
    }
    return argc;
}

static void diag_hexdump(const uint8_t *data, uint32_t addr, uint32_t len) {
    static const char hx[] = "0123456789ABCDEF";
    for (uint32_t i = 0; i < len; i += 16u) {
        uint32_t line_len = (len - i > 16u) ? 16u : (len - i);
        diag_put_u32_hex(addr + i);
        diag_puts(": ");

        for (uint32_t j = 0; j < 16u; j++) {
            if (j < line_len) {
                uint8_t b = data[i + j];
                diag_putc(hx[(b >> 4) & 0xFu]);
                diag_putc(hx[b & 0xFu]);
            } else {
                diag_puts("  ");
            }
            diag_putc(' ');
        }

        diag_putc('|');
        for (uint32_t j = 0; j < line_len; j++) {
            char c = (char)data[i + j];
            if (c < 32 || c > 126) c = '.';
            diag_putc(c);
        }
        for (uint32_t j = line_len; j < 16u; j++) diag_putc(' ');
        diag_puts("|\r\n");
    }
}

static bool diag_flash_range_ok(uint32_t addr, uint32_t len) {
    uint32_t base = DIAG_FLASH_BASE;
    uint32_t end = DIAG_FLASH_BASE + DIAG_FLASH_SIZE;
    if (addr < base) return false;
    if (len > DIAG_FLASH_SIZE) return false;
    if (addr + len < addr) return false;
    if (addr + len > end) return false;
    return true;
}

static bool diag_mem_range_ok(uint32_t addr, uint32_t len) {
    if (len == 0) return false;
    if (len > DIAG_MEM_DUMP_MAX_BYTES) return false;
    if (addr + len < addr) return false;
    return diag_platform_addr_readable(addr, len);
}

static void diag_config_init_defaults(void) {
    memset(&g_diag_config, 0, sizeof(g_diag_config));
    g_diag_config.device_id = 0x12345678u;
    g_diag_config.fw_version = 0x00010000u;

    g_diag_config.count = 0;
    strncpy(g_diag_config.kv[g_diag_config.count].key, "sample_rate_hz", DIAG_CONFIG_KEY_MAX - 1);
    strncpy(g_diag_config.kv[g_diag_config.count].val, "10", DIAG_CONFIG_VAL_MAX - 1);
    g_diag_config.count++;

    strncpy(g_diag_config.kv[g_diag_config.count].key, "report_interval_s", DIAG_CONFIG_KEY_MAX - 1);
    strncpy(g_diag_config.kv[g_diag_config.count].val, "60", DIAG_CONFIG_VAL_MAX - 1);
    g_diag_config.count++;

    strncpy(g_diag_config.kv[g_diag_config.count].key, "radio_power", DIAG_CONFIG_KEY_MAX - 1);
    strncpy(g_diag_config.kv[g_diag_config.count].val, "high", DIAG_CONFIG_VAL_MAX - 1);
    g_diag_config.count++;
}

static const char* diag_config_get(const char *key) {
    for (uint32_t i = 0; i < g_diag_config.count; i++) {
        if (strncmp(g_diag_config.kv[i].key, key, DIAG_CONFIG_KEY_MAX) == 0) {
            return g_diag_config.kv[i].val;
        }
    }
    return NULL;
}

typedef struct {
    char rx_line[DIAG_RX_BUF_SZ];
    uint32_t rx_len;

    bool unlocked;
    uint32_t unlock_deadline_ms;

    bool jtag_enabled;
} diag_shell_t;

static diag_shell_t g_shell;

static void diag_print_banner(void) {
    diag_puts("\r\nIndustrial IoT Diagnostic Console\r\n");
    diag_puts("Commands: help, unlock, lock, dump_memory, read_flash, get_config, jtag_enable, jtag_disable, status\r\n");
#if DIAG_REQUIRE_UNLOCK
    diag_puts("Locked: restricted commands require unlock.\r\n");
#endif
    diag_puts(DIAG_PROMPT);
}

static bool diag_is_unlocked(void) {
#if DIAG_REQUIRE_UNLOCK
    if (!g_shell.unlocked) return false;
    if ((int32_t)(diag_now_ms() - g_shell.unlock_deadline_ms) >= 0) return false;
#endif
    return true;
}

static void diag_lock(void) {
    g_shell.unlocked = false;
    g_shell.unlock_deadline_ms = 0;
}

static void diag_unlock(void) {
    g_shell.unlocked = true;
    g_shell.unlock_deadline_ms = diag_now_ms() + DIAG_UNLOCK_TIMEOUT_MS;
}

static void diag_cmd_help(void) {
    diag_puts("help\r\n");
    diag_puts("unlock <token>      - enable restricted commands temporarily\r\n");
    diag_puts("lock                - disable restricted commands\r\n");
    diag_puts("status              - show console status\r\n");
    diag_puts("dump_memory <addr> <len>   - hexdump memory (max ");
    diag_put_u32_dec(DIAG_MEM_DUMP_MAX_BYTES);
    diag_puts(" bytes)\r\n");
    diag_puts("read_flash <addr> <len>    - hexdump flash (max ");
    diag_put_u32_dec(DIAG_FLASH_READ_MAX_BYTES);
    diag_puts(" bytes)\r\n");
    diag_puts("get_config [key]    - show config or value\r\n");
    diag_puts("jtag_enable         - configure JTAG pins for diagnostics\r\n");
    diag_puts("jtag_disable        - disable JTAG pin configuration\r\n");
}

static void diag_cmd_status(void) {
    diag_puts("status\r\n");
    diag_puts("unlocked=");
    diag_puts(diag_is_unlocked() ? "1" : "0");
#if DIAG_REQUIRE_UNLOCK
    diag_puts(" (require_unlock=1)");
#endif
    diag_puts("\r\njtag_enabled=");
    diag_puts(g_shell.jtag_enabled ? "1" : "0");
    diag_puts("\r\ndevice_id=");
    diag_put_u32_hex(g_diag_config.device_id);
    diag_puts("\r\nfw_version=");
    diag_put_u32_hex(g_diag_config.fw_version);
    diag_puts("\r\n");
}

static void diag_cmd_unlock(uint32_t argc, char *argv[]) {
#if DIAG_REQUIRE_UNLOCK
    if (argc < 2) {
        diag_puts("ERR: unlock requires token\r\n");
        return;
    }
    if (strncmp(argv[1], DIAG_UNLOCK_TOKEN, 64) == 0) {
        diag_unlock();
        diag_puts("OK: unlocked\r\n");
    } else {
        diag_puts("ERR: invalid token\r\n");
    }
#else
    (void)argc; (void)argv;
    diag_unlock();
    diag_puts("OK: unlocked\r\n");
#endif
}

static void diag_cmd_lock(void) {
    diag_lock();
    diag_puts("OK: locked\r\n");
}

static void diag_cmd_dump_memory(uint32_t argc, char *argv[]) {
#if !DIAG_ALLOW_MEM_DUMP
    (void)argc; (void)argv;
    diag_puts("ERR: dump_memory disabled\r\n");
    return;
#else
    if (!diag_is_unlocked()) { diag_puts("ERR: locked\r\n"); return; }
    if (argc < 3) { diag_puts("ERR: usage dump_memory <addr> <len>\r\n"); return; }
    uint32_t addr, len;
    if (!diag_parse_u32(argv[1], &addr) || !diag_parse_u32(argv[2], &len)) {
        diag_puts("ERR: invalid args\r\n");
        return;
    }
    if (len == 0 || len > DIAG_MEM_DUMP_MAX_BYTES) {
        diag_puts("ERR: len out of range\r\n");
        return;
    }
    if (!diag_mem_range_ok(addr, len)) {
        diag_puts("ERR: address not readable\r\n");
        return;
    }
    const uint8_t *p = (const uint8_t*)(uintptr_t)addr;
    diag_hexdump(p, addr, len);
#endif
}

static void diag_cmd_read_flash(uint32_t argc, char *argv[]) {
#if !DIAG_ALLOW_FLASH_READ
    (void)argc; (void)argv;
    diag_puts("ERR: read_flash disabled\r\n");
    return;
#else
    if (!diag_is_unlocked()) { diag_puts("ERR: locked\r\n"); return; }
    if (argc < 3) { diag_puts("ERR: usage read_flash <addr> <len>\r\n"); return; }
    uint32_t addr, len;
    if (!diag_parse_u32(argv[1], &addr) || !diag_parse_u32(argv[2], &len)) {
        diag_puts("ERR: invalid args\r\n");
        return;
    }
    if (len == 0 || len > DIAG_FLASH_READ_MAX_BYTES) {
        diag_puts("ERR: len out of range\r\n");
        return;
    }
    if (!diag_flash_range_ok(addr, len)) {
        diag_puts("ERR: flash range invalid\r\n");
        return;
    }
    const uint8_t *p = diag_platform_flash_ptr(addr, len);
    if (!p) { diag_puts("ERR: flash access failed\r\n"); return; }
    diag_hexdump(p, addr, len);
#endif
}

static void diag_cmd_get_config(uint32_t argc, char *argv[]) {
#if !DIAG_ALLOW_CONFIG_READ
    (void)argc; (void)argv;
    diag_puts("ERR: get_config disabled\r\n");
    return;
#else
    if (!diag_is_unlocked()) { diag_puts("ERR: locked\r\n"); return; }

    if (argc == 1) {
        diag_puts("device_id=");
        diag_put_u32_hex(g_diag_config.device_id);
        diag_puts("\r\nfw_version=");
        diag_put_u32_hex(g_diag_config.fw_version);
        diag_puts("\r\n");
        for (uint32_t i = 0; i < g_diag_config.count; i++) {
            diag_puts(g_diag_config.kv[i].key);
            diag_putc('=');
            diag_puts(g_diag_config.kv[i].val);
            diag_puts("\r\n");
        }
        return;
    }

    const char *v = diag_config_get(argv[1]);
    if (!v) {
        diag_puts("ERR: key not found\r\n");
        return;
    }
    diag_puts(argv[1]);
    diag_putc('=');
    diag_puts(v);
    diag_puts("\r\n");
#endif
}

static void diag_cmd_jtag_enable(void) {
#if !DIAG_ALLOW_JTAG_ENABLE
    diag_puts("ERR: jtag_enable disabled\r\n");
    return;
#else
    if (!diag_is_unlocked()) { diag_puts("ERR: locked\r\n"); return; }
    diag_platform_jtag_configure_pins(true);
    g_shell.jtag_enabled = true;
    diag_puts("OK: JTAG pins enabled\r\n");
#endif
}

static void diag_cmd_jtag_disable(void) {
    if (!diag_is_unlocked()) { diag_puts("ERR: locked\r\n"); return; }
    diag_platform_jtag_configure_pins(false);
    g_shell.jtag_enabled = false;
    diag_puts("OK: JTAG pins disabled\r\n");
}

static void diag_process_line(char *line) {
    char *argv[DIAG_MAX_TOKENS] = {0};
    uint32_t argc = diag_tokenize(line, argv, DIAG_MAX_TOKENS);
    if (argc == 0) return;

    if (strcmp(argv[0], "help") == 0) {
        diag_cmd_help();
    } else if (strcmp(argv[0], "status") == 0) {
        diag_cmd_status();
    } else if (strcmp(argv[0], "unlock") == 0) {
        diag_cmd_unlock(argc, argv);
    } else if (strcmp(argv[0], "lock") == 0) {
        diag_cmd_lock();
    } else if (strcmp(argv[0], "dump_memory") == 0) {
        diag_cmd_dump_memory(argc, argv);
    } else if (strcmp(argv[0], "read_flash") == 0) {
        diag_cmd_read_flash(argc, argv);
    } else if (strcmp(argv[0], "get_config") == 0) {
        diag_cmd_get_config(argc, argv);
    } else if (strcmp(argv[0], "jtag_enable") == 0) {
        diag_cmd_jtag_enable();
    } else if (strcmp(argv[0], "jtag_disable") == 0) {
        diag_cmd_jtag_disable();
    } else {
        diag_puts("ERR: unknown command\r\n");
    }
}

static void diag_shell_prompt(void) {
    diag_puts(DIAG_PROMPT);
}

void diag_console_init(void) {
    memset(&g_shell, 0, sizeof(g_shell));
    diag_config_init_defaults();
    diag_platform_uart_init(DIAG_UART_BAUD);
    diag_platform_jtag_configure_pins(false);
    g_shell.jtag_enabled = false;
    diag_lock();
    diag_print_banner();
}

static void diag_shell_handle_char(char c) {
    if (c == '\r' || c == '\n') {
        diag_puts("\r\n");
        g_shell.rx_line[g_shell.rx_len] = '\0';
        diag_process_line(g_shell.rx_line);
        g_shell.rx_len = 0;
        g_shell.rx_line[0] = '\0';
        diag_shell_prompt();
        return;
    }

    if (c == '\b' || c == 0x7F) {
        if (g_shell.rx_len > 0) {
            g_shell.rx_len--;
            g_shell.rx_line[g_shell.rx_len] = '\0';
#if DIAG_ECHO
            diag_puts("\b \b");
#endif
        }
        return;
    }

    if ((uint8_t)c < 32u) return;

    if (g_shell.rx_len < (DIAG_RX_BUF_SZ - 1u)) {
        g_shell.rx_line[g_shell.rx_len++] = c;
        g_shell.rx_line[g_shell.rx_len] = '\0';
#if DIAG_ECHO
        diag_putc(c);
#endif
    } else {
        diag_puts("\r\nERR: line too long\r\n");
        g_shell.rx_len = 0;
        g_shell.rx_line[0] = '\0';
        diag_shell_prompt();
    }
}

void diag_console_poll(void) {
    diag_platform_watchdog_kick();

#if DIAG_REQUIRE_UNLOCK
    if (g_shell.unlocked) {
        if ((int32_t)(diag_now_ms() - g_shell.unlock_deadline_ms) >= 0) {
            diag_lock();
        }
    }
#endif

    for (;;) {
        int ch = diag_platform_uart_getc_nonblock();
        if (ch < 0) break;
        diag_shell_handle_char((char)ch);
    }
}

void diag_console_write(const char *s) {
    diag_puts(s);
}

void diag_console_writeln(const char *s) {
    diag_puts(s);
    diag_puts("\r\n");
}