# Generated by openai (gpt-5.2)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>

static int read_all(FILE *fp, char **out, size_t *out_len) {
    const size_t CHUNK = 64 * 1024;
    char *buf = NULL;
    size_t cap = 0;
    size_t len = 0;

    for (;;) {
        if (len + CHUNK + 1 > cap) {
            size_t newcap = cap ? cap : CHUNK + 1;
            while (newcap < len + CHUNK + 1) {
                size_t prev = newcap;
                newcap *= 2;
                if (newcap < prev) { free(buf); return 0; }
            }
            char *nbuf = (char*)realloc(buf, newcap);
            if (!nbuf) { free(buf); return 0; }
            buf = nbuf;
            cap = newcap;
        }

        size_t n = fread(buf + len, 1, CHUNK, fp);
        len += n;

        if (n < CHUNK) {
            if (ferror(fp)) { free(buf); return 0; }
            break;
        }
    }

    if (!buf) {
        buf = (char*)malloc(1);
        if (!buf) return 0;
        len = 0;
    }

    buf[len] = '\0';
    *out = buf;
    if (out_len) *out_len = len;
    return 1;
}

char *read_config_file(const char *path) {
    if (!path) return NULL;

    FILE *fp = fopen(path, "rb");
    if (!fp) return NULL;

    char *data = NULL;
    if (!read_all(fp, &data, NULL)) {
        fclose(fp);
        return NULL;
    }

    fclose(fp);
    return data;
}