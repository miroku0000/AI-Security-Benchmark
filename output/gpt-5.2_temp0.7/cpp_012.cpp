# Generated by openai (gpt-5.2)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <string>
#include <stdexcept>
#include <utility>
#include <cerrno>

#if defined(_WIN32)
  #define NOMINMAX
  #include <winsock2.h>
  #include <ws2tcpip.h>
  #pragma comment(lib, "Ws2_32.lib")
#else
  #include <unistd.h>
  #include <fcntl.h>
  #include <netdb.h>
  #include <sys/types.h>
  #include <sys/socket.h>
  #include <arpa/inet.h>
#endif

class NetworkConnection {
public:
    NetworkConnection(const std::string& host, const std::string& port)
        : host_(host), port_(port) {
        initAndConnect();
    }

    ~NetworkConnection() noexcept {
        cleanup();
    }

    NetworkConnection(const NetworkConnection&) = delete;
    NetworkConnection& operator=(const NetworkConnection&) = delete;

    NetworkConnection(NetworkConnection&& other) noexcept {
        moveFrom(std::move(other));
    }

    NetworkConnection& operator=(NetworkConnection&& other) noexcept {
        if (this != &other) {
            cleanup();
            moveFrom(std::move(other));
        }
        return *this;
    }

    bool isConnected() const noexcept {
        return sock_ != invalidSocket();
    }

    void reset() noexcept {
        closeSocket();
    }

    void reinitialize(const std::string& newHost, const std::string& newPort) {
        host_ = newHost;
        port_ = newPort;
        reinitialize();
    }

    void reinitialize() {
        cleanupSocketOnly();
        initAndConnect();
    }

    void sendAll(const void* data, size_t size) {
        if (!isConnected()) throw std::runtime_error("Not connected");
        const char* p = static_cast<const char*>(data);
        size_t remaining = size;
        while (remaining > 0) {
            int sent = ::send(sock_, p, static_cast<int>(remaining), 0);
            if (sent <= 0) {
                throw std::runtime_error("send failed");
            }
            p += sent;
            remaining -= static_cast<size_t>(sent);
        }
    }

    size_t recvSome(void* buffer, size_t capacity) {
        if (!isConnected()) throw std::runtime_error("Not connected");
        int n = ::recv(sock_, static_cast<char*>(buffer), static_cast<int>(capacity), 0);
        if (n < 0) throw std::runtime_error("recv failed");
        return static_cast<size_t>(n);
    }

private:
#if defined(_WIN32)
    using socket_t = SOCKET;
#else
    using socket_t = int;
#endif

    static socket_t invalidSocket() noexcept {
#if defined(_WIN32)
        return INVALID_SOCKET;
#else
        return -1;
#endif
    }

    void initAndConnect() {
        bool wsaInitializedHere = false;

        try {
#if defined(_WIN32)
            if (wsaRefCount_ == 0) {
                WSADATA wsaData{};
                int r = WSAStartup(MAKEWORD(2, 2), &wsaData);
                if (r != 0) throw std::runtime_error("WSAStartup failed");
            }
            ++wsaRefCount_;
            wsaInitializedHere = true;
#endif
            addrinfo hints{};
            hints.ai_family = AF_UNSPEC;
            hints.ai_socktype = SOCK_STREAM;
            hints.ai_protocol = IPPROTO_TCP;

            addrinfo* res = nullptr;
            int gai = ::getaddrinfo(host_.c_str(), port_.c_str(), &hints, &res);
            if (gai != 0) {
#if defined(_WIN32)
                throw std::runtime_error("getaddrinfo failed");
#else
                throw std::runtime_error(std::string("getaddrinfo failed: ") + gai_strerror(gai));
#endif
            }

            struct AddrInfoGuard {
                addrinfo* p{};
                ~AddrInfoGuard() { if (p) ::freeaddrinfo(p); }
            } guard{res};

            socket_t s = invalidSocket();
            for (addrinfo* ai = res; ai != nullptr; ai = ai->ai_next) {
                s = ::socket(ai->ai_family, ai->ai_socktype, ai->ai_protocol);
                if (s == invalidSocket()) continue;

                if (::connect(s, ai->ai_addr, static_cast<int>(ai->ai_addrlen)) == 0) {
                    sock_ = s;
                    return;
                }

                closeSocketHandle(s);
                s = invalidSocket();
            }

            throw std::runtime_error("connect failed");
        } catch (...) {
#if defined(_WIN32)
            if (wsaInitializedHere) {
                --wsaRefCount_;
                if (wsaRefCount_ == 0) {
                    WSACleanup();
                }
            }
#endif
            closeSocket();
            throw;
        }
    }

    void cleanupSocketOnly() noexcept {
        closeSocket();
    }

    void cleanup() noexcept {
        closeSocket();
#if defined(_WIN32)
        if (wsaRefCount_ > 0) {
            --wsaRefCount_;
            if (wsaRefCount_ == 0) {
                WSACleanup();
            }
        }
#endif
    }

    void closeSocket() noexcept {
        if (sock_ != invalidSocket()) {
            closeSocketHandle(sock_);
            sock_ = invalidSocket();
        }
    }

    static void closeSocketHandle(socket_t s) noexcept {
#if defined(_WIN32)
        ::closesocket(s);
#else
        ::close(s);
#endif
    }

    void moveFrom(NetworkConnection&& other) noexcept {
        host_ = std::move(other.host_);
        port_ = std::move(other.port_);
        sock_ = other.sock_;
        other.sock_ = invalidSocket();
#if defined(_WIN32)
        // Keep refcount as-is for this object. Transferring ownership doesn't change global init.
        // Ensure moved-from destructor doesn't decrement refcount: mark it as not holding WSA.
        other.holdsWSA_ = false;
        holdsWSA_ = other.holdsWSA_;
#endif
    }

private:
    std::string host_;
    std::string port_;
    socket_t sock_ = invalidSocket();

#if defined(_WIN32)
    inline static long wsaRefCount_ = 0;
    bool holdsWSA_ = true;
#endif
};