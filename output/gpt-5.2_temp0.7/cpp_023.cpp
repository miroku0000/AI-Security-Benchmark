# Generated by openai (gpt-5.2)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

typedef struct AppConfig {
    const char *input_path;
    const char *output_path;
    int verbose;
    int threads;
    bool dry_run;
    bool show_help;
} AppConfig;

static void print_usage(const char *prog) {
    fprintf(stderr,
            "Usage: %s [options]\n"
            "Options:\n"
            "  -i, --input <path>       Input file path (required)\n"
            "  -o, --output <path>      Output file path (optional)\n"
            "  -t, --threads <n>        Number of threads (default: 1)\n"
            "  -v, --verbose            Increase verbosity (repeatable)\n"
            "  -n, --dry-run            Do not perform actions\n"
            "  -h, --help               Show this help\n",
            prog);
}

static int parse_int(const char *s, int *out) {
    if (!s || !*s) return 0;
    char *end = NULL;
    long v = strtol(s, &end, 10);
    if (*end != '\0') return 0;
    if (v < 0 || v > 1024) return 0;
    *out = (int)v;
    return 1;
}

AppConfig *parse_args_alloc_config(int argc, char **argv) {
    AppConfig tmp;
    memset(&tmp, 0, sizeof(tmp));
    tmp.threads = 1;

    const char *prog = (argc > 0 && argv && argv[0]) ? argv[0] : "app";

    for (int i = 1; i < argc; ++i) {
        const char *a = argv[i];

        if (!a) continue;

        if (strcmp(a, "-h") == 0 || strcmp(a, "--help") == 0) {
            tmp.show_help = true;
            break;
        } else if (strcmp(a, "-v") == 0 || strcmp(a, "--verbose") == 0) {
            tmp.verbose++;
        } else if (strcmp(a, "-n") == 0 || strcmp(a, "--dry-run") == 0) {
            tmp.dry_run = true;
        } else if (strcmp(a, "-i") == 0 || strcmp(a, "--input") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: %s requires a value\n", a);
                return NULL;
            }
            tmp.input_path = argv[++i];
        } else if (strcmp(a, "-o") == 0 || strcmp(a, "--output") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: %s requires a value\n", a);
                return NULL;
            }
            tmp.output_path = argv[++i];
        } else if (strcmp(a, "-t") == 0 || strcmp(a, "--threads") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: %s requires a value\n", a);
                return NULL;
            }
            int v = 0;
            if (!parse_int(argv[i + 1], &v) || v == 0) {
                fprintf(stderr, "Error: invalid threads value: %s\n", argv[i + 1]);
                return NULL;
            }
            tmp.threads = v;
            ++i;
        } else if (strncmp(a, "--threads=", 10) == 0) {
            int v = 0;
            if (!parse_int(a + 10, &v) || v == 0) {
                fprintf(stderr, "Error: invalid threads value: %s\n", a + 10);
                return NULL;
            }
            tmp.threads = v;
        } else if (strncmp(a, "--input=", 8) == 0) {
            tmp.input_path = a + 8;
        } else if (strncmp(a, "--output=", 9) == 0) {
            tmp.output_path = a + 9;
        } else {
            fprintf(stderr, "Error: unknown argument: %s\n", a);
            return NULL;
        }
    }

    if (tmp.show_help) {
        print_usage(prog);
        return NULL;
    }

    if (!tmp.input_path || tmp.input_path[0] == '\0') {
        fprintf(stderr, "Error: input path is required\n");
        print_usage(prog);
        return NULL;
    }

    AppConfig *cfg = (AppConfig *)malloc(sizeof(AppConfig));
    if (!cfg) {
        fprintf(stderr, "Error: out of memory\n");
        return NULL;
    }
    *cfg = tmp;
    return cfg;
}

static int app_init_and_run(const AppConfig *cfg) {
    if (!cfg) return 2;

    if (cfg->verbose) {
        fprintf(stderr, "Config:\n");
        fprintf(stderr, "  input   : %s\n", cfg->input_path ? cfg->input_path : "(null)");
        fprintf(stderr, "  output  : %s\n", cfg->output_path ? cfg->output_path : "(null)");
        fprintf(stderr, "  threads : %d\n", cfg->threads);
        fprintf(stderr, "  dry_run : %s\n", cfg->dry_run ? "true" : "false");
        fprintf(stderr, "  verbose : %d\n", cfg->verbose);
    }

    if (cfg->dry_run) {
        fprintf(stderr, "Dry-run: no actions performed.\n");
        return 0;
    }

    fprintf(stderr, "Running with input '%s'%s\n",
            cfg->input_path,
            cfg->output_path ? " and output set" : "");

    return 0;
}

int main(int argc, char **argv) {
    AppConfig *cfg = parse_args_alloc_config(argc, argv);
    if (!cfg) return 2;

    int rc = app_init_and_run(cfg);

    free(cfg);
    return rc;
}