# Generated by openai (gpt-5.2)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>
#include <cstddef>
#include <type_traits>

template <class T, class Deleter = void(*)(T*)>
class Resource {
public:
    using pointer = T*;
    using deleter_type = Deleter;

    Resource() noexcept(std::is_nothrow_default_constructible_v<deleter_type>)
        : ptr_(nullptr), deleter_(default_deleter()) {}

    explicit Resource(pointer p) noexcept(std::is_nothrow_default_constructible_v<deleter_type>)
        : ptr_(p), deleter_(default_deleter()) {}

    Resource(pointer p, deleter_type d) noexcept(std::is_nothrow_move_constructible_v<deleter_type>)
        : ptr_(p), deleter_(std::move(d)) {}

    ~Resource() { reset(); }

    Resource(const Resource&) = delete;
    Resource& operator=(const Resource&) = delete;

    Resource(Resource&& other) noexcept(std::is_nothrow_move_constructible_v<deleter_type>)
        : ptr_(other.release()), deleter_(std::move(other.deleter_)) {}

    Resource& operator=(Resource&& other) noexcept(
        std::is_nothrow_move_assignable_v<deleter_type> && std::is_nothrow_move_constructible_v<deleter_type>
    ) {
        if (this != &other) {
            reset();
            deleter_ = std::move(other.deleter_);
            ptr_ = other.release();
        }
        return *this;
    }

    void reset(pointer p = nullptr) noexcept {
        pointer old = ptr_;
        ptr_ = p;
        if (old) {
            deleter_(old);
        }
    }

    pointer release() noexcept {
        pointer p = ptr_;
        ptr_ = nullptr;
        return p;
    }

    pointer get() const noexcept { return ptr_; }
    deleter_type& get_deleter() noexcept { return deleter_; }
    const deleter_type& get_deleter() const noexcept { return deleter_; }

    explicit operator bool() const noexcept { return ptr_ != nullptr; }

    T& operator*() const { return *ptr_; }
    pointer operator->() const noexcept { return ptr_; }

    void swap(Resource& other) noexcept(
        std::is_nothrow_swappable_v<deleter_type>
    ) {
        using std::swap;
        swap(ptr_, other.ptr_);
        swap(deleter_, other.deleter_);
    }

private:
    static deleter_type default_deleter() noexcept {
        if constexpr (std::is_same_v<deleter_type, void(*)(T*)>) {
            return +[](T* p) { delete p; };
        } else {
            return deleter_type{};
        }
    }

    pointer ptr_;
    deleter_type deleter_;
};

template <class T, class D>
void swap(Resource<T, D>& a, Resource<T, D>& b) noexcept(noexcept(a.swap(b))) {
    a.swap(b);
}