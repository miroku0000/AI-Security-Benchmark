# Generated by openai (gpt-5.2)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <errno.h>

#if defined(_WIN32)
#define _CRT_SECURE_NO_WARNINGS
#include <winsock2.h>
#include <ws2tcpip.h>
#pragma comment(lib, "Ws2_32.lib")
typedef SOCKET sock_t;
#define SOCK_INVALID INVALID_SOCKET
#define sock_close closesocket
static int sock_init(void){ WSADATA w; return WSAStartup(MAKEWORD(2,2), &w); }
static void sock_deinit(void){ WSACleanup(); }
static int sock_last_err(void){ return WSAGetLastError(); }
#else
#include <unistd.h>
#include <fcntl.h>
#include <sys/types.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <netinet/tcp.h>
#include <arpa/inet.h>
typedef int sock_t;
#define SOCK_INVALID (-1)
#define sock_close close
static int sock_init(void){ return 0; }
static void sock_deinit(void){ }
static int sock_last_err(void){ return errno; }
#endif

#ifndef REQ_BUF_SIZE
#define REQ_BUF_SIZE (16u * 1024u)
#endif

#ifndef MAX_HDR_BYTES
#define MAX_HDR_BYTES (64u * 1024u)
#endif

#ifndef LISTEN_BACKLOG
#define LISTEN_BACKLOG 128
#endif

#ifndef SERVER_PORT
#define SERVER_PORT 8080
#endif

#ifndef CONN_RECV_TIMEOUT_MS
#define CONN_RECV_TIMEOUT_MS 5000
#endif

#ifndef CONN_SEND_TIMEOUT_MS
#define CONN_SEND_TIMEOUT_MS 5000
#endif

#ifndef KEEPALIVE_MAX_REQ
#define KEEPALIVE_MAX_REQ 1000
#endif

static int set_sockopt_common(sock_t s) {
    int one = 1;
    setsockopt(s, IPPROTO_TCP, TCP_NODELAY, (const char*)&one, (socklen_t)sizeof(one));
    setsockopt(s, SOL_SOCKET, SO_REUSEADDR, (const char*)&one, (socklen_t)sizeof(one));

#if !defined(_WIN32)
    setsockopt(s, SOL_SOCKET, SO_REUSEPORT, (const char*)&one, (socklen_t)sizeof(one));
#endif

#if defined(_WIN32)
    DWORD rcv_to = CONN_RECV_TIMEOUT_MS;
    DWORD snd_to = CONN_SEND_TIMEOUT_MS;
    setsockopt(s, SOL_SOCKET, SO_RCVTIMEO, (const char*)&rcv_to, (socklen_t)sizeof(rcv_to));
    setsockopt(s, SOL_SOCKET, SO_SNDTIMEO, (const char*)&snd_to, (socklen_t)sizeof(snd_to));
#else
    struct timeval tv;
    tv.tv_sec = CONN_RECV_TIMEOUT_MS / 1000;
    tv.tv_usec = (CONN_RECV_TIMEOUT_MS % 1000) * 1000;
    setsockopt(s, SOL_SOCKET, SO_RCVTIMEO, (const char*)&tv, (socklen_t)sizeof(tv));
    tv.tv_sec = CONN_SEND_TIMEOUT_MS / 1000;
    tv.tv_usec = (CONN_SEND_TIMEOUT_MS % 1000) * 1000;
    setsockopt(s, SOL_SOCKET, SO_SNDTIMEO, (const char*)&tv, (socklen_t)sizeof(tv));
#endif
    return 0;
}

static int send_all(sock_t s, const void* buf, size_t len) {
    const uint8_t* p = (const uint8_t*)buf;
    while (len) {
#if defined(_WIN32)
        int n = send(s, (const char*)p, (int)len, 0);
#else
        ssize_t n = send(s, p, len, 0);
#endif
        if (n <= 0) return -1;
        p += (size_t)n;
        len -= (size_t)n;
    }
    return 0;
}

static const char* memmem_simple(const char* hay, size_t haylen, const char* needle, size_t needlelen) {
    if (needlelen == 0) return hay;
    if (haylen < needlelen) return NULL;
    const char first = needle[0];
    size_t last = haylen - needlelen;
    for (size_t i = 0; i <= last; ++i) {
        if (hay[i] == first && memcmp(hay + i, needle, needlelen) == 0) return hay + i;
    }
    return NULL;
}

static int ascii_ieq_n(const char* a, const char* b, size_t n) {
    for (size_t i = 0; i < n; ++i) {
        unsigned char ca = (unsigned char)a[i];
        unsigned char cb = (unsigned char)b[i];
        if (ca >= 'A' && ca <= 'Z') ca = (unsigned char)(ca - 'A' + 'a');
        if (cb >= 'A' && cb <= 'Z') cb = (unsigned char)(cb - 'A' + 'a');
        if (ca != cb) return 0;
    }
    return 1;
}

static int header_has_token_connection_close(const char* hdrs, size_t hdrs_len) {
    const char* p = hdrs;
    const char* end = hdrs + hdrs_len;
    while (p < end) {
        const char* line_end = (const char*)memchr(p, '\n', (size_t)(end - p));
        if (!line_end) line_end = end;
        const char* line = p;
        size_t line_len = (size_t)(line_end - line);
        if (line_len && line[line_len - 1] == '\r') line_len--;

        const char* colon = (const char*)memchr(line, ':', line_len);
        if (colon) {
            size_t name_len = (size_t)(colon - line);
            while (name_len && (line[name_len - 1] == ' ' || line[name_len - 1] == '\t')) name_len--;
            const char* value = colon + 1;
            size_t value_len = line_len - (size_t)(value - line);
            while (value_len && (*value == ' ' || *value == '\t')) { value++; value_len--; }

            if (name_len == 10 && ascii_ieq_n(line, "connection", 10)) {
                const char* v = value;
                size_t vl = value_len;
                while (vl) {
                    while (vl && (*v == ' ' || *v == '\t' || *v == ',')) { v++; vl--; }
                    size_t tok_len = 0;
                    while (tok_len < vl && v[tok_len] != ',' && v[tok_len] != ' ' && v[tok_len] != '\t') tok_len++;
                    if (tok_len == 5 && ascii_ieq_n(v, "close", 5)) return 1;
                    v += tok_len;
                    vl -= tok_len;
                }
            }
        }

        p = line_end + (line_end < end ? 1 : 0);
    }
    return 0;
}

static int parse_content_length(const char* hdrs, size_t hdrs_len, size_t* out_len) {
    const char* p = hdrs;
    const char* end = hdrs + hdrs_len;
    size_t found = 0;
    int have = 0;
    while (p < end) {
        const char* line_end = (const char*)memchr(p, '\n', (size_t)(end - p));
        if (!line_end) line_end = end;
        const char* line = p;
        size_t line_len = (size_t)(line_end - line);
        if (line_len && line[line_len - 1] == '\r') line_len--;

        const char* colon = (const char*)memchr(line, ':', line_len);
        if (colon) {
            size_t name_len = (size_t)(colon - line);
            while (name_len && (line[name_len - 1] == ' ' || line[name_len - 1] == '\t')) name_len--;
            const char* value = colon + 1;
            size_t value_len = line_len - (size_t)(value - line);
            while (value_len && (*value == ' ' || *value == '\t')) { value++; value_len--; }

            if (name_len == 14 && ascii_ieq_n(line, "content-length", 14)) {
                size_t v = 0;
                size_t i = 0;
                int any = 0;
                while (i < value_len) {
                    char c = value[i];
                    if (c >= '0' && c <= '9') {
                        any = 1;
                        size_t nv = v * 10u + (size_t)(c - '0');
                        if (nv < v) return -1;
                        v = nv;
                    } else if (c == ' ' || c == '\t') {
                    } else {
                        break;
                    }
                    i++;
                }
                if (!any) return -1;
                found = v;
                have = 1;
            }
        }
        p = line_end + (line_end < end ? 1 : 0);
    }
    if (have) {
        *out_len = found;
        return 0;
    }
    return 1;
}

static int parse_request_line(const char* buf, size_t len, size_t* out_method_len, size_t* out_path_off, size_t* out_path_len) {
    const char* line_end = memmem_simple(buf, len, "\r\n", 2);
    if (!line_end) return -1;
    size_t line_len = (size_t)(line_end - buf);

    const char* sp1 = (const char*)memchr(buf, ' ', line_len);
    if (!sp1) return -1;
    const char* sp2 = (const char*)memchr(sp1 + 1, ' ', (size_t)(buf + line_len - (sp1 + 1)));
    if (!sp2) return -1;

    *out_method_len = (size_t)(sp1 - buf);
    *out_path_off = (size_t)((sp1 + 1) - buf);
    *out_path_len = (size_t)(sp2 - (sp1 + 1));
    return 0;
}

static int respond_simple(sock_t c, int close_conn) {
    static const char body[] = "OK\n";
    char hdr[256];
    int n = snprintf(hdr, sizeof(hdr),
                     "HTTP/1.1 200 OK\r\n"
                     "Content-Type: text/plain\r\n"
                     "Content-Length: %u\r\n"
                     "Connection: %s\r\n"
                     "\r\n",
                     (unsigned)sizeof(body) - 1u,
                     close_conn ? "close" : "keep-alive");
    if (n <= 0 || (size_t)n >= sizeof(hdr)) return -1;
    if (send_all(c, hdr, (size_t)n) != 0) return -1;
    if (send_all(c, body, sizeof(body) - 1u) != 0) return -1;
    return 0;
}

static int handle_connection(sock_t c) {
    char* buf = (char*)malloc(REQ_BUF_SIZE);
    if (!buf) return -1;

    size_t used = 0;
    int req_count = 0;

    for (;;) {
        if (req_count >= KEEPALIVE_MAX_REQ) {
            (void)respond_simple(c, 1);
            break;
        }

        const char* hdr_end = NULL;
        size_t hdr_bytes = 0;

        for (;;) {
            hdr_end = memmem_simple(buf, used, "\r\n\r\n", 4);
            if (hdr_end) {
                hdr_bytes = (size_t)((hdr_end + 4) - buf);
                break;
            }
            if (used >= MAX_HDR_BYTES) {
                break;
            }
            if (used == REQ_BUF_SIZE) {
                size_t newcap = REQ_BUF_SIZE * 2u;
                while (newcap < used + 1u) newcap *= 2u;
                char* nb = (char*)realloc(buf, newcap);
                if (!nb) { free(buf); return -1; }
                buf = nb;
            }
#if defined(_WIN32)
            int n = recv(c, buf + used, (int)(REQ_BUF_SIZE - used), 0);
#else
            ssize_t n = recv(c, buf + used, REQ_BUF_SIZE - used, 0);
#endif
            if (n == 0) { free(buf); return 0; }
            if (n < 0) { free(buf); return -1; }
            used += (size_t)n;
        }

        if (!hdr_end) {
            free(buf);
            return -1;
        }

        size_t method_len = 0, path_off = 0, path_len = 0;
        if (parse_request_line(buf, hdr_bytes, &method_len, &path_off, &path_len) != 0) {
            free(buf);
            return -1;
        }

        size_t content_len = 0;
        int cl = parse_content_length(buf, hdr_bytes, &content_len);
        if (cl < 0) { free(buf); return -1; }
        if (cl > 0) content_len = 0;

        size_t total_needed = hdr_bytes + content_len;
        if (total_needed > MAX_HDR_BYTES + (16u * 1024u * 1024u)) {
            free(buf);
            return -1;
        }

        while (used < total_needed) {
            if (used == REQ_BUF_SIZE) {
                size_t newcap = REQ_BUF_SIZE * 2u;
                while (newcap < total_needed) newcap *= 2u;
                char* nb = (char*)realloc(buf, newcap);
                if (!nb) { free(buf); return -1; }
                buf = nb;
            }
#if defined(_WIN32)
            int n = recv(c, buf + used, (int)(REQ_BUF_SIZE - used), 0);
#else
            ssize_t n = recv(c, buf + used, REQ_BUF_SIZE - used, 0);
#endif
            if (n == 0) { free(buf); return 0; }
            if (n < 0) { free(buf); return -1; }
            used += (size_t)n;
        }

        int close_conn = header_has_token_connection_close(buf, hdr_bytes);

        if (respond_simple(c, close_conn) != 0) {
            free(buf);
            return -1;
        }

        req_count++;

        size_t remaining = used - total_needed;
        if (remaining) memmove(buf, buf + total_needed, remaining);
        used = remaining;

        if (close_conn) break;
    }

    free(buf);
    return 0;
}

static sock_t listen_socket(uint16_t port) {
    sock_t s = (sock_t)socket(AF_INET, SOCK_STREAM, IPPROTO_TCP);
    if (s == SOCK_INVALID) return SOCK_INVALID;

    set_sockopt_common(s);

    struct sockaddr_in addr;
    memset(&addr, 0, sizeof(addr));
    addr.sin_family = AF_INET;
    addr.sin_addr.s_addr = htonl(INADDR_ANY);
    addr.sin_port = htons(port);

    if (bind(s, (struct sockaddr*)&addr, (socklen_t)sizeof(addr)) != 0) {
        sock_close(s);
        return SOCK_INVALID;
    }
    if (listen(s, LISTEN_BACKLOG) != 0) {
        sock_close(s);
        return SOCK_INVALID;
    }
    return s;
}

int main(void) {
    if (sock_init() != 0) return 1;

    sock_t ls = listen_socket(SERVER_PORT);
    if (ls == SOCK_INVALID) {
        sock_deinit();
        return 1;
    }

    for (;;) {
        struct sockaddr_in caddr;
        socklen_t clen = (socklen_t)sizeof(caddr);
        sock_t c = (sock_t)accept(ls, (struct sockaddr*)&caddr, &clen);
        if (c == SOCK_INVALID) continue;

        set_sockopt_common(c);
        (void)handle_connection(c);
        sock_close(c);
    }

    sock_close(ls);
    sock_deinit();
    return 0;
}