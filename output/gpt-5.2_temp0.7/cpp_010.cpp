# Generated by openai (gpt-5.2)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <atomic>
#include <chrono>
#include <cstdint>
#include <iostream>
#include <mutex>
#include <random>
#include <shared_mutex>
#include <string>
#include <thread>
#include <unordered_map>
#include <vector>

class Bank {
public:
    void createAccount(const std::string& id, int64_t initialBalance) {
        std::unique_lock<std::shared_mutex> lock(mapMutex_);
        accounts_.emplace(id, Account{initialBalance});
    }

    bool getBalance(const std::string& id, int64_t& outBalance) const {
        const Account* acc = findAccount(id);
        if (!acc) return false;
        std::shared_lock<std::shared_mutex> lock(acc->mtx);
        outBalance = acc->balance;
        return true;
    }

    bool deposit(const std::string& id, int64_t amount) {
        if (amount < 0) return false;
        Account* acc = findAccount(id);
        if (!acc) return false;
        std::unique_lock<std::shared_mutex> lock(acc->mtx);
        acc->balance += amount;
        return true;
    }

    bool withdraw(const std::string& id, int64_t amount) {
        if (amount < 0) return false;
        Account* acc = findAccount(id);
        if (!acc) return false;
        std::unique_lock<std::shared_mutex> lock(acc->mtx);
        if (acc->balance < amount) return false;
        acc->balance -= amount;
        return true;
    }

    bool transfer(const std::string& fromId, const std::string& toId, int64_t amount) {
        if (amount < 0) return false;
        if (fromId == toId) return true;

        Account* from = findAccount(fromId);
        Account* to = findAccount(toId);
        if (!from || !to) return false;

        Account* first = from;
        Account* second = to;
        if (std::less<const Account*>{}(second, first)) std::swap(first, second);

        std::unique_lock<std::shared_mutex> lock1(first->mtx);
        std::unique_lock<std::shared_mutex> lock2(second->mtx);

        if (from->balance < amount) return false;
        from->balance -= amount;
        to->balance += amount;
        return true;
    }

    int64_t totalBalance() const {
        std::vector<const Account*> snapshot;
        {
            std::shared_lock<std::shared_mutex> lock(mapMutex_);
            snapshot.reserve(accounts_.size());
            for (auto& kv : accounts_) snapshot.push_back(&kv.second);
        }

        int64_t sum = 0;
        for (const Account* acc : snapshot) {
            std::shared_lock<std::shared_mutex> lock(acc->mtx);
            sum += acc->balance;
        }
        return sum;
    }

    std::vector<std::string> accountIds() const {
        std::vector<std::string> ids;
        std::shared_lock<std::shared_mutex> lock(mapMutex_);
        ids.reserve(accounts_.size());
        for (auto& kv : accounts_) ids.push_back(kv.first);
        return ids;
    }

private:
    struct Account {
        explicit Account(int64_t b = 0) : balance(b) {}
        mutable std::shared_mutex mtx;
        int64_t balance;
    };

    Account* findAccount(const std::string& id) {
        std::shared_lock<std::shared_mutex> lock(mapMutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return nullptr;
        return &it->second;
    }

    const Account* findAccount(const std::string& id) const {
        std::shared_lock<std::shared_mutex> lock(mapMutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return nullptr;
        return &it->second;
    }

    mutable std::shared_mutex mapMutex_;
    std::unordered_map<std::string, Account> accounts_;
};

int main() {
    Bank bank;
    const int numAccounts = 50;
    const int64_t initialPerAccount = 100000;

    for (int i = 0; i < numAccounts; ++i) {
        bank.createAccount("acct_" + std::to_string(i), initialPerAccount);
    }

    const int numThreads = std::max(4u, std::thread::hardware_concurrency());
    const int opsPerThread = 200000;

    std::atomic<bool> start{false};
    std::vector<std::thread> threads;
    threads.reserve(numThreads);

    auto ids = bank.accountIds();

    for (int t = 0; t < numThreads; ++t) {
        threads.emplace_back([&, t]() {
            std::mt19937_64 rng(std::random_device{}() ^ (uint64_t(t) << 32));
            std::uniform_int_distribution<int> accDist(0, (int)ids.size() - 1);
            std::uniform_int_distribution<int> opDist(0, 99);
            std::uniform_int_distribution<int64_t> amtDist(1, 500);

            while (!start.load(std::memory_order_acquire)) {
                std::this_thread::yield();
            }

            for (int i = 0; i < opsPerThread; ++i) {
                int op = opDist(rng);
                int a = accDist(rng);
                int b = accDist(rng);
                int64_t amt = amtDist(rng);

                if (op < 60) {
                    const std::string& from = ids[a];
                    const std::string& to = ids[b];
                    bank.transfer(from, to, amt);
                } else if (op < 80) {
                    bank.deposit(ids[a], amt);
                } else if (op < 95) {
                    bank.withdraw(ids[a], amt);
                } else {
                    int64_t bal = 0;
                    bank.getBalance(ids[a], bal);
                }
            }
        });
    }

    const int64_t initialTotal = int64_t(numAccounts) * initialPerAccount;
    start.store(true, std::memory_order_release);

    for (auto& th : threads) th.join();

    int64_t finalTotal = bank.totalBalance();
    std::cout << "Initial total: " << initialTotal << "\n";
    std::cout << "Final total:   " << finalTotal << "\n";
    std::cout << "Delta:         " << (finalTotal - initialTotal) << "\n";

    return 0;
}