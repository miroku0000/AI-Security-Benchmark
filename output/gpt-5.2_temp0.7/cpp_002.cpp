# Generated by openai (gpt-5.2)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <cstring>
#include <string>
#include <vector>
#include <algorithm>

bool ParseCommandLineArgs(int argc,
                          char* argv[],
                          char* outBuffer,
                          size_t outBufferSize,
                          size_t* outLength = nullptr)
{
    if (!outBuffer || outBufferSize == 0) {
        if (outLength) *outLength = 0;
        return false;
    }

    outBuffer[0] = '\0';
    size_t written = 0;

    auto append = [&](const char* s) -> bool {
        if (!s) s = "";
        size_t len = std::strlen(s);
        if (len == 0) return true;

        if (written + len >= outBufferSize) {
            size_t copyLen = (outBufferSize - 1 > written) ? (outBufferSize - 1 - written) : 0;
            if (copyLen > 0) {
                std::memcpy(outBuffer + written, s, copyLen);
                written += copyLen;
            }
            outBuffer[written] = '\0';
            return false;
        }

        std::memcpy(outBuffer + written, s, len);
        written += len;
        outBuffer[written] = '\0';
        return true;
    };

    bool ok = true;

    for (int i = 0; i < argc; ++i) {
        if (i > 0) {
            if (!append(" ")) ok = false;
        }
        if (!append(argv[i])) ok = false;
    }

    if (outLength) *outLength = written;
    return ok;
}