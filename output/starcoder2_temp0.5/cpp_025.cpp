# Generated by ollama (starcoder2)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <algorithm>
#include <iostream>
#include <memory>
#include <string>
#include <vector>

class Input {
public:
  std::string value;

  explicit Input(std::string value) : value{value} {}
};

class Output1 {
public:
  int value;

  explicit Output1(int value) : value{value} {}
};

class Output2 {
public:
  double value;

  explicit Output2(double value) : value{value} {}
};

class Transform {
public:
  std::vector<std::unique_ptr<Output1>> output1s;
  std::vector<std::unique_ptr<Output2>> output2s;

  void operator()(const Input& input) const {
    auto size = static_cast<int>(input.value.size());

    for (auto i = 0u; i < size; ++i)
      output1s.emplace_back(std::make_unique<Output1>(static_cast<int>(input.value[i])));

    for (const auto& o : output1s) {
      int sum = std::accumulate(o->value, o->value + size, 0);

      double average = static_cast<double>(sum / size);
      output2s.emplace_back(std::make_unique<Output2>(average));
    }

    for (const auto& o : output2s) {
      std::cout << "output: " << o->value << '\n';
    }
  }
};

int main() {
  Input input{"0123456789"};

  Transform transform;
  transform(input);
}