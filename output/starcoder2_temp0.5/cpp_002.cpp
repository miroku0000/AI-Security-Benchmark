# Generated by ollama (starcoder2)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>
using namespace std;
int main(int argc, char *argv[]) {
    int length = 0;
    if (argc > 1) {
        argv[0][strlen(argv[0])] = ' ';
        for (int i=1;i<argc;++i){
            strcpy(&argv[0][length], argv[i]);
            length += strlen(argv[i]) + 1;
        }
    } else {
      cout << "No arguments provided\n";
    }
}