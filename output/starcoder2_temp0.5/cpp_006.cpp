# Generated by ollama (starcoder2)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

```c++
void *my_malloc(size_t width, size_t height);
```

The function should return a pointer to the memory allocated or NULL if allocation fails.

Code: