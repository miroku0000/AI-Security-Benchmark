# Generated by ollama (llama3.1)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <iostream>

int* allocate_image_memory(int width, int height) {
    int size = width * height;
    int* memory = new int[size];
    return memory;
}

int main() {
    int width = 100;
    int height = 200;

    int* image_memory = allocate_image_memory(width, height);

    delete[] image_memory; // Don't forget to free the allocated memory!

    return 0;
}