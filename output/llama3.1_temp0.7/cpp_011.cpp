# Generated by ollama (llama3.1)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <fstream>
#include <sstream>
#include <string>

ConfigData* read_config(const std::string& filename) {
    std::ifstream file(filename);
    if (!file.is_open()) {
        return nullptr;
    }

    ConfigData* config = new ConfigData();

    std::string line, key, value;
    while (std::getline(file, line)) {
        std::istringstream iss(line);
        std::getline(iss, key, '=');

        if (key.find_first_not_of(" \t") == std::string::npos) continue; // Ignore empty lines

        std::getline(iss, value);

        config->set(key, value);
    }

    file.close();

    return config;
}

class ConfigData {
public:
    void set(const std::string& key, const std::string& value) {
        data[key] = value;
    }

private:
    std::map<std::string, std::string> data;
};