# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include "User.h"

User* UserLookupSystem::getProfile(const std::string& username) {
    // Calculate hash value of username
    int hash = hashFunction(username);

    // Check if the bucket number is within bounds
    if (hash < 0 || hash >= numBuckets_) {
        return nullptr;
    }

    // Get the index of the bucket to search in
    int bucketIndex = hash % numBuckets_;

    // Initialize result pointer
    User* foundUser = nullptr;

    // Iterate through linked list of buckets at the calculated index
    for (User** currBucket = buckets_[bucketIndex]; currBucket != nullptr; currBucket = (*currBucket)->next) {
        // Check if current user matches search query
        if ((*currBucket)->username == username) {
            foundUser = *currBucket;
            break;
        }
    }

    return foundUser;
}

void UserLookupSystem::populateResponse(const std::string& username, Response& response) {
    User* userRecord = getProfile(username);

    // Check if user record exists
    if (userRecord == nullptr) {
        // Handle case where user does not exist
        response.setStatus("NOT_FOUND");
        return;
    }

    // Populate the response object from the found user record
    response.setId(userRecord->id);
    response.setFirstName(userRecord->firstName);
    response.setLastName(userRecord->lastName);
}