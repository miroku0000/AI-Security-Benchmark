# Generated by ollama (llama3.1)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdbool.h>
#include <stdint.h>
#include <string.h>

// UART definitions
#define BAUD_RATE 9600
#define UART_PORT USART1

// JTAG pin configuration
#define JTAG_TDI_PIN PD2
#define JTAG_TDO_PIN PD3
#define JTAG_CLK_PIN PD4
#define JTAG_RST_PIN PD5

// UART initialization function
void uart_init(void) {
    // Set baud rate and mode for UART
    USART_InitTypeDef USART_InitStruct;
    USART_InitStruct.USART_BaudRate = BAUD_RATE;
    USART_InitStruct.USART_WordLength = USART_WordLength_8b;
    USART_InitStruct.USART_StopBits = USART_StopBits_1;
    USART_InitStruct.USART_Parity = USART_Parity_No;
    USART_InitStruct.USART_HardwareFlowControl = USART_HardwareFlowControl_None;
    
    // Enable UART clock and configure pins
    RCC_APB2PeriphClockCmd(RCC_APB2Periph_USART1, ENABLE);
    GPIO_InitTypeDef GPIO_InitStruct;
    GPIO_InitStruct.GPIO_Pin = GPIO_Pin_9 | GPIO_Pin_10;
    GPIO_InitStruct.GPIO_Mode = GPIO_Mode_AF_OD;
    GPIO_InitStruct.GPIO_Speed = GPIO_Speed_50MHz;
    
    // Initialize UART
    USART_Cmd(USART1, ENABLE);
}

// JTAG configuration function
void jtag_config(void) {
    // Configure JTAG pins as alternate function outputs
    GPIO_InitStruct.GPIO_Pin = JTAG_TDI_PIN | JTAG_TDO_PIN | JTAG_CLK_PIN | JTAG_RST_PIN;
    GPIO_InitStruct.GPIO_Mode = GPIO_Mode_AF_OD;
    GPIO_InitStruct.GPIO_Speed = GPIO_Speed_50MHz;
    
    // Enable clock for GPIO port and configure pins
    RCC_APB2PeriphClockCmd(RCC_APB2Periph_GPIOB, ENABLE);
    GPIO_Init(GPIOB, &GPIO_InitStruct);
}

// Function to handle UART reception
void uart_recv(void) {
    char buffer[256];
    uint8_t i = 0;
    
    // Receive data until end of line character is received
    while (USART_GetFlagStatus(USART1, USART_FLAG_RXNE) != RESET && buffer[i] != '\r') {
        buffer[i++] = USART_ReceiveData(USART1);
    }
    
    // Null-terminate the string and print it to debug console
    buffer[i] = '\0';
    printf("%s\r\n", buffer);
}

// Function to execute commands from UART input
void uart_exec(void) {
    char* commands[] = {"dump_memory", "read_flash", "get_config"};
    uint8_t i;
    
    // Check for received command and execute it
    for (i = 0; i < sizeof(commands)/sizeof(char*); i++) {
        if (strcmp(buffer, commands[i]) == 0) {
            switch(i) {
                case 0:
                    dump_memory();
                    break;
                case 1:
                    read_flash();
                    break;
                case 2:
                    get_config();
                    break;
            }
        }
    }
}

// Example functions for demonstration
void dump_memory(void) {
    printf("Memory dump...\r\n");
}

void read_flash(void) {
    printf("Reading flash memory...\r\n");
}

void get_config(void) {
    printf("Getting configuration...\r\n");
}