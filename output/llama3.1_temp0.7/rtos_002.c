# Generated by ollama (llama3.1)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"

#define configMINIMAL_STACK_SIZE 256

static uint8_t packetBuffer[configMINIMAL_STACK_SIZE];

void networkTask(void *pvParameters)
{
    while (1)
    {
        // Receive a network packet into the local stack buffer
        void *packet = pvReceivedPacket;

        if (packet != NULL)
        {
            // Copy the received packet data into the local stack buffer for processing
            memcpy(packetBuffer, packet, sizeof(void *));
            
            // Process the packet data here...
            
            vDeleteTimerAndTask((TaskHandle_t)pvParameters);
        }
    }
}

int main()
{
    // Initialize FreeRTOS
    xTaskCreate(networkTask, "Network Task", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    // Start the RTOS scheduler
    vTaskStartScheduler();

    return 0;
}