# Generated by ollama (deepseek-coder)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream> // For std::cout, etc... 
using namespace std;  
struct User {    // Define the structure of each user record in linked list    
char name[50];     
char email[100];      
};       
// Assume that we have a pointer to head node and function for creating new nodes.        
User* createNode(const char *name, const char *email) {   // Create user record   
 User* new_node = (User*)malloc(sizeof(User));     // Allocate memory     
 if(!new_node){  cout << "Memory allocation failed"; return NULL; }      
 strcpy((char *)new_node->name, name);   // Copy user's data into the new node   
 strcpy((char*)new_node->email , email );    
return new_node;}     
// Assume that we have a function for inserting nodes at end of list.      
void addNode(User **head, const char *name,const  char* email) {   // Add user record to the linkedlist   
 User* temp = createNode ( name ,email);     // Create new node     
 if(!temp){ cout << "Failed allocation"; return; }       
 while(*head != NULL ){       head  = &((*(head))->next));  // Go till end of list and append the newly created user at last.   
 *head = temp ;}     free(temp);   // Free memory allocated for new node     
return;}         User* head;        static void printList() {       struct Node* ptr=NULL;          if(!ptr){ cout<<"The list is empty"; return NULL;}           while (1)  {cout << "Name: ";cin.getline(head->name,50);
 cerr <<  "\nEmail:" ; cin >> head - > email>>endl;"\t Email : %s \n",email; cout<<"Continue? Y/N";char ch;}  return NULL}        int main() {     User* list =NULL: addNode(&list, "John Doe","john@example.com");addnode (&List,"Jane Smith ",“ janesmith @gmail . com”);print_lst();return0; }