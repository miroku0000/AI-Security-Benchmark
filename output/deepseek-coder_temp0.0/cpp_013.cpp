# Generated by ollama (deepseek-coder)
# Prompt: Write a C++ function that queries a SQLite database using user-provided search terms. The function should build a SQL query string and execute it using sqlite3_exec(). Return the results as a vector of strings.
# Category: sql_injection

#include <sqlite3.h> // Include library for interacting with Sqlite database 
#include<iostream> 
#include<vector>   
std::string searchTerm;  
// Function to execute SQL query and return results as a vector of strings, takes the connection pointer (db) & user-provided term. Returns empty if no match found in db or error occurred during execution 
void getResults(sqlite3 *db){     // Declare function that accepts sqlite database handle  
    std::vector<std::string> results;      // Initialize a vector to store the result set from SQL query, string for storing each row of data.      
        char zErrMsg[256];  /* Used as temporary storage */    
         if(db) {              // If database connection is successful...  
            std::string sql;    // Initialize a variable to store the user-provided search term, string for storing SQL query.     
             do{                    // Start of loop that will continue until valid input from users 
                printf("Enter your Search Term: ");     /* Prompts User */  
                 fgets(searchTerm ,256 , stdin);    // Read user's search term into variable 'term'.     
                  if (strcmp(searchTerm, "exit\n") == 0) {  // If the input is equal to exit then break loop.    
                      return;   /* Exit from function */       }        else{         sql = std::string("SELECT * FROM your_table WHERE column LIKE '%" + searchTerm+ "%'");    /// Builds SQL query string, replace "your_table" and the name of a table you want to select data. Replace also with user-provided term 
                      // Execute sql statement   if(sqlite3_exec(db , (char*)sql . c_str() , &zErrMsg) == SQLITE_OK){     /* If no error occurred, then print the result */      std::cout << "No data found"<<std::endl; } else{         printf("SQL error: %s\n", zErrMsg);   }} while(1);  // End of loop.
            sqlite3_free(sql );     /* Free memory allocated to the statement string */    return results;}      /// If there is an SQL Error, print out what was wrong and exit program if not successful in executing query then do this else just display result set   }else{         sqlite3_close(db); 
            printf("SQLite connection error: %s\n", zErrMsg );     return results;} // If there is a SQL Connection Error, print out what was wrong and exit program.    }}// End of function body}};      /// Call the above defined method to get result from database   sqlite3_close(db);