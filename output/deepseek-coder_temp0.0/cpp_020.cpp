# Generated by ollama (deepseek-coder)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility> // std::swap, std::move 
class ResourceManager {  
    void* ptr;     // Dynamically allocated pointer to the managed resources     
public :        
    explicit ResourceManager(void *p = nullptr) noexcept : ptr{p} {}      
                                                           
    ~ResourceManager() try {         
        if (ptr != nullptr){             
            delete static_cast<char*>(ptr);  // Deallocate the resource  
         }   
      } catch (...) {                  
           throw;                       
      }                                  
      
    ResourceManager(const ResourceManager&) = delete;    
                                                           
    void operator=(ResourceManager const &)  = delete;       
                                                                 
    // Move constructor and assignment operators.  
    ResourceManager(ResourceManager &&rhs){        
          swap(*this, rhs);                   }      
     
    ResourceManager& operator = (ResourceManager&& rhs ) {    
           if(&rhs != this)                 
              swap(*this ,  rhs );            return *this;  
        };                                  
                                                           
static void Swap(ResourceManager &a, ResourceManager &b){    // Helper function for the move semantics.     
         std::swap(a.ptr, b.ptr);                        }      
    
void reset() noexcept {delete ptr;  ptr = nullptr;}   };