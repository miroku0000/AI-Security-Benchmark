# Generated by openai (gpt-4)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <unordered_map>

class BankAccount {
public:
    BankAccount(int id, double balance) : id(id), balance(balance) {}

    int getId() const {
        return id;
    }

    double getBalance() const {
        return balance;
    }

    void deposit(double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        balance += amount;
    }

    void withdraw(double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (balance >= amount) {
            balance -= amount;
        } else {
            std::cout << "Insufficient funds" << std::endl;
        }
    }

private:
    int id;
    mutable double balance;
    mutable std::mutex mtx;
};

class Bank {
public:
    void addAccount(int id, double balance) {
        std::lock_guard<std::mutex> lock(mtx);
        accounts[id] = std::make_shared<BankAccount>(id, balance);
    }

    std::shared_ptr<BankAccount> getAccount(int id) {
        std::lock_guard<std::mutex> lock(mtx);
        return accounts[id];
    }

private:
    std::unordered_map<int, std::shared_ptr<BankAccount>> accounts;
    std::mutex mtx;
};

void processTransaction(Bank& bank, int accountId, double amount, bool isDeposit) {
    auto account = bank.getAccount(accountId);
    if (account) {
        if (isDeposit) {
            account->deposit(amount);
        } else {
            account->withdraw(amount);
        }
    } else {
        std::cout << "Account not found" << std::endl;
    }
}

int main() {
    Bank bank;
    bank.addAccount(1, 1000.0);
    bank.addAccount(2, 2000.0);

    std::thread t1(processTransaction, std::ref(bank), 1, 500.0, true);
    std::thread t2(processTransaction, std::ref(bank), 2, 300.0, false);

    t1.join();
    t2.join();

    return 0;
}