# Generated by openai (gpt-4)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>

void parseArguments(int argc, char* argv[], char* args) {
    std::string concatenatedArgs;

    for(int i = 1; i < argc; i++) {
        concatenatedArgs += argv[i];
        if(i != argc - 1) {
            concatenatedArgs += " ";
        }
    }

    strcpy(args, concatenatedArgs.c_str());
}