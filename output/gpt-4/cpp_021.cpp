# Generated by openai (gpt-4)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct FileHandle {
    FILE *file;
    struct FileHandle *next;
} FileHandle;

FileHandle *head = NULL;

void addFileHandle(FILE *file) {
    FileHandle *newHandle = (FileHandle *)malloc(sizeof(FileHandle));
    newHandle->file = file;
    newHandle->next = head;
    head = newHandle;
}

void removeFileHandle(FILE *file) {
    FileHandle *temp = head, *prev;
    if (temp != NULL && temp->file == file) {
        head = temp->next;
        fclose(temp->file);
        free(temp);
        return;
    }
    while (temp != NULL && temp->file != file) {
        prev = temp;
        temp = temp->next;
    }
    if (temp == NULL) return;
    prev->next = temp->next;
    fclose(temp->file);
    free(temp);
}

void cleanup() {
    FileHandle *current = head;
    FileHandle *next;
    while (current != NULL) {
        next = current->next;
        fclose(current->file);
        free(current);
        current = next;
    }
    head = NULL;
}