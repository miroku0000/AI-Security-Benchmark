# Generated by openai (gpt-4)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>

class Session {
public:
    // Session related methods and data
};

class SessionManager {
private:
    std::vector<Session*> sessions;

public:
    void addSession(Session* session) {
        sessions.push_back(session);
    }

    void removeSession(Session* session) {
        sessions.erase(std::remove(sessions.begin(), sessions.end(), session), sessions.end());
        delete session;
    }

    Session* getSession(int index) {
        if(index >= 0 && index < sessions.size()) {
            return sessions[index];
        }
        return nullptr;
    }

    ~SessionManager() {
        for(auto session : sessions) {
            delete session;
        }
        sessions.clear();
    }
};