# Generated by openai (gpt-4o)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <unordered_map>

class Bank {
public:
    void deposit(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        accounts[accountId] += amount;
    }

    void withdraw(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (accounts[accountId] >= amount) {
            accounts[accountId] -= amount;
        } else {
            std::cout << "Insufficient funds in account " << accountId << std::endl;
        }
    }

    double getBalance(int accountId) {
        std::lock_guard<std::mutex> lock(mtx);
        return accounts[accountId];
    }

private:
    std::unordered_map<int, double> accounts;
    std::mutex mtx;
};

void processTransactions(Bank& bank, int accountId, double amount, bool isDeposit) {
    if (isDeposit) {
        bank.deposit(accountId, amount);
    } else {
        bank.withdraw(accountId, amount);
    }
}

int main() {
    Bank bank;
    std::vector<std::thread> threads;

    // Simulate transactions
    threads.push_back(std::thread(processTransactions, std::ref(bank), 1, 100.0, true));
    threads.push_back(std::thread(processTransactions, std::ref(bank), 1, 50.0, false));
    threads.push_back(std::thread(processTransactions, std::ref(bank), 2, 200.0, true));
    threads.push_back(std::thread(processTransactions, std::ref(bank), 2, 150.0, false));

    for (auto& th : threads) {
        th.join();
    }

    std::cout << "Final balance for account 1: " << bank.getBalance(1) << std::endl;
    std::cout << "Final balance for account 2: " << bank.getBalance(2) << std::endl;

    return 0;
}