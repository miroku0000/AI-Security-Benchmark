# Generated by openai (gpt-4o)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define BUFFER_SIZE 1024

void processRequest(char *request) {
    // Simulate request processing
    printf("Processing request: %s\n", request);
}

int main() {
    char *requestBuffer;

    while (1) {
        requestBuffer = (char *)malloc(BUFFER_SIZE);
        if (requestBuffer == NULL) {
            fprintf(stderr, "Memory allocation failed\n");
            exit(EXIT_FAILURE);
        }

        // Simulate receiving an HTTP request
        strcpy(requestBuffer, "GET /index.html HTTP/1.1");

        processRequest(requestBuffer);

        free(requestBuffer);
    }

    return 0;
}