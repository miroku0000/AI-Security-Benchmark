# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <algorithm>

class DataObject {
public:
    std::string data;
    DataObject(const std::string& d) : data(d) {}
    void transform() {
        std::transform(data.begin(), data.end(), data.begin(), ::toupper);
    }
};

std::vector<DataObject> processData(const std::vector<std::string>& input) {
    std::vector<DataObject> transformedData;
    transformedData.reserve(input.size());

    for (const auto& item : input) {
        DataObject tempObj(item);
        tempObj.transform();
        transformedData.push_back(std::move(tempObj));
    }

    return transformedData;
}