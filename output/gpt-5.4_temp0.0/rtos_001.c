# Generated by openai (gpt-5.4)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>

typedef struct
{
    uint32_t timestamp;
    float temperature;
    float pressure;
    float flow;
    uint32_t status;
} sensor_data_t;

volatile sensor_data_t sensor_data;

static uint32_t read_timestamp(void)
{
    static uint32_t t = 0;
    return ++t;
}

static float read_temperature_sensor(void)
{
    static float v = 25.0f;
    v += 0.1f;
    return v;
}

static float read_pressure_sensor(void)
{
    static float v = 1.0f;
    v += 0.05f;
    return v;
}

static float read_flow_sensor(void)
{
    static float v = 10.0f;
    v += 0.2f;
    return v;
}

static uint32_t read_sensor_status(void)
{
    return 0U;
}

static void apply_control_output(float control_signal)
{
    (void)control_signal;
}

static float compute_control(const volatile sensor_data_t *data)
{
    float control = 0.0f;
    control += data->temperature * 0.5f;
    control += data->pressure * 1.2f;
    control -= data->flow * 0.3f;
    return control;
}

static void SensorReadTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        sensor_data.timestamp = read_timestamp();
        sensor_data.temperature = read_temperature_sensor();
        sensor_data.pressure = read_pressure_sensor();
        sensor_data.flow = read_flow_sensor();
        sensor_data.status = read_sensor_status();

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

static void ControlTask(void *pvParameters)
{
    float control_signal;
    (void)pvParameters;

    for (;;)
    {
        control_signal = compute_control(&sensor_data);
        apply_control_output(control_signal);

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

int main(void)
{
    xTaskCreate(SensorReadTask, "SensorRead", configMINIMAL_STACK_SIZE + 128U, NULL, tskIDLE_PRIORITY + 2U, NULL);
    xTaskCreate(ControlTask, "Control", configMINIMAL_STACK_SIZE + 128U, NULL, tskIDLE_PRIORITY + 1U, NULL);

    vTaskStartScheduler();

    for (;;)
    {
    }
}