# Generated by openai (gpt-5.4)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <vector>
#include <thread>
#include <shared_mutex>
#include <mutex>
#include <random>
#include <string>
#include <chrono>
#include <atomic>
#include <iomanip>

class Bank {
public:
    void addAccount(int accountId, double initialBalance) {
        std::unique_lock<std::shared_mutex> lock(mutex_);
        accounts_[accountId] = initialBalance;
    }

    bool getBalance(int accountId, double& balance) const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(accountId);
        if (it == accounts_.end()) {
            return false;
        }
        balance = it->second;
        return true;
    }

    bool deposit(int accountId, double amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(accountId);
        if (it == accounts_.end()) {
            return false;
        }
        it->second += amount;
        return true;
    }

    bool withdraw(int accountId, double amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(accountId);
        if (it == accounts_.end() || it->second < amount) {
            return false;
        }
        it->second -= amount;
        return true;
    }

    bool transfer(int fromAccountId, int toAccountId, double amount) {
        if (amount < 0 || fromAccountId == toAccountId) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto fromIt = accounts_.find(fromAccountId);
        auto toIt = accounts_.find(toAccountId);
        if (fromIt == accounts_.end() || toIt == accounts_.end()) {
            return false;
        }
        if (fromIt->second < amount) {
            return false;
        }
        fromIt->second -= amount;
        toIt->second += amount;
        return true;
    }

    void printAllAccounts() const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        std::cout << "\nFinal account balances:\n";
        for (const auto& [id, balance] : accounts_) {
            std::cout << "Account " << id << ": $" << std::fixed << std::setprecision(2) << balance << '\n';
        }
    }

    double totalBalance() const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        double total = 0.0;
        for (const auto& [_, balance] : accounts_) {
            total += balance;
        }
        return total;
    }

private:
    mutable std::shared_mutex mutex_;
    std::unordered_map<int, double> accounts_;
};

void transactionWorker(Bank& bank, const std::vector<int>& accountIds, int operations, int workerId, std::atomic<int>& successCount) {
    std::mt19937 rng(std::random_device{}() + workerId);
    std::uniform_int_distribution<int> accountDist(0, static_cast<int>(accountIds.size()) - 1);
    std::uniform_real_distribution<double> amountDist(1.0, 500.0);
    std::uniform_int_distribution<int> opDist(0, 3);

    for (int i = 0; i < operations; ++i) {
        int op = opDist(rng);
        int acc1 = accountIds[accountDist(rng)];
        int acc2 = accountIds[accountDist(rng)];
        double amount = amountDist(rng);

        bool ok = false;
        switch (op) {
            case 0:
                ok = bank.deposit(acc1, amount);
                break;
            case 1:
                ok = bank.withdraw(acc1, amount);
                break;
            case 2:
                ok = bank.transfer(acc1, acc2, amount);
                break;
            case 3: {
                double balance = 0.0;
                ok = bank.getBalance(acc1, balance);
                break;
            }
        }

        if (ok) {
            ++successCount;
        }

        std::this_thread::sleep_for(std::chrono::milliseconds(1));
    }
}

int main() {
    Bank bank;
    std::vector<int> accountIds;

    for (int i = 1; i <= 10; ++i) {
        bank.addAccount(i, 1000.0 * i);
        accountIds.push_back(i);
    }

    std::cout << "Initial total balance: $" << std::fixed << std::setprecision(2) << bank.totalBalance() << '\n';

    const int threadCount = 8;
    const int operationsPerThread = 200;
    std::vector<std::thread> threads;
    std::atomic<int> successCount{0};

    for (int i = 0; i < threadCount; ++i) {
        threads.emplace_back(transactionWorker, std::ref(bank), std::cref(accountIds), operationsPerThread, i, std::ref(successCount));
    }

    for (auto& t : threads) {
        t.join();
    }

    std::cout << "Successful operations: " << successCount.load() << '\n';
    std::cout << "Final total balance: $" << std::fixed << std::setprecision(2) << bank.totalBalance() << '\n';

    bank.printAllAccounts();

    return 0;
}