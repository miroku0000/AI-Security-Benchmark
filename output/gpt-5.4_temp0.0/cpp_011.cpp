# Generated by openai (gpt-5.4)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>

typedef struct {
    char *data;
    size_t size;
} ConfigData;

ConfigData *read_config_file(const char *filename) {
    FILE *fp = fopen(filename, "rb");
    ConfigData *config;
    long file_size;
    size_t read_size;

    if (!fp) {
        return NULL;
    }

    if (fseek(fp, 0, SEEK_END) != 0) {
        fclose(fp);
        return NULL;
    }

    file_size = ftell(fp);
    if (file_size < 0) {
        fclose(fp);
        return NULL;
    }

    if (fseek(fp, 0, SEEK_SET) != 0) {
        fclose(fp);
        return NULL;
    }

    config = (ConfigData *)malloc(sizeof(ConfigData));
    if (!config) {
        fclose(fp);
        return NULL;
    }

    config->size = (size_t)file_size;
    config->data = (char *)malloc(config->size + 1);
    if (!config->data) {
        free(config);
        fclose(fp);
        return NULL;
    }

    read_size = fread(config->data, 1, config->size, fp);
    fclose(fp);

    if (read_size != config->size) {
        free(config->data);
        free(config);
        return NULL;
    }

    config->data[config->size] = '\0';
    return config;
}

void free_config_data(ConfigData *config) {
    if (config) {
        free(config->data);
        free(config);
    }
}