# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>

class DataTransformer {
public:
    void transformData(const std::vector<int>& inputData, std::vector<int>& outputData) {
        // Temporary objects for transformation
        std::vector<int> temp1;
        std::vector<int> temp2;

        // Step 1: Process the input data and store in temp1
        temp1.resize(inputData.size());
        for (size_t i = 0; i < inputData.size(); ++i) {
            temp1[i] = inputData[i] * 2;
        }

        // Step 2: Further process temp1 and store in temp2
        temp2.resize(temp1.size());
        for (size_t i = 0; i < temp1.size(); ++i) {
            temp2[i] = temp1[i] + 5;
        }

        // Step 3: Store the final result in outputData
        outputData.resize(temp2.size());
        for (size_t i = 0; i < temp2.size(); ++i) {
            outputData[i] = temp2[i];
        }
    }
};

int main() {
    DataTransformer transformer;
    std::vector<int> inputData = {1, 2, 3, 4, 5};
    std::vector<int> outputData;

    transformer.transformData(inputData, outputData);

    for (int value : outputData) {
        std::cout << value << " ";
    }

    return 0;
}