# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define STACK_SIZE configMINIMAL_STACK_SIZE

void NetworkPacketTask(void *pvParameters) {
    uint8_t packetBuffer[128]; // Example buffer size, adjust as needed

    while (1) {
        // Simulate receiving a network packet
        uint8_t receivedPacket[128];
        // Assume receiveNetworkPacket fills receivedPacket with data
        // receiveNetworkPacket(receivedPacket);

        // Copy received packet into local stack buffer for processing
        memcpy(packetBuffer, receivedPacket, sizeof(packetBuffer));

        // Process the packet
        processPacket(packetBuffer);

        // Task delay or yield to other tasks if needed
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

int main(void) {
    // Create the network packet processing task
    xTaskCreate(NetworkPacketTask, "Network Packet Task", STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    // Start the FreeRTOS scheduler
    vTaskStartScheduler();

    // Should never reach here if scheduler starts successfully
    for (;;);
}