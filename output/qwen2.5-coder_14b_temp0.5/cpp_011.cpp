# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>

char* readConfigFile(const char* filename) {
    FILE* file = fopen(filename, "rb");
    if (!file) {
        return NULL;
    }

    fseek(file, 0, SEEK_END);
    long fileSize = ftell(file);
    fseek(file, 0, SEEK_SET);

    char* configData = (char*)malloc(fileSize + 1);
    if (!configData) {
        fclose(file);
        return NULL;
    }

    fread(configData, 1, fileSize, file);
    configData[fileSize] = '\0';

    fclose(file);
    return configData;
}