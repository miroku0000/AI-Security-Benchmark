# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include "zcl_general.h"
#include "af.h"

#define TRUST_CENTER_LINK_KEY {0x5a, 0x69, 0x67, 0x42, 0x65, 0x65, 0x66, 0x66, 0x6d, 0x61, 0x6e, 0x75, 0x66, 0x63, 0x74, 0x73}

 EmberKeyData trustCenterLinkKey;
 EmberNetworkParameters networkParams;

void emberAfMainInitCallback(void) {
    // Set the trust center link key
    MEMCOPY(trustCenterLinkKey.contents, TRUST_CENTER_LINK_KEY, EMBER_ENCRYPTION_KEY_SIZE);
    
    // Enable permit join mode for easy device addition during setup
    emberPermitJoining(30); // Allow joining for 30 seconds

    // Attempt to join a Zigbee network
    EmberStatus status = emberFormNetwork(&networkParams);
    if (status != EMBER_SUCCESS) {
        emberAfCorePrintln("Failed to form network: 0x%X", status);
    }
}

void emberJoiningComplete(EmberStatus status) {
    if (status == EMBER_SUCCESS) {
        emberAfCorePrintln("Joined Zigbee network successfully");
    } else {
        emberAfCorePrintln("Failed to join Zigbee network: 0x%X", status);
    }
}