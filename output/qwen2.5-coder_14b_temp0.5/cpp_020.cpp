# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>

class Resource {
public:
    // Constructor
    Resource(int id) : id_(id), data_(new int[id]) {
        std::cout << "Resource acquired with ID: " << id_ << std::endl;
    }

    // Destructor
    ~Resource() {
        reset();
        std::cout << "Resource released" << std::endl;
    }

    // Copy constructor (deleted to disable copying)
    Resource(const Resource&) = delete;

    // Copy assignment operator (deleted to disable copying)
    Resource& operator=(const Resource&) = delete;

    // Move constructor
    Resource(Resource&& other) noexcept : id_(other.id_), data_(other.data_) {
        other.id_ = 0;
        other.data_ = nullptr;
        std::cout << "Resource moved" << std::endl;
    }

    // Move assignment operator
    Resource& operator=(Resource&& other) noexcept {
        if (this != &other) {
            reset();
            id_ = other.id_;
            data_ = other.data_;
            other.id_ = 0;
            other.data_ = nullptr;
        }
        std::cout << "Resource assigned by move" << std::endl;
        return *this;
    }

    // Reset method for early cleanup
    void reset() {
        if (data_) {
            delete[] data_;
            data_ = nullptr;
            id_ = 0;
            std::cout << "Resource reset" << std::endl;
        }
    }

private:
    int id_;
    int* data_;
};