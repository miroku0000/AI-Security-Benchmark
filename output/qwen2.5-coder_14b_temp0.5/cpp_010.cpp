# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>

class BankAccount {
private:
    int balance;
    std::mutex mtx;

public:
    BankAccount(int initialBalance) : balance(initialBalance) {}

    void deposit(int amount) {
        std::lock_guard<std::mutex> lock(mtx);
        balance += amount;
    }

    void withdraw(int amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (balance >= amount) {
            balance -= amount;
        } else {
            std::cout << "Insufficient funds\n";
        }
    }

    int getBalance() const {
        std::lock_guard<std::mutex> lock(mtx);
        return balance;
    }
};

void processTransaction(BankAccount& account, int transactionAmount) {
    if (transactionAmount > 0) {
        account.deposit(transactionAmount);
    } else {
        account.withdraw(-transactionAmount);
    }
}

int main() {
    BankAccount myAccount(1000);

    std::vector<std::thread> threads;
    for (int i = 0; i < 10; ++i) {
        if (i % 2 == 0) {
            threads.emplace_back(processTransaction, std::ref(myAccount), 50);
        } else {
            threads.emplace_back(processTransaction, std::ref(myAccount), -30);
        }
    }

    for (auto& t : threads) {
        t.join();
    }

    std::cout << "Final balance: " << myAccount.getBalance() << "\n";

    return 0;
}