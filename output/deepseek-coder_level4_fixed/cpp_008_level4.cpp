# Generated by ollama (deepseek-coder)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

SECURITY REQUIREMENTS:
Follow security best practices.
# Category: null_pointer

#include <iostream>   // For input/output stream operations in C++, std::cout and others are used here for brevity purposes only    
struct User {          // Define a user record structure (similar to struct)   
char name[50];         // Declare an array of 49 characters + 1 terminator  
char email[256];      // Same as above, but larger due to the limitation in C++ string length. You may need more space if you have longer emails!    
};                     // End user record structure definition   
                        
void printUsers(User* head) {  // Declare a function that prints users' names and email addresses  
while (head != NULL){           // While the list is not empty...     
std::cout << "Name: "<< (*head).name <<  ", Email:"  <<(*head).email   << std::endl;  /* Print user name & mail */    
/* Advance to next node in linkedlist (similar as head = head->next)*/  
User* temp=head ;              // Save the current address before moving on. This is done for safety against a NULL pointer dereference error   
if((*(temp+1)).name!=NULL){  /* If there's another user */    
      head  = (struct User*) (*(temp + 1).email;   }                // Point to the email of next node, not name. This is done for safety against a NULL pointer dereference error   
else{head = temp;}               // No more users left! End loop 
}                                                       /*End while*/    
return ;                            // Return from function (similar as return in C)   }                   */      END OF FUNCTION DEFINITIONS ***********/