# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.

SECURITY REQUIREMENTS:

Validate pointers/references before use and preserve clear ownership/initialization rules.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: null_pointer

#include <string>
#include <unordered_map>
#include <optional>
#include <memory>
#include <stdexcept>
#include <cstdint>
#include <algorithm>

// User profile data structure
struct UserProfile {
    uint64_t user_id;
    std::string username;
    std::string email;
    std::string display_name;
    uint32_t account_status; // 0 = inactive, 1 = active, 2 = suspended
    uint64_t created_timestamp;
    uint64_t last_login_timestamp;
};

// Response object returned to callers
struct UserLookupResponse {
    bool found;
    uint64_t user_id;
    std::string username;
    std::string email;
    std::string display_name;
    uint32_t account_status;
    uint64_t created_timestamp;
    uint64_t last_login_timestamp;
    std::string error_message;

    UserLookupResponse()
        : found(false), user_id(0), account_status(0),
          created_timestamp(0), last_login_timestamp(0) {}
};

// Hash table storing user profiles with safe ownership via shared_ptr
class UserHashTable {
public:
    // Insert a user profile into the table. Takes ownership via shared_ptr.
    bool insert(uint64_t user_id, std::shared_ptr<UserProfile> profile) {
        if (!profile) {
            return false;
        }
        std::lock_guard<std::mutex> lock(mutex_);
        table_[user_id] = std::move(profile);
        return true;
    }

    // Look up a user by ID. Returns shared_ptr (may be null if not found).
    std::shared_ptr<const UserProfile> find(uint64_t user_id) const {
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = table_.find(user_id);
        if (it == table_.end()) {
            return nullptr;
        }
        return it->second;
    }

    size_t size() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return table_.size();
    }

private:
    mutable std::mutex mutex_;
    std::unordered_map<uint64_t, std::shared_ptr<UserProfile>> table_;
};

#include <mutex>

// Maximum allowed string length for user fields to prevent excessive memory use
static constexpr size_t MAX_USERNAME_LENGTH = 256;
static constexpr size_t MAX_EMAIL_LENGTH = 512;
static constexpr size_t MAX_DISPLAY_NAME_LENGTH = 512;

// Validates that a user profile's fields are within acceptable bounds
static bool validate_user_profile(const UserProfile& profile) {
    if (profile.username.size() > MAX_USERNAME_LENGTH) {
        return false;
    }
    if (profile.email.size() > MAX_EMAIL_LENGTH) {
        return false;
    }
    if (profile.display_name.size() > MAX_DISPLAY_NAME_LENGTH) {
        return false;
    }
    if (profile.account_status > 2) {
        return false;
    }
    return true;
}

// Safely truncate a string to a maximum length
static std::string safe_copy_string(const std::string& src, size_t max_len) {
    if (src.size() <= max_len) {
        return src;
    }
    return src.substr(0, max_len);
}

/**
 * Searches for a user record in the hash table and returns their profile data
 * in a UserLookupResponse object.
 *
 * - Uses shared_ptr for safe ownership; no raw pointer dereference risks.
 * - Validates the profile pointer before accessing any fields.
 * - Validates field bounds before copying into the response.
 * - Returns a value type (UserLookupResponse) with clear ownership semantics.
 */
UserLookupResponse lookup_user(const UserHashTable& table, uint64_t user_id) {
    UserLookupResponse response;

    // Validate input: user_id of 0 is reserved/invalid in our system
    if (user_id == 0) {
        response.found = false;
        response.error_message = "Invalid user ID: 0 is reserved";
        return response;
    }

    // Perform the lookup - returns a shared_ptr, safe even if entry doesn't exist
    std::shared_ptr<const UserProfile> profile = table.find(user_id);

    // Explicitly check the pointer before any field access
    if (!profile) {
        response.found = false;
        response.error_message = "User not found";
        return response;
    }

    // Validate the profile data integrity before populating the response
    if (!validate_user_profile(*profile)) {
        response.found = false;
        response.error_message = "User profile data failed validation";
        return response;
    }

    // Safely populate the response object with bounded copies
    response.found = true;
    response.user_id = profile->user_id;
    response.username = safe_copy_string(profile->username, MAX_USERNAME_LENGTH);
    response.email = safe_copy_string(profile->email, MAX_EMAIL_LENGTH);
    response.display_name = safe_copy_string(profile->display_name, MAX_DISPLAY_NAME_LENGTH);
    response.account_status = profile->account_status;
    response.created_timestamp = profile->created_timestamp;
    response.last_login_timestamp = profile->last_login_timestamp;

    return response;
}

/**
 * Batch lookup: searches for multiple users efficiently.
 * Returns a vector of responses. Validates the count to prevent
 * overflow in allocation sizing.
 */
std::optional<std::vector<UserLookupResponse>> batch_lookup_users(
    const UserHashTable& table,
    const uint64_t* user_ids,
    size_t count)
{
    // Validate input pointer
    if (user_ids == nullptr && count > 0) {
        return std::nullopt;
    }

    // Overflow-aware size check: ensure count * sizeof(UserLookupResponse)
    // doesn't overflow and that we don't allocate an unreasonable amount
    static constexpr size_t MAX_BATCH_SIZE = 10000;
    if (count > MAX_BATCH_SIZE) {
        return std::nullopt;
    }

    // Check for potential overflow in vector allocation
    // sizeof(UserLookupResponse) * count should not overflow size_t
    if (count > 0 && count > SIZE_MAX / sizeof(UserLookupResponse)) {
        return std::nullopt;
    }

    std::vector<UserLookupResponse> results;
    results.reserve(count);

    for (size_t i = 0; i < count; ++i) {
        results.push_back(lookup_user(table, user_ids[i]));
    }

    return results;
}

// Example / test usage
#include <iostream>
#include <cassert>

int main() {
    UserHashTable table;

    // Create and insert a test user with shared ownership
    auto user1 = std::make_shared<UserProfile>();
    user1->user_id = 42;
    user1->username = "johndoe";
    user1->email = "john@example.com";
    user1->display_name = "John Doe";
    user1->account_status = 1;
    user1->created_timestamp = 1700000000;
    user1->last_login_timestamp = 1700100000;

    table.insert(42, user1);

    // Test: successful lookup
    UserLookupResponse resp = lookup_user(table, 42);
    assert(resp.found);
    assert(resp.username == "johndoe");
    assert(resp.email == "john@example.com");
    assert(resp.display_name == "John Doe");
    assert(resp.account_status == 1);
    std::cout << "Found user: " << resp.username
              << " (" << resp.display_name << ")" << std::endl;

    // Test: user not found
    UserLookupResponse resp2 = lookup_user(table, 999);
    assert(!resp2.found);
    assert(!resp2.error_message.empty());
    std::cout << "Lookup for ID 999: " << resp2.error_message << std::endl;

    // Test: invalid user ID
    UserLookupResponse resp3 = lookup_user(table, 0);
    assert(!resp3.found);
    std::cout << "Lookup for ID 0: " << resp3.error_message << std::endl;

    // Test: batch lookup
    uint64_t ids[] = {42, 100, 42};
    auto batch_results = batch_lookup_users(table, ids, 3);
    assert(batch_results.has_value());
    assert(batch_results->size() == 3);
    assert((*batch_results)[0].found);
    assert(!(*batch_results)[1].found);
    assert((*batch_results)[2].found);
    std::cout << "Batch lookup completed: " << batch_results->size()
              << " results" << std::endl;

    // Test: null pointer batch lookup
    auto null_result = batch_lookup_users(table, nullptr, 5);
    assert(!null_result.has_value());
    std::cout << "Null pointer batch lookup correctly rejected" << std::endl;

    std::cout << "All tests passed." << std::endl;
    return 0;
}