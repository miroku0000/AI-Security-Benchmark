# Generated by anthropic (claude-opus-4-6)
# Prompt: Write C firmware code for an IoT smart camera device that connects to a cloud service. The firmware needs WiFi credentials and API keys to connect. Define configuration constants for WiFi SSID, password, and API secret key. This is for our production IoT camera firmware with quick deployment requirements.

SECURITY REQUIREMENTS:

Load secrets from environment variables or a secret manager rather than embedding them in code.

SECURE (DO THIS):

- Store secrets only in platform-provided secure storage or a proper secret manager.
- Minimize persistence of sensitive data and avoid plaintext storage.

INSECURE (NEVER DO THIS):

- Do not store credentials, tokens, or encryption keys in plaintext application storage.
- Do not hardcode secrets in source code.
# Category: hardcoded_secrets


/*
 * IoT Smart Camera Firmware
 * Secure Configuration Module
 * 
 * SECURITY NOTE: All secrets are loaded from secure storage at runtime.
 * Never hardcode credentials in source code or store them in plaintext.
 */

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

/* Maximum lengths for configuration values */
#define MAX_SSID_LEN        64
#define MAX_PASSWORD_LEN    128
#define MAX_API_KEY_LEN     256
#define MAX_ENDPOINT_LEN    256

/* Non-secret configuration constants */
#define CAMERA_FIRMWARE_VERSION   "2.1.0"
#define CAMERA_MODEL              "IOTCAM-PRO-3000"
#define CLOUD_ENDPOINT            "https://api.iotcamera.example.com/v2"
#define HEARTBEAT_INTERVAL_SEC    30
#define MAX_RECONNECT_ATTEMPTS    5
#define STREAM_RESOLUTION_DEFAULT "1080p"
#define FRAME_RATE_DEFAULT        30

/* Environment variable names for secrets */
#define ENV_WIFI_SSID         "IOTCAM_WIFI_SSID"
#define ENV_WIFI_PASSWORD     "IOTCAM_WIFI_PASSWORD"
#define ENV_API_SECRET_KEY    "IOTCAM_API_SECRET_KEY"
#define ENV_DEVICE_TOKEN      "IOTCAM_DEVICE_TOKEN"
#define ENV_TLS_CLIENT_CERT   "IOTCAM_TLS_CLIENT_CERT_PATH"
#define ENV_TLS_CLIENT_KEY    "IOTCAM_TLS_CLIENT_KEY_PATH"

/* Secure storage partition name (for embedded secure element / TEE) */
#define SECURE_STORAGE_NAMESPACE  "iotcam_secrets"

/* Return codes */
typedef enum {
    CONFIG_OK = 0,
    CONFIG_ERR_NOT_FOUND = -1,
    CONFIG_ERR_TOO_LONG = -2,
    CONFIG_ERR_SECURE_STORAGE = -3,
    CONFIG_ERR_NULL_PARAM = -4,
    CONFIG_ERR_WIPED = -5
} config_status_t;

/* Runtime configuration structure - holds secrets only in memory */
typedef struct {
    char wifi_ssid[MAX_SSID_LEN];
    char wifi_password[MAX_PASSWORD_LEN];
    char api_secret_key[MAX_API_KEY_LEN];
    char device_token[MAX_API_KEY_LEN];
    char tls_cert_path[MAX_ENDPOINT_LEN];
    char tls_key_path[MAX_ENDPOINT_LEN];
    bool secrets_loaded;
    bool secrets_verified;
} camera_config_t;

/*
 * Forward declarations for platform-specific secure storage.
 * On a real embedded platform, these would interface with:
 *   - Hardware Secure Element (e.g., ATECC608A)
 *   - Trusted Execution Environment (TEE)
 *   - Encrypted NVS partition (e.g., ESP-IDF NVS with encryption)
 *   - ARM TrustZone secure world
 */
static config_status_t platform_secure_storage_read(const char *namespace,
                                                      const char *key,
                                                      char *out_buf,
                                                      size_t buf_len);
static void secure_memzero(void *ptr, size_t len);
static bool validate_credential(const char *value, size_t max_len);

/*
 * Securely wipe memory - resistant to compiler optimization removal.
 * Uses volatile to prevent the compiler from optimizing away the zeroing.
 */
static void secure_memzero(void *ptr, size_t len)
{
    volatile unsigned char *p = (volatile unsigned char *)ptr;
    while (len--) {
        *p++ = 0;
    }
}

/*
 * Validate that a credential value is non-empty and within bounds.
 */
static bool validate_credential(const char *value, size_t max_len)
{
    if (value == NULL) {
        return false;
    }
    size_t len = strnlen(value, max_len);
    if (len == 0 || len >= max_len) {
        return false;
    }
    return true;
}

/*
 * Platform-specific secure storage read.
 * 
 * In production, this would read from:
 *   1. Hardware secure element (preferred)
 *   2. TEE-protected storage
 *   3. Encrypted flash partition
 * 
 * For development/provisioning, falls back to environment variables.
 * Environment variables should be set by a secure provisioning tool,
 * NOT stored in shell profiles or scripts checked into version control.
 */
static config_status_t platform_secure_storage_read(const char *namespace,
                                                      const char *key,
                                                      char *out_buf,
                                                      size_t buf_len)
{
    if (namespace == NULL || key == NULL || out_buf == NULL || buf_len == 0) {
        return CONFIG_ERR_NULL_PARAM;
    }

    /*
     * PRODUCTION PATH: Read from hardware secure element or encrypted storage.
     * 
     * Example for ESP-IDF with encrypted NVS:
     *   nvs_handle_t handle;
     *   esp_err_t err = nvs_open(namespace, NVS_READONLY, &handle);
     *   if (err == ESP_OK) {
     *       size_t required_size = buf_len;
     *       err = nvs_get_str(handle, key, out_buf, &required_size);
     *       nvs_close(handle);
     *       if (err == ESP_OK) return CONFIG_OK;
     *   }
     * 
     * Example for secure element (ATECC608A):
     *   atca_status = atcab_read_zone(ATCA_ZONE_DATA, slot, 0, 0, out_buf, buf_len);
     */

    /*
     * DEVELOPMENT/PROVISIONING FALLBACK: Read from environment variables.
     * The provisioning system sets these ephemerally during device setup.
     */
    const char *env_value = getenv(key);
    if (env_value == NULL) {
        fprintf(stderr, "[CONFIG] Secret '%s' not found in secure storage or environment\n", key);
        return CONFIG_ERR_NOT_FOUND;
    }

    size_t value_len = strlen(env_value);
    if (value_len >= buf_len) {
        fprintf(stderr, "[CONFIG] Secret '%s' exceeds maximum length\n", key);
        return CONFIG_ERR_TOO_LONG;
    }

    strncpy(out_buf, env_value, buf_len - 1);
    out_buf[buf_len - 1] = '\0';

    return CONFIG_OK;
}

/*
 * Initialize camera configuration by loading all secrets from secure storage.
 * Returns CONFIG_OK on success, error code on failure.
 */
config_status_t camera_config_init(camera_config_t *config)
{
    if (config == NULL) {
        return CONFIG_ERR_NULL_PARAM;
    }

    /* Zero out the entire config structure first */
    secure_memzero(config, sizeof(camera_config_t));
    config->secrets_loaded = false;
    config->secrets_verified = false;

    printf("[CONFIG] Loading secrets from secure storage...\n");
    printf("[CONFIG] Firmware: %s | Model: %s\n", CAMERA_FIRMWARE_VERSION, CAMERA_MODEL);

    /* Load WiFi SSID from secure storage */
    config_status_t status = platform_secure_storage_read(
        SECURE_STORAGE_NAMESPACE,
        ENV_WIFI_SSID,
        config->wifi_ssid,
        MAX_SSID_LEN
    );
    if (status != CONFIG_OK) {
        fprintf(stderr, "[CONFIG] Failed to load WiFi SSID (error: %d)\n", status);
        camera_config_wipe(config);
        return status;
    }

    /* Load WiFi password from secure storage */
    status = platform_secure_storage_read(
        SECURE_STORAGE_NAMESPACE,
        ENV_WIFI_PASSWORD,
        config->wifi_password,
        MAX_PASSWORD_LEN
    );
    if (status != CONFIG_OK) {
        fprintf(stderr, "[CONFIG] Failed to load WiFi password (error: %d)\n", status);
        camera_config_wipe(config);
        return status;
    }

    /* Load API secret key from secure storage */
    status = platform_secure_storage_read(
        SECURE_STORAGE_NAMESPACE,
        ENV_API_SECRET_KEY,
        config->api_secret_key,
        MAX_API_KEY_LEN
    );
    if (status != CONFIG_OK) {
        fprintf(stderr, "[CONFIG] Failed to load API secret key (error: %d)\n", status);
        camera_config_wipe(config);
        return status;
    }

    /* Load device authentication token from secure storage */
    status = platform_secure_storage_read(
        SECURE_STORAGE_NAMESPACE,
        ENV_DEVICE_TOKEN,
        config->device_token,
        MAX_API_KEY_LEN
    );
    if (status != CONFIG_OK) {
        fprintf(stderr, "[CONFIG] Failed to load device token (error: %d)\n", status);
        camera_config_wipe(config);
        return status;
    }

    /* Load TLS client certificate path */
    status = platform_secure_storage_read(
        SECURE_STORAGE_NAMESPACE,
        ENV_TLS_CLIENT_CERT,
        config->tls_cert_path,
        MAX_ENDPOINT_LEN
    );
    if (status != CONFIG_OK) {
        fprintf(stderr, "[CONFIG] Failed to load TLS cert path (error: %d)\n", status);
        camera_config_wipe(config);
        return status;
    }

    /* Load TLS client key path */
    status = platform_secure_storage_read(
        SECURE_STORAGE_NAMESPACE,
        ENV_TLS_CLIENT_KEY,
        config->tls_key_path,
        MAX_ENDPOINT_LEN
    );
    if (status != CONFIG_OK) {
        fprintf(stderr, "[CONFIG] Failed to load TLS key path (error: %d)\n", status);
        camera_config_wipe(config);
        return status;
    }

    /* Validate all loaded credentials */
    if (!validate_credential(config->wifi_ssid, MAX_SSID_LEN)) {
        fprintf(stderr, "[CONFIG] WiFi SSID validation failed\n");
        camera_config_wipe(config);
        return CONFIG_ERR_NOT_FOUND;
    }
    if (!validate_credential(config->wifi_password, MAX_PASSWORD_LEN)) {
        fprintf(stderr, "[CONFIG] WiFi password validation failed\n");
        camera_config_wipe(config);
        return CONFIG_ERR_NOT_FOUND;
    }
    if (!validate_credential(config->api_secret_key, MAX_API_KEY_LEN)) {
        fprintf(stderr, "[CONFIG] API secret key validation failed\n");
        camera_config_wipe(config);
        return CONFIG_ERR_NOT_FOUND;
    }
    if (!validate_credential(config->device_token, MAX_API_KEY_LEN)) {
        fprintf(stderr, "[CONFIG] Device token validation failed\n");
        camera_config_wipe(config);
        return CONFIG_ERR_NOT_FOUND;
    }

    config->secrets_loaded = true;
    config->secrets_verified = true;

    /* Log success without revealing any secret values */
    printf("[CONFIG] All secrets loaded and validated successfully\n");
    printf("[CONFIG] WiFi SSID length: %zu chars\n", strlen(config->wifi_ssid));
    printf("[CONFIG] Cloud endpoint: %s\n", CLOUD_ENDPOINT);
    printf("[CONFIG] Heartbeat interval: %d seconds\n", HEARTBEAT_INTERVAL_SEC);

    return CONFIG_OK;
}

/*
 * Securely wipe all secrets from the configuration structure.
 * Call this when secrets are no longer needed or on shutdown.
 */
config_status_t camera_config_wipe(camera_config_t *config)
{
    if (config == NULL) {
        return CONFIG_ERR_NULL_PARAM;
    }

    printf("[CONFIG] Securely wiping secrets from memory\n");

    secure_memzero(config->wifi_ssid, MAX_SSID_LEN);
    secure_memzero(config->wifi_password, MAX_PASSWORD_LEN);
    secure_memzero(config->api_secret_key, MAX_API_KEY_LEN);
    secure_memzero(config->device_token, MAX_API_KEY_LEN);
    secure_memzero(config->tls_cert_path, MAX_ENDPOINT_LEN);
    secure_memzero(config->tls_key_path, MAX_ENDPOINT_LEN);

    config->secrets_loaded = false;
    config->secrets_verified = false;

    return CONFIG_OK;
}

/*
 * Check if configuration is ready for use.
 */
bool camera_config_is_ready(const camera_config_t *config)
{
    if (config == NULL) {
        return false;
    }
    return config->secrets_loaded && config->secrets_verified;
}

/*
 * Simulated WiFi connection using loaded credentials.
 */
static config_status_t wifi_connect(const camera_config_t *config)
{
    if (!camera_config_is_ready(config)) {
        fprintf(stderr, "[WIFI] Configuration not ready\n");
        return CONFIG_ERR_NOT_FOUND;
    }

    printf("[WIFI] Connecting to WiFi network (SSID length: %zu)...\n",
           strlen(config->wifi_ssid));

    /*
     * In production, this would call the WiFi driver:
     *   wifi_config_t wifi_cfg = {};
     *   strncpy((char*)wifi_cfg.sta.ssid, config->wifi_ssid, sizeof(wifi_cfg.sta.ssid));
     *   strncpy((char*)wifi_cfg.sta.password, config->wifi_password, sizeof(wifi_cfg.sta.password));
     *   esp_wifi_set_config(WIFI_IF_STA, &wifi_cfg);
     *   esp_wifi_start();
     *   esp_wifi_connect();
     *   // Then wipe the password from wifi_cfg
     *   secure_memzero(&wifi_cfg.sta.password, sizeof(wifi_cfg.sta.password));
     */

    printf("[WIFI] WiFi connection initiated\n");
    return CONFIG_OK;
}

/*
 * Simulated cloud service connection using API credentials.
 */
static config_status_t cloud_connect(const camera_config_t *config)
{
    if (!camera_config_is_ready(config)) {
        fprintf(stderr, "[CLOUD] Configuration not ready\n");
        return CONFIG_ERR_NOT_FOUND;
    }

    printf("[CLOUD] Connecting to cloud: %s\n", CLOUD_ENDPOINT);
    printf("[CLOUD] Using TLS mutual authentication\n");
    printf("[CLOUD] Device token length: %zu chars\n", strlen(config->device_token));

    /*
     * In production, this would:
     *   1. Initialize TLS with client certificate
     *   2. Establish MQTT/HTTPS connection to CLOUD_ENDPOINT
     *   3. Authenticate with device_token and api_secret_key
     *   4. Begin streaming/heartbeat loop
     */

    printf("[CLOUD] Cloud connection initiated\n");
    return CONFIG_OK;
}

/*
 * Main firmware entry point.
 */
int main(void)
{
    printf("========================================\n");
    printf("  IoT Smart Camera Firmware %s\n", CAMERA_FIRMWARE_VERSION);
    printf("  Model: %s\n", CAMERA_MODEL);
    printf("========================================\n\n");

    /* Allocate config on stack - will be wiped on function exit */
    camera_config_t config;
    config_status_t status;

    /* Load all secrets from secure storage */
    status = camera_config_init(&config);
    if (status != CONFIG_OK) {
        fprintf(stderr, "[MAIN] FATAL: Failed to load configuration (error: %d)\n", status);
        fprintf(stderr, "[MAIN] Ensure secrets are provisioned in secure storage.\n");
        fprintf(stderr, "[MAIN] For development, set environment variables:\n");
        fprintf(stderr, "  export %s=\"<your_wifi_ssid>\"\n", ENV_WIFI_SSID);
        fprintf(stderr, "  export %s=\"<your_wifi_password>\"\n", ENV_WIFI_PASSWORD);
        fprintf(stderr, "  export %s=\"<your_api_key>\"\n", ENV_API_SECRET_KEY);
        fprintf(stderr, "  export %s=\"<your_device_token>\"\n", ENV_DEVICE_TOKEN);
        fprintf(stderr, "  export %s=\"<path_to_cert>\"\n", ENV_TLS_CLIENT_CERT);
        fprintf(stderr, "  export %s=\"<path_to_key>\"\n", ENV_TLS_CLIENT_KEY);
        return 1;
    }

    /* Connect to WiFi */
    status = wifi_connect(&config);
    if (status != CONFIG_OK) {
        fprintf(stderr, "[MAIN] Failed to initiate WiFi connection\n");
        camera_config_wipe(&config);
        return 1;
    }

    /* Connect to cloud service */
    status = cloud_connect(&config);
    if (status != CONFIG_OK) {
        fprintf(stderr, "[MAIN] Failed to initiate cloud connection\n");
        camera_config_wipe(&config);
        return 1;
    }

    printf("\n[MAIN] Camera firmware initialized successfully\n");
    printf("[MAIN] Streaming at %s @ %d FPS\n", STREAM_RESOLUTION_DEFAULT, FRAME_RATE_DEFAULT);
    printf("[MAIN] Heartbeat every %d seconds\n", HEARTBEAT_INTERVAL_SEC);

    /*
     * In production, the main loop would run here:
     *   while (running) {
     *       camera_capture_frame();
     *       cloud_send_frame();
     *       cloud_heartbeat();
     *       process_cloud_commands();
     *       watchdog_feed();
     *   }
     */

    /* Securely wipe all secrets before shutdown */
    camera_config_wipe(&config);
    printf("[MAIN] Secrets wiped. Firmware shutdown complete.\n");

    return 0;
}