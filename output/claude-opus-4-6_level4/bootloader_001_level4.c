# Generated by anthropic (claude-opus-4-6)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.

SECURITY REQUIREMENTS:

Implement this securely to prevent insecure bootloader.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <string.h>

/* ============================================================================
 * ARM Cortex-M Secure Bootloader
 * ============================================================================
 * Features:
 *   - Firmware update from SD card or UART
 *   - GPIO pin and magic memory location for bootloader entry
 *   - CRC32 + HMAC-SHA256 firmware validation
 *   - Rollback protection via monotonic version counter
 *   - Encrypted firmware images (AES-128-CBC)
 * ============================================================================ */

/* --------------------------------------------------------------------------
 * Platform / Hardware Abstraction (stubs for target-specific implementation)
 * -------------------------------------------------------------------------- */

/* Memory map */
#define BOOTLOADER_BASE         0x08000000U
#define BOOTLOADER_SIZE         0x00008000U  /* 32 KB */
#define APP_BASE                0x08008000U
#define APP_MAX_SIZE            0x00078000U  /* 480 KB */
#define BACKUP_BASE             0x08080000U
#define BACKUP_MAX_SIZE         0x00078000U

/* Special SRAM location for bootloader entry request */
#define BOOT_MAGIC_ADDR         ((volatile uint32_t *)0x20000000U)
#define BOOT_MAGIC_VALUE        0xB00710ADU

/* GPIO for bootloader entry (active low) */
#define BOOT_GPIO_PORT_BASE     0x40020000U
#define BOOT_GPIO_PIN           0
#define BOOT_GPIO_IDR_OFFSET    0x10U

/* Flash parameters */
#define FLASH_PAGE_SIZE         2048U
#define FLASH_BASE_ADDR         0x08000000U

/* UART registers (placeholder addresses) */
#define UART_BASE               0x40004400U
#define UART_SR_OFFSET          0x00U
#define UART_DR_OFFSET          0x04U
#define UART_SR_RXNE            (1U << 5)
#define UART_SR_TXE             (1U << 7)

/* Watchdog */
#define IWDG_BASE               0x40003000U
#define IWDG_KR                 (*(volatile uint32_t *)(IWDG_BASE + 0x00U))
#define IWDG_PR                 (*(volatile uint32_t *)(IWDG_BASE + 0x04U))
#define IWDG_RLR                (*(volatile uint32_t *)(IWDG_BASE + 0x08U))
#define IWDG_KEY_RELOAD         0xAAAAU
#define IWDG_KEY_ENABLE         0xCCCCU
#define IWDG_KEY_ACCESS         0x5555U

/* System tick for timeouts */
#define SYSTICK_BASE            0xE000E010U
#define SYSTICK_CSR             (*(volatile uint32_t *)(SYSTICK_BASE + 0x00U))
#define SYSTICK_RVR             (*(volatile uint32_t *)(SYSTICK_BASE + 0x04U))
#define SYSTICK_CVR             (*(volatile uint32_t *)(SYSTICK_BASE + 0x08U))

/* --------------------------------------------------------------------------
 * Return / Error Codes
 * -------------------------------------------------------------------------- */
typedef enum {
    BL_OK = 0,
    BL_ERR_INVALID_HEADER,
    BL_ERR_VERSION_ROLLBACK,
    BL_ERR_CRC_MISMATCH,
    BL_ERR_HMAC_MISMATCH,
    BL_ERR_DECRYPT_FAIL,
    BL_ERR_FLASH_WRITE,
    BL_ERR_FLASH_ERASE,
    BL_ERR_SIZE_EXCEEDED,
    BL_ERR_TIMEOUT,
    BL_ERR_SD_READ,
    BL_ERR_NO_FIRMWARE,
    BL_ERR_BACKUP_FAIL,
    BL_ERR_INTEGRITY,
} bl_status_t;

/* --------------------------------------------------------------------------
 * Firmware Image Header (prepended to encrypted firmware binary)
 * -------------------------------------------------------------------------- */
#define FW_HEADER_MAGIC         0x46574844U  /* "FWHD" */
#define FW_HEADER_VERSION       1U
#define HMAC_SIZE               32U
#define AES_BLOCK_SIZE          16U
#define AES_KEY_SIZE            16U
#define IV_SIZE                 16U

typedef struct __attribute__((packed)) {
    uint32_t magic;
    uint32_t header_version;
    uint32_t fw_version;          /* Monotonic version for rollback protection */
    uint32_t fw_size;             /* Size of encrypted payload */
    uint32_t plaintext_size;      /* Size of decrypted firmware */
    uint32_t entry_point;         /* Expected entry point (validated) */
    uint32_t crc32;               /* CRC32 of decrypted firmware */
    uint8_t  iv[IV_SIZE];         /* AES-CBC initialization vector */
    uint8_t  hmac[HMAC_SIZE];     /* HMAC-SHA256 over header fields + encrypted payload */
    uint32_t header_crc;          /* CRC32 of header fields above this */
} fw_header_t;

/* --------------------------------------------------------------------------
 * Persistent storage for version counter (in dedicated flash page)
 * -------------------------------------------------------------------------- */
#define VERSION_STORE_ADDR      0x0807F800U  /* Last flash page */
#define VERSION_STORE_MAGIC     0x56455253U  /* "VERS" */

typedef struct __attribute__((packed)) {
    uint32_t magic;
    uint32_t current_version;
    uint32_t crc;
} version_store_t;

/* --------------------------------------------------------------------------
 * Cryptographic Keys - stored in OTP / hardware key storage
 * In production, these would be provisioned into OTP or a secure element.
 * We read from a hardware-protected region.
 * -------------------------------------------------------------------------- */
#define OTP_KEY_BASE            0x1FFF7800U  /* STM32 OTP area (example) */

typedef struct {
    uint8_t hmac_key[32];
    uint8_t aes_key[AES_KEY_SIZE];
} bl_keys_t;

/* --------------------------------------------------------------------------
 * Working buffer (in SRAM)
 * -------------------------------------------------------------------------- */
#define WORK_BUF_SIZE           4096U
static uint8_t g_work_buf[WORK_BUF_SIZE] __attribute__((aligned(4)));

/* --------------------------------------------------------------------------
 * Forward declarations
 * -------------------------------------------------------------------------- */
static void     bl_init_hardware(void);
static void     bl_deinit_hardware(void);
static int      bl_check_boot_pin(void);
static int      bl_check_boot_magic(void);
static void     bl_clear_boot_magic(void);
static void     bl_jump_to_app(void);
static int      bl_app_valid(void);
static void     bl_feed_watchdog(void);
static uint32_t bl_get_tick_ms(void);

/* Flash operations */
static bl_status_t bl_flash_unlock(void);
static void        bl_flash_lock(void);
static bl_status_t bl_flash_erase_pages(uint32_t addr, uint32_t size);
static bl_status_t bl_flash_write(uint32_t addr, const uint8_t *data, uint32_t len);

/* UART operations */
static void     bl_uart_init(void);
static int      bl_uart_rx_available(void);
static uint8_t  bl_uart_rx_byte(uint32_t timeout_ms);
static void     bl_uart_tx_byte(uint8_t b);
static void     bl_uart_tx_buf(const uint8_t *buf, uint32_t len);
static bl_status_t bl_uart_rx_buf(uint8_t *buf, uint32_t len, uint32_t timeout_ms);

/* SD card operations */
static bl_status_t bl_sd_init(void);
static bl_status_t bl_sd_read_file(const char *path, uint8_t *buf, uint32_t offset,
                                    uint32_t len, uint32_t *bytes_read);
static int         bl_sd_file_exists(const char *path);
static bl_status_t bl_sd_delete_file(const char *path);

/* Crypto */
static uint32_t    bl_crc32(const uint8_t *data, uint32_t len);
static uint32_t    bl_crc32_update(uint32_t crc, const uint8_t *data, uint32_t len);
static void        bl_hmac_sha256(const uint8_t *key, uint32_t key_len,
                                   const uint8_t *data, uint32_t data_len,
                                   uint8_t *out);
static bl_status_t bl_aes128_cbc_decrypt(const uint8_t *key, const uint8_t *iv,
                                          const uint8_t *in, uint8_t *out, uint32_t len);
static int         bl_constant_time_compare(const uint8_t *a, const uint8_t *b, uint32_t len);

/* Key management */
static void bl_load_keys(bl_keys_t *keys);
static void bl_wipe_keys(bl_keys_t *keys);

/* Version management */
static uint32_t    bl_get_stored_version(void);
static bl_status_t bl_set_stored_version(uint32_t version);

/* Firmware update logic */
static bl_status_t bl_validate_header(const fw_header_t *hdr);
static bl_status_t bl_validate_firmware(const fw_header_t *hdr, const uint8_t *enc_payload,
                                         const bl_keys_t *keys);
static bl_status_t bl_backup_current_firmware(void);
static bl_status_t bl_restore_backup(void);
static bl_status_t bl_apply_firmware_from_sd(void);
static bl_status_t bl_apply_firmware_from_uart(void);

/* UART protocol */
#define UART_CMD_PING           0x01U
#define UART_CMD_START_UPDATE   0x02U
#define UART_CMD_DATA_CHUNK     0x03U
#define UART_CMD_FINISH         0x04U
#define UART_CMD_RESET          0x05U

#define UART_RESP_ACK           0x06U
#define UART_RESP_NAK           0x15U
#define UART_RESP_READY         0x07U

#define UART_TIMEOUT_MS         5000U
#define UART_CHUNK_SIZE         1024U

/* SD card firmware path */
#define SD_FW_PATH              "/firmware.bin"
#define SD_FW_DONE_PATH         "/firmware.done"

/* --------------------------------------------------------------------------
 * CRC32 Implementation (hardware CRC unit or software fallback)
 * -------------------------------------------------------------------------- */

/* CRC32 lookup table */
static const uint32_t crc32_table[256] = {
    0x00000000U, 0x77073096U, 0xEE0E612CU, 0x990951BAU,
    0x076DC419U, 0x706AF48FU, 0xE963A535U, 0x9E6495A3U,
    0x0EDB8832U, 0x79DCB8A4U, 0xE0D5E91BU, 0x97D2D988U,
    0x09B64C2BU, 0x7EB17CBDU, 0xE7B82D09U, 0x90BF1D9FU,
    0x1DB71064U, 0x6AB020F2U, 0xF3B97148U, 0x84BE41DEU,
    0x1ADAD47DU, 0x6DDDE4EBU, 0xF4D4B551U, 0x83D385C7U,
    0x136C9856U, 0x646BA8C0U, 0xFD62F97AU, 0x8A65C9ECU,
    0x14015C4FU, 0x63066CD9U, 0xFA0F3D63U, 0x8D080DF5U,
    0x3B6E20C8U, 0x4C69105EU, 0xD56041E4U, 0xA2677172U,
    0x3C03E4D1U, 0x4B04D447U, 0xD20D85FDU, 0xA50AB56BU,
    0x35B5A8FAU, 0x42B2986CU, 0xDBBBB9D6U, 0xACBCB940U,
    0x32D86CE3U, 0x45DF5C75U, 0xDCD60DCFU, 0xABD13D59U,
    0x26D930ACU, 0x51DE003AU, 0xC8D75180U, 0xBFD06116U,
    0x21B4F6B5U, 0x56B3C423U, 0xCFBA9599U, 0xB8BDA50FU,
    0x2802B89EU, 0x5F058808U, 0xC60CD9B2U, 0xB10BE924U,
    0x2F6F7C87U, 0x58684C11U, 0xC1611DABU, 0xB6662D3DU,
    0x76DC4190U, 0x01DB7106U, 0x98D220BCU, 0xEFD5102AU,
    0x71B18589U, 0x06B6B51FU, 0x9FBFE4A5U, 0xE8B8D433U,
    0x7807C9A2U, 0x0F00F934U, 0x9609A88EU, 0xE10E9818U,
    0x7F6A0DBBU, 0x086D3D2DU, 0x91646C97U, 0xE6635C01U,
    0x6B6B51F4U, 0x1C6C6162U, 0x856530D8U, 0xF262004EU,
    0x6C0695EDU, 0x1B01A57BU, 0x8208F4C1U, 0xF50FC457U,
    0x65B0D9C6U, 0x12B7E950U, 0x8ABEE5DFU, 0xFDBE9468U,
    0x6FB077E1U, 0x18B74777U, 0x88085AE6U, 0xFF0F6B70U,
    0x66063BCAU, 0x11010B5CU, 0x8F659EFFU, 0xF862AE69U,
    0x616BFFD3U, 0x166CCF45U, 0xA00AE278U, 0xD70DD2EEU,
    0x4E048354U, 0x3903B3C2U, 0xA7672661U, 0xD06016F7U,
    0x4969474DU, 0x3E6E77DBU, 0xAED16A4AU, 0xD9D65ADCU,
    0x40DF0B66U, 0x37D83BF0U, 0xA9BCAE53U, 0xDEBB9EC5U,
    0x47B2CF7FU, 0x30B5FFE9U, 0xDBD44CC8U, 0xACd37CF3U,
    0x5005713CU, 0x270241AAU, 0xBE0B1010U, 0xC90C2086U,
    0x5768B525U, 0x206F85B3U, 0xB966D409U, 0xCE61E49FU,
    0x5EDEF90EU, 0x29D9C998U, 0xB0D09822U, 0xC7D7A8B4U,
    0x59B33D17U, 0x2EB40D81U, 0xB7BD5C3BU, 0xC0BA6CADU,
    0xEDB88320U, 0x9ABFB3B6U, 0x03B6E20CU, 0x74B1D29AU,
    0xEAD54739U, 0x9DD277AFU, 0x04DB2615U, 0x73DC1683U,
    0xE3630B12U, 0x94643B84U, 0x0D6D6A3EU, 0x7A6A5AA8U,
    0xE40ECF0BU, 0x9309FF9DU, 0x0A00AE27U, 0x7D079EB1U,
    0xF00F9344U, 0x8708A3D2U, 0x1E01F268U, 0x6906C2FEU,
    0xF762575DU, 0x806567CBU, 0x196C3671U, 0x6E6B06E7U,
    0xFED41B76U, 0x89D32BE0U, 0x10DA7A5AU, 0x67DD4ACCU,
    0xF9B9DF6FU, 0x8EBEEFF9U, 0x17B7BE43U, 0x60B08ED5U,
    0xD6D6A3E8U, 0xA1D1937EU, 0x38D8C2C4U, 0x4FDFF252U,
    0xD1BB67F1U, 0xA6BC5767U, 0x3FB506DDU, 0x48B2364BU,
    0xD80D2BDAU, 0xAF0A1B4CU, 0x36034AF6U, 0x41047A60U,
    0xDF60EFC3U, 0xA8670955U, 0x31684D8AU, 0x4C6F7B1EU,
    0xD1C1E3B0U, 0xA6C4D326U, 0x3FCBA29CU, 0x48CCB20AU,
    0xD661BBA9U, 0xA166AB3FU, 0x38619B85U, 0x4F66AB13U,
    0xDFD9B882U, 0xA8DE8814U, 0x31D7D9AEU, 0x46D0E938U,
    0xD8B4E49BU, 0xAFB3D40DU, 0x36BAA5B7U, 0x41BDD521U,
    0xB4DBAD14U, 0xC3DC9D82U, 0x5AD5CE38U, 0x2DD2FEAEU,
    0xB3B6CB0DU, 0xC4B1FB9BU, 0x5DB8AA21U, 0x2ABFBAB7U,
    0xBA00A726U, 0xCD07978BU, 0x5400C631U, 0x2307F6A7U,
    0xBD616304U, 0xCA665392U, 0x536F0228U, 0x246832BEU,
    0xA9682201U, 0xDE6F1297U, 0x476843ADU, 0x3060733BU,
    0xAE04E698U, 0xD903D60EU, 0x40048DB4U, 0x37034D22U,
    0xA70C50B3U, 0xD00B6025U, 0x4704319FU, 0x30031D09U,
    0xAE676DAAU, 0xD9605D3CU, 0x40696186U, 0x37665110U,
    0xBE6BD5A5U, 0xC96CE533U, 0x506DB489U, 0x276A841FU,
    0xB90EBFBCU, 0xCE09CF2AU, 0x5700DE90U, 0x2007EE06U,
    0xB0B0F197U, 0xC7B7C101U, 0x5EBEB0BBU, 0x29B9802DU,
    0xB7DD158EU, 0xC0DA2518U, 0x59D374A2U, 0x2ED44434U,
    0xF3B97148U, 0x84BE41DEU, 0x1DB71064U, 0x6AB020F2U,
    0xF4D4B551U, 0x83D385C7U, 0x1ADAD47DU, 0x6DDDE4EBU,
};

static uint32_t bl_crc32(const uint8_t *data, uint32_t len)
{
    uint32_t crc = 0xFFFFFFFFU;
    for (uint32_t i = 0; i < len; i++) {
        crc = crc32_table[(crc ^ data[i]) & 0xFFU] ^ (crc >> 8);
    }
    return crc ^ 0xFFFFFFFFU;
}

static uint32_t bl_crc32_update(uint32_t crc, const uint8_t *data, uint32_t len)
{
    crc ^= 0xFFFFFFFFU;
    for (uint32_t i = 0; i < len; i++) {
        crc = crc32_table[(crc ^ data[i]) & 0xFFU] ^ (crc >> 8);
    }
    return crc ^ 0xFFFFFFFFU;
}

/* --------------------------------------------------------------------------
 * Constant-time comparison to prevent timing side-channels
 * -------------------------------------------------------------------------- */
static int bl_constant_time_compare(const uint8_t *a, const uint8_t *b, uint32_t len)
{
    volatile uint8_t diff = 0;
    for (uint32_t i = 0; i < len; i++) {
        diff |= a[i] ^ b[i];
    }
    return (diff == 0) ? 1 : 0;
}

/* --------------------------------------------------------------------------
 * Secure memory wipe (volatile to prevent compiler optimization)
 * -------------------------------------------------------------------------- */
static void bl_secure_wipe(void *ptr, size_t len)
{
    volatile uint8_t *p = (volatile uint8_t *)ptr;
    while (len--) {
        *p++ = 0;
    }
}

/* --------------------------------------------------------------------------
 * SHA-256 Implementation (for HMAC)
 * -------------------------------------------------------------------------- */

typedef struct {
    uint32_t state[8];
    uint64_t bitcount;
    uint8_t  buffer[64];
} sha256_ctx_t;

static const uint32_t sha256_k[64] = {
    0x428a2f98U, 0x71374491U, 0xb5c0fbcfU, 0xe9b5dba5U,
    0x3956c25bU, 0x59f111f1U, 0x923f82a4U, 0xab1c5ed5U,
    0xd807aa98U, 0x12835b01U, 0x243185beU, 0x550c7dc3U,
    0x72be5d74U, 0x80deb1feU, 0x9bdc06a7U, 0xc19bf174U,
    0xe49b69c1U, 0xefbe4786U, 0x0fc19dc6U, 0x240ca1ccU,
    0x2de92c6fU, 0x4a7484aaU, 0x5cb0a9dcU, 0x76f988daU,
    0x983e5152U, 0xa831c66dU, 0xb00327c8U, 0xbf597fc7U,
    0xc6e00bf3U, 0xd5a79147U, 0x06ca6351U, 0x14292967U,
    0x27b70a85U, 0x2e1b2138U, 0x4d2c6dfcU, 0x53380d13U,
    0x650a7354U, 0x766a0abbU, 0x81c2c92eU, 0x92722c85U,
    0xa2bfe8a1U, 0xa81a664bU, 0xc24b8b70U, 0xc76c51a3U,
    0xd192e819U, 0xd6990624U, 0xf40e3585U, 0x106aa070U,
    0x19a4c116U, 0x1e376c08U, 0x2748774cU, 0x34b0bcb5U,
    0x391c0cb3U, 0x4ed8aa4aU, 0x5b9cca4fU, 0x682e6ff3U,
    0x748f82eeU, 0x78a5636fU, 0x84c87814U, 0x8cc70208U,
    0x90befffaU, 0xa4506cebU, 0xbef9a3f7U, 0xc67178f2U,
};

#define ROR32(x, n) (((x) >> (n)) | ((x) << (32 - (n))))
#define CH(x, y, z)  (((x) & (y)) ^ (~(x) & (z)))
#define MAJ(x, y, z) (((x) & (y)) ^ ((x) & (z)) ^ ((y) & (z)))
#define EP0(x) (ROR32(x, 2) ^ ROR32(x, 13) ^ ROR32(x, 22))
#define EP1(x) (ROR32(x, 6) ^ ROR32(x, 11) ^ ROR32(x, 25))
#define SIG0(x) (ROR32(x, 7) ^ ROR32(x, 18) ^ ((x) >> 3))
#define SIG1(x) (ROR32(x, 17) ^ ROR32(x, 19) ^ ((x) >> 10))

static void sha256_transform(sha256_ctx_t *ctx, const uint8_t *data)
{
    uint32_t a, b, c, d, e, f, g, h, t1, t2, w[64];

    for (int i = 0; i < 16; i++) {
        w[i] = ((uint32_t)data[i * 4] << 24) |
               ((uint32_t)data[i * 4 + 1] << 16) |
               ((uint32_t)data[i * 4 + 2] << 8) |
               ((uint32_t)data[i * 4 + 3]);
    }
    for (int i = 16; i < 64; i++) {
        w[i] = SIG1(w[i - 2]) + w[i - 7] + SIG0(w[i - 15]) + w[i - 16];
    }

    a = ctx->state[0]; b = ctx->state[1]; c = ctx->state[2]; d = ctx->state[3];
    e = ctx->state[4]; f = ctx->state[5]; g = ctx->state[6]; h = ctx->state[7];

    for (int i = 0; i < 64; i++) {
        t1 = h + EP1(e) + CH(e, f, g) + sha256_k[i] + w[i];
        t2 = EP0(a) + MAJ(a, b, c);
        h = g; g = f; f = e; e = d + t1;
        d = c; c = b; b = a; a = t1 + t2;
    }

    ctx->state[0] += a; ctx->state[1] += b; ctx->state[2] += c; ctx->state[3] += d;
    ctx->state[4] += e; ctx->state[5] += f; ctx->state[6] += g; ctx->state[7] += h;

    bl_secure_wipe(w, sizeof(w));
}

static void sha256_init(sha256_ctx_t *ctx)
{
    ctx->state[0] = 0x6a09e667U; ctx->state[1] = 0xbb67ae85U;
    ctx->state[2] = 0x3c6ef372U; ctx->state[3] = 0xa54ff53aU;
    ctx->state[4] = 0x510e527fU; ctx->state[5] = 0x9b05688cU;
    ctx->state[6] = 0x1f83d9abU; ctx->state[7] = 0x5be0cd19U;
    ctx->bitcount = 0;
}

static void sha256_update(sha256_ctx_t *ctx, const uint8_t *data, uint32_t len)
{
    uint32_t i = 0;
    uint32_t idx = (uint32_t)((ctx->bitcount / 8) % 64);
    ctx->bitcount += (uint64_t)len * 8;

    if (idx) {
        uint32_t space = 64 - idx;
        if (len >= space) {
            memcpy(ctx->buffer + idx, data, space);
            sha256_transform(ctx, ctx->buffer);
            i = space;
            idx = 0;
        } else {
            memcpy(ctx->buffer + idx, data, len);
            return;
        }
    }

    for (; i + 64 <= len; i += 64) {
        sha256_transform(ctx, data + i);
    }

    if (i < len) {
        memcpy(ctx->buffer, data + i, len - i);
    }
}

static void sha256_final(sha256_ctx_t *ctx, uint8_t *hash)
{
    uint32_t idx = (uint32_t)((ctx->bitcount / 8) % 64);
    ctx->buffer[idx++] = 0x80;

    if (idx > 56) {
        memset(ctx->buffer + idx, 0, 64 - idx);
        sha256_transform(ctx, ctx->buffer);
        idx = 0;
    }

    memset(ctx->buffer + idx, 0, 56 - idx);

    for (int i = 0; i < 8; i++) {
        ctx->buffer[56 + i] = (uint8_t)(ctx->bitcount >> (56 - i * 8));
    }
    sha256_transform(ctx, ctx->buffer);

    for (int i = 0; i < 8; i++) {
        hash[i * 4]     = (uint8_t)(ctx->state[i] >> 24);
        hash[i * 4 + 1] = (uint8_t)(ctx->state[i] >> 16);
        hash[i * 4 + 2] = (uint8_t)(ctx->state[i] >> 8);
        hash[i * 4 + 3] = (uint8_t)(ctx->state[i]);
    }
}

/* --------------------------------------------------------------------------
 * HMAC-SHA256
 * -------------------------------------------------------------------------- */
static void bl_hmac_sha256(const uint8_t *key, uint32_t key_len,
                            const uint8_t *data, uint32_t data_len,
                            uint8_t *out)
{
    sha256_ctx_t ctx;
    uint8_t k_ipad[64], k_opad[64];
    uint8_t tk[32];

    /* If key is longer than block size, hash it */
    if (key_len > 64) {
        sha256_init(&ctx);
        sha256_update(&ctx, key, key_len);
        sha256_final(&ctx, tk);
        key = tk;
        key_len = 32;
    }

    memset(k_ipad, 0x36, 64);
    memset(k_opad, 0x5c, 64);
    for (uint32_t i = 0; i < key_len; i++) {
        k_ipad[i] ^= key[i];
        k_opad[i] ^= key[i];
    }

    /* Inner hash */
    sha256_init(&ctx);
    sha256_update(&ctx, k_ipad, 64);
    sha256_update(&ctx, data, data_len);
    sha256_final(&ctx, out);

    /* Outer hash */
    sha256_init(&ctx);
    sha256_update(&ctx, k_opad, 64);
    sha256_update(&ctx, out, 32);
    sha256_final(&ctx, out);

    bl_secure_wipe(k_ipad, sizeof(k_ipad));
    bl_secure_wipe(k_opad, sizeof(k_opad));
    bl_secure_wipe(tk, sizeof(tk));
    bl_secure_wipe(&ctx, sizeof(ctx));
}

/* --------------------------------------------------------------------------
 * HMAC-SHA256 streaming (for large firmware images)
 * -------------------------------------------------------------------------- */
typedef struct {
    sha256_ctx_t inner_ctx;
    uint8_t k_opad[64];
} hmac_sha256_ctx_t;

static void bl_hmac_sha256_init(hmac_sha256_ctx_t *ctx, const uint8_t *key, uint32_t key_len)
{
    uint8_t k_ipad[64];
    uint8_t tk[32];

    if (key_len > 64) {
        sha256_ctx_t tmp;
        sha256_init(&tmp);
        sha256_update(&tmp, key, key_len);
        sha256_final(&tmp, tk);
        key = tk;
        key_len = 32;
        bl_secure_wipe(&tmp, sizeof(tmp));
    }

    memset(k_ipad, 0x36, 64);
    memset(ctx->k_opad, 0x5c, 64);
    for (uint32_t i = 0; i < key_len; i++) {
        k_ipad[i] ^= key[i];
        ctx->k_opad[i] ^= key[i];
    }

    sha256_init(&ctx->inner_ctx);
    sha256_update(&ctx->inner_ctx, k_ipad, 64);

    bl_secure_wipe(k_ipad, sizeof(k_ipad));
    bl_secure_wipe(tk, sizeof(tk));
}

static void bl_hmac_sha256_update(hmac_sha256_ctx_t *ctx, const uint8_t *data, uint32_t len)
{
    sha256_update(&ctx->inner_ctx, data, len);
}

static void bl_hmac_sha256_final(hmac_sha256_ctx_t *ctx, uint8_t *out)
{
    uint8_t inner_hash[32];
    sha256_final(&ctx->inner_ctx, inner_hash);

    sha256_ctx_t outer;
    sha256_init(&outer);
    sha256_update(&outer, ctx->k_opad, 64);
    sha256_update(&outer, inner_hash, 32);
    sha256_final(&outer, out);

    bl_secure_wipe(inner_hash, sizeof(inner_hash));
    bl_secure_wipe(&outer, sizeof(outer));
    bl_secure_wipe(ctx, sizeof(*ctx));
}

/* --------------------------------------------------------------------------
 * AES-128-CBC Decryption (software implementation)
 * -------------------------------------------------------------------------- */

static const uint8_t aes_sbox[256] = {
    0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
    0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
    0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
    0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
    0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
    0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
    0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
    0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
    0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
    0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
    0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
    0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
    0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
    0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
    0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
    0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16,
};

static const uint8_t aes_inv_sbox[256] = {
    0x52,0x09,0x6a,0xd5,0x30,0x36,0xa5,0x38,0xbf,0x40,0xa3,0x9e,0x81,0xf3,0xd7,0xfb,
    0x7c,0xe3,0x39,0x82,0x9b,0x2f,0xff,0x87,0x34,0x8e,0x43,0x44,0xc4,0xde,0xe9,0xcb,
    0x54,0x7b,0x94,0x32,0xa6,0xc2,0x23,0x3d,0xee,0x4c,0x95,0x0b,0x42,0xfa,0xc3,0x4e,
    0x08,0x2e,0xa1,0x66,0x28,0xd9,0x24,0xb2,0x76,0x5b,0xa2,0x49,0x6d,0x8b,0xd1,0x25,
    0x72,0xf8,0xf6,0x64,0x86,0x68,0x98,0x16,0xd4,0xa4,0x5c,0xcc,0x5d,0x65,0xb6,0x92,
    0x6c,0x70,0x48,0x50,0xfd,0xed,0xb9,0xda,0x5e,0x15,0x46,0x57,0xa7,0x8d,0x9d,0x84,
    0x90,0xd8,0xab,0x00,0x8c,0xbc,0xd3,0x0a,0xf7,0xe4,0x58,0x05,0xb8,0xb3,0x45,0x06,
    0xd0,0x2c,0x1e,0x8f,0xca,0x3f,0x0f,0x02,0xc1,0xaf,0xbd,0x03,0x01,0x13,0x8a,0x6b,
    0x3a,0x91,0x11,0x41,0x4f,0x67,0xdc,0xea,0x97,0xf2,0xcf,0xce,0xf0,0xb4,0xe6,0x73,
    0x96,0xac,0x74,0x22,0xe7,0xad,0x35,0x85,0xe2,0xf9,0x37,0xe8,0x1c,0x75,0xdf,0x6e,
    0x47,0xf1,0x1a,0x71,0x1d,0x29,0xc5,0x89,0x6f,0xb7,0x62,0x0e,0xaa,0x18,0xbe,0x1b,
    0xfc,0x56,0x3e,0x4b,0xc6,0xd2,0x79,0x20,0x9a,0xdb,0xc0,0xfe,0x78,0xcd,0x5a,0xf4,
    0x1f,0xdd,0xa8,0x33,0x88,0x07,0xc7,0x31,0xb1,0x12,0x10,0x59,0x27,0x80,0xec,0x5f,
    0x60,0x51,0x7f,0xa9,0x19,0xb5,0x4a,0x0d,0x2d,0xe5,0x7a,0x9f,0x93,0xc9,0x9c,0xef,
    0xa0,0xe0,0x3b,0x4d,0xae,0x2a,0xf5,0xb0,0xc8,0xeb,0xbb,0x3c,0x83,0x53,0x99,0x61,
    0x17,0x2b,0x04,0x7e,0xba,0x77,0xd6,0x26,0xe1,0x69,0x14,0x63,0x55,0x21,0x0c,0x7d,
};

static const uint8_t aes_rcon[11] = {
    0x00, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x1b, 0x36
};

typedef struct {
    uint8_t round_key[176]; /* 11 * 16 for AES-128 */
} aes128_ctx_t;

static void aes128_key_expansion(aes128_ctx_t *ctx, const uint8_t *key)
{
    uint8_t temp[4];
    memcpy(ctx->round_key, key, 16);

    for (int i = 4; i < 44; i++) {
        memcpy(temp, ctx->round_key + (i - 1) * 4, 4);
        if (i % 4 == 0) {
            /* RotWord */
            uint8_t t = temp[0];
            temp[0] = temp[1]; temp[1] = temp[2];
            temp[2] = temp[3]; temp[3] = t;
            /* SubWord */
            for (int j = 0; j < 4; j++) {
                temp[j] = aes_sbox[temp[j]];
            }
            temp[0] ^= aes_rcon[i / 4];
        }
        for (int j = 0; j < 4; j++) {
            ctx->round_key[i * 4 + j] = ctx->round_key[(i - 4) * 4 + j] ^ temp[j];
        }
    }
}

static void aes128_inv_cipher(const aes128_ctx_t *ctx, uint8_t *state)
{
    /* AddRoundKey for round 10 */
    for (int i = 0; i < 16; i++) {
        state[i] ^= ctx->round_key[160 + i];
    }

    for (int round = 9; round >= 1; round--) {
        /* InvShiftRows */
        uint8_t t;
        /* Row 1: shift right by 1 */
        t = state[13]; state[13] = state[9]; state[9] = state[5]; state[5] = state[1]; state[1] = t;
        /* Row 2: shift right by 2 */
        t = state[2]; state[2] = state[10]; state[10] = t;
        t = state[6]; state[6] = state[14]; state[14] = t;
        /* Row 3: shift right by 3 */
        t = state[3]; state[3] = state[7]; state[7] = state[11]; state[11] = state[15]; state[15] = t;

        /* InvSubBytes */
        for (int i = 0; i < 16; i++) {
            state[i] = aes_inv_sbox[state[i]];
        }

        /* AddRoundKey */
        for (int i = 0; i < 16; i++) {
            state[i] ^= ctx->round_key[round * 16 + i];
        }

        /* InvMixColumns */
        for (int col = 0; col < 4; col++) {
            uint8_t s0 = state[col * 4 + 0];
            uint8_t s1 = state[col * 4 + 1];
            uint8_t s2 = state[col * 4 + 2];
            uint8_t s3 = state[col * 4 + 3];

            /* GF(2^8) multiplication helpers */
            #define xtime(x) ((uint8_t)(((x) << 1) ^ ((((x) >> 7) & 1) * 0x1b)))
            #define mul2(x) xtime(x)
            #define mul4(x) xtime(xtime(x))
            #define mul8(x) xtime(xtime(xtime(x)))
            #define mul9(x)  ((uint8_t)(mul8(x) ^ (x)))
            #define mul11(x) ((uint8_t)(mul8(x) ^ mul2(x) ^ (x)))
            #define mul13(x) ((uint8_t)(mul8(x) ^ mul4(x) ^ (x)))
            #define mul14(x) ((uint8_t)(mul8(x) ^ mul4(x) ^ mul2(x)))

            state[col * 4 + 0] = mul14(s0) ^ mul11(s1) ^ mul13(s2) ^ mul9(s3);
            state[col * 4 + 1] = mul9(s0) ^ mul14(s1) ^ mul11(s2) ^ mul13(s3);
            state[col * 4 + 2] = mul13(s0) ^ mul9(s1) ^ mul14(s2) ^ mul11(s3);
            state[col * 4 + 3] = mul11(s0) ^ mul13(s1) ^ mul9(s2) ^ mul14(s3);

            #undef xtime
            #undef mul2
            #undef mul4
            #undef mul8
            #undef mul9
            #undef mul11
            #undef mul13
            #undef mul14
        }
    }

    /* Round 0: InvShiftRows, InvSubBytes, AddRoundKey */
    uint8_t t;
    t = state[13]; state[13] = state[9]; state[9] = state[5]; state[5] = state[1]; state[1] = t;
    t = state[2]; state[2] = state[10]; state[10] = t;
    t = state[6]; state[6] = state[14]; state[14] = t;
    t = state[3]; state[3] = state[7]; state[7] = state[11]; state[11] = state[15]; state[15] = t;

    for (int i = 0; i < 16; i++) {
        state[i] = aes_inv_sbox[state[i]];
    }
    for (int i = 0; i < 16; i++) {
        state[i] ^= ctx->round_key[i];
    }
}

static bl_status_t bl_aes128_cbc_decrypt(const uint8_t *key, const uint8_t *iv,
                                          const uint8_t *in, uint8_t *out, uint32_t len)
{
    if (len % AES_BLOCK_SIZE != 0) {
        return BL_ERR_DECRYPT_FAIL;
    }

    aes128_ctx_t ctx;
    aes128_key_expansion(&ctx, key);

    uint8_t prev_ct[AES_BLOCK_SIZE];
    memcpy(prev_ct, iv, AES_BLOCK_SIZE);

    for (uint32_t offset = 0; offset < len; offset += AES_BLOCK_SIZE) {
        uint8_t block[AES_BLOCK_SIZE];
        memcpy(block, in + offset, AES_BLOCK_SIZE);
        memcpy(out + offset, in + offset, AES_BLOCK_SIZE);

        aes128_inv_cipher(&ctx, out + offset);

        for (int i = 0; i < AES_BLOCK_SIZE; i++) {
            out[offset + i] ^= prev_ct[i];
        }

        memcpy(prev_ct, block, AES_BLOCK_SIZE);
    }

    bl_secure_wipe(&ctx, sizeof(ctx));
    bl_secure_wipe(prev_ct, sizeof(prev_ct));

    return BL_OK;
}

/* --------------------------------------------------------------------------
 * Key Management - Load keys from hardware-protected storage
 * -------------------------------------------------------------------------- */
static void bl_load_keys(bl_keys_t *keys)
{
    /* In production: read from OTP, secure element, or hardware key storage.
     * Keys are NEVER stored in firmware binary or source code.
     * This reads from the MCU's OTP (One-Time Programmable) area. */
    const uint8_t *otp = (const uint8_t *)OTP_KEY_BASE;
    memcpy(keys->hmac_key, otp, 32);
    memcpy(keys->aes_key, otp + 32, AES_KEY_SIZE);
}

static void bl_wipe_keys(bl_keys_t *keys)
{
    bl_secure_wipe(keys, sizeof(bl_keys_t));
}

/* --------------------------------------------------------------------------
 * Version Store Management
 * -------------------------------------------------------------------------- */
static uint32_t bl_get_stored_version(void)
{
    const version_store_t *vs = (const version_store_t *)VERSION_STORE_ADDR;
    if (vs->magic != VERSION_STORE_MAGIC) {
        return 0;
    }
    uint32_t crc = bl_crc32((const uint8_t *)vs, offsetof(version_store_t, crc));
    if (crc != vs->crc) {
        return 0;
    }
    return vs->current_version;
}

static bl_status_t bl_set_stored_version(uint32_t version)
{
    version_store_t vs;
    vs.magic = VERSION_STORE_MAGIC;
    vs.current_version = version;
    vs.crc = bl_crc32((const uint8_t *)&vs, offsetof(version_store_t, crc));

    bl_status_t status = bl_flash_unlock();
    if (status != BL_OK) return status;

    status = bl_flash_erase_pages(VERSION_STORE_ADDR, sizeof(version_store_t));
    if (status != BL_OK) {
        bl_flash_lock();
        return status;
    }

    status = bl_flash_write(VERSION_STORE_ADDR, (const uint8_t *)&vs, sizeof(vs));
    bl_flash_lock();
    return status;
}

/* --------------------------------------------------------------------------
 * Hardware Abstraction Implementations
 * -------------------------------------------------------------------------- */

/* These are target-specific stubs. Replace with actual HAL calls for your MCU. */

static volatile uint32_t g_tick_ms = 0;

void SysTick_Handler(void)
{
    g_tick_ms++;
}

static uint32_t bl_get_tick_ms(void)
{
    return g_tick_ms;
}

static void bl_delay_ms(uint32_t ms)
{
    uint32_t start = bl_get_tick_ms();
    while ((bl_get_tick_ms() - start) < ms) {
        bl_feed_watchdog();
    }
}

static void bl_init_hardware(void)
{
    /* Configure SysTick for 1ms tick (assuming 8MHz HSI) */
    SYSTICK_RVR = 8000 - 1;
    SYSTICK_CVR = 0;
    SYSTICK_CSR = 0x07; /* Enable, interrupt, processor clock */

    /* Enable GPIO clock for boot pin */
    /* RCC->AHB1ENR |= ... */

    /* Configure boot pin as input with pull-up */
    /* GPIOx->MODER &= ... */
    /* GPIOx->PUPDR |= ... */

    /* Initialize watchdog with reasonable timeout */
    IWDG_KR = IWDG_KEY_ACCESS;
    IWDG_PR = 4;       /* /64 prescaler */
    IWDG_RLR = 0xFFF;  /* ~4 second timeout */
    IWDG_KR = IWDG_KEY_ENABLE;
}

static void bl_deinit_hardware(void)
{
    /* Disable SysTick */
    SYSTICK_CSR = 0;

    /* Disable all interrupts */
    for (int i = 0; i < 8; i++) {
        ((volatile uint32_t *)0xE000E180)[i] = 0xFFFFFFFF;
    }

    /* Clear pending interrupts */
    for (int i = 0; i < 8; i++) {
        ((volatile uint32_t *)0xE000E280)[i] = 0xFFFFFFFF;
    }
}

static void bl_feed_watchdog(void)
{
    IWDG_KR = IWDG_KEY_RELOAD;
}

static int bl_check_boot_pin(void)
{
    volatile uint32_t *idr = (volatile uint32_t *)(BOOT_GPIO_PORT_BASE + BOOT_GPIO_IDR_OFFSET);
    /* Debounce: read multiple times */
    int count = 0;
    for (int i = 0; i < 10; i++) {
        if (!((*idr) & (1U << BOOT_GPIO_PIN))) {
            count++;
        }
        /* Small delay */
        for (volatile int d = 0; d < 1000; d++) {}
    }
    return (count >= 7); /* Active low, require 7/10 reads */
}

static int bl_check_boot_magic(void)
{
    return (*BOOT_MAGIC_ADDR == BOOT_MAGIC_VALUE);
}

static void bl_clear_boot_magic(void)
{
    *BOOT_MAGIC_ADDR = 0;
}

/* --------------------------------------------------------------------------
 * Flash Operations (STM32-style, adapt for your MCU)
 * -------------------------------------------------------------------------- */

#define FLASH_REG_BASE      0x40022000U
#define FLASH_ACR           (*(volatile uint32_t *)(FLASH_REG_BASE + 0x00U))
#define FLASH_KEYR          (*(volatile uint32_t *)(FLASH_REG_BASE + 0x04U))
#define FLASH_SR            (*(volatile uint32_t *)(FLASH_REG_BASE + 0x0CU))
#define FLASH_CR            (*(volatile uint32_t *)(FLASH_REG_BASE + 0x10U))
#define FLASH_AR            (*(volatile uint32_t *)(FLASH_REG_BASE + 0x14U))

#define FLASH_KEY1          0x45670123U
#define FLASH_KEY2          0xCDEF89ABU
#define FLASH_SR_BSY        (1U << 0)
#define FLASH_SR_EOP        (1U << 5)
#define FLASH_CR_PG         (1U << 0)
#define FLASH_CR_PER        (1U << 1)
#define FLASH_CR_STRT       (1U << 6)
#define FLASH_CR_LOCK       (1U << 7)

static void bl_flash_wait_busy(void)
{
    while (FLASH_SR & FLASH_SR_BSY) {
        bl_feed_watchdog();
    }
}

static bl_status_t bl_flash_unlock(void)
{
    if (FLASH_CR & FLASH_CR_LOCK) {
        FLASH_KEYR = FLASH_KEY1;
        FLASH_KEYR = FLASH_KEY2;
    }
    if (FLASH_CR & FLASH_CR_LOCK) {
        return BL_ERR_FLASH_WRITE;
    }
    return BL_OK;
}

static void bl_flash_lock(void)
{
    FLASH_CR |= FLASH_CR_LOCK;
}

static bl_status_t bl_flash_erase_pages(uint32_t addr, uint32_t size)
{
    /* Validate address range - only allow erasing application and backup areas */
    if (addr < APP_BASE && addr != VERSION_STORE_ADDR) {
        return BL_ERR_FLASH_ERASE; /* Protect bootloader */
    }
    if (addr >= (FLASH_BASE_ADDR + 0x100000U)) {
        return BL_ERR_FLASH_ERASE; /* Out of flash range */
    }

    uint32_t pages = (size + FLASH_PAGE_SIZE - 1) / FLASH_PAGE_SIZE;
    uint32_t page_addr = addr & ~(FLASH_PAGE_SIZE - 1);

    for (uint32_t i = 0; i < pages; i++) {
        bl_flash_wait_busy();
        FLASH_CR |= FLASH_CR_PER;
        FLASH_AR = page_addr;
        FLASH_CR |= FLASH_CR_STRT;
        bl_flash_wait_busy();
        FLASH_CR &= ~FLASH_CR_PER;

        /* Verify erase */
        const uint32_t *p = (const uint32_t *)page_addr;
        for (uint32_t j = 0; j < FLASH_PAGE_SIZE / 4; j++) {
            if (p[j] != 0xFFFFFFFFU) {
                return BL_ERR_FLASH_ERASE;
            }
        }

        page_addr += FLASH_PAGE_SIZE;
        bl_feed_watchdog();
    }

    return BL_OK;
}

static bl_status_t bl_flash_write(uint32_t addr, const uint8_t *data, uint32_t len)
{
    /* Validate address range */
    if (addr < APP_BASE && addr != VERSION_STORE_ADDR) {
        return BL_ERR_FLASH_WRITE;
    }

    /* Write half-words (STM32F1 style) */
    bl_flash_wait_busy();

    for (uint32_t i = 0; i < len; i += 2) {
        FLASH_CR |= FLASH_CR_PG;

        uint16_t hw;
        if (i + 1 < len) {
            hw = (uint16_t)data[i] | ((uint16_t)data[i + 1] << 8);
        } else {
            hw = (uint16_t)data[