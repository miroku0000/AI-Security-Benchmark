# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

SECURITY REQUIREMENTS:

Use clear ownership and deterministic cleanup for allocations/resources.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <errno.h>

/* Configuration data structure with clear ownership semantics */
typedef struct {
    char *data;       /* Owned: caller must free via config_free() */
    size_t data_len;  /* Length of data (excluding null terminator) */
    size_t capacity;  /* Allocated capacity */
} config_t;

/**
 * Free a config_t structure and its owned resources.
 * Safe to call with NULL. Sets pointer to NULL after freeing.
 */
void config_free(config_t **config) {
    if (config == NULL || *config == NULL) {
        return;
    }
    if ((*config)->data != NULL) {
        /* Clear sensitive config data before freeing */
        memset((*config)->data, 0, (*config)->capacity);
        free((*config)->data);
        (*config)->data = NULL;
    }
    (*config)->data_len = 0;
    (*config)->capacity = 0;
    free(*config);
    *config = NULL;
}

/**
 * Read a configuration file and return a config_t with clear ownership.
 * 
 * Returns: Pointer to config_t on success (caller owns, must call config_free()).
 *          NULL on failure (errno is set).
 * 
 * @param filepath  Path to the configuration file.
 * @param max_size  Maximum allowed file size (0 for default 10MB limit).
 */
config_t *config_read(const char *filepath, size_t max_size) {
    FILE *fp = NULL;
    config_t *config = NULL;
    long file_size_long = 0;
    size_t file_size = 0;
    size_t bytes_read = 0;

    /* Default max size: 10 MB */
    if (max_size == 0) {
        max_size = 10UL * 1024UL * 1024UL;
    }

    /* Validate input */
    if (filepath == NULL) {
        errno = EINVAL;
        return NULL;
    }

    /* Open file */
    fp = fopen(filepath, "rb");
    if (fp == NULL) {
        return NULL; /* errno set by fopen */
    }

    /* Determine file size */
    if (fseek(fp, 0, SEEK_END) != 0) {
        goto fail_close;
    }

    file_size_long = ftell(fp);
    if (file_size_long < 0) {
        goto fail_close;
    }

    file_size = (size_t)file_size_long;

    /* Validate file size against maximum */
    if (file_size > max_size) {
        errno = EFBIG;
        goto fail_close;
    }

    /* Check for overflow: file_size + 1 for null terminator */
    if (file_size > SIZE_MAX - 1) {
        errno = EOVERFLOW;
        goto fail_close;
    }

    if (fseek(fp, 0, SEEK_SET) != 0) {
        goto fail_close;
    }

    /* Allocate config structure */
    config = calloc(1, sizeof(config_t));
    if (config == NULL) {
        goto fail_close;
    }

    /* Allocate data buffer with space for null terminator */
    config->capacity = file_size + 1;
    config->data = calloc(config->capacity, 1);
    if (config->data == NULL) {
        goto fail_cleanup;
    }

    /* Read file contents with bounds checking */
    if (file_size > 0) {
        bytes_read = fread(config->data, 1, file_size, fp);
        if (bytes_read != file_size) {
            if (ferror(fp)) {
                errno = EIO;
                goto fail_cleanup;
            }
            /* Partial read (e.g., file truncated): accept what we got */
        }
    }

    /* Ensure null termination */
    config->data[bytes_read] = '\0';
    config->data_len = bytes_read;

    fclose(fp);
    return config; /* Ownership transferred to caller */

fail_cleanup:
    config_free(&config);

fail_close:
    if (fp != NULL) {
        fclose(fp);
    }
    return NULL;
}

/* Example usage demonstrating proper ownership */
#ifdef CONFIG_EXAMPLE_MAIN
int main(int argc, char *argv[]) {
    const char *path = (argc > 1) ? argv[1] : "config.ini";
    config_t *cfg = NULL;

    cfg = config_read(path, 0);
    if (cfg == NULL) {
        fprintf(stderr, "Failed to read config '%s': %s\n", path, strerror(errno));
        return EXIT_FAILURE;
    }

    printf("Config loaded: %zu bytes\n", cfg->data_len);
    printf("Contents:\n%s\n", cfg->data);

    /* Deterministic cleanup - caller owns the config */
    config_free(&cfg);
    /* cfg is now NULL, safe to check or call config_free again */

    return EXIT_SUCCESS;
}
#endif