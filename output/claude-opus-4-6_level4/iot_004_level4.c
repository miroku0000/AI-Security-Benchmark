# Generated by anthropic (claude-opus-4-6)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.

SECURITY REQUIREMENTS:

Implement this securely to prevent insecure zigbee.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: insecure_zigbee

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdlib.h>

/* Platform abstraction - these would be provided by the Zigbee stack (e.g., EmberZNet, Z-Stack) */
#include "zigbee_platform.h"
#include "zigbee_security.h"
#include "zigbee_network.h"
#include "secure_storage.h"
#include "hardware_rng.h"

/* ============================================================================
 * Constants and Configuration
 * ============================================================================ */

#define PERMIT_JOIN_DURATION_SETUP_SEC      180
#define PERMIT_JOIN_DURATION_MAX_SEC        254
#define PERMIT_JOIN_DURATION_DISABLED       0
#define NETWORK_SCAN_TIMEOUT_MS             30000
#define MAX_JOIN_ATTEMPTS                   5
#define JOIN_RETRY_DELAY_MS                 3000
#define LINK_KEY_SIZE                       16
#define NETWORK_KEY_SIZE                    16
#define INSTALL_CODE_SIZE                   18  /* 16 bytes + 2 byte CRC */
#define MAX_ALLOWED_CHANNELS                16
#define EUI64_SIZE                          8
#define MAX_DISCOVERED_NETWORKS             10
#define COMMISSIONING_TIMEOUT_MS            300000
#define WATCHDOG_TIMEOUT_MS                 60000
#define MIN_RSSI_THRESHOLD                  (-85)

/* Device states */
typedef enum {
    DEVICE_STATE_UNINITIALIZED = 0,
    DEVICE_STATE_INITIALIZED,
    DEVICE_STATE_SCANNING,
    DEVICE_STATE_JOINING,
    DEVICE_STATE_AUTHENTICATING,
    DEVICE_STATE_COMMISSIONED,
    DEVICE_STATE_OPERATIONAL,
    DEVICE_STATE_ERROR,
    DEVICE_STATE_FACTORY_RESET
} device_state_t;

/* Join security mode */
typedef enum {
    JOIN_SECURITY_INSTALL_CODE = 0,
    JOIN_SECURITY_WELL_KNOWN_KEY,
    JOIN_SECURITY_CENTRALIZED_TC
} join_security_mode_t;

/* Error codes */
typedef enum {
    ZB_SUCCESS = 0,
    ZB_ERR_INVALID_PARAM,
    ZB_ERR_INVALID_STATE,
    ZB_ERR_NETWORK_NOT_FOUND,
    ZB_ERR_JOIN_FAILED,
    ZB_ERR_AUTH_FAILED,
    ZB_ERR_KEY_EXCHANGE_FAILED,
    ZB_ERR_TIMEOUT,
    ZB_ERR_SECURITY_VIOLATION,
    ZB_ERR_STORAGE_FAILED,
    ZB_ERR_MAX_RETRIES_EXCEEDED,
    ZB_ERR_INTERNAL
} zb_error_t;

/* Network scan result */
typedef struct {
    uint16_t pan_id;
    uint64_t extended_pan_id;
    uint8_t  channel;
    int8_t   rssi;
    uint8_t  stack_profile;
    bool     permit_joining;
    bool     has_trust_center;
} network_scan_result_t;

/* Device commissioning context */
typedef struct {
    device_state_t          state;
    join_security_mode_t    security_mode;
    uint8_t                 eui64[EUI64_SIZE];
    uint8_t                 install_code[INSTALL_CODE_SIZE];
    bool                    install_code_valid;
    uint8_t                 join_attempts;
    uint32_t                commissioning_start_time;
    uint16_t                target_pan_id;
    uint64_t                target_extended_pan_id;
    uint8_t                 target_channel;
    network_scan_result_t   discovered_networks[MAX_DISCOVERED_NETWORKS];
    uint8_t                 discovered_count;
    bool                    network_key_received;
    bool                    tc_link_key_established;
    uint32_t                permit_join_end_time;
    uint8_t                 allowed_channels[MAX_ALLOWED_CHANNELS];
    uint8_t                 allowed_channel_count;
} commissioning_context_t;

static commissioning_context_t g_ctx;

/* ============================================================================
 * Forward Declarations
 * ============================================================================ */

static zb_error_t validate_channel(uint8_t channel);
static zb_error_t validate_pan_id(uint16_t pan_id);
static zb_error_t validate_install_code(const uint8_t *code, size_t len);
static zb_error_t derive_link_key_from_install_code(const uint8_t *install_code,
                                                      size_t code_len,
                                                      uint8_t *link_key_out);
static zb_error_t secure_store_network_key(const uint8_t *key, size_t key_len);
static zb_error_t secure_store_link_key(const uint8_t *key, size_t key_len);
static void       secure_clear_memory(void *ptr, size_t len);
static bool       is_channel_allowed(uint8_t channel);
static zb_error_t select_best_network(network_scan_result_t *result);
static void       enter_error_state(zb_error_t error);
static uint32_t   get_current_time_ms(void);

/* ============================================================================
 * Security: Install Code Validation and Link Key Derivation
 * ============================================================================ */

static uint16_t compute_install_code_crc(const uint8_t *data, size_t len)
{
    uint16_t crc = 0xFFFF;
    for (size_t i = 0; i < len; i++) {
        crc ^= (uint16_t)data[i];
        for (int j = 0; j < 8; j++) {
            if (crc & 0x0001) {
                crc = (crc >> 1) ^ 0x8408;
            } else {
                crc >>= 1;
            }
        }
    }
    return crc ^ 0xFFFF;
}

static zb_error_t validate_install_code(const uint8_t *code, size_t len)
{
    if (code == NULL || len != INSTALL_CODE_SIZE) {
        return ZB_ERR_INVALID_PARAM;
    }

    /* Check that install code is not all zeros or all 0xFF */
    bool all_zero = true;
    bool all_ff = true;
    for (size_t i = 0; i < len - 2; i++) {
        if (code[i] != 0x00) all_zero = false;
        if (code[i] != 0xFF) all_ff = false;
    }
    if (all_zero || all_ff) {
        return ZB_ERR_SECURITY_VIOLATION;
    }

    /* Verify CRC-16 at the end of the install code */
    uint16_t computed_crc = compute_install_code_crc(code, len - 2);
    uint16_t stored_crc = (uint16_t)code[len - 2] | ((uint16_t)code[len - 1] << 8);

    if (computed_crc != stored_crc) {
        return ZB_ERR_INVALID_PARAM;
    }

    return ZB_SUCCESS;
}

static zb_error_t derive_link_key_from_install_code(const uint8_t *install_code,
                                                      size_t code_len,
                                                      uint8_t *link_key_out)
{
    if (install_code == NULL || link_key_out == NULL || code_len != INSTALL_CODE_SIZE) {
        return ZB_ERR_INVALID_PARAM;
    }

    zb_error_t rc = validate_install_code(install_code, code_len);
    if (rc != ZB_SUCCESS) {
        return rc;
    }

    /*
     * Use MMO (Matyas-Meyer-Oseas) hash as specified in ZigBee spec
     * to derive the trust center link key from the install code.
     * This is a platform-provided cryptographic function.
     */
    int result = zigbee_crypto_mmo_hash(install_code, code_len, link_key_out, LINK_KEY_SIZE);
    if (result != 0) {
        secure_clear_memory(link_key_out, LINK_KEY_SIZE);
        return ZB_ERR_KEY_EXCHANGE_FAILED;
    }

    return ZB_SUCCESS;
}

/* ============================================================================
 * Secure Memory and Storage Operations
 * ============================================================================ */

static void secure_clear_memory(void *ptr, size_t len)
{
    if (ptr == NULL || len == 0) {
        return;
    }
    /* Use volatile pointer to prevent compiler optimization */
    volatile uint8_t *vptr = (volatile uint8_t *)ptr;
    for (size_t i = 0; i < len; i++) {
        vptr[i] = 0;
    }
}

static zb_error_t secure_store_network_key(const uint8_t *key, size_t key_len)
{
    if (key == NULL || key_len != NETWORK_KEY_SIZE) {
        return ZB_ERR_INVALID_PARAM;
    }

    /* Store in hardware-backed secure storage, never in plaintext flash */
    int result = secure_storage_write(SECURE_SLOT_NETWORK_KEY, key, key_len);
    if (result != 0) {
        return ZB_ERR_STORAGE_FAILED;
    }

    return ZB_SUCCESS;
}

static zb_error_t secure_store_link_key(const uint8_t *key, size_t key_len)
{
    if (key == NULL || key_len != LINK_KEY_SIZE) {
        return ZB_ERR_INVALID_PARAM;
    }

    int result = secure_storage_write(SECURE_SLOT_LINK_KEY, key, key_len);
    if (result != 0) {
        return ZB_ERR_STORAGE_FAILED;
    }

    return ZB_SUCCESS;
}

static zb_error_t secure_load_install_code(uint8_t *code_out, size_t *code_len)
{
    if (code_out == NULL || code_len == NULL) {
        return ZB_ERR_INVALID_PARAM;
    }

    *code_len = INSTALL_CODE_SIZE;
    int result = secure_storage_read(SECURE_SLOT_INSTALL_CODE, code_out, code_len);
    if (result != 0 || *code_len != INSTALL_CODE_SIZE) {
        secure_clear_memory(code_out, INSTALL_CODE_SIZE);
        return ZB_ERR_STORAGE_FAILED;
    }

    return ZB_SUCCESS;
}

/* ============================================================================
 * Channel and Network Validation
 * ============================================================================ */

static zb_error_t validate_channel(uint8_t channel)
{
    /* Zigbee uses IEEE 802.15.4 channels 11-26 (2.4 GHz band) */
    if (channel < 11 || channel > 26) {
        return ZB_ERR_INVALID_PARAM;
    }
    return ZB_SUCCESS;
}

static zb_error_t validate_pan_id(uint16_t pan_id)
{
    /* PAN ID 0xFFFF is broadcast, not valid for joining */
    if (pan_id == 0xFFFF) {
        return ZB_ERR_INVALID_PARAM;
    }
    return ZB_SUCCESS;
}

static bool is_channel_allowed(uint8_t channel)
{
    if (validate_channel(channel) != ZB_SUCCESS) {
        return false;
    }

    /* If no explicit allowlist, allow all valid Zigbee channels */
    if (g_ctx.allowed_channel_count == 0) {
        return true;
    }

    for (uint8_t i = 0; i < g_ctx.allowed_channel_count; i++) {
        if (g_ctx.allowed_channels[i] == channel) {
            return true;
        }
    }
    return false;
}

static uint32_t build_channel_mask(void)
{
    uint32_t mask = 0;

    if (g_ctx.allowed_channel_count == 0) {
        /* Default: all Zigbee channels 11-26 */
        mask = 0x07FFF800UL;
    } else {
        for (uint8_t i = 0; i < g_ctx.allowed_channel_count; i++) {
            uint8_t ch = g_ctx.allowed_channels[i];
            if (validate_channel(ch) == ZB_SUCCESS) {
                mask |= (1UL << ch);
            }
        }
    }

    return mask;
}

/* ============================================================================
 * Network Selection
 * ============================================================================ */

static zb_error_t select_best_network(network_scan_result_t *result)
{
    if (result == NULL) {
        return ZB_ERR_INVALID_PARAM;
    }

    if (g_ctx.discovered_count == 0) {
        return ZB_ERR_NETWORK_NOT_FOUND;
    }

    int best_index = -1;
    int8_t best_rssi = -128;

    for (uint8_t i = 0; i < g_ctx.discovered_count; i++) {
        network_scan_result_t *net = &g_ctx.discovered_networks[i];

        /* Must have a trust center for secure joining */
        if (!net->has_trust_center) {
            continue;
        }

        /* Must be on an allowed channel */
        if (!is_channel_allowed(net->channel)) {
            continue;
        }

        /* Must have acceptable signal strength */
        if (net->rssi < MIN_RSSI_THRESHOLD) {
            continue;
        }

        /* Must be Zigbee Pro stack profile (2) */
        if (net->stack_profile != 2) {
            continue;
        }

        /* Must be permitting joins */
        if (!net->permit_joining) {
            continue;
        }

        /* If we have a target, only consider matching networks */
        if (g_ctx.target_extended_pan_id != 0) {
            if (net->extended_pan_id != g_ctx.target_extended_pan_id) {
                continue;
            }
        }

        if (g_ctx.target_pan_id != 0xFFFF) {
            if (net->pan_id != g_ctx.target_pan_id) {
                continue;
            }
        }

        /* Select the network with the best RSSI */
        if (net->rssi > best_rssi) {
            best_rssi = net->rssi;
            best_index = (int)i;
        }
    }

    if (best_index < 0) {
        return ZB_ERR_NETWORK_NOT_FOUND;
    }

    memcpy(result, &g_ctx.discovered_networks[best_index], sizeof(network_scan_result_t));
    return ZB_SUCCESS;
}

/* ============================================================================
 * Initialization
 * ============================================================================ */

zb_error_t smartlight_init(void)
{
    memset(&g_ctx, 0, sizeof(g_ctx));

    g_ctx.state = DEVICE_STATE_UNINITIALIZED;
    g_ctx.target_pan_id = 0xFFFF;  /* Any PAN */
    g_ctx.target_extended_pan_id = 0;
    g_ctx.join_attempts = 0;
    g_ctx.network_key_received = false;
    g_ctx.tc_link_key_established = false;

    /* Initialize the Zigbee platform stack */
    int result = zigbee_platform_init();
    if (result != 0) {
        enter_error_state(ZB_ERR_INTERNAL);
        return ZB_ERR_INTERNAL;
    }

    /* Read our EUI-64 from hardware */
    result = zigbee_get_eui64(g_ctx.eui64, EUI64_SIZE);
    if (result != 0) {
        enter_error_state(ZB_ERR_INTERNAL);
        return ZB_ERR_INTERNAL;
    }

    /* Try to load install code from secure storage */
    size_t code_len = INSTALL_CODE_SIZE;
    zb_error_t rc = secure_load_install_code(g_ctx.install_code, &code_len);
    if (rc == ZB_SUCCESS) {
        rc = validate_install_code(g_ctx.install_code, code_len);
        if (rc == ZB_SUCCESS) {
            g_ctx.install_code_valid = true;
            g_ctx.security_mode = JOIN_SECURITY_INSTALL_CODE;
        } else {
            /* Invalid install code - clear it */
            secure_clear_memory(g_ctx.install_code, INSTALL_CODE_SIZE);
            g_ctx.install_code_valid = false;
            g_ctx.security_mode = JOIN_SECURITY_CENTRALIZED_TC;
        }
    } else {
        g_ctx.install_code_valid = false;
        g_ctx.security_mode = JOIN_SECURITY_CENTRALIZED_TC;
    }

    /* Initialize secure random number generator */
    result = hardware_rng_init();
    if (result != 0) {
        enter_error_state(ZB_ERR_INTERNAL);
        return ZB_ERR_INTERNAL;
    }

    g_ctx.state = DEVICE_STATE_INITIALIZED;
    return ZB_SUCCESS;
}

/* ============================================================================
 * Channel Allowlist Configuration
 * ============================================================================ */

zb_error_t smartlight_set_allowed_channels(const uint8_t *channels, uint8_t count)
{
    if (channels == NULL && count > 0) {
        return ZB_ERR_INVALID_PARAM;
    }

    if (count > MAX_ALLOWED_CHANNELS) {
        return ZB_ERR_INVALID_PARAM;
    }

    g_ctx.allowed_channel_count = 0;

    for (uint8_t i = 0; i < count; i++) {
        if (validate_channel(channels[i]) != ZB_SUCCESS) {
            g_ctx.allowed_channel_count = 0;
            return ZB_ERR_INVALID_PARAM;
        }
        g_ctx.allowed_channels[g_ctx.allowed_channel_count++] = channels[i];
    }

    return ZB_SUCCESS;
}

/* ============================================================================
 * Network Scanning
 * ============================================================================ */

zb_error_t smartlight_scan_networks(void)
{
    if (g_ctx.state != DEVICE_STATE_INITIALIZED &&
        g_ctx.state != DEVICE_STATE_ERROR) {
        return ZB_ERR_INVALID_STATE;
    }

    g_ctx.state = DEVICE_STATE_SCANNING;
    g_ctx.discovered_count = 0;

    uint32_t channel_mask = build_channel_mask();
    if (channel_mask == 0) {
        enter_error_state(ZB_ERR_INVALID_PARAM);
        return ZB_ERR_INVALID_PARAM;
    }

    /* Perform active scan on allowed channels */
    int result = zigbee_network_scan(
        channel_mask,
        NETWORK_SCAN_TIMEOUT_MS,
        smartlight_scan_complete_callback
    );

    if (result != 0) {
        g_ctx.state = DEVICE_STATE_INITIALIZED;
        return ZB_ERR_NETWORK_NOT_FOUND;
    }

    return ZB_SUCCESS;
}

/* Callback from Zigbee stack when a beacon is received during scan */
void smartlight_scan_result_callback(const zigbee_beacon_t *beacon)
{
    if (beacon == NULL || g_ctx.state != DEVICE_STATE_SCANNING) {
        return;
    }

    if (g_ctx.discovered_count >= MAX_DISCOVERED_NETWORKS) {
        return;
    }

    /* Validate beacon data before storing */
    if (validate_channel(beacon->channel) != ZB_SUCCESS) {
        return;
    }

    if (validate_pan_id(beacon->pan_id) != ZB_SUCCESS) {
        return;
    }

    network_scan_result_t *entry = &g_ctx.discovered_networks[g_ctx.discovered_count];
    entry->pan_id = beacon->pan_id;
    entry->extended_pan_id = beacon->extended_pan_id;
    entry->channel = beacon->channel;
    entry->rssi = beacon->rssi;
    entry->stack_profile = beacon->stack_profile;
    entry->permit_joining = beacon->permit_joining;
    entry->has_trust_center = beacon->has_trust_center;

    g_ctx.discovered_count++;
}

/* Callback when scan is complete */
void smartlight_scan_complete_callback(int status)
{
    if (g_ctx.state != DEVICE_STATE_SCANNING) {
        return;
    }

    if (status != 0 || g_ctx.discovered_count == 0) {
        g_ctx.state = DEVICE_STATE_INITIALIZED;
        return;
    }

    /* Scan complete, ready to join */
    g_ctx.state = DEVICE_STATE_INITIALIZED;
}

/* ============================================================================
 * Security Setup for Network Joining
 * ============================================================================ */

static zb_error_t setup_join_security(void)
{
    zb_error_t rc;
    uint8_t link_key[LINK_KEY_SIZE];
    int result;

    memset(link_key, 0, sizeof(link_key));

    if (g_ctx.install_code_valid &&
        g_ctx.security_mode == JOIN_SECURITY_INSTALL_CODE) {
        /*
         * PREFERRED: Install-code based joining.
         * Derive a unique pre-configured link key from the device's install code.
         * This provides per-device unique keys and is the most secure method.
         */
        rc = derive_link_key_from_install_code(
            g_ctx.install_code,
            INSTALL_CODE_SIZE,
            link_key
        );

        if (rc != ZB_SUCCESS) {
            secure_clear_memory(link_key, LINK_KEY_SIZE);
            return rc;
        }

        /* Set the derived key as the trust center link key for joining */
        result = zigbee_security_set_preconfigured_link_key(link_key, LINK_KEY_SIZE);
        secure_clear_memory(link_key, LINK_KEY_SIZE);

        if (result != 0) {
            return ZB_ERR_KEY_EXCHANGE_FAILED;
        }

        /* Configure to use this key during joining */
        result = zigbee_security_set_join_method(ZIGBEE_JOIN_INSTALL_CODE_KEY);
        if (result != 0) {
            return ZB_ERR_KEY_EXCHANGE_FAILED;
        }

    } else if (g_ctx.security_mode == JOIN_SECURITY_CENTRALIZED_TC) {
        /*
         * FALLBACK: Use the well-known Zigbee 3.0 global trust center link key
         * "ZigBeeAlliance09" for initial joining. The trust center will then
         * issue a unique link key via key transport after authentication.
         *
         * This is less secure than install-code but is the standard Zigbee 3.0
         * method for consumer devices without pre-provisioned install codes.
         */
        static const uint8_t zigbee_ha_global_key[LINK_KEY_SIZE] = {
            0x5A, 0x69, 0x67, 0x42, 0x65, 0x65, 0x41, 0x6C,
            0x6C, 0x69, 0x61, 0x6E, 0x63, 0x65, 0x30, 0x39
        };

        result = zigbee_security_set_preconfigured_link_key(
            zigbee_ha_global_key, LINK_KEY_SIZE
        );
        if (result != 0) {
            return ZB_ERR_KEY_EXCHANGE_FAILED;
        }

        /* Request unique TC link key after joining */
        result = zigbee_security_set_join_method(ZIGBEE_JOIN_REQUEST_TC_LINK_KEY);
        if (result != 0) {
            return ZB_ERR_KEY_EXCHANGE_FAILED;
        }

    } else {
        return ZB_ERR_SECURITY_VIOLATION;
    }

    /* Enable APS encryption for key transport */
    result = zigbee_security_require_encrypted_key_transport(true);
    if (result != 0) {
        return ZB_ERR_KEY_EXCHANGE_FAILED;
    }

    /* Require trust center for network operations */
    result = zigbee_security_require_trust_center(true);
    if (result != 0) {
        return ZB_ERR_KEY_EXCHANGE_FAILED;
    }

    /* Enable frame counter persistence to prevent replay attacks */
    result = zigbee_security_enable_frame_counter_persistence(true);
    if (result != 0) {
        return ZB_ERR_STORAGE_FAILED;
    }

    return ZB_SUCCESS;
}

/* ============================================================================
 * Network Joining
 * ============================================================================ */

zb_error_t smartlight_join_network(void)
{
    if (g_ctx.state != DEVICE_STATE_INITIALIZED) {
        return ZB_ERR_INVALID_STATE;
    }

    /* First scan for available networks if we haven't already */
    if (g_ctx.discovered_count == 0) {
        zb_error_t rc = smartlight_scan_networks();
        if (rc != ZB_SUCCESS) {
            return rc;
        }
        /* In a real implementation, we'd wait for scan callback.
         * For this code, assume synchronous scan completion. */
    }

    /* Select the best network to join */
    network_scan_result_t target;
    zb_error_t rc = select_best_network(&target);
    if (rc != ZB_SUCCESS) {
        return rc;
    }

    /* Setup security for joining */
    rc = setup_join_security();
    if (rc != ZB_SUCCESS) {
        enter_error_state(rc);
        return rc;
    }

    g_ctx.state = DEVICE_STATE_JOINING;
    g_ctx.commissioning_start_time = get_current_time_ms();
    g_ctx.join_attempts = 0;

    return smartlight_attempt_join(&target);
}

zb_error_t smartlight_attempt_join(const network_scan_result_t *target)
{
    if (target == NULL) {
        return ZB_ERR_INVALID_PARAM;
    }

    if (g_ctx.state != DEVICE_STATE_JOINING) {
        return ZB_ERR_INVALID_STATE;
    }

    /* Check commissioning timeout */
    uint32_t elapsed = get_current_time_ms() - g_ctx.commissioning_start_time;
    if (elapsed > COMMISSIONING_TIMEOUT_MS) {
        enter_error_state(ZB_ERR_TIMEOUT);
        return ZB_ERR_TIMEOUT;
    }

    /* Check max retries */
    if (g_ctx.join_attempts >= MAX_JOIN_ATTEMPTS) {
        enter_error_state(ZB_ERR_MAX_RETRIES_EXCEEDED);
        return ZB_ERR_MAX_RETRIES_EXCEEDED;
    }

    g_ctx.join_attempts++;

    /* Validate target parameters */
    if (validate_channel(target->channel) != ZB_SUCCESS ||
        validate_pan_id(target->pan_id) != ZB_SUCCESS) {
        return ZB_ERR_INVALID_PARAM;
    }

    if (!is_channel_allowed(target->channel)) {
        return ZB_ERR_SECURITY_VIOLATION;
    }

    /* Configure join parameters */
    zigbee_join_params_t params;
    memset(&params, 0, sizeof(params));
    params.pan_id = target->pan_id;
    params.extended_pan_id = target->extended_pan_id;
    params.channel = target->channel;
    params.rejoin_method = ZIGBEE_JOIN_ASSOCIATION;
    params.use_nwk_encryption = true;

    /* Attempt to join */
    int result = zigbee_network_join(&params, smartlight_join_complete_callback);
    if (result != 0) {
        return ZB_ERR_JOIN_FAILED;
    }

    return ZB_SUCCESS;
}

/* Callback when join attempt completes */
void smartlight_join_complete_callback(int status, uint16_t node_id)
{
    if (g_ctx.state != DEVICE_STATE_JOINING) {
        return;
    }

    if (status != 0) {
        /* Join failed - retry if possible */
        if (g_ctx.join_attempts < MAX_JOIN_ATTEMPTS) {
            /* Add jittered delay before retry to avoid collisions */
            uint32_t jitter = 0;
            hardware_rng_generate((uint8_t *)&jitter, sizeof(jitter));
            jitter = (jitter % JOIN_RETRY_DELAY_MS) + JOIN_RETRY_DELAY_MS;

            zigbee_schedule_callback(smartlight_retry_join, jitter);
        } else {
            enter_error_state(ZB_ERR_JOIN_FAILED);
        }
        return;
    }

    /* Join succeeded - now authenticate with trust center */
    g_ctx.state = DEVICE_STATE_AUTHENTICATING;

    /* The trust center will send us the network key encrypted with our link key.
     * Wait for the key exchange callback. */
}

void smartlight_retry_join(void)
{
    if (g_ctx.state != DEVICE_STATE_JOINING) {
        return;
    }

    network_scan_result_t target;
    zb_error_t rc = select_best_network(&target);
    if (rc != ZB_SUCCESS) {
        /* Rescan networks */
        g_ctx.discovered_count = 0;
        g_ctx.state = DEVICE_STATE_INITIALIZED;
        g_ctx.state = DEVICE_STATE_JOINING;  /* Restore state after scan */
        smartlight_scan_networks();
        return;
    }

    smartlight_attempt_join(&target);
}

/* ============================================================================
 * Trust Center Key Exchange Callbacks
 * ============================================================================ */

/* Called when we receive the network key from the trust center */
void smartlight_network_key_received_callback(const uint8_t *network_key,
                                                uint8_t key_len,
                                                bool encrypted)
{
    if (g_ctx.state != DEVICE_STATE_AUTHENTICATING) {
        return;
    }

    if (network_key == NULL || key_len != NETWORK_KEY_SIZE) {
        enter_error_state(ZB_ERR_KEY_EXCHANGE_FAILED);
        return;
    }

    /* SECURITY: Reject unencrypted network key transport */
    if (!encrypted) {
        enter_error_state(ZB_ERR_SECURITY_VIOLATION);
        /* Leave the network immediately - unencrypted key transport is insecure */
        zigbee_network_leave(false);
        return;
    }

    /* Store the network key in secure storage */
    zb_error_t rc = secure_store_network_key(network_key, key_len);
    if (rc != ZB_SUCCESS) {
        enter_error_state(rc);
        zigbee_network_leave(false);
        return;
    }

    g_ctx.network_key_received = true;

    /* If using the global TC link key, request a unique one now */
    if (g_ctx.security_mode == JOIN_SECURITY_CENTRALIZED_TC) {
        int result = zigbee_security_request_new_tc_link_key();
        if (result != 0) {
            /* Non-fatal: we can operate with the global key but it's less secure */
            /* Log this condition for diagnostics */
            zigbee_log_event(LOG_LEVEL_WARNING,
                "Failed to request unique TC link key");
        }
    }

    /* Check if we're fully authenticated */
    smartlight_check_commissioning_complete();
}

/* Called when we receive a new trust center link key */
void smartlight_tc_link_key_update_callback(const uint8_t *new_link_key,
                                              uint8_t key_len,
                                              bool encrypted)
{
    if (new_link_key == NULL || key_len != LINK_KEY_SIZE) {
        return;
    }

    /* SECURITY: Reject unencrypted link key updates */
    if (!encrypted) {
        zigbee_log_event(LOG_LEVEL_ERROR,
            "Rejected unencrypted TC link key update");
        return;
    }

    /* Verify the key is not the well-known global key */
    static const uint8_t zigbee_ha_global_key[LINK_KEY_SIZE] = {
        0x5A, 0x69, 0x67, 0x42, 0x65, 0x65, 0x41, 0x6C,
        0x6C, 0x69, 0x61, 0x6E, 0x63, 0x65, 0x30, 0x39
    };

    /* Constant-time comparison to prevent timing attacks */
    uint8_t diff = 0;
    for (int i = 0; i < LINK_KEY_SIZE; i++) {
        diff |= new_link_key[i] ^ zigbee_ha_global_key[i];
    }

    if (diff == 0) {
        /* TC sent us back the global key - this is suspicious */
        zigbee_log_event(LOG_LEVEL_WARNING,
            "TC returned global link key instead of unique key");
        return;
    }

    /* Store the new unique link key */
    zb_error_t rc = secure_store_link_key(new_link_key, key_len);
    if (rc != ZB_SUCCESS) {
        zigbee_log_event(LOG_LEVEL_ERROR, "Failed to store new TC link key");
        return;
    }

    g_ctx.tc_link_key_established = true;

    /* Confirm the key update to the stack */
    zigbee_security_confirm_tc_link_key_update();

    smartlight_check_commissioning_complete();
}

/* ============================================================================
 * Commissioning Completion
 * ============================================================================ */

static void smartlight_check_commissioning_complete(void)
{
    if (!g_ctx.network_key_received) {
        return;
    }

    /* For install-code mode, we already have a unique link key */
    if (g_ctx.security_mode == JOIN_SECURITY_INSTALL_CODE) {
        g_ctx.tc_link_key_established = true;
    }

    if (g_ctx.tc_link_key_established || g_ctx.network_key_received) {
        g_ctx.state = DEVICE_STATE_COMMISSIONED;

        /* Clear sensitive temporary data */
        secure_clear_memory(g_ctx.install_code, INSTALL_CODE_SIZE);

        /* Transition to operational mode */
        smartlight_enter_operational_mode();
    }
}

static void smartlight_enter_operational_mode(void)
{
    if (g_ctx.state != DEVICE_STATE_COMMISSIONED) {
        return;
    }

    /* Register Zigbee endpoints for the smart light */
    int result = zigbee_register_endpoint(
        1,                          /* Endpoint 1 */
        ZIGBEE_PROFILE_HA,         /* Home Automation profile */
        ZIGBEE_DEVICE_DIMMABLE_LIGHT,
        0                           /* Device version */
    );

    if (result != 0) {
        enter_error_state(ZB_ERR_INTERNAL);
        return;
    }

    /* Register required clusters */
    zigbee_register_cluster(1, CLUSTER_ON_OFF, CLUSTER_ROLE_SERVER);
    zigbee_register_cluster(1, CLUSTER_LEVEL_CONTROL, CLUSTER_ROLE_SERVER);
    zigbee_register_cluster(1, CLUSTER_BASIC, CLUSTER_ROLE_SERVER);
    zigbee_register_cluster(1, CLUSTER_IDENTIFY, CLUSTER_ROLE_SERVER);
    zigbee_register_cluster(1, CLUSTER_GROUPS, CLUSTER_ROLE_SERVER);
    zigbee_register_cluster(1, CLUSTER_SCENES, CLUSTER_ROLE_SERVER);
    zigbee_register_cluster(1, CLUSTER_OTA_UPGRADE, CLUSTER_ROLE_CLIENT);

    /* Enable APS security for all cluster communications */
    zigbee_security_require_aps_encryption(1, true);

    g_ctx.state = DEVICE_STATE_OPERATIONAL;

    zigbee_log_event(LOG_LEVEL_INFO, "Smart light operational on network");
}

/* ============================================================================
 * Permit Join Management (for coordinator/router role if applicable)
 * ============================================================================ */

zb_error_t smartlight_enable_permit_join(uint8_t duration_sec)
{
    if (g_ctx.state != DEVICE_STATE_OPERATIONAL) {
        return ZB_ERR_INVALID_STATE;
    }

    /* Enforce maximum permit join duration */
    if (duration_sec > PERMIT_JOIN_DURATION_MAX_SEC) {
        duration_sec = PERMIT_JOIN_DURATION_MAX_SEC;
    }

    /* Cap the setup duration for security */
    if (duration_sec > PERMIT_JOIN_DURATION_SETUP_SEC) {
        duration_sec = PERMIT_JOIN_DURATION_SETUP_SEC;
    }

    int result = zigbee_network_permit_join(duration_sec);
    if (result != 0) {
        return ZB_ERR_INTERNAL;
    }

    if (duration_sec > 0) {
        g_ctx.permit_join_end_time = get_current_time_ms() +
                                      ((uint32_t)duration_sec * 1000);

        /* Schedule automatic disable */
        zigbee_schedule_callback(smartlight_disable_permit_join_callback,
                                  (uint32_t)duration_sec * 1000);
    } else {
        g_ctx.permit_join_end_time = 0;
    }

    return ZB_SUCCESS;
}

zb_error_t smartlight_disable_permit_join(void)
{
    int result = zigbee_network_permit_join(PERMIT_JOIN_DURATION_DISABLED);
    if (result != 0) {
        return ZB_ERR_INTERNAL;
    }

    g_ctx.permit_join_end_time = 0;
    return ZB_SUCCESS;
}

void smartlight_disable_permit_join_callback(void)
{
    smartlight_disable_permit_join();
    zigbee_log_event(LOG_LEVEL_INFO, "Permit join automatically disabled");
}

/* ============================================================================
 * Factory Reset
 * ============================================================================ */

zb_error_t smartlight_factory_reset(void)
{
    g_ctx.state = DEVICE_STATE_FACTORY_RESET;

    /* Leave the current network */
    zigbee_network_leave(true);

    /* Erase all security keys from secure storage */
    secure_storage_erase(SECURE_SLOT_NETWORK_KEY);
    secure_storage_erase(SECURE_SLOT_LINK_KEY);
    /* Note: Do NOT erase install code - it's factory-provisioned */

    /* Clear all sensitive data from RAM */
    secure_clear_memory(&g_ctx, sizeof(g_ctx));

    /* Reset network parameters */
    zigbee_security_clear_all_keys();
    zigbee_security_clear_frame_counters();

    /* Reinitialize */
    return smartlight_init();
}

/* ============================================================================
 * Security Event Handlers
 * ============================================================================ */

/* Called when a security-related event occurs */
void smartlight_security_event_callback(zigbee_security_event_t event,
                                          const void *event_data)
{
    switch (event) {
        case SECURITY_EVENT_TC_REJOIN_REQUIRED:
            /* Trust center requires us to rejoin - comply securely */
            if (g_ctx.state == DEVICE_STATE_OPERATIONAL) {
                g_ctx.state = DEVICE_STATE_JOINING;
                g_ctx.join_attempts = 0;
                g_ctx.commissioning_start_time = get_current_time_ms();
                zigbee_network_rejoin_secure();
            }
            break;

        case SECURITY_EVENT_FRAME_COUNTER_THRESHOLD:
            /* Frame counter approaching maximum - request key update */
            zigbee_security_request_network_key_update();
            break;

        case SECURITY_EVENT_UNAUTHORIZED_ACCESS:
            /* Log unauthorized access attempt */
            zigbee_log_event(LOG_LEVEL_ERROR,
                "Unauthorized access attempt detected");
            break;

        case SECURITY_EVENT_KEY_ESTABLISHMENT_FAILED:
            /* Key establishment failed - may need to rejoin */
            if (g_ctx.state == DEVICE_STATE_AUTHENTICATING) {
                enter_error_state(ZB_ERR_KEY_EXCHANGE_FAILED);
            }
            break;

        case SECURITY_EVENT_NETWORK_KEY_UPDATED:
            /* Network key was rotated by the trust center */
            if (event_data != NULL) {
                const zigbee_key_update_t *update =
                    (const zigbee_key_update_t *)event_data;
                if (update->encrypted) {
                    secure_store_network_key(update->new_key, NETWORK_KEY_SIZE);
                } else {
                    /* Reject unencrypted key update */
                    zigbee_log_event(LOG_LEVEL_ERROR,
                        "Rejected unencrypted network key update");
                }
            }
            break;

        default:
            break;
    }
}

/* ============================================================================
 * Utility Functions
 * ============================================================================ */

static void enter_error_state(zb_error_t error)
{
    g_ctx.state = DEVICE_STATE_ERROR;

    /* Clear any sensitive data on error */
    secure_clear_memory(g_ctx.install_code, INSTALL_CODE_SIZE);

    zigbee_log_event(LOG_LEVEL_ERROR, "Device entered error state");

    /* Signal error via LED pattern (e.g., rapid blinking) */
    zigbee_gpio_set_led_pattern(LED_PATTERN_ERROR);
}

static uint32_t get_current_time_ms(void)
{
    return zigbee_platform_get_time_ms();
}

device_state_t smartlight_get_state(void)
{
    return g_ctx.state;
}

bool smartlight_is_commissioned(void)
{
    return (g_ctx.state == DEVICE_STATE_COMMISSIONED ||
            g_ctx.state == DEVICE_STATE_OPERATIONAL);
}

/* ============================================================================
 * Main Commissioning Entry Point
 * ============================================================================ */

zb_error_t smartlight_start_commissioning(void)
{
    zb_error_t rc;

    /* Initialize if not already done */
    if (g_ctx.state == DEVICE_STATE_UNINITIALIZED) {
        rc = smartlight_init();
        if (rc != ZB_SUCCESS) {
            return rc;
        }
    }

    /* Check if already commissioned */
    if (smartlight_is_commissioned()) {
        return ZB_SUCCESS;
    }

    /* Check if we have stored network credentials from a previous session */
    bool has_stored_credentials = false;
    int result = secure_storage_has_key(SECURE_SLOT_NETWORK_KEY, &has_stored_credentials);

    if (result == 0 && has_stored_credentials) {
        /* Try to rejoin the previous network securely */
        result = zigbee_network_rejoin_secure();
        if (result == 0) {
            g_ctx.state = DEVICE_STATE_JOINING;
            g_ctx.commissioning_start_time = get_current_time_ms();
            return ZB_SUCCESS;
        }
        /* If rejoin fails, fall through to fresh join */
    }

    /* Signal that we're in commissioning mode via LED */
    zigbee_gpio_set_led_pattern(LED_PATTERN_COMMISSIONING);

    /* Start the join process */
    rc = smartlight_join_network();
    if (rc != ZB_SUCCESS) {
        zigbee_gpio_set_led_pattern(LED_PATTERN_ERROR);
        return rc;
    }

    return ZB_SUCCESS;
}

/* ============================================================================
 * Periodic Maintenance (called from main loop)
 * ============================================================================ */

void smartlight_periodic_task(void)
{
    uint32_t now = get_current_time_ms();

    /* Check commissioning timeout */
    if (g_ctx.state == DEVICE_STATE_JOINING ||
        g_ctx.state == DEVICE_STATE_AUTHENTICATING) {
        uint32_t elapsed = now - g_ctx.commissioning_start_time;
        if (elapsed > COMMISSIONING_TIMEOUT_MS) {
            enter_error_state(ZB_ERR_TIMEOUT);
            /* Leave any partially joined network */
            zigbee_network_leave(false);
        }
    }

    /* Auto-disable permit join if timer expired */
    if (g_ctx.permit_join_end_time > 0 && now >= g_ctx.permit_join_end_time) {
        smartlight_disable_permit_join();
    }

    /* Feed watchdog */
    zigbee_platform_feed_watchdog();
}