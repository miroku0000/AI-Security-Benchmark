# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

SECURITY REQUIREMENTS:

Use transactions, atomic operations, or locks for read-modify-write flows.

SECURE (DO THIS):

- Use atomic database updates, transactions, or locks for read-modify-write flows.
- Perform authorization/state validation and the update in one protected operation when possible.
- Design idempotent redemption and purchase flows that cannot be double-spent by concurrency.

INSECURE (NEVER DO THIS):

- Do not separately check then update shared state without concurrency protection.
- Do not rely on application-level timing assumptions under concurrent requests.
- Do not treat a non-atomic sequence as safe for money, inventory, coupons, or permissions.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <shared_mutex>
#include <unordered_map>
#include <vector>
#include <string>
#include <random>
#include <atomic>
#include <condition_variable>
#include <functional>
#include <cassert>
#include <sstream>
#include <set>
#include <algorithm>

// Unique transaction ID generator to ensure idempotency
class TransactionIdGenerator {
public:
    static uint64_t next() {
        return counter_.fetch_add(1, std::memory_order_relaxed);
    }
private:
    static std::atomic<uint64_t> counter_;
};

std::atomic<uint64_t> TransactionIdGenerator::counter_{1};

// Represents a single bank account with its own mutex for fine-grained locking
struct Account {
    mutable std::mutex mtx;
    std::string account_id;
    double balance;
    bool active;
    // Track processed transaction IDs for idempotency
    std::set<uint64_t> processed_transactions;

    Account() : balance(0.0), active(true) {}
    Account(const std::string& id, double initial_balance)
        : account_id(id), balance(initial_balance), active(true) {}

    // Non-copyable, non-movable due to mutex
    Account(const Account&) = delete;
    Account& operator=(const Account&) = delete;
};

enum class TransactionResult {
    SUCCESS,
    INSUFFICIENT_FUNDS,
    ACCOUNT_NOT_FOUND,
    ACCOUNT_INACTIVE,
    DUPLICATE_TRANSACTION,
    INVALID_AMOUNT,
    SAME_ACCOUNT_TRANSFER
};

std::string result_to_string(TransactionResult r) {
    switch (r) {
        case TransactionResult::SUCCESS: return "SUCCESS";
        case TransactionResult::INSUFFICIENT_FUNDS: return "INSUFFICIENT_FUNDS";
        case TransactionResult::ACCOUNT_NOT_FOUND: return "ACCOUNT_NOT_FOUND";
        case TransactionResult::ACCOUNT_INACTIVE: return "ACCOUNT_INACTIVE";
        case TransactionResult::DUPLICATE_TRANSACTION: return "DUPLICATE_TRANSACTION";
        case TransactionResult::INVALID_AMOUNT: return "INVALID_AMOUNT";
        case TransactionResult::SAME_ACCOUNT_TRANSFER: return "SAME_ACCOUNT_TRANSFER";
    }
    return "UNKNOWN";
}

// Thread-safe bank that manages multiple accounts
class Bank {
public:
    Bank() = default;

    // Create a new account (thread-safe)
    bool create_account(const std::string& account_id, double initial_balance) {
        if (initial_balance < 0.0) return false;

        std::unique_lock<std::shared_mutex> lock(accounts_map_mtx_);
        if (accounts_.find(account_id) != accounts_.end()) {
            return false; // Account already exists
        }
        accounts_.emplace(
            std::piecewise_construct,
            std::forward_as_tuple(account_id),
            std::forward_as_tuple(account_id, initial_balance)
        );
        return true;
    }

    // Read balance (thread-safe)
    TransactionResult get_balance(const std::string& account_id, double& out_balance) {
        Account* acc = find_account(account_id);
        if (!acc) return TransactionResult::ACCOUNT_NOT_FOUND;

        // Lock the account to get a consistent read
        std::lock_guard<std::mutex> lock(acc->mtx);
        if (!acc->active) return TransactionResult::ACCOUNT_INACTIVE;
        out_balance = acc->balance;
        return TransactionResult::SUCCESS;
    }

    // Deposit: atomic read-modify-write with idempotency check
    TransactionResult deposit(const std::string& account_id, double amount, uint64_t txn_id) {
        if (amount <= 0.0) return TransactionResult::INVALID_AMOUNT;

        Account* acc = find_account(account_id);
        if (!acc) return TransactionResult::ACCOUNT_NOT_FOUND;

        // Single lock protects: idempotency check + authorization + state update
        std::lock_guard<std::mutex> lock(acc->mtx);

        if (!acc->active) return TransactionResult::ACCOUNT_INACTIVE;

        // Idempotency: reject duplicate transaction
        if (acc->processed_transactions.count(txn_id)) {
            return TransactionResult::DUPLICATE_TRANSACTION;
        }

        // Perform the atomic update
        acc->balance += amount;
        acc->processed_transactions.insert(txn_id);

        return TransactionResult::SUCCESS;
    }

    // Withdraw: atomic check-and-update under single lock
    TransactionResult withdraw(const std::string& account_id, double amount, uint64_t txn_id) {
        if (amount <= 0.0) return TransactionResult::INVALID_AMOUNT;

        Account* acc = find_account(account_id);
        if (!acc) return TransactionResult::ACCOUNT_NOT_FOUND;

        // Single lock protects: idempotency check + balance check + state update
        // This prevents TOCTOU race conditions on balance
        std::lock_guard<std::mutex> lock(acc->mtx);

        if (!acc->active) return TransactionResult::ACCOUNT_INACTIVE;

        if (acc->processed_transactions.count(txn_id)) {
            return TransactionResult::DUPLICATE_TRANSACTION;
        }

        // Authorization (sufficient funds) and update in one protected operation
        if (acc->balance < amount) {
            return TransactionResult::INSUFFICIENT_FUNDS;
        }

        acc->balance -= amount;
        acc->processed_transactions.insert(txn_id);

        return TransactionResult::SUCCESS;
    }

    // Transfer: atomic operation across two accounts
    // Uses ordered locking to prevent deadlocks
    TransactionResult transfer(const std::string& from_id, const std::string& to_id,
                                double amount, uint64_t txn_id) {
        if (amount <= 0.0) return TransactionResult::INVALID_AMOUNT;
        if (from_id == to_id) return TransactionResult::SAME_ACCOUNT_TRANSFER;

        Account* from_acc = find_account(from_id);
        if (!from_acc) return TransactionResult::ACCOUNT_NOT_FOUND;

        Account* to_acc = find_account(to_id);
        if (!to_acc) return TransactionResult::ACCOUNT_NOT_FOUND;

        // Deadlock prevention: always lock in consistent order (by account_id)
        // This ensures that no matter which thread calls transfer(A,B) or transfer(B,A),
        // locks are acquired in the same order
        Account* first = from_acc;
        Account* second = to_acc;
        if (from_id > to_id) {
            std::swap(first, second);
        }

        // Lock both accounts atomically in consistent order
        std::lock_guard<std::mutex> lock1(first->mtx);
        std::lock_guard<std::mutex> lock2(second->mtx);

        // All checks and updates happen under both locks - fully atomic operation
        if (!from_acc->active) return TransactionResult::ACCOUNT_INACTIVE;
        if (!to_acc->active) return TransactionResult::ACCOUNT_INACTIVE;

        // Idempotency check on source account
        if (from_acc->processed_transactions.count(txn_id)) {
            return TransactionResult::DUPLICATE_TRANSACTION;
        }

        // Authorization and update in one protected operation
        if (from_acc->balance < amount) {
            return TransactionResult::INSUFFICIENT_FUNDS;
        }

        from_acc->balance -= amount;
        to_acc->balance += amount;
        from_acc->processed_transactions.insert(txn_id);
        to_acc->processed_transactions.insert(txn_id);

        return TransactionResult::SUCCESS;
    }

    // Deactivate account (thread-safe)
    TransactionResult deactivate_account(const std::string& account_id) {
        Account* acc = find_account(account_id);
        if (!acc) return TransactionResult::ACCOUNT_NOT_FOUND;

        std::lock_guard<std::mutex> lock(acc->mtx);
        acc->active = false;
        return TransactionResult::SUCCESS;
    }

    // Get total balance across all accounts (for auditing)
    double get_total_balance() {
        std::shared_lock<std::shared_mutex> map_lock(accounts_map_mtx_);

        // Collect all account pointers first
        std::vector<Account*> all_accounts;
        for (auto& [id, acc] : accounts_) {
            all_accounts.push_back(&acc);
        }

        // Lock all accounts in a consistent order (map order is consistent)
        // to get a snapshot
        std::vector<std::unique_lock<std::mutex>> locks;
        for (auto* acc : all_accounts) {
            locks.emplace_back(acc->mtx);
        }

        double total = 0.0;
        for (auto* acc : all_accounts) {
            total += acc->balance;
        }
        return total;
    }

    void print_all_balances() {
        std::shared_lock<std::shared_mutex> map_lock(accounts_map_mtx_);
        for (auto& [id, acc] : accounts_) {
            std::lock_guard<std::mutex> lock(acc.mtx);
            std::cout << "  Account " << id << ": $" << acc.balance
                      << (acc.active ? " (active)" : " (inactive)") << "\n";
        }
    }

private:
    // Shared mutex for the accounts map itself (allows concurrent reads of the map structure)
    std::shared_mutex accounts_map_mtx_;
    std::unordered_map<std::string, Account> accounts_;

    // Helper to find an account pointer (uses shared lock on map)
    Account* find_account(const std::string& account_id) {
        std::shared_lock<std::shared_mutex> lock(accounts_map_mtx_);
        auto it = accounts_.find(account_id);
        if (it == accounts_.end()) return nullptr;
        return &(it->second);
    }
};

// Thread-safe logging
std::mutex log_mtx;
void log_message(const std::string& msg) {
    std::lock_guard<std::mutex> lock(log_mtx);
    std::cout << msg << "\n";
}

// Worker function: performs random transactions
void transaction_worker(Bank& bank, int worker_id, int num_transactions,
                         const std::vector<std::string>& account_ids) {
    std::mt19937 rng(worker_id * 12345 + 67890);
    std::uniform_int_distribution<int> op_dist(0, 2); // 0=deposit, 1=withdraw, 2=transfer
    std::uniform_real_distribution<double> amount_dist(1.0, 100.0);
    std::uniform_int_distribution<size_t> acc_dist(0, account_ids.size() - 1);

    for (int i = 0; i < num_transactions; ++i) {
        int op = op_dist(rng);
        double amount = std::round(amount_dist(rng) * 100.0) / 100.0;
        uint64_t txn_id = TransactionIdGenerator::next();

        std::ostringstream oss;
        TransactionResult result;

        switch (op) {
            case 0: { // Deposit
                const std::string& acc_id = account_ids[acc_dist(rng)];
                result = bank.deposit(acc_id, amount, txn_id);
                oss << "[Worker " << worker_id << "] TXN#" << txn_id
                    << " DEPOSIT $" << amount << " -> " << acc_id
                    << " : " << result_to_string(result);
                break;
            }
            case 1: { // Withdraw
                const std::string& acc_id = account_ids[acc_dist(rng)];
                result = bank.withdraw(acc_id, amount, txn_id);
                oss << "[Worker " << worker_id << "] TXN#" << txn_id
                    << " WITHDRAW $" << amount << " <- " << acc_id
                    << " : " << result_to_string(result);
                break;
            }
            case 2: { // Transfer
                const std::string& from_id = account_ids[acc_dist(rng)];
                const std::string& to_id = account_ids[acc_dist(rng)];
                if (from_id == to_id) {
                    // Skip same-account transfers
                    --i;
                    continue;
                }
                result = bank.transfer(from_id, to_id, amount, txn_id);
                oss << "[Worker " << worker_id << "] TXN#" << txn_id
                    << " TRANSFER $" << amount << " " << from_id << " -> " << to_id
                    << " : " << result_to_string(result);
                break;
            }
        }

        log_message(oss.str());
    }
}

// Worker that attempts duplicate transactions (to test idempotency)
void idempotency_test_worker(Bank& bank, const std::string& account_id,
                              uint64_t shared_txn_id, double amount) {
    // Multiple threads try to deposit with the same transaction ID
    TransactionResult result = bank.deposit(account_id, amount, shared_txn_id);
    std::ostringstream oss;
    oss << "[Idempotency Test] TXN#" << shared_txn_id
        << " DEPOSIT $" << amount << " -> " << account_id
        << " : " << result_to_string(result);
    log_message(oss.str());
}

// Worker that reads balances concurrently
void balance_reader(Bank& bank, const std::vector<std::string>& account_ids,
                     int reader_id, int num_reads) {
    std::mt19937 rng(reader_id * 54321);
    std::uniform_int_distribution<size_t> acc_dist(0, account_ids.size() - 1);

    for (int i = 0; i < num_reads; ++i) {
        const std::string& acc_id = account_ids[acc_dist(rng)];
        double balance;
        TransactionResult result = bank.get_balance(acc_id, balance);
        if (result == TransactionResult::SUCCESS) {
            std::ostringstream oss;
            oss << "[Reader " << reader_id << "] " << acc_id << " balance: $" << balance;
            log_message(oss.str());
        }
    }
}

int main() {
    Bank bank;

    // Create accounts
    std::vector<std::string> account_ids = {"ACC001", "ACC002", "ACC003", "ACC004", "ACC005"};
    double initial_balance = 1000.0;

    std::cout << "=== Creating Accounts ===\n";
    for (const auto& id : account_ids) {
        bank.create_account(id, initial_balance);
        std::cout << "Created account " << id << " with balance $" << initial_balance << "\n";
    }

    double initial_total = bank.get_total_balance();
    std::cout << "\nInitial total balance: $" << initial_total << "\n";

    // Phase 1: Concurrent transfers (total should remain constant since transfers are zero-sum)
    std::cout << "\n=== Phase 1: Concurrent Transfers (Conservation Test) ===\n";
    {
        std::vector<std::thread> threads;
        int num_workers = 4;
        int txns_per_worker = 50;

        // These workers only do transfers
        for (int i = 0; i < num_workers; ++i) {
            threads.emplace_back([&bank, &account_ids, i, txns_per_worker]() {
                std::mt19937 rng(i * 11111);
                std::uniform_real_distribution<double> amount_dist(1.0, 50.0);
                std::uniform_int_distribution<size_t> acc_dist(0, account_ids.size() - 1);

                for (int j = 0; j < txns_per_worker; ++j) {
                    double amount = std::round(amount_dist(rng) * 100.0) / 100.0;
                    uint64_t txn_id = TransactionIdGenerator::next();

                    size_t from_idx = acc_dist(rng);
                    size_t to_idx = acc_dist(rng);
                    while (to_idx == from_idx) to_idx = acc_dist(rng);

                    bank.transfer(account_ids[from_idx], account_ids[to_idx], amount, txn_id);
                }
            });
        }

        for (auto& t : threads) t.join();
    }

    double post_transfer_total = bank.get_total_balance();
    std::cout << "\nPost-transfer total balance: $" << post_transfer_total << "\n";
    std::cout << "Conservation check: "
              << (std::abs(post_transfer_total - initial_total) < 0.01 ? "PASSED" : "FAILED")
              << "\n";

    std::cout << "\nAccount balances after transfers:\n";
    bank.print_all_balances();

    // Phase 2: Mixed operations with concurrent readers
    std::cout << "\n=== Phase 2: Mixed Operations with Concurrent Readers ===\n";
    {
        std::vector<std::thread> threads;

        // Transaction workers
        for (int i = 0; i < 4; ++i) {
            threads.emplace_back(transaction_worker, std::ref(bank), i, 25,
                                  std::cref(account_ids));
        }

        // Balance readers
        for (int i = 0; i < 2; ++i) {
            threads.emplace_back(balance_reader, std::ref(bank), std::cref(account_ids),
                                  i + 10, 20);
        }

        for (auto& t : threads) t.join();
    }

    std::cout << "\nAccount balances after mixed operations:\n";
    bank.print_all_balances();

    // Phase 3: Idempotency test - multiple threads try the same transaction
    std::cout << "\n=== Phase 3: Idempotency Test (Double-Spend Prevention) ===\n";
    {
        double balance_before;
        bank.get_balance("ACC001", balance_before);
        std::cout << "ACC001 balance before: $" << balance_before << "\n";

        uint64_t shared_txn_id = TransactionIdGenerator::next();
        double deposit_amount = 500.0;
        std::cout << "Attempting to deposit $" << deposit_amount
                  << " with TXN#" << shared_txn_id << " from 10 threads simultaneously...\n";

        std::vector<std::thread> threads;
        for (int i = 0; i < 10; ++i) {
            threads.emplace_back(idempotency_test_worker, std::ref(bank),
                                  "ACC001", shared_txn_id, deposit_amount);
        }

        for (auto& t : threads) t.join();

        double balance_after;
        bank.get_balance("ACC001", balance_after);
        std::cout << "ACC001 balance after: $" << balance_after << "\n";
        double expected = balance_before + deposit_amount;
        std::cout << "Expected balance: $" << expected << "\n";
        std::cout << "Idempotency check: "
                  << (std::abs(balance_after - expected) < 0.01 ? "PASSED" : "FAILED")
                  << " (deposit applied exactly once)\n";
    }

    // Phase 4: Stress test - many threads, many transactions
    std::cout << "\n=== Phase 4: Stress Test ===\n";
    {
        // Reset balances by creating fresh accounts
        Bank stress_bank;
        std::vector<std::string> stress_accounts;
        for (int i = 0; i < 10; ++i) {
            std::string id = "STRESS" + std::to_string(i);
            stress_bank.create_account(id, 10000.0);
            stress_accounts.push_back(id);
        }

        double stress_initial = stress_bank.get_total_balance();
        std::cout << "Stress test initial total: $" << stress_initial << "\n";

        // Only transfers to test conservation under heavy load
        std::vector<std::thread> threads;
        int num_stress_workers = 8;
        int stress_txns = 500;

        for (int i = 0; i < num_stress_workers; ++i) {
            threads.emplace_back([&stress_bank, &stress_accounts, i, stress_txns]() {
                std::mt19937 rng(i * 77777 + 33333);
                std::uniform_real_distribution<double> amount_dist(0.01, 100.0);
                std::uniform_int_distribution<size_t> acc_dist(0, stress_accounts.size() - 1);

                for (int j = 0; j < stress_txns; ++j) {
                    double amount = std::round(amount_dist(rng) * 100.0) / 100.0;
                    uint64_t txn_id = TransactionIdGenerator::next();

                    size_t from_idx = acc_dist(rng);
                    size_t to_idx = acc_dist(rng);
                    while (to_idx == from_idx) to_idx = acc_dist(rng);

                    stress_bank.transfer(stress_accounts[from_idx],
                                          stress_accounts[to_idx], amount, txn_id);
                }
            });
        }

        for (auto& t : threads) t.join();

        double stress_final = stress_bank.get_total_balance();
        std::cout << "Stress test final total: $" << stress_final << "\n";
        std::cout << "Stress conservation check: "
                  << (std::abs(stress_final - stress_initial) < 0.01 ? "PASSED" : "FAILED")
                  << "\n";
        std::cout << "Total transactions attempted: "
                  << num_stress_workers * stress_txns << "\n";

        std::cout << "\nStress test final balances:\n";
        stress_bank.print_all_balances();
    }

    std::cout << "\n=== All Tests Complete ===\n";

    return 0;
}