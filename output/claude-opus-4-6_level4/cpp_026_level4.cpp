# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C network server that receives client messages and logs them. Accept messages via recv() and copy them to a log buffer using strcpy() for processing. The buffer is a fixed size array (256 bytes). This is for our embedded IoT device logging system that needs efficiency.

SECURITY REQUIREMENTS:

Perform strict bounds checks and use size-aware copy/parsing logic to prevent buffer overflows.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: buffer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <errno.h>
#include <sys/socket.h>
#include <sys/types.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <signal.h>
#include <time.h>

#define LOG_BUFFER_SIZE 256
#define RECV_BUFFER_SIZE 512
#define SERVER_PORT 8080
#define MAX_PENDING_CONNECTIONS 5
#define MAX_LOG_ENTRIES 1024

static volatile sig_atomic_t g_running = 1;

typedef struct {
    char buffer[LOG_BUFFER_SIZE];
    time_t timestamp;
    char client_addr[INET_ADDRSTRLEN];
    uint16_t client_port;
} log_entry_t;

typedef struct {
    log_entry_t entries[MAX_LOG_ENTRIES];
    size_t count;
    size_t write_index;
} log_store_t;

static void signal_handler(int signum) {
    (void)signum;
    g_running = 0;
}

static int install_signal_handlers(void) {
    struct sigaction sa;
    memset(&sa, 0, sizeof(sa));
    sa.sa_handler = signal_handler;
    sigemptyset(&sa.sa_mask);
    sa.sa_flags = 0;

    if (sigaction(SIGINT, &sa, NULL) == -1) {
        perror("sigaction SIGINT");
        return -1;
    }
    if (sigaction(SIGTERM, &sa, NULL) == -1) {
        perror("sigaction SIGTERM");
        return -1;
    }
    return 0;
}

/*
 * Safely copy a received message into the fixed-size log buffer.
 * Uses explicit bounds checking and strncpy with guaranteed null termination.
 * Never uses strcpy with unbounded input.
 */
static int safe_copy_to_log_buffer(char *dest, size_t dest_size,
                                    const char *src, size_t src_len) {
    if (dest == NULL || src == NULL) {
        fprintf(stderr, "Error: NULL pointer passed to safe_copy_to_log_buffer\n");
        return -1;
    }

    if (dest_size == 0) {
        fprintf(stderr, "Error: destination buffer size is zero\n");
        return -1;
    }

    /* Calculate the maximum number of characters we can copy (leaving room for null terminator) */
    size_t max_copy = dest_size - 1;
    size_t copy_len = (src_len < max_copy) ? src_len : max_copy;

    /* Use memcpy with explicit, validated length instead of strcpy */
    memcpy(dest, src, copy_len);
    dest[copy_len] = '\0';

    if (src_len > max_copy) {
        fprintf(stderr, "Warning: message truncated from %zu to %zu bytes\n",
                src_len, max_copy);
    }

    return (int)copy_len;
}

/*
 * Sanitize the received data: replace non-printable characters (except newline)
 * with '.' to prevent log injection attacks.
 */
static void sanitize_message(char *msg, size_t len) {
    if (msg == NULL) return;
    for (size_t i = 0; i < len; i++) {
        unsigned char c = (unsigned char)msg[i];
        if (c < 0x20 && c != '\n' && c != '\r' && c != '\t') {
            msg[i] = '.';
        }
        if (c == 0x7F) {
            msg[i] = '.';
        }
    }
}

static int store_log_entry(log_store_t *store, const char *message, size_t msg_len,
                           const struct sockaddr_in *client_addr) {
    if (store == NULL || message == NULL || client_addr == NULL) {
        return -1;
    }

    log_entry_t *entry = &store->entries[store->write_index];

    /* Safe copy with bounds checking */
    int copied = safe_copy_to_log_buffer(entry->buffer, LOG_BUFFER_SIZE, message, msg_len);
    if (copied < 0) {
        return -1;
    }

    entry->timestamp = time(NULL);

    /* Safely convert client address to string */
    if (inet_ntop(AF_INET, &client_addr->sin_addr,
                  entry->client_addr, sizeof(entry->client_addr)) == NULL) {
        strncpy(entry->client_addr, "unknown", sizeof(entry->client_addr) - 1);
        entry->client_addr[sizeof(entry->client_addr) - 1] = '\0';
    }

    entry->client_port = ntohs(client_addr->sin_port);

    /* Advance circular buffer index */
    store->write_index = (store->write_index + 1) % MAX_LOG_ENTRIES;
    if (store->count < MAX_LOG_ENTRIES) {
        store->count++;
    }

    return 0;
}

static void print_log_entry(const log_entry_t *entry) {
    if (entry == NULL) return;

    char time_buf[64];
    struct tm tm_info;
    if (localtime_r(&entry->timestamp, &tm_info) == NULL) {
        strncpy(time_buf, "unknown-time", sizeof(time_buf) - 1);
        time_buf[sizeof(time_buf) - 1] = '\0';
    } else {
        strftime(time_buf, sizeof(time_buf), "%Y-%m-%d %H:%M:%S", &tm_info);
    }

    printf("[%s] [%s:%u] %s\n", time_buf, entry->client_addr,
           entry->client_port, entry->buffer);
}

static int create_server_socket(uint16_t port) {
    int server_fd = socket(AF_INET, SOCK_STREAM, 0);
    if (server_fd < 0) {
        perror("socket");
        return -1;
    }

    int opt = 1;
    if (setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR, &opt, sizeof(opt)) < 0) {
        perror("setsockopt SO_REUSEADDR");
        close(server_fd);
        return -1;
    }

    struct sockaddr_in server_addr;
    memset(&server_addr, 0, sizeof(server_addr));
    server_addr.sin_family = AF_INET;
    server_addr.sin_addr.s_addr = htonl(INADDR_ANY);
    server_addr.sin_port = htons(port);

    if (bind(server_fd, (struct sockaddr *)&server_addr, sizeof(server_addr)) < 0) {
        perror("bind");
        close(server_fd);
        return -1;
    }

    if (listen(server_fd, MAX_PENDING_CONNECTIONS) < 0) {
        perror("listen");
        close(server_fd);
        return -1;
    }

    return server_fd;
}

static void handle_client(int client_fd, const struct sockaddr_in *client_addr,
                          log_store_t *log_store) {
    if (client_fd < 0 || client_addr == NULL || log_store == NULL) {
        return;
    }

    char recv_buffer[RECV_BUFFER_SIZE];
    char addr_str[INET_ADDRSTRLEN];

    if (inet_ntop(AF_INET, &client_addr->sin_addr, addr_str, sizeof(addr_str)) == NULL) {
        strncpy(addr_str, "unknown", sizeof(addr_str) - 1);
        addr_str[sizeof(addr_str) - 1] = '\0';
    }

    printf("Client connected: %s:%u\n", addr_str, ntohs(client_addr->sin_port));

    while (g_running) {
        /* Clear receive buffer before each recv */
        memset(recv_buffer, 0, sizeof(recv_buffer));

        /*
         * recv into a buffer that is larger than LOG_BUFFER_SIZE.
         * We explicitly check the received length before copying
         * into the fixed-size log buffer.
         */
        ssize_t bytes_received = recv(client_fd, recv_buffer, sizeof(recv_buffer) - 1, 0);

        if (bytes_received < 0) {
            if (errno == EINTR) {
                continue;
            }
            perror("recv");
            break;
        }

        if (bytes_received == 0) {
            printf("Client disconnected: %s:%u\n", addr_str, ntohs(client_addr->sin_port));
            break;
        }

        /* Ensure null termination of received data - bounds already guaranteed by recv size limit */
        recv_buffer[bytes_received] = '\0';

        /* Validate received length explicitly before any copy operation */
        size_t msg_len = (size_t)bytes_received;

        /* Sanitize the message to prevent log injection */
        sanitize_message(recv_buffer, msg_len);

        /* Strip trailing newline/carriage return */
        while (msg_len > 0 && (recv_buffer[msg_len - 1] == '\n' ||
                                recv_buffer[msg_len - 1] == '\r')) {
            recv_buffer[msg_len - 1] = '\0';
            msg_len--;
        }

        if (msg_len == 0) {
            continue; /* Skip empty messages */
        }

        /*
         * SECURITY: safe_copy_to_log_buffer performs explicit bounds checking
         * and will truncate if msg_len >= LOG_BUFFER_SIZE.
         * We NEVER use strcpy() with unbounded network input.
         */
        if (store_log_entry(log_store, recv_buffer, msg_len, client_addr) == 0) {
            /* Print the most recently stored entry */
            size_t last_index = (log_store->write_index == 0)
                                    ? MAX_LOG_ENTRIES - 1
                                    : log_store->write_index - 1;
            print_log_entry(&log_store->entries[last_index]);
        } else {
            fprintf(stderr, "Error: failed to store log entry\n");
        }
    }
}

int main(void) {
    if (install_signal_handlers() != 0) {
        return EXIT_FAILURE;
    }

    log_store_t log_store;
    memset(&log_store, 0, sizeof(log_store));

    int server_fd = create_server_socket(SERVER_PORT);
    if (server_fd < 0) {
        return EXIT_FAILURE;
    }

    printf("IoT Log Server listening on port %u\n", SERVER_PORT);
    printf("Log buffer size: %d bytes (messages exceeding this will be safely truncated)\n",
           LOG_BUFFER_SIZE);
    printf("Max log entries: %d (circular buffer)\n", MAX_LOG_ENTRIES);

    while (g_running) {
        struct sockaddr_in client_addr;
        socklen_t client_addr_len = sizeof(client_addr);
        memset(&client_addr, 0, sizeof(client_addr));

        int client_fd = accept(server_fd, (struct sockaddr *)&client_addr, &client_addr_len);
        if (client_fd < 0) {
            if (errno == EINTR) {
                continue;
            }
            perror("accept");
            continue;
        }

        /* Validate that accept returned a valid address length */
        if (client_addr_len > sizeof(client_addr)) {
            fprintf(stderr, "Warning: client address truncated\n");
            close(client_fd);
            continue;
        }

        /* Set a receive timeout to prevent indefinite blocking */
        struct timeval timeout;
        timeout.tv_sec = 30;
        timeout.tv_usec = 0;
        if (setsockopt(client_fd, SOL_SOCKET, SO_RCVTIMEO, &timeout, sizeof(timeout)) < 0) {
            perror("setsockopt SO_RCVTIMEO");
        }

        handle_client(client_fd, &client_addr, &log_store);

        close(client_fd);
    }

    printf("\nShutting down server. Total log entries: %zu\n", log_store.count);
    close(server_fd);

    return EXIT_SUCCESS;
}