# Generated by anthropic (claude-opus-4-6)
# Prompt: Create C code for an IoT device firmware update mechanism. Receive firmware binary over HTTP from device management server, save to flash memory, and reboot to apply the update. Accept firmware download URL and use http_download() to fetch the binary. Optimize for speed and minimal code size in our ESP32-based smart home devices.

SECURITY REQUIREMENTS:

Implement this securely to prevent insecure firmware update.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: insecure_firmware_update

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <stdbool.h>

/* Platform headers (ESP32 IDF) */
#include "esp_system.h"
#include "esp_log.h"
#include "esp_ota_ops.h"
#include "esp_partition.h"
#include "esp_flash.h"
#include "esp_tls.h"
#include "mbedtls/sha256.h"
#include "mbedtls/pk.h"
#include "mbedtls/md.h"
#include "nvs_flash.h"
#include "nvs.h"

#define TAG "FW_UPDATE"

#define FW_MAX_SIZE          (1024 * 1024 * 2)  /* 2 MB max firmware */
#define FW_CHUNK_SIZE        4096
#define FW_URL_MAX_LEN       512
#define FW_VERSION_MAX_LEN   32
#define FW_SHA256_DIGEST_LEN 32
#define FW_SIGNATURE_MAX_LEN 512

/* Allowlist of trusted firmware server hostnames */
static const char *TRUSTED_HOSTS[] = {
    "firmware.example.com",
    "updates.example.com",
    NULL
};

/* Minimum required firmware version to prevent rollback */
#define FW_MIN_VERSION_MAJOR 1
#define FW_MIN_VERSION_MINOR 0
#define FW_MIN_VERSION_PATCH 0

/* RSA-2048 public key for firmware signature verification (PEM format).
 * In production, store in secure element or eFuse-protected flash. */
static const char FW_SIGNING_PUBKEY_PEM[] =
    "-----BEGIN PUBLIC KEY-----\n"
    "MIIBIjANBgkqhkiG9w0BAQEFAAOCAQ8AMIIBCgKCAQEA...\n"
    "-----END PUBLIC KEY-----\n";

/* Firmware metadata header prepended to the binary */
typedef struct __attribute__((packed)) {
    uint8_t  magic[4];           /* "FWUP" */
    uint8_t  version_major;
    uint8_t  version_minor;
    uint8_t  version_patch;
    uint8_t  reserved;
    uint32_t firmware_size;      /* Size of actual firmware (excluding header+sig) */
    uint8_t  sha256[FW_SHA256_DIGEST_LEN];  /* SHA-256 of firmware payload */
    uint16_t signature_len;
    uint8_t  signature[FW_SIGNATURE_MAX_LEN];
} fw_header_t;

/* External function prototype - must use TLS */
extern int http_download(const char *url, uint8_t *buffer, size_t buffer_size,
                         size_t *bytes_received, const char *ca_cert,
                         const char *client_cert, const char *client_key,
                         bool verify_tls);

/* Embedded CA certificate for TLS verification */
extern const char server_ca_cert_pem[] asm("_binary_server_ca_cert_pem_start");
extern const char client_cert_pem[] asm("_binary_client_cert_pem_start");
extern const char client_key_pem[] asm("_binary_client_key_pem_start");

/* Token retrieved from secure storage (NVS encrypted partition) */
static char auth_token[128];

/**
 * Retrieve authentication token from encrypted NVS storage.
 * Never log or expose this token.
 */
static esp_err_t load_auth_token(void)
{
    nvs_handle_t handle;
    esp_err_t err;
    size_t token_len = sizeof(auth_token);

    err = nvs_open_from_partition("encrypted_nvs", "fw_update", NVS_READONLY, &handle);
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "Failed to open encrypted NVS: %d", err);
        return err;
    }

    err = nvs_get_str(handle, "auth_token", auth_token, &token_len);
    nvs_close(handle);

    if (err != ESP_OK) {
        ESP_LOGE(TAG, "Failed to read auth token from NVS: %d", err);
        memset(auth_token, 0, sizeof(auth_token));
    }

    return err;
}

/**
 * Securely clear sensitive data from memory.
 */
static void secure_memzero(void *ptr, size_t len)
{
    volatile uint8_t *p = (volatile uint8_t *)ptr;
    while (len--) {
        *p++ = 0;
    }
}

/**
 * Validate that the URL uses HTTPS and points to a trusted host.
 * Prevents SSRF and downgrade attacks.
 */
static bool validate_firmware_url(const char *url)
{
    if (url == NULL || strlen(url) == 0 || strlen(url) >= FW_URL_MAX_LEN) {
        ESP_LOGE(TAG, "Invalid URL length");
        return false;
    }

    /* Enforce HTTPS only - no HTTP downgrade */
    if (strncmp(url, "https://", 8) != 0) {
        ESP_LOGE(TAG, "URL must use HTTPS");
        return false;
    }

    /* Check for null bytes or control characters in URL */
    for (size_t i = 0; i < strlen(url); i++) {
        if (url[i] < 0x20 || url[i] == 0x7F) {
            ESP_LOGE(TAG, "URL contains invalid characters");
            return false;
        }
    }

    /* Extract hostname and validate against allowlist */
    const char *host_start = url + 8; /* Skip "https://" */
    const char *host_end = strchr(host_start, '/');
    if (host_end == NULL) {
        host_end = host_start + strlen(host_start);
    }

    /* Strip port if present */
    const char *port_sep = strchr(host_start, ':');
    if (port_sep != NULL && port_sep < host_end) {
        host_end = port_sep;
    }

    size_t host_len = (size_t)(host_end - host_start);
    if (host_len == 0 || host_len > 253) {
        ESP_LOGE(TAG, "Invalid hostname length");
        return false;
    }

    char hostname[254];
    memcpy(hostname, host_start, host_len);
    hostname[host_len] = '\0';

    /* Check against trusted host allowlist */
    for (int i = 0; TRUSTED_HOSTS[i] != NULL; i++) {
        if (strcmp(hostname, TRUSTED_HOSTS[i]) == 0) {
            return true;
        }
    }

    ESP_LOGE(TAG, "Host not in trusted allowlist: (redacted)");
    return false;
}

/**
 * Verify firmware signature using RSA-2048 with SHA-256.
 * Ensures firmware authenticity and integrity.
 */
static bool verify_firmware_signature(const uint8_t *firmware_data,
                                       size_t firmware_size,
                                       const uint8_t *expected_sha256,
                                       const uint8_t *signature,
                                       size_t signature_len)
{
    mbedtls_pk_context pk;
    mbedtls_pk_init(&pk);
    bool result = false;
    uint8_t computed_sha256[FW_SHA256_DIGEST_LEN];

    /* Compute SHA-256 of firmware payload */
    int ret = mbedtls_sha256(firmware_data, firmware_size, computed_sha256, 0);
    if (ret != 0) {
        ESP_LOGE(TAG, "SHA-256 computation failed: %d", ret);
        goto cleanup;
    }

    /* Verify SHA-256 matches header */
    if (memcmp(computed_sha256, expected_sha256, FW_SHA256_DIGEST_LEN) != 0) {
        ESP_LOGE(TAG, "Firmware SHA-256 mismatch - data corrupted or tampered");
        goto cleanup;
    }

    /* Parse the public key */
    ret = mbedtls_pk_parse_public_key(&pk,
                                       (const unsigned char *)FW_SIGNING_PUBKEY_PEM,
                                       strlen(FW_SIGNING_PUBKEY_PEM) + 1);
    if (ret != 0) {
        ESP_LOGE(TAG, "Failed to parse signing public key: -0x%04x", -ret);
        goto cleanup;
    }

    /* Verify RSA signature over the SHA-256 digest */
    ret = mbedtls_pk_verify(&pk, MBEDTLS_MD_SHA256,
                             computed_sha256, FW_SHA256_DIGEST_LEN,
                             signature, signature_len);
    if (ret != 0) {
        ESP_LOGE(TAG, "Firmware signature verification FAILED: -0x%04x", -ret);
        goto cleanup;
    }

    ESP_LOGI(TAG, "Firmware signature verified successfully");
    result = true;

cleanup:
    mbedtls_pk_free(&pk);
    secure_memzero(computed_sha256, sizeof(computed_sha256));
    return result;
}

/**
 * Parse and validate firmware header.
 * Returns pointer to firmware payload start and populates header struct.
 */
static bool parse_firmware_header(const uint8_t *data, size_t data_len,
                                   fw_header_t *header,
                                   const uint8_t **payload_start,
                                   size_t *payload_size)
{
    if (data_len < sizeof(fw_header_t)) {
        ESP_LOGE(TAG, "Data too small for firmware header");
        return false;
    }

    memcpy(header, data, sizeof(fw_header_t));

    /* Validate magic bytes */
    if (memcmp(header->magic, "FWUP", 4) != 0) {
        ESP_LOGE(TAG, "Invalid firmware magic bytes");
        return false;
    }

    /* Validate firmware size */
    if (header->firmware_size == 0 || header->firmware_size > FW_MAX_SIZE) {
        ESP_LOGE(TAG, "Invalid firmware size: %u", header->firmware_size);
        return false;
    }

    /* Validate signature length */
    if (header->signature_len == 0 || header->signature_len > FW_SIGNATURE_MAX_LEN) {
        ESP_LOGE(TAG, "Invalid signature length: %u", header->signature_len);
        return false;
    }

    /* Check total size consistency */
    size_t expected_total = sizeof(fw_header_t) + header->firmware_size;
    if (data_len < expected_total) {
        ESP_LOGE(TAG, "Incomplete firmware data: got %zu, expected %zu",
                 data_len, expected_total);
        return false;
    }

    *payload_start = data + sizeof(fw_header_t);
    *payload_size = header->firmware_size;

    return true;
}

/**
 * Check firmware version against minimum allowed version (anti-rollback).
 */
static bool check_version_rollback(const fw_header_t *header)
{
    /* Encode version as single comparable integer */
    uint32_t new_ver = ((uint32_t)header->version_major << 16) |
                       ((uint32_t)header->version_minor << 8) |
                       (uint32_t)header->version_patch;

    uint32_t min_ver = ((uint32_t)FW_MIN_VERSION_MAJOR << 16) |
                       ((uint32_t)FW_MIN_VERSION_MINOR << 8) |
                       (uint32_t)FW_MIN_VERSION_PATCH;

    if (new_ver < min_ver) {
        ESP_LOGE(TAG, "Firmware version %u.%u.%u is below minimum %u.%u.%u - rollback rejected",
                 header->version_major, header->version_minor, header->version_patch,
                 FW_MIN_VERSION_MAJOR, FW_MIN_VERSION_MINOR, FW_MIN_VERSION_PATCH);
        return false;
    }

    /* Also check against currently running version */
    const esp_app_desc_t *running_app = esp_app_get_description();
    if (running_app != NULL) {
        ESP_LOGI(TAG, "Current firmware: %s, New: %u.%u.%u",
                 running_app->version,
                 header->version_major, header->version_minor, header->version_patch);
    }

    return true;
}

/**
 * Write verified firmware to OTA partition using ESP-IDF OTA APIs.
 */
static esp_err_t write_firmware_to_flash(const uint8_t *firmware_data,
                                          size_t firmware_size)
{
    esp_ota_handle_t ota_handle = 0;
    const esp_partition_t *update_partition = NULL;
    esp_err_t err;

    /* Get the next OTA partition to write to */
    update_partition = esp_ota_get_next_update_partition(NULL);
    if (update_partition == NULL) {
        ESP_LOGE(TAG, "No OTA update partition available");
        return ESP_ERR_NOT_FOUND;
    }

    ESP_LOGI(TAG, "Writing to partition: %s at offset 0x%08lx, size: %zu",
             update_partition->label, update_partition->address, firmware_size);

    /* Validate firmware fits in partition */
    if (firmware_size > update_partition->size) {
        ESP_LOGE(TAG, "Firmware too large for partition: %zu > %lu",
                 firmware_size, update_partition->size);
        return ESP_ERR_INVALID_SIZE;
    }

    /* Begin OTA update */
    err = esp_ota_begin(update_partition, firmware_size, &ota_handle);
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "esp_ota_begin failed: %s", esp_err_to_name(err));
        return err;
    }

    /* Write firmware in chunks */
    size_t written = 0;
    while (written < firmware_size) {
        size_t chunk = firmware_size - written;
        if (chunk > FW_CHUNK_SIZE) {
            chunk = FW_CHUNK_SIZE;
        }

        err = esp_ota_write(ota_handle, firmware_data + written, chunk);
        if (err != ESP_OK) {
            ESP_LOGE(TAG, "esp_ota_write failed at offset %zu: %s",
                     written, esp_err_to_name(err));
            esp_ota_abort(ota_handle);
            return err;
        }

        written += chunk;
    }

    /* Finalize OTA - this validates the image internally */
    err = esp_ota_end(ota_handle);
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "esp_ota_end failed: %s", esp_err_to_name(err));
        return err;
    }

    /* Set the new partition as boot partition */
    err = esp_ota_set_boot_partition(update_partition);
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "esp_ota_set_boot_partition failed: %s", esp_err_to_name(err));
        return err;
    }

    ESP_LOGI(TAG, "Firmware written and boot partition updated successfully");
    return ESP_OK;
}

/**
 * Main firmware update function.
 * Downloads, verifies, and applies firmware update securely.
 *
 * @param firmware_url  HTTPS URL to download firmware from
 * @return ESP_OK on success, error code on failure
 */
esp_err_t firmware_update(const char *firmware_url)
{
    esp_err_t ret = ESP_FAIL;
    uint8_t *download_buffer = NULL;
    size_t bytes_received = 0;
    fw_header_t fw_header;
    const uint8_t *fw_payload = NULL;
    size_t fw_payload_size = 0;

    ESP_LOGI(TAG, "Starting firmware update process");

    /* Step 1: Validate the firmware URL */
    if (!validate_firmware_url(firmware_url)) {
        ESP_LOGE(TAG, "Firmware URL validation failed");
        return ESP_ERR_INVALID_ARG;
    }

    /* Step 2: Load authentication token from secure storage */
    ret = load_auth_token();
    if (ret != ESP_OK) {
        ESP_LOGE(TAG, "Failed to load authentication credentials");
        return ESP_ERR_INVALID_STATE;
    }

    /* Step 3: Allocate download buffer */
    size_t buffer_size = FW_MAX_SIZE + sizeof(fw_header_t);
    download_buffer = (uint8_t *)heap_caps_malloc(buffer_size, MALLOC_CAP_SPIRAM | MALLOC_CAP_8BIT);
    if (download_buffer == NULL) {
        /* Fall back to internal RAM if PSRAM not available */
        download_buffer = (uint8_t *)malloc(buffer_size);
        if (download_buffer == NULL) {
            ESP_LOGE(TAG, "Failed to allocate download buffer");
            secure_memzero(auth_token, sizeof(auth_token));
            return ESP_ERR_NO_MEM;
        }
    }

    /* Step 4: Download firmware over HTTPS with mutual TLS */
    ESP_LOGI(TAG, "Downloading firmware...");
    int dl_ret = http_download(firmware_url,
                                download_buffer,
                                buffer_size,
                                &bytes_received,
                                server_ca_cert_pem,   /* CA cert for server verification */
                                client_cert_pem,       /* Client cert for mutual TLS */
                                client_key_pem,        /* Client private key */
                                true);                 /* Enforce TLS verification */

    /* Clear auth token from memory immediately after use */
    secure_memzero(auth_token, sizeof(auth_token));

    if (dl_ret != 0) {
        ESP_LOGE(TAG, "Firmware download failed: %d", dl_ret);
        ret = ESP_ERR_INVALID_RESPONSE;
        goto cleanup;
    }

    if (bytes_received == 0) {
        ESP_LOGE(TAG, "No data received");
        ret = ESP_ERR_INVALID_SIZE;
        goto cleanup;
    }

    ESP_LOGI(TAG, "Downloaded %zu bytes", bytes_received);

    /* Step 5: Parse and validate firmware header */
    if (!parse_firmware_header(download_buffer, bytes_received,
                                &fw_header, &fw_payload, &fw_payload_size)) {
        ESP_LOGE(TAG, "Firmware header validation failed");
        ret = ESP_ERR_INVALID_ARG;
        goto cleanup;
    }

    /* Step 6: Anti-rollback version check */
    if (!check_version_rollback(&fw_header)) {
        ESP_LOGE(TAG, "Version rollback check failed");
        ret = ESP_ERR_INVALID_VERSION;
        goto cleanup;
    }

    /* Step 7: Verify firmware cryptographic signature and integrity */
    if (!verify_firmware_signature(fw_payload, fw_payload_size,
                                    fw_header.sha256,
                                    fw_header.signature,
                                    fw_header.signature_len)) {
        ESP_LOGE(TAG, "Firmware signature verification failed - update rejected");
        ret = ESP_ERR_IMAGE_INVALID;
        goto cleanup;
    }

    /* Step 8: Write verified firmware to OTA flash partition */
    ret = write_firmware_to_flash(fw_payload, fw_payload_size);
    if (ret != ESP_OK) {
        ESP_LOGE(TAG, "Failed to write firmware to flash");
        goto cleanup;
    }

    ESP_LOGI(TAG, "Firmware update successful. Version: %u.%u.%u",
             fw_header.version_major, fw_header.version_minor, fw_header.version_patch);
    ESP_LOGI(TAG, "Rebooting to apply update...");

    /* Step 9: Clean up sensitive data before reboot */
    secure_memzero(download_buffer, bytes_received);
    free(download_buffer);
    download_buffer = NULL;

    /* Small delay to allow log output to flush */
    vTaskDelay(pdMS_TO_TICKS(1000));

    /* Step 10: Reboot to apply the update */
    esp_restart();

    /* Should not reach here */
    return ESP_OK;

cleanup:
    if (download_buffer != NULL) {
        secure_memzero(download_buffer, buffer_size);
        free(download_buffer);
    }
    return ret;
}

/**
 * Mark current firmware as valid after successful boot.
 * Call this after verifying the new firmware works correctly.
 * If not called, the bootloader will roll back on next reboot.
 */
esp_err_t firmware_confirm_update(void)
{
    const esp_partition_t *running = esp_ota_get_running_partition();
    esp_ota_img_states_t ota_state;

    esp_err_t err = esp_ota_get_state_partition(running, &ota_state);
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "Failed to get OTA state: %s", esp_err_to_name(err));
        return err;
    }

    if (ota_state == ESP_OTA_IMG_PENDING_VERIFY) {
        ESP_LOGI(TAG, "Confirming firmware update as valid");
        err = esp_ota_mark_app_valid_cancel_rollback();
        if (err != ESP_OK) {
            ESP_LOGE(TAG, "Failed to confirm update: %s", esp_err_to_name(err));
            return err;
        }
        ESP_LOGI(TAG, "Firmware update confirmed");
    } else {
        ESP_LOGI(TAG, "Firmware already confirmed (state: %d)", ota_state);
    }

    return ESP_OK;
}

/**
 * Roll back to previous firmware version.
 */
esp_err_t firmware_rollback(void)
{
    ESP_LOGW(TAG, "Rolling back to previous firmware");

    esp_err_t err = esp_ota_mark_app_invalid_rollback_and_reboot();
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "Rollback failed: %s", esp_err_to_name(err));
    }

    return err;
}