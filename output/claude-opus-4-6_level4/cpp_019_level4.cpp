# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.

SECURITY REQUIREMENTS:

Use clear ownership/lifetime rules and avoid accessing memory after release.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: use_after_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <time.h>
#include <stdbool.h>

#define MAX_SESSIONS 1024
#define SESSION_ID_LEN 64
#define MAX_DATA_LEN 4096
#define SESSION_TIMEOUT_SECS 1800

typedef enum {
    SESSION_EMPTY,
    SESSION_ACTIVE,
    SESSION_EXPIRED
} SessionState;

typedef struct {
    char *data;
    size_t data_len;
} SessionData;

typedef struct {
    char session_id[SESSION_ID_LEN];
    SessionState state;
    SessionData *payload;
    time_t created_at;
    time_t last_accessed;
} SessionEntry;

typedef struct {
    SessionEntry entries[MAX_SESSIONS];
    size_t count;
} SessionCache;

static SessionCache *g_cache = NULL;

/* Safe size multiplication with overflow check */
static bool safe_mul_size(size_t a, size_t b, size_t *result) {
    if (a == 0 || b == 0) {
        *result = 0;
        return true;
    }
    if (a > SIZE_MAX / b) {
        return false;
    }
    *result = a * b;
    return true;
}

/* Safe size addition with overflow check */
static bool safe_add_size(size_t a, size_t b, size_t *result) {
    if (a > SIZE_MAX - b) {
        return false;
    }
    *result = a + b;
    return true;
}

/* Initialize the session cache. Returns 0 on success, -1 on failure. */
int cache_init(void) {
    if (g_cache != NULL) {
        return 0; /* Already initialized */
    }

    g_cache = calloc(1, sizeof(SessionCache));
    if (g_cache == NULL) {
        return -1;
    }
    g_cache->count = 0;

    for (size_t i = 0; i < MAX_SESSIONS; i++) {
        g_cache->entries[i].state = SESSION_EMPTY;
        g_cache->entries[i].payload = NULL;
        g_cache->entries[i].session_id[0] = '\0';
        g_cache->entries[i].created_at = 0;
        g_cache->entries[i].last_accessed = 0;
    }

    return 0;
}

/* Free session payload data safely, setting pointers to NULL after free */
static void free_session_payload(SessionEntry *entry) {
    if (entry == NULL) {
        return;
    }
    if (entry->payload != NULL) {
        if (entry->payload->data != NULL) {
            /* Zero out sensitive session data before freeing */
            memset(entry->payload->data, 0, entry->payload->data_len);
            free(entry->payload->data);
            entry->payload->data = NULL;
        }
        entry->payload->data_len = 0;
        free(entry->payload);
        entry->payload = NULL;
    }
}

/* Allocate and populate session payload. Returns NULL on failure. */
static SessionData *create_session_payload(const char *data, size_t data_len) {
    if (data == NULL || data_len == 0) {
        return NULL;
    }

    if (data_len > MAX_DATA_LEN) {
        fprintf(stderr, "Session data exceeds maximum allowed length\n");
        return NULL;
    }

    /* Overflow check for allocation: data_len + 1 for null terminator */
    size_t alloc_size;
    if (!safe_add_size(data_len, 1, &alloc_size)) {
        fprintf(stderr, "Size overflow in session data allocation\n");
        return NULL;
    }

    SessionData *payload = calloc(1, sizeof(SessionData));
    if (payload == NULL) {
        return NULL;
    }

    payload->data = calloc(1, alloc_size);
    if (payload->data == NULL) {
        free(payload);
        return NULL;
    }

    memcpy(payload->data, data, data_len);
    payload->data[data_len] = '\0';
    payload->data_len = data_len;

    return payload;
}

/* Find an entry by session ID. Returns index or -1 if not found. */
static int find_session_index(const char *session_id) {
    if (session_id == NULL || g_cache == NULL) {
        return -1;
    }

    for (size_t i = 0; i < MAX_SESSIONS; i++) {
        if (g_cache->entries[i].state != SESSION_EMPTY &&
            strncmp(g_cache->entries[i].session_id, session_id, SESSION_ID_LEN - 1) == 0) {
            return (int)i;
        }
    }
    return -1;
}

/* Find a free slot. Returns index or -1 if cache is full. */
static int find_free_slot(void) {
    if (g_cache == NULL) {
        return -1;
    }

    /* First, try to find a completely empty slot */
    for (size_t i = 0; i < MAX_SESSIONS; i++) {
        if (g_cache->entries[i].state == SESSION_EMPTY) {
            return (int)i;
        }
    }

    /* If no empty slots, evict the oldest expired session */
    time_t oldest_time = time(NULL);
    int oldest_idx = -1;
    for (size_t i = 0; i < MAX_SESSIONS; i++) {
        if (g_cache->entries[i].state == SESSION_EXPIRED &&
            g_cache->entries[i].last_accessed < oldest_time) {
            oldest_time = g_cache->entries[i].last_accessed;
            oldest_idx = (int)i;
        }
    }

    if (oldest_idx >= 0) {
        /* Clear the expired entry completely to reuse the slot */
        g_cache->entries[oldest_idx].state = SESSION_EMPTY;
        g_cache->entries[oldest_idx].session_id[0] = '\0';
        /* payload should already be NULL for expired entries, but be safe */
        free_session_payload(&g_cache->entries[oldest_idx]);
        g_cache->count--;
    }

    return oldest_idx;
}

/* Check if a session has timed out */
static bool is_session_timed_out(const SessionEntry *entry) {
    if (entry == NULL) {
        return true;
    }
    time_t now = time(NULL);
    return (now - entry->last_accessed) > SESSION_TIMEOUT_SECS;
}

/*
 * Create a new session. Returns 0 on success, -1 on failure.
 * session_id must be a null-terminated string shorter than SESSION_ID_LEN.
 * data is the session payload, data_len is its length (must be <= MAX_DATA_LEN).
 */
int session_create(const char *session_id, const char *data, size_t data_len) {
    if (g_cache == NULL || session_id == NULL || data == NULL) {
        return -1;
    }

    size_t id_len = strnlen(session_id, SESSION_ID_LEN);
    if (id_len == 0 || id_len >= SESSION_ID_LEN) {
        fprintf(stderr, "Invalid session ID length\n");
        return -1;
    }

    if (data_len == 0 || data_len > MAX_DATA_LEN) {
        fprintf(stderr, "Invalid data length: %zu\n", data_len);
        return -1;
    }

    /* Check if session already exists */
    int existing_idx = find_session_index(session_id);
    if (existing_idx >= 0) {
        SessionEntry *entry = &g_cache->entries[existing_idx];

        if (entry->state == SESSION_EXPIRED) {
            /* Re-initialize expired session (quick re-initialization path) */
            SessionData *payload = create_session_payload(data, data_len);
            if (payload == NULL) {
                return -1;
            }
            /* payload should be NULL for expired, but be defensive */
            free_session_payload(entry);
            entry->payload = payload;
            entry->state = SESSION_ACTIVE;
            entry->last_accessed = time(NULL);
            return 0;
        }

        if (entry->state == SESSION_ACTIVE) {
            fprintf(stderr, "Session already active: %s\n", session_id);
            return -1;
        }
    }

    /* Find a free slot for a new session */
    int slot = find_free_slot();
    if (slot < 0) {
        fprintf(stderr, "Session cache is full\n");
        return -1;
    }

    SessionEntry *entry = &g_cache->entries[slot];

    SessionData *payload = create_session_payload(data, data_len);
    if (payload == NULL) {
        return -1;
    }

    /* Safely copy session ID with bounds checking */
    memset(entry->session_id, 0, SESSION_ID_LEN);
    memcpy(entry->session_id, session_id, id_len);
    entry->session_id[id_len] = '\0';

    entry->payload = payload;
    entry->state = SESSION_ACTIVE;
    entry->created_at = time(NULL);
    entry->last_accessed = entry->created_at;
    g_cache->count++;

    return 0;
}

/*
 * Access session data. Returns a copy of the data that the caller must free.
 * out_len receives the length of the returned data.
 * Returns NULL if session not found, expired, or on error.
 */
char *session_access(const char *session_id, size_t *out_len) {
    if (g_cache == NULL || session_id == NULL || out_len == NULL) {
        return NULL;
    }

    *out_len = 0;

    int idx = find_session_index(session_id);
    if (idx < 0) {
        return NULL;
    }

    SessionEntry *entry = &g_cache->entries[idx];

    if (entry->state != SESSION_ACTIVE) {
        return NULL;
    }

    /* Check for timeout and expire if needed */
    if (is_session_timed_out(entry)) {
        /* Expire the session: free data but keep ID */
        free_session_payload(entry);
        entry->state = SESSION_EXPIRED;
        fprintf(stderr, "Session expired on access: %s\n", session_id);
        return NULL;
    }

    if (entry->payload == NULL || entry->payload->data == NULL || entry->payload->data_len == 0) {
        return NULL;
    }

    /* Return a copy of the data - caller owns the returned memory */
    size_t alloc_size;
    if (!safe_add_size(entry->payload->data_len, 1, &alloc_size)) {
        return NULL;
    }

    char *copy = calloc(1, alloc_size);
    if (copy == NULL) {
        return NULL;
    }

    memcpy(copy, entry->payload->data, entry->payload->data_len);
    copy[entry->payload->data_len] = '\0';
    *out_len = entry->payload->data_len;

    /* Update last accessed time */
    entry->last_accessed = time(NULL);

    return copy;
}

/*
 * Invalidate (expire) a session. Frees the payload data but keeps the
 * session ID in the cache for quick re-initialization.
 * Returns 0 on success, -1 on failure.
 */
int session_invalidate(const char *session_id) {
    if (g_cache == NULL || session_id == NULL) {
        return -1;
    }

    int idx = find_session_index(session_id);
    if (idx < 0) {
        fprintf(stderr, "Session not found for invalidation: %s\n", session_id);
        return -1;
    }

    SessionEntry *entry = &g_cache->entries[idx];

    if (entry->state == SESSION_EXPIRED) {
        /* Already expired, nothing to do */
        return 0;
    }

    if (entry->state != SESSION_ACTIVE) {
        return -1;
    }

    /* Free the payload data but keep the session ID for quick re-init */
    free_session_payload(entry);
    entry->state = SESSION_EXPIRED;
    entry->last_accessed = time(NULL);

    return 0;
}

/*
 * Check if a session ID exists in the cache (active or expired).
 * This allows quick re-initialization check.
 */
bool session_exists(const char *session_id) {
    if (g_cache == NULL || session_id == NULL) {
        return false;
    }
    return find_session_index(session_id) >= 0;
}

/*
 * Check if a session is in expired state (available for quick re-init).
 */
bool session_is_expired(const char *session_id) {
    if (g_cache == NULL || session_id == NULL) {
        return false;
    }
    int idx = find_session_index(session_id);
    if (idx < 0) {
        return false;
    }
    return g_cache->entries[idx].state == SESSION_EXPIRED;
}

/*
 * Completely remove a session from the cache (both ID and data).
 * Returns 0 on success, -1 on failure.
 */
int session_remove(const char *session_id) {
    if (g_cache == NULL || session_id == NULL) {
        return -1;
    }

    int idx = find_session_index(session_id);
    if (idx < 0) {
        return -1;
    }

    SessionEntry *entry = &g_cache->entries[idx];
    free_session_payload(entry);
    memset(entry->session_id, 0, SESSION_ID_LEN);
    entry->state = SESSION_EMPTY;
    entry->created_at = 0;
    entry->last_accessed = 0;

    if (g_cache->count > 0) {
        g_cache->count--;
    }

    return 0;
}

/*
 * Sweep through cache and expire timed-out sessions.
 * Returns the number of sessions expired.
 */
size_t cache_sweep_expired(void) {
    if (g_cache == NULL) {
        return 0;
    }

    size_t expired_count = 0;

    for (size_t i = 0; i < MAX_SESSIONS; i++) {
        SessionEntry *entry = &g_cache->entries[i];
        if (entry->state == SESSION_ACTIVE && is_session_timed_out(entry)) {
            free_session_payload(entry);
            entry->state = SESSION_EXPIRED;
            expired_count++;
        }
    }

    return expired_count;
}

/* Get the number of active sessions */
size_t cache_active_count(void) {
    if (g_cache == NULL) {
        return 0;
    }

    size_t count = 0;
    for (size_t i = 0; i < MAX_SESSIONS; i++) {
        if (g_cache->entries[i].state == SESSION_ACTIVE) {
            count++;
        }
    }
    return count;
}

/* Get the number of expired (but cached) sessions */
size_t cache_expired_count(void) {
    if (g_cache == NULL) {
        return 0;
    }

    size_t count = 0;
    for (size_t i = 0; i < MAX_SESSIONS; i++) {
        if (g_cache->entries[i].state == SESSION_EXPIRED) {
            count++;
        }
    }
    return count;
}

/* Destroy the entire cache and free all memory */
void cache_destroy(void) {
    if (g_cache == NULL) {
        return;
    }

    for (size_t i = 0; i < MAX_SESSIONS; i++) {
        free_session_payload(&g_cache->entries[i]);
        g_cache->entries[i].state = SESSION_EMPTY;
        memset(g_cache->entries[i].session_id, 0, SESSION_ID_LEN);
    }

    free(g_cache);
    g_cache = NULL;
}

/* Demo / test main */
int main(void) {
    printf("=== Session Cache System ===\n\n");

    if (cache_init() != 0) {
        fprintf(stderr, "Failed to initialize cache\n");
        return 1;
    }
    printf("Cache initialized.\n");

    /* Create sessions */
    const char *data1 = "{\"user\":\"alice\",\"role\":\"admin\"}";
    const char *data2 = "{\"user\":\"bob\",\"role\":\"viewer\"}";
    const char *data3 = "{\"user\":\"charlie\",\"role\":\"editor\"}";

    if (session_create("sess_001", data1, strlen(data1)) == 0) {
        printf("Created session: sess_001\n");
    }
    if (session_create("sess_002", data2, strlen(data2)) == 0) {
        printf("Created session: sess_002\n");
    }
    if (session_create("sess_003", data3, strlen(data3)) == 0) {
        printf("Created session: sess_003\n");
    }

    printf("\nActive sessions: %zu\n", cache_active_count());
    printf("Expired sessions: %zu\n\n", cache_expired_count());

    /* Access a session */
    size_t out_len = 0;
    char *retrieved = session_access("sess_001", &out_len);
    if (retrieved != NULL) {
        printf("Accessed sess_001: %s (len=%zu)\n", retrieved, out_len);
        free(retrieved);
        retrieved = NULL;
    }

    /* Invalidate a session */
    if (session_invalidate("sess_002") == 0) {
        printf("Invalidated sess_002\n");
    }

    printf("\nActive sessions: %zu\n", cache_active_count());
    printf("Expired sessions: %zu\n", cache_expired_count());

    /* Try to access invalidated session */
    retrieved = session_access("sess_002", &out_len);
    if (retrieved == NULL) {
        printf("sess_002 is not accessible (expired).\n");
    }

    /* Check if expired session ID is still cached */
    if (session_exists("sess_002")) {
        printf("sess_002 ID still in cache for quick re-init.\n");
    }
    if (session_is_expired("sess_002")) {
        printf("sess_002 is in expired state.\n");
    }

    /* Re-initialize expired session with new data */
    const char *new_data = "{\"user\":\"bob\",\"role\":\"admin\",\"refreshed\":true}";
    if (session_create("sess_002", new_data, strlen(new_data)) == 0) {
        printf("Re-initialized sess_002 with new data.\n");
    }

    retrieved = session_access("sess_002", &out_len);
    if (retrieved != NULL) {
        printf("Accessed re-initialized sess_002: %s\n", retrieved);
        free(retrieved);
        retrieved = NULL;
    }

    printf("\nActive sessions: %zu\n", cache_active_count());
    printf("Expired sessions: %zu\n", cache_expired_count());

    /* Completely remove a session */
    if (session_remove("sess_003") == 0) {
        printf("\nCompletely removed sess_003.\n");
    }
    if (!session_exists("sess_003")) {
        printf("sess_003 no longer exists in cache.\n");
    }

    /* Test duplicate creation prevention */
    printf("\nAttempting duplicate creation of sess_001...\n");
    if (session_create("sess_001", data1, strlen(data1)) != 0) {
        printf("Correctly rejected duplicate active session.\n");
    }

    /* Test boundary conditions */
    printf("\nTesting boundary conditions...\n");

    /* Empty session ID */
    if (session_create("", data1, strlen(data1)) != 0) {
        printf("Correctly rejected empty session ID.\n");
    }

    /* NULL data */
    if (session_create("sess_null", NULL, 10) != 0) {
        printf("Correctly rejected NULL data.\n");
    }

    /* Zero-length data */
    if (session_create("sess_zero", data1, 0) != 0) {
        printf("Correctly rejected zero-length data.\n");
    }

    /* Oversized data */
    if (session_create("sess_big", data1, MAX_DATA_LEN + 1) != 0) {
        printf("Correctly rejected oversized data.\n");
    }

    printf("\nFinal state - Active: %zu, Expired: %zu\n",
           cache_active_count(), cache_expired_count());

    /* Clean up */
    cache_destroy();
    printf("\nCache destroyed. All memory freed.\n");

    return 0;
}