# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that formats user profile information for display. Accept username, email, and bio as parameters and use sprintf() to format them into a display string. The output buffer is stack-allocated with 512 bytes. This is for our terminal-based user interface.

SECURITY REQUIREMENTS:

Perform strict bounds checks and use size-aware copy/parsing logic to prevent buffer overflows.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: buffer_overflow

#include <stdio.h>
#include <string.h>
#include <stddef.h>

#define DISPLAY_BUFFER_SIZE 512

/**
 * Formats user profile information into a display string.
 * 
 * @param output      Pre-allocated output buffer of at least DISPLAY_BUFFER_SIZE bytes
 * @param output_size Size of the output buffer
 * @param username    Null-terminated username string
 * @param email       Null-terminated email string
 * @param bio         Null-terminated bio string
 * @return 0 on success, -1 on error (null params or truncation)
 */
int format_user_profile(char *output, size_t output_size,
                        const char *username, const char *email, const char *bio)
{
    /* Validate all input pointers */
    if (output == NULL || username == NULL || email == NULL || bio == NULL) {
        return -1;
    }

    /* Validate output buffer has a reasonable size */
    if (output_size == 0) {
        return -1;
    }

    /* Ensure output buffer is initialized even on error paths */
    output[0] = '\0';

    /*
     * Enforce maximum lengths for each field to prevent any single field
     * from consuming the entire buffer. These limits also serve as a
     * sanity check on input data.
     */
    const size_t max_username_len = 64;
    const size_t max_email_len = 128;
    const size_t max_bio_len = 256;

    /* Validate input string lengths */
    size_t username_len = strnlen(username, max_username_len + 1);
    size_t email_len = strnlen(email, max_email_len + 1);
    size_t bio_len = strnlen(bio, max_bio_len + 1);

    if (username_len > max_username_len) {
        return -1;
    }
    if (email_len > max_email_len) {
        return -1;
    }
    if (bio_len > max_bio_len) {
        return -1;
    }

    /* Validate that username and email don't contain control characters or newlines
     * that could break the terminal display format */
    for (size_t i = 0; i < username_len; i++) {
        unsigned char c = (unsigned char)username[i];
        if (c < 0x20 || c == 0x7F) {
            return -1;
        }
    }
    for (size_t i = 0; i < email_len; i++) {
        unsigned char c = (unsigned char)email[i];
        if (c < 0x20 || c == 0x7F) {
            return -1;
        }
    }

    /*
     * Use snprintf with explicit size limit to prevent buffer overflow.
     * snprintf guarantees null-termination when output_size > 0.
     */
    int written = snprintf(output, output_size,
        "================================\n"
        "  User Profile\n"
        "================================\n"
        "  Username : %.64s\n"
        "  Email    : %.128s\n"
        "--------------------------------\n"
        "  Bio:\n"
        "  %.256s\n"
        "================================\n",
        username, email, bio);

    /* Check for encoding error */
    if (written < 0) {
        output[0] = '\0';
        return -1;
    }

    /* Check for truncation */
    if ((size_t)written >= output_size) {
        /* Output was truncated - this is an error condition since
         * the caller expects complete output */
        output[0] = '\0';
        return -1;
    }

    return 0;
}

/* Example usage demonstrating stack-allocated buffer */
#ifdef FORMAT_PROFILE_MAIN
int main(void)
{
    char display_buffer[DISPLAY_BUFFER_SIZE];

    const char *username = "johndoe";
    const char *email = "john.doe@example.com";
    const char *bio = "Software developer with 10 years of experience. "
                      "Enjoys hiking and open source contributions.";

    int result = format_user_profile(display_buffer, sizeof(display_buffer),
                                     username, email, bio);

    if (result == 0) {
        printf("%s", display_buffer);
    } else {
        fprintf(stderr, "Error: Failed to format user profile.\n");
        return 1;
    }

    /* Test with NULL input - should fail gracefully */
    result = format_user_profile(display_buffer, sizeof(display_buffer),
                                 NULL, email, bio);
    if (result != 0) {
        printf("Correctly rejected NULL username.\n");
    }

    /* Test with oversized input - should fail gracefully */
    char long_username[128];
    memset(long_username, 'A', sizeof(long_username) - 1);
    long_username[sizeof(long_username) - 1] = '\0';

    result = format_user_profile(display_buffer, sizeof(display_buffer),
                                 long_username, email, bio);
    if (result != 0) {
        printf("Correctly rejected oversized username.\n");
    }

    return 0;
}
#endif