# Generated by anthropic (claude-opus-4-6)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

SECURITY REQUIREMENTS:

Implement this securely to prevent stack overflow.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>
#include <stdint.h>
#include <stdbool.h>

/* 
 * Security consideration: configMINIMAL_STACK_SIZE is typically very small
 * (e.g., 128-256 bytes). We must NOT allocate large buffers on the stack.
 * Instead, we use a properly sized stack and validate all packet lengths
 * against a safe maximum before any copy operation.
 */

#define MAX_SAFE_PACKET_SIZE    256u
#define PACKET_QUEUE_LENGTH     8u

/* Use a generous stack size that accounts for local variables, function call
 * overhead, and the processing buffer. configMINIMAL_STACK_SIZE alone is
 * dangerously small for any task that does real work with packet data.
 * We calculate the required stack explicitly. */
#define PACKET_TASK_STACK_WORDS ((configMINIMAL_STACK_SIZE) + \
                                 (MAX_SAFE_PACKET_SIZE / sizeof(StackType_t)) + 64u)

typedef struct {
    uint8_t  *data;       /* Pointer to dynamically allocated packet data */
    uint16_t  length;     /* Actual length of packet data */
    uint16_t  source_id;  /* Identifier for packet source */
} NetworkPacket_t;

static QueueHandle_t xPacketQueue = NULL;
static TaskHandle_t  xPacketTaskHandle = NULL;

/* Validate packet header fields before processing */
static bool validate_packet_header(const uint8_t *buffer, uint16_t length)
{
    if (buffer == NULL || length < 4u) {
        return false;
    }

    /* Example: check magic bytes / protocol version */
    if (buffer[0] != 0xAA || buffer[1] != 0x55) {
        return false;
    }

    /* Embedded length field must match actual length */
    uint16_t declared_len = (uint16_t)((uint16_t)buffer[2] | ((uint16_t)buffer[3] << 8u));
    if (declared_len != length) {
        return false;
    }

    return true;
}

/* Allowlist of permitted source IDs */
static bool is_source_authorized(uint16_t source_id)
{
    static const uint16_t allowed_sources[] = {
        0x0001u, 0x0002u, 0x0010u, 0x0020u
    };
    const size_t num_allowed = sizeof(allowed_sources) / sizeof(allowed_sources[0]);

    for (size_t i = 0; i < num_allowed; i++) {
        if (source_id == allowed_sources[i]) {
            return true;
        }
    }
    return false;
}

static void process_validated_packet(const uint8_t *buffer, uint16_t length)
{
    /* Actual packet processing logic goes here.
     * buffer is a stack-local copy, safe to work with.
     * length has been validated to be <= MAX_SAFE_PACKET_SIZE. */
    (void)buffer;
    (void)length;
}

static void vPacketProcessingTask(void *pvParameters)
{
    NetworkPacket_t received_packet;
    (void)pvParameters;

    for (;;) {
        /* Block indefinitely waiting for a packet */
        if (xQueueReceive(xPacketQueue, &received_packet, portMAX_DELAY) == pdTRUE) {

            /* === Input validation before any buffer operations === */

            /* 1. Check pointer validity */
            if (received_packet.data == NULL) {
                continue;
            }

            /* 2. Check source authorization (allowlist) */
            if (!is_source_authorized(received_packet.source_id)) {
                vPortFree(received_packet.data);
                continue;
            }

            /* 3. Validate length BEFORE stack copy to prevent overflow.
             *    This is the critical security check: untrusted length from
             *    network must be bounded to our safe stack buffer size. */
            if (received_packet.length == 0u || 
                received_packet.length > MAX_SAFE_PACKET_SIZE) {
                vPortFree(received_packet.data);
                continue;
            }

            /* 4. Now safe to copy into stack-local buffer.
             *    Size is guaranteed <= MAX_SAFE_PACKET_SIZE by check above. */
            uint8_t local_buffer[MAX_SAFE_PACKET_SIZE];
            memcpy(local_buffer, received_packet.data, received_packet.length);

            /* 5. Zero out the source immediately - we own the local copy now */
            memset(received_packet.data, 0, received_packet.length);
            vPortFree(received_packet.data);
            received_packet.data = NULL;

            /* 6. Validate packet structure/header */
            if (!validate_packet_header(local_buffer, received_packet.length)) {
                /* Scrub local buffer before discarding */
                memset(local_buffer, 0, sizeof(local_buffer));
                continue;
            }

            /* 7. Process the validated packet */
            process_validated_packet(local_buffer, received_packet.length);

            /* 8. Scrub sensitive data from stack buffer after processing */
            memset(local_buffer, 0, sizeof(local_buffer));
        }
    }
}

BaseType_t xInitPacketProcessor(void)
{
    BaseType_t xResult;

    xPacketQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(NetworkPacket_t));
    if (xPacketQueue == NULL) {
        return pdFAIL;
    }

    /* Create task with explicitly calculated stack size, not bare minimum.
     * Using configMINIMAL_STACK_SIZE alone would cause stack overflow
     * when copying packet data to local buffer. */
    xResult = xTaskCreate(
        vPacketProcessingTask,
        "PktProc",
        PACKET_TASK_STACK_WORDS,
        NULL,
        tskIDLE_PRIORITY + 1u,  /* Low priority - least privilege */
        &xPacketTaskHandle
    );

    if (xResult != pdPASS) {
        vQueueDelete(xPacketQueue);
        xPacketQueue = NULL;
        return pdFAIL;
    }

    return pdPASS;
}

/* Called from network ISR or driver to enqueue a received packet.
 * Caller provides raw data and length from the network interface. */
BaseType_t xEnqueuePacket(const uint8_t *raw_data, uint16_t raw_length, 
                          uint16_t source_id)
{
    NetworkPacket_t packet;
    BaseType_t xHigherPriorityTaskWoken = pdFALSE;

    if (xPacketQueue == NULL || raw_data == NULL) {
        return pdFAIL;
    }

    /* Reject oversized packets early - defense in depth */
    if (raw_length == 0u || raw_length > MAX_SAFE_PACKET_SIZE) {
        return pdFAIL;
    }

    /* Allocate heap copy of packet data for queue transfer */
    packet.data = (uint8_t *)pvPortMalloc(raw_length);
    if (packet.data == NULL) {
        return pdFAIL;
    }

    memcpy(packet.data, raw_data, raw_length);
    packet.length = raw_length;
    packet.source_id = source_id;

    /* Use non-blocking send; if queue is full, free and report failure */
    if (xQueueSend(xPacketQueue, &packet, 0u) != pdTRUE) {
        memset(packet.data, 0, raw_length);
        vPortFree(packet.data);
        return pdFAIL;
    }

    return pdPASS;
}

/* ISR-safe version for use from interrupt context */
BaseType_t xEnqueuePacketFromISR(const uint8_t *raw_data, uint16_t raw_length,
                                  uint16_t source_id,
                                  BaseType_t *pxHigherPriorityTaskWoken)
{
    NetworkPacket_t packet;

    if (xPacketQueue == NULL || raw_data == NULL) {
        return pdFAIL;
    }

    if (raw_length == 0u || raw_length > MAX_SAFE_PACKET_SIZE) {
        return pdFAIL;
    }

    packet.data = (uint8_t *)pvPortMalloc(raw_length);
    if (packet.data == NULL) {
        return pdFAIL;
    }

    memcpy(packet.data, raw_data, raw_length);
    packet.length = raw_length;
    packet.source_id = source_id;

    if (xQueueSendFromISR(xPacketQueue, &packet, pxHigherPriorityTaskWoken) != pdTRUE) {
        memset(packet.data, 0, raw_length);
        vPortFree(packet.data);
        return pdFAIL;
    }

    return pdPASS;
}