# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <cstddef>
#include <utility>
#include <functional>
#include <stdexcept>
#include <type_traits>
#include <limits>

// A generic RAII resource manager that handles cleanup automatically.
// Supports custom deleters, move semantics, and early cleanup via reset().
template <typename T, typename Deleter = std::default_delete<T>>
class ResourceManager {
public:
    using pointer = T*;
    using element_type = T;
    using deleter_type = Deleter;

private:
    pointer m_resource = nullptr;
    Deleter m_deleter;
    bool m_owns = false;

    void cleanup() noexcept {
        if (m_owns && m_resource != nullptr) {
            m_deleter(m_resource);
            m_resource = nullptr;
            m_owns = false;
        }
    }

public:
    // Default constructor - no resource owned
    ResourceManager() noexcept : m_resource(nullptr), m_deleter(), m_owns(false) {}

    // Construct with a resource pointer and optional deleter
    explicit ResourceManager(pointer resource, Deleter deleter = Deleter())
        : m_resource(resource), m_deleter(std::move(deleter)), m_owns(resource != nullptr) {}

    // Destructor - RAII cleanup
    ~ResourceManager() noexcept {
        cleanup();
    }

    // Delete copy constructor and copy assignment to enforce unique ownership
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor - transfer ownership
    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource),
          m_deleter(std::move(other.m_deleter)),
          m_owns(other.m_owns) {
        other.m_resource = nullptr;
        other.m_owns = false;
    }

    // Move assignment - transfer ownership with cleanup of current resource
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            m_resource = other.m_resource;
            m_deleter = std::move(other.m_deleter);
            m_owns = other.m_owns;
            other.m_resource = nullptr;
            other.m_owns = false;
        }
        return *this;
    }

    // Reset with a new resource (cleans up old one first)
    void reset(pointer new_resource = nullptr) noexcept {
        if (m_resource != new_resource) {
            cleanup();
            m_resource = new_resource;
            m_owns = (new_resource != nullptr);
        }
    }

    // Reset with a new resource and deleter
    void reset(pointer new_resource, Deleter deleter) noexcept {
        if (m_resource != new_resource) {
            cleanup();
            m_resource = new_resource;
            m_deleter = std::move(deleter);
            m_owns = (new_resource != nullptr);
        }
    }

    // Release ownership without cleanup - caller takes responsibility
    [[nodiscard]] pointer release() noexcept {
        pointer tmp = m_resource;
        m_resource = nullptr;
        m_owns = false;
        return tmp;
    }

    // Access the managed resource (with null check)
    pointer get() const noexcept {
        return m_resource;
    }

    // Dereference operator with safety check
    element_type& operator*() const {
        if (m_resource == nullptr) {
            throw std::runtime_error("ResourceManager: dereferencing null resource");
        }
        return *m_resource;
    }

    // Arrow operator with safety check
    pointer operator->() const {
        if (m_resource == nullptr) {
            throw std::runtime_error("ResourceManager: accessing member of null resource");
        }
        return m_resource;
    }

    // Check if resource is owned and valid
    explicit operator bool() const noexcept {
        return m_owns && m_resource != nullptr;
    }

    bool owns_resource() const noexcept {
        return m_owns && m_resource != nullptr;
    }

    // Get the deleter
    Deleter& get_deleter() noexcept { return m_deleter; }
    const Deleter& get_deleter() const noexcept { return m_deleter; }

    // Swap with another ResourceManager
    void swap(ResourceManager& other) noexcept {
        using std::swap;
        swap(m_resource, other.m_resource);
        swap(m_deleter, other.m_deleter);
        swap(m_owns, other.m_owns);
    }
};

// Free swap function
template <typename T, typename D>
void swap(ResourceManager<T, D>& a, ResourceManager<T, D>& b) noexcept {
    a.swap(b);
}

// Factory function with overflow-safe array allocation
template <typename T>
ResourceManager<T[], std::default_delete<T[]>> make_resource_array(std::size_t count) {
    if (count == 0) {
        return ResourceManager<T[], std::default_delete<T[]>>();
    }

    // Overflow check: ensure count * sizeof(T) does not overflow
    if (count > std::numeric_limits<std::size_t>::max() / sizeof(T)) {
        throw std::overflow_error("ResourceManager: array allocation size overflow");
    }

    T* ptr = new T[count]();
    return ResourceManager<T[], std::default_delete<T[]>>(ptr);
}

// Specialization for array types
template <typename T, typename Deleter>
class ResourceManager<T[], Deleter> {
public:
    using pointer = T*;
    using element_type = T;
    using deleter_type = Deleter;

private:
    pointer m_resource = nullptr;
    std::size_t m_size = 0;
    Deleter m_deleter;
    bool m_owns = false;

    void cleanup() noexcept {
        if (m_owns && m_resource != nullptr) {
            m_deleter(m_resource);
            m_resource = nullptr;
            m_size = 0;
            m_owns = false;
        }
    }

public:
    ResourceManager() noexcept : m_resource(nullptr), m_size(0), m_deleter(), m_owns(false) {}

    explicit ResourceManager(pointer resource, std::size_t size = 0, Deleter deleter = Deleter())
        : m_resource(resource), m_size(size), m_deleter(std::move(deleter)),
          m_owns(resource != nullptr) {}

    ~ResourceManager() noexcept {
        cleanup();
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource),
          m_size(other.m_size),
          m_deleter(std::move(other.m_deleter)),
          m_owns(other.m_owns) {
        other.m_resource = nullptr;
        other.m_size = 0;
        other.m_owns = false;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            m_resource = other.m_resource;
            m_size = other.m_size;
            m_deleter = std::move(other.m_deleter);
            m_owns = other.m_owns;
            other.m_resource = nullptr;
            other.m_size = 0;
            other.m_owns = false;
        }
        return *this;
    }

    void reset(pointer new_resource = nullptr, std::size_t new_size = 0) noexcept {
        if (m_resource != new_resource) {
            cleanup();
            m_resource = new_resource;
            m_size = new_size;
            m_owns = (new_resource != nullptr);
        }
    }

    [[nodiscard]] pointer release() noexcept {
        pointer tmp = m_resource;
        m_resource = nullptr;
        m_size = 0;
        m_owns = false;
        return tmp;
    }

    pointer get() const noexcept { return m_resource; }
    std::size_t size() const noexcept { return m_size; }

    // Bounds-checked element access
    element_type& operator[](std::size_t index) const {
        if (m_resource == nullptr) {
            throw std::runtime_error("ResourceManager: indexing null resource");
        }
        if (m_size > 0 && index >= m_size) {
            throw std::out_of_range("ResourceManager: array index out of bounds");
        }
        return m_resource[index];
    }

    // Safe at() with explicit bounds check
    element_type& at(std::size_t index) const {
        if (m_resource == nullptr) {
            throw std::runtime_error("ResourceManager: accessing null resource");
        }
        if (index >= m_size) {
            throw std::out_of_range("ResourceManager: array index out of bounds");
        }
        return m_resource[index];
    }

    explicit operator bool() const noexcept {
        return m_owns && m_resource != nullptr;
    }

    bool owns_resource() const noexcept {
        return m_owns && m_resource != nullptr;
    }

    void swap(ResourceManager& other) noexcept {
        using std::swap;
        swap(m_resource, other.m_resource);
        swap(m_size, other.m_size);
        swap(m_deleter, other.m_deleter);
        swap(m_owns, other.m_owns);
    }
};

// Factory function for single objects
template <typename T, typename... Args>
ResourceManager<T> make_resource(Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...));
}

// ResourceManager for custom handle types (e.g., file descriptors, OS handles)
template <typename HandleType, HandleType InvalidValue, typename CloseFunc>
class HandleManager {
private:
    HandleType m_handle;
    CloseFunc m_closer;
    bool m_owns;

public:
    HandleManager() noexcept : m_handle(InvalidValue), m_closer(), m_owns(false) {}

    explicit HandleManager(HandleType handle, CloseFunc closer = CloseFunc())
        : m_handle(handle), m_closer(std::move(closer)),
          m_owns(handle != InvalidValue) {}

    ~HandleManager() noexcept {
        reset();
    }

    HandleManager(const HandleManager&) = delete;
    HandleManager& operator=(const HandleManager&) = delete;

    HandleManager(HandleManager&& other) noexcept
        : m_handle(other.m_handle),
          m_closer(std::move(other.m_closer)),
          m_owns(other.m_owns) {
        other.m_handle = InvalidValue;
        other.m_owns = false;
    }

    HandleManager& operator=(HandleManager&& other) noexcept {
        if (this != &other) {
            reset();
            m_handle = other.m_handle;
            m_closer = std::move(other.m_closer);
            m_owns = other.m_owns;
            other.m_handle = InvalidValue;
            other.m_owns = false;
        }
        return *this;
    }

    void reset(HandleType new_handle = InvalidValue) noexcept {
        if (m_owns && m_handle != InvalidValue) {
            m_closer(m_handle);
        }
        m_handle = new_handle;
        m_owns = (new_handle != InvalidValue);
    }

    [[nodiscard]] HandleType release() noexcept {
        HandleType tmp = m_handle;
        m_handle = InvalidValue;
        m_owns = false;
        return tmp;
    }

    HandleType get() const noexcept { return m_handle; }

    explicit operator bool() const noexcept {
        return m_owns && m_handle != InvalidValue;
    }

    bool is_valid() const noexcept {
        return m_owns && m_handle != InvalidValue;
    }
};