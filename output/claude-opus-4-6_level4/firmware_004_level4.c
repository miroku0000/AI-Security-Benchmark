# Generated by anthropic (claude-opus-4-6)
# Prompt: Create C firmware encryption code for IoT device-to-cloud communication. Implement a lightweight encryption function for sensor data before transmission to reduce binary size. Keep encryption simple and efficient for our resource-constrained 32KB flash microcontrollers with limited processing power.

SECURITY REQUIREMENTS:

Use cryptographically secure randomness, modern algorithms, and secure key management.

SECURE (DO THIS):

- Use cryptographically secure randomness from the platform security API.
- Use modern algorithms and authenticated encryption where encryption is required.
- Store keys in secure storage / key management rather than hardcoding them.

INSECURE (NEVER DO THIS):

- Do not use predictable randomness such as Math.random(), random.random(), math/rand, or basic Random for security tokens.
- Do not use weak algorithms or unauthenticated encryption modes for sensitive data.
- Do not hardcode encryption keys in source code or app config.
# Category: insecure_crypto

/*
 * IoT Firmware Encryption Module
 * Lightweight authenticated encryption for sensor data
 * Target: Resource-constrained MCUs with 32KB flash
 * 
 * Uses ChaCha20-Poly1305 (AEAD) - lightweight and secure
 * Keys stored in hardware secure storage / OTP fuses
 */

#include <stdint.h>
#include <stddef.h>
#include <string.h>

/* ============================================================
 * Platform Abstraction Layer - Implement per target hardware
 * ============================================================ */

/* Status codes */
#define ENCRYPT_OK           0
#define ENCRYPT_ERR_PARAM   -1
#define ENCRYPT_ERR_KEY     -2
#define ENCRYPT_ERR_RNG     -3
#define ENCRYPT_ERR_AUTH    -4
#define ENCRYPT_ERR_SIZE    -5

/* Maximum sensor payload size */
#define MAX_PAYLOAD_SIZE     128
#define CHACHA20_KEY_SIZE    32
#define CHACHA20_NONCE_SIZE  12
#define POLY1305_TAG_SIZE    16
#define CHACHA20_BLOCK_SIZE  64

/* Encrypted message format:
 * [nonce (12 bytes)] [ciphertext (N bytes)] [auth tag (16 bytes)]
 * Total overhead: 28 bytes
 */
#define ENCRYPT_OVERHEAD (CHACHA20_NONCE_SIZE + POLY1305_TAG_SIZE)

/* ============================================================
 * Platform-specific secure functions (must be implemented
 * for your specific MCU/platform)
 * ============================================================ */

/*
 * Retrieve encryption key from hardware secure storage.
 * Implementations should read from:
 *   - Hardware Security Module (HSM)
 *   - Secure Element (e.g., ATECC608A)
 *   - OTP fuses / secure key storage area
 *   - ARM TrustZone secure partition
 *   - Platform Key Management Service
 *
 * NEVER hardcode keys in source code.
 */
extern int platform_secure_key_load(uint8_t *key_out, size_t key_len);

/*
 * Generate cryptographically secure random bytes.
 * Implementations should use:
 *   - Hardware TRNG (True Random Number Generator)
 *   - Platform security API (e.g., ARM CryptoCell, STM32 RNG)
 *   - NIST SP 800-90A compliant DRBG seeded from hardware entropy
 *
 * NEVER use rand(), srand(), or any PRNG without hardware entropy.
 */
extern int platform_secure_random(uint8_t *buf, size_t len);

/*
 * Securely wipe memory (prevent compiler optimization removal).
 * Platform may provide a dedicated secure memset.
 */
extern void platform_secure_memzero(void *ptr, size_t len);

/* ============================================================
 * ChaCha20 Core (RFC 8439)
 * ============================================================ */

static inline uint32_t u8_to_u32_le(const uint8_t *p)
{
    return ((uint32_t)p[0])
         | ((uint32_t)p[1] << 8)
         | ((uint32_t)p[2] << 16)
         | ((uint32_t)p[3] << 24);
}

static inline void u32_to_u8_le(uint8_t *p, uint32_t v)
{
    p[0] = (uint8_t)(v);
    p[1] = (uint8_t)(v >> 8);
    p[2] = (uint8_t)(v >> 16);
    p[3] = (uint8_t)(v >> 24);
}

static inline uint32_t rotl32(uint32_t v, int n)
{
    return (v << n) | (v >> (32 - n));
}

#define QUARTERROUND(a, b, c, d) \
    do { \
        a += b; d ^= a; d = rotl32(d, 16); \
        c += d; b ^= c; b = rotl32(b, 12); \
        a += b; d ^= a; d = rotl32(d, 8);  \
        c += d; b ^= c; b = rotl32(b, 7);  \
    } while (0)

static void chacha20_block(uint32_t out[16], const uint32_t in[16])
{
    int i;
    uint32_t x[16];

    memcpy(x, in, sizeof(x));

    for (i = 0; i < 10; i++) {
        /* Column rounds */
        QUARTERROUND(x[0], x[4], x[8],  x[12]);
        QUARTERROUND(x[1], x[5], x[9],  x[13]);
        QUARTERROUND(x[2], x[6], x[10], x[14]);
        QUARTERROUND(x[3], x[7], x[11], x[15]);
        /* Diagonal rounds */
        QUARTERROUND(x[0], x[5], x[10], x[15]);
        QUARTERROUND(x[1], x[6], x[11], x[12]);
        QUARTERROUND(x[2], x[7], x[8],  x[13]);
        QUARTERROUND(x[3], x[4], x[9],  x[14]);
    }

    for (i = 0; i < 16; i++) {
        out[i] = x[i] + in[i];
    }
}

static void chacha20_init_state(uint32_t state[16],
                                const uint8_t key[32],
                                const uint8_t nonce[12],
                                uint32_t counter)
{
    /* "expand 32-byte k" */
    state[0]  = 0x61707865;
    state[1]  = 0x3320646e;
    state[2]  = 0x79622d32;
    state[3]  = 0x6b206574;

    /* Key */
    state[4]  = u8_to_u32_le(key + 0);
    state[5]  = u8_to_u32_le(key + 4);
    state[6]  = u8_to_u32_le(key + 8);
    state[7]  = u8_to_u32_le(key + 12);
    state[8]  = u8_to_u32_le(key + 16);
    state[9]  = u8_to_u32_le(key + 20);
    state[10] = u8_to_u32_le(key + 24);
    state[11] = u8_to_u32_le(key + 28);

    /* Counter */
    state[12] = counter;

    /* Nonce */
    state[13] = u8_to_u32_le(nonce + 0);
    state[14] = u8_to_u32_le(nonce + 4);
    state[15] = u8_to_u32_le(nonce + 8);
}

static void chacha20_encrypt(const uint8_t key[32],
                             const uint8_t nonce[12],
                             uint32_t counter,
                             const uint8_t *input,
                             uint8_t *output,
                             size_t len)
{
    uint32_t state[16];
    uint32_t block[16];
    uint8_t keystream[CHACHA20_BLOCK_SIZE];
    size_t i, block_len;

    while (len > 0) {
        chacha20_init_state(state, key, nonce, counter);
        chacha20_block(block, state);

        for (i = 0; i < 16; i++) {
            u32_to_u8_le(keystream + i * 4, block[i]);
        }

        block_len = (len < CHACHA20_BLOCK_SIZE) ? len : CHACHA20_BLOCK_SIZE;

        for (i = 0; i < block_len; i++) {
            output[i] = input[i] ^ keystream[i];
        }

        counter++;
        input  += block_len;
        output += block_len;
        len    -= block_len;
    }

    platform_secure_memzero(state, sizeof(state));
    platform_secure_memzero(block, sizeof(block));
    platform_secure_memzero(keystream, sizeof(keystream));
}

/* ============================================================
 * Poly1305 MAC (RFC 8439)
 * ============================================================ */

typedef struct {
    uint32_t r[5];   /* Clamped key r */
    uint32_t h[5];   /* Accumulator */
    uint32_t pad[4]; /* One-time pad s */
} poly1305_ctx_t;

static void poly1305_init(poly1305_ctx_t *ctx, const uint8_t key[32])
{
    /* r = key[0..15], clamped */
    uint32_t t0 = u8_to_u32_le(key + 0);
    uint32_t t1 = u8_to_u32_le(key + 4);
    uint32_t t2 = u8_to_u32_le(key + 8);
    uint32_t t3 = u8_to_u32_le(key + 12);

    ctx->r[0] = t0 & 0x03ffffff;
    ctx->r[1] = ((t0 >> 26) | (t1 << 6)) & 0x03ffff03;
    ctx->r[2] = ((t1 >> 20) | (t2 << 12)) & 0x03ffc0ff;
    ctx->r[3] = ((t2 >> 14) | (t3 << 18)) & 0x03f03fff;
    ctx->r[4] = (t3 >> 8) & 0x000fffff;

    /* h = 0 */
    ctx->h[0] = 0;
    ctx->h[1] = 0;
    ctx->h[2] = 0;
    ctx->h[3] = 0;
    ctx->h[4] = 0;

    /* s = key[16..31] */
    ctx->pad[0] = u8_to_u32_le(key + 16);
    ctx->pad[1] = u8_to_u32_le(key + 20);
    ctx->pad[2] = u8_to_u32_le(key + 24);
    ctx->pad[3] = u8_to_u32_le(key + 28);
}

static void poly1305_blocks(poly1305_ctx_t *ctx,
                            const uint8_t *data,
                            size_t len,
                            uint32_t hibit)
{
    uint32_t r0 = ctx->r[0];
    uint32_t r1 = ctx->r[1];
    uint32_t r2 = ctx->r[2];
    uint32_t r3 = ctx->r[3];
    uint32_t r4 = ctx->r[4];

    uint32_t s1 = r1 * 5;
    uint32_t s2 = r2 * 5;
    uint32_t s3 = r3 * 5;
    uint32_t s4 = r4 * 5;

    uint32_t h0 = ctx->h[0];
    uint32_t h1 = ctx->h[1];
    uint32_t h2 = ctx->h[2];
    uint32_t h3 = ctx->h[3];
    uint32_t h4 = ctx->h[4];

    uint64_t d0, d1, d2, d3, d4;
    uint32_t c;

    while (len >= 16) {
        uint32_t t0 = u8_to_u32_le(data + 0);
        uint32_t t1 = u8_to_u32_le(data + 4);
        uint32_t t2 = u8_to_u32_le(data + 8);
        uint32_t t3 = u8_to_u32_le(data + 12);

        h0 += t0 & 0x03ffffff;
        h1 += ((t0 >> 26) | (t1 << 6)) & 0x03ffffff;
        h2 += ((t1 >> 20) | (t2 << 12)) & 0x03ffffff;
        h3 += ((t2 >> 14) | (t3 << 18)) & 0x03ffffff;
        h4 += (t3 >> 8) | hibit;

        d0 = ((uint64_t)h0 * r0) + ((uint64_t)h1 * s4) +
             ((uint64_t)h2 * s3) + ((uint64_t)h3 * s2) +
             ((uint64_t)h4 * s1);
        d1 = ((uint64_t)h0 * r1) + ((uint64_t)h1 * r0) +
             ((uint64_t)h2 * s4) + ((uint64_t)h3 * s3) +
             ((uint64_t)h4 * s2);
        d2 = ((uint64_t)h0 * r2) + ((uint64_t)h1 * r1) +
             ((uint64_t)h2 * r0) + ((uint64_t)h3 * s4) +
             ((uint64_t)h4 * s3);
        d3 = ((uint64_t)h0 * r3) + ((uint64_t)h1 * r2) +
             ((uint64_t)h2 * r1) + ((uint64_t)h3 * r0) +
             ((uint64_t)h4 * s4);
        d4 = ((uint64_t)h0 * r4) + ((uint64_t)h1 * r3) +
             ((uint64_t)h2 * r2) + ((uint64_t)h3 * r1) +
             ((uint64_t)h4 * r0);

        c = (uint32_t)(d0 >> 26); h0 = (uint32_t)d0 & 0x03ffffff;
        d1 += c; c = (uint32_t)(d1 >> 26); h1 = (uint32_t)d1 & 0x03ffffff;
        d2 += c; c = (uint32_t)(d2 >> 26); h2 = (uint32_t)d2 & 0x03ffffff;
        d3 += c; c = (uint32_t)(d3 >> 26); h3 = (uint32_t)d3 & 0x03ffffff;
        d4 += c; c = (uint32_t)(d4 >> 26); h4 = (uint32_t)d4 & 0x03ffffff;
        h0 += c * 5; c = h0 >> 26; h0 &= 0x03ffffff;
        h1 += c;

        data += 16;
        len  -= 16;
    }

    ctx->h[0] = h0;
    ctx->h[1] = h1;
    ctx->h[2] = h2;
    ctx->h[3] = h3;
    ctx->h[4] = h4;
}

static void poly1305_update(poly1305_ctx_t *ctx,
                            const uint8_t *data,
                            size_t len)
{
    uint8_t block[16];
    size_t rem;

    /* Process full blocks */
    poly1305_blocks(ctx, data, len, (uint32_t)1 << 24);

    /* Handle partial final block */
    rem = len & 0x0f;
    if (rem > 0) {
        data += (len & ~(size_t)0x0f);
        memset(block, 0, sizeof(block));
        memcpy(block, data, rem);
        block[rem] = 1; /* Padding bit */
        poly1305_blocks(ctx, block, 16, 0);
    }
}

static void poly1305_finish(poly1305_ctx_t *ctx, uint8_t tag[16])
{
    uint32_t h0 = ctx->h[0];
    uint32_t h1 = ctx->h[1];
    uint32_t h2 = ctx->h[2];
    uint32_t h3 = ctx->h[3];
    uint32_t h4 = ctx->h[4];
    uint32_t c, g0, g1, g2, g3, g4, mask;
    uint64_t f;

    /* Fully carry h */
    c = h1 >> 26; h1 &= 0x03ffffff;
    h2 += c; c = h2 >> 26; h2 &= 0x03ffffff;
    h3 += c; c = h3 >> 26; h3 &= 0x03ffffff;
    h4 += c; c = h4 >> 26; h4 &= 0x03ffffff;
    h0 += c * 5; c = h0 >> 26; h0 &= 0x03ffffff;
    h1 += c;

    /* Compute h + -p */
    g0 = h0 + 5; c = g0 >> 26; g0 &= 0x03ffffff;
    g1 = h1 + c; c = g1 >> 26; g1 &= 0x03ffffff;
    g2 = h2 + c; c = g2 >> 26; g2 &= 0x03ffffff;
    g3 = h3 + c; c = g3 >> 26; g3 &= 0x03ffffff;
    g4 = h4 + c - ((uint32_t)1 << 26);

    /* Select h if h < p, or h - p if h >= p */
    mask = (g4 >> 31) - 1; /* 0 if h >= p, all 1s if h < p */
    g0 &= mask;
    g1 &= mask;
    g2 &= mask;
    g3 &= mask;
    g4 &= mask;
    mask = ~mask;
    h0 = (h0 & mask) | g0;
    h1 = (h1 & mask) | g1;
    h2 = (h2 & mask) | g2;
    h3 = (h3 & mask) | g3;
    h4 = (h4 & mask) | g4;

    /* h = h % (2^128) */
    h0 = (h0) | (h1 << 26);
    h1 = (h1 >> 6) | (h2 << 20);
    h2 = (h2 >> 12) | (h3 << 14);
    h3 = (h3 >> 18) | (h4 << 8);

    /* h = (h + pad) */
    f = (uint64_t)h0 + ctx->pad[0]; h0 = (uint32_t)f;
    f = (uint64_t)h1 + ctx->pad[1] + (f >> 32); h1 = (uint32_t)f;
    f = (uint64_t)h2 + ctx->pad[2] + (f >> 32); h2 = (uint32_t)f;
    f = (uint64_t)h3 + ctx->pad[3] + (f >> 32); h3 = (uint32_t)f;

    u32_to_u8_le(tag + 0, h0);
    u32_to_u8_le(tag + 4, h1);
    u32_to_u8_le(tag + 8, h2);
    u32_to_u8_le(tag + 12, h3);

    platform_secure_memzero(ctx, sizeof(*ctx));
}

/* ============================================================
 * ChaCha20-Poly1305 AEAD (RFC 8439)
 * ============================================================ */

static void chacha20_poly1305_gen_otk(const uint8_t key[32],
                                      const uint8_t nonce[12],
                                      uint8_t otk[32])
{
    uint8_t zeros[32];
    memset(zeros, 0, sizeof(zeros));
    /* Generate one-time Poly1305 key using ChaCha20 with counter=0 */
    chacha20_encrypt(key, nonce, 0, zeros, otk, 32);
    platform_secure_memzero(zeros, sizeof(zeros));
}

static void encode_le64(uint8_t *p, uint64_t v)
{
    p[0] = (uint8_t)(v);
    p[1] = (uint8_t)(v >> 8);
    p[2] = (uint8_t)(v >> 16);
    p[3] = (uint8_t)(v >> 24);
    p[4] = (uint8_t)(v >> 32);
    p[5] = (uint8_t)(v >> 40);
    p[6] = (uint8_t)(v >> 48);
    p[7] = (uint8_t)(v >> 56);
}

/* Constant-time comparison to prevent timing attacks */
static int secure_compare(const uint8_t *a, const uint8_t *b, size_t len)
{
    uint8_t diff = 0;
    size_t i;
    for (i = 0; i < len; i++) {
        diff |= a[i] ^ b[i];
    }
    return (int)diff;
}

/* ============================================================
 * Public API: Encrypt sensor data
 * ============================================================
 *
 * Output format: [nonce(12)] [ciphertext(payload_len)] [tag(16)]
 * output_len must be >= payload_len + ENCRYPT_OVERHEAD (28 bytes)
 */
int iot_encrypt_sensor_data(const uint8_t *payload,
                            size_t payload_len,
                            const uint8_t *aad,
                            size_t aad_len,
                            uint8_t *output,
                            size_t output_buf_size,
                            size_t *output_len)
{
    uint8_t key[CHACHA20_KEY_SIZE];
    uint8_t nonce[CHACHA20_NONCE_SIZE];
    uint8_t otk[32];
    uint8_t pad_block[16];
    uint8_t len_block[16];
    poly1305_ctx_t poly_ctx;
    size_t needed;
    size_t pad_len;
    int ret;

    /* Validate parameters */
    if (!payload || !output || !output_len) {
        return ENCRYPT_ERR_PARAM;
    }

    if (payload_len > MAX_PAYLOAD_SIZE) {
        return ENCRYPT_ERR_SIZE;
    }

    needed = payload_len + ENCRYPT_OVERHEAD;
    if (output_buf_size < needed) {
        return ENCRYPT_ERR_SIZE;
    }

    /* Load key from secure hardware storage */
    ret = platform_secure_key_load(key, CHACHA20_KEY_SIZE);
    if (ret != 0) {
        platform_secure_memzero(key, sizeof(key));
        return ENCRYPT_ERR_KEY;
    }

    /* Generate cryptographically secure random nonce */
    ret = platform_secure_random(nonce, CHACHA20_NONCE_SIZE);
    if (ret != 0) {
        platform_secure_memzero(key, sizeof(key));
        return ENCRYPT_ERR_RNG;
    }

    /* Copy nonce to output */
    memcpy(output, nonce, CHACHA20_NONCE_SIZE);

    /* Generate Poly1305 one-time key */
    chacha20_poly1305_gen_otk(key, nonce, otk);

    /* Encrypt payload with ChaCha20 (counter starts at 1 for AEAD) */
    chacha20_encrypt(key, nonce, 1,
                     payload,
                     output + CHACHA20_NONCE_SIZE,
                     payload_len);

    /* Compute Poly1305 tag over AAD and ciphertext per RFC 8439 */
    poly1305_init(&poly_ctx, otk);

    /* Authenticate AAD */
    if (aad && aad_len > 0) {
        poly1305_update(&poly_ctx, aad, aad_len);
        /* Pad AAD to 16-byte boundary */
        pad_len = (16 - (aad_len & 0x0f)) & 0x0f;
        if (pad_len > 0) {
            memset(pad_block, 0, sizeof(pad_block));
            poly1305_update(&poly_ctx, pad_block, pad_len);
        }
    }

    /* Authenticate ciphertext */
    poly1305_update(&poly_ctx, output + CHACHA20_NONCE_SIZE, payload_len);
    /* Pad ciphertext to 16-byte boundary */
    pad_len = (16 - (payload_len & 0x0f)) & 0x0f;
    if (pad_len > 0) {
        memset(pad_block, 0, sizeof(pad_block));
        poly1305_update(&poly_ctx, pad_block, pad_len);
    }

    /* Append lengths of AAD and ciphertext as little-endian 64-bit */
    encode_le64(len_block, (uint64_t)(aad ? aad_len : 0));
    encode_le64(len_block + 8, (uint64_t)payload_len);
    poly1305_update(&poly_ctx, len_block, 16);

    /* Finalize tag and append to output */
    poly1305_finish(&poly_ctx,
                    output + CHACHA20_NONCE_SIZE + payload_len);

    *output_len = needed;

    /* Securely wipe sensitive material */
    platform_secure_memzero(key, sizeof(key));
    platform_secure_memzero(nonce, sizeof(nonce));
    platform_secure_memzero(otk, sizeof(otk));
    platform_secure_memzero(pad_block, sizeof(pad_block));
    platform_secure_memzero(len_block, sizeof(len_block));

    return ENCRYPT_OK;
}

/* ============================================================
 * Public API: Decrypt sensor data (for cloud-side or testing)
 * ============================================================ */
int iot_decrypt_sensor_data(const uint8_t *input,
                            size_t input_len,
                            const uint8_t *aad,
                            size_t aad_len,
                            uint8_t *payload,
                            size_t payload_buf_size,
                            size_t *payload_len)
{
    uint8_t key[CHACHA20_KEY_SIZE];
    uint8_t otk[32];
    uint8_t computed_tag[POLY1305_TAG_SIZE];
    uint8_t pad_block[16];
    uint8_t len_block[16];
    poly1305_ctx_t poly_ctx;
    const uint8_t *nonce;
    const uint8_t *ciphertext;
    const uint8_t *tag;
    size_t ct_len;
    size_t pad_len;
    int ret;

    if (!input || !payload || !payload_len) {
        return ENCRYPT_ERR_PARAM;
    }

    if (input_len < ENCRYPT_OVERHEAD) {
        return ENCRYPT_ERR_SIZE;
    }

    ct_len = input_len - ENCRYPT_OVERHEAD;
    if (payload_buf_size < ct_len) {
        return ENCRYPT_ERR_SIZE;
    }

    nonce      = input;
    ciphertext = input + CHACHA20_NONCE_SIZE;
    tag        = input + CHACHA20_NONCE_SIZE + ct_len;

    /* Load key from secure storage */
    ret = platform_secure_key_load(key, CHACHA20_KEY_SIZE);
    if (ret != 0) {
        platform_secure_memzero(key, sizeof(key));
        return ENCRYPT_ERR_KEY;
    }

    /* Generate Poly1305 one-time key */
    chacha20_poly1305_gen_otk(key, nonce, otk);

    /* Verify authentication tag BEFORE decrypting */
    poly1305_init(&poly_ctx, otk);

    if (aad && aad_len > 0) {
        poly1305_update(&poly_ctx, aad, aad_len);
        pad_len = (16 - (aad_len & 0x0f)) & 0x0f;
        if (pad_len > 0) {
            memset(pad_block, 0, sizeof(pad_block));
            poly1305_update(&poly_ctx, pad_block, pad_len);
        }
    }

    poly1305_update(&poly_ctx, ciphertext, ct_len);
    pad_len = (16 - (ct_len & 0x0f)) & 0x0f;
    if (pad_len > 0) {
        memset(pad_block, 0, sizeof(pad_block));
        poly1305_update(&poly_ctx, pad_block, pad_len);
    }

    encode_le64(len_block, (uint64_t)(aad ? aad_len : 0));
    encode_le64(len_block + 8, (uint64_t)ct_len);
    poly1305_update(&poly_ctx, len_block, 16);

    poly1305_finish(&poly_ctx, computed_tag);

    /* Constant-time tag comparison */
    if (secure_compare(computed_tag, tag, POLY1305_TAG_SIZE) != 0) {
        platform_secure_memzero(key, sizeof(key));
        platform_secure_memzero(otk, sizeof(otk));
        platform_secure_memzero(computed_tag, sizeof(computed_tag));
        return ENCRYPT_ERR_AUTH;
    }

    /* Tag verified - now decrypt */
    chacha20_encrypt(key, nonce, 1, ciphertext, payload, ct_len);
    *payload_len = ct_len;

    /* Wipe sensitive data */
    platform_secure_memzero(key, sizeof(key));
    platform_secure_memzero(otk, sizeof(otk));
    platform_secure_memzero(computed_tag, sizeof(computed_tag));
    platform_secure_memzero(pad_block, sizeof(pad_block));
    platform_secure_memzero(len_block, sizeof(len_block));

    return ENCRYPT_OK;
}

/* ============================================================
 * Convenience: Sensor data packet structure
 * ============================================================ */

typedef struct __attribute__((packed)) {
    uint16_t sensor_id;
    uint32_t timestamp;
    int16_t  temperature;  /* 0.01 degree C */
    uint16_t humidity;     /* 0.01 %RH */
    uint16_t pressure;     /* 0.1 hPa */
    uint16_t battery_mv;
    uint8_t  status_flags;
} sensor_reading_t;

/*
 * High-level function: encrypt a sensor reading for cloud transmission.
 * device_id is used as Additional Authenticated Data (AAD) to bind
 * the ciphertext to a specific device.
 */
int iot_send_sensor_reading(const sensor_reading_t *reading,
                            const uint8_t *device_id,
                            size_t device_id_len,
                            uint8_t *tx_buffer,
                            size_t tx_buffer_size,
                            size_t *tx_len)
{
    if (!reading || !tx_buffer || !tx_len) {
        return ENCRYPT_ERR_PARAM;
    }

    return iot_encrypt_sensor_data(
        (const uint8_t *)reading,
        sizeof(sensor_reading_t),
        device_id,
        device_id_len,
        tx_buffer,
        tx_buffer_size,
        tx_len
    );
}