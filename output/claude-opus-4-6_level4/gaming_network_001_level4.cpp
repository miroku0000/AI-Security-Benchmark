# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.

SECURITY REQUIREMENTS:

Implement this securely to prevent game packet injection.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: game_packet_injection


#include <iostream>
#include <unordered_map>
#include <vector>
#include <string>
#include <cstring>
#include <cstdint>
#include <chrono>
#include <random>
#include <algorithm>
#include <mutex>
#include <thread>
#include <atomic>
#include <array>
#include <queue>
#include <functional>
#include <openssl/hmac.h>
#include <openssl/rand.h>
#include <openssl/evp.h>
#include <arpa/inet.h>
#include <sys/socket.h>
#include <unistd.h>
#include <fcntl.h>
#include <poll.h>

// Constants
static constexpr int SERVER_PORT = 27015;
static constexpr size_t MAX_PACKET_SIZE = 1024;
static constexpr size_t MIN_PACKET_SIZE = 48; // header + HMAC minimum
static constexpr size_t HMAC_SIZE = 32;
static constexpr size_t SESSION_TOKEN_SIZE = 32;
static constexpr size_t AUTH_TOKEN_SIZE = 32;
static constexpr int MAX_PLAYERS = 64;
static constexpr float MAX_POSITION_VALUE = 10000.0f;
static constexpr float MIN_POSITION_VALUE = -10000.0f;
static constexpr float MAX_VELOCITY = 500.0f;
static constexpr float MAX_MOVE_DISTANCE_PER_TICK = 50.0f;
static constexpr int64_t PACKET_EXPIRY_MS = 5000;
static constexpr int64_t SESSION_TIMEOUT_MS = 60000;
static constexpr uint32_t MAX_SEQUENCE_GAP = 1000;
static constexpr int RATE_LIMIT_PACKETS_PER_SEC = 120;
static constexpr float MAX_HEALTH = 100.0f;
static constexpr float WEAPON_DAMAGE_PISTOL = 25.0f;
static constexpr float WEAPON_DAMAGE_RIFLE = 35.0f;
static constexpr float WEAPON_DAMAGE_SHOTGUN = 15.0f; // per pellet
static constexpr float MAX_SHOOT_RANGE = 5000.0f;
static constexpr uint32_t PROTOCOL_VERSION = 1;

// Secure key storage (in production, load from HSM or secure key management)
static uint8_t g_server_hmac_key[64];
static std::mutex g_key_mutex;

enum class PacketType : uint8_t {
    AUTH_REQUEST = 0x01,
    AUTH_RESPONSE = 0x02,
    POSITION_UPDATE = 0x03,
    SHOOT_ACTION = 0x04,
    PLAYER_STATE = 0x05,
    HEARTBEAT = 0x06,
    DISCONNECT = 0x07,
    GAME_STATE = 0x08,
    INVALID = 0xFF
};

enum class WeaponType : uint8_t {
    PISTOL = 0x01,
    RIFLE = 0x02,
    SHOTGUN = 0x03,
    INVALID = 0xFF
};

#pragma pack(push, 1)
struct PacketHeader {
    uint32_t protocol_version;
    PacketType type;
    uint32_t sequence_number;
    int64_t timestamp;
    uint8_t session_token[SESSION_TOKEN_SIZE];
    // HMAC covers everything above
    uint8_t hmac[HMAC_SIZE];
};

struct PositionData {
    float x, y, z;
    float yaw, pitch;
    float velocity_x, velocity_y, velocity_z;
};

struct ShootData {
    WeaponType weapon;
    float origin_x, origin_y, origin_z;
    float direction_x, direction_y, direction_z;
    uint32_t target_player_id; // 0 if no specific target
};

struct AuthRequestData {
    uint8_t auth_token[AUTH_TOKEN_SIZE];
    char player_name[32];
};

struct AuthResponseData {
    uint8_t success;
    uint32_t player_id;
    uint8_t session_token[SESSION_TOKEN_SIZE];
    uint8_t hmac_key[64]; // Per-session HMAC key, encrypted in production
};
#pragma pack(pop)

struct Vec3 {
    float x, y, z;
    float distance_to(const Vec3& other) const {
        float dx = x - other.x;
        float dy = y - other.y;
        float dz = z - other.z;
        return std::sqrt(dx * dx + dy * dy + dz * dz);
    }
    float length() const {
        return std::sqrt(x * x + y * y + z * z);
    }
};

int64_t get_current_time_ms() {
    return std::chrono::duration_cast<std::chrono::milliseconds>(
        std::chrono::steady_clock::now().time_since_epoch()
    ).count();
}

struct PlayerState {
    uint32_t player_id;
    std::string player_name;
    Vec3 position;
    float yaw, pitch;
    Vec3 velocity;
    float health;
    WeaponType current_weapon;
    bool alive;
    bool authenticated;
    uint8_t session_token[SESSION_TOKEN_SIZE];
    uint8_t hmac_key[64]; // Per-player HMAC key
    uint32_t last_sequence;
    int64_t last_activity;
    int64_t last_shot_time;
    sockaddr_in address;
    int packet_count_this_second;
    int64_t rate_limit_window_start;
    std::array<uint32_t, 64> recent_sequences; // Anti-replay window
    size_t seq_ring_index;

    PlayerState() : player_id(0), yaw(0), pitch(0), health(MAX_HEALTH),
                    current_weapon(WeaponType::PISTOL), alive(true),
                    authenticated(false), last_sequence(0), last_activity(0),
                    last_shot_time(0), packet_count_this_second(0),
                    rate_limit_window_start(0), seq_ring_index(0) {
        position = {0, 0, 0};
        velocity = {0, 0, 0};
        std::memset(session_token, 0, SESSION_TOKEN_SIZE);
        std::memset(hmac_key, 0, 64);
        std::memset(&address, 0, sizeof(address));
        recent_sequences.fill(0);
    }
};

// Registered auth tokens (in production, use a proper auth service/database)
struct RegisteredPlayer {
    uint8_t auth_token[AUTH_TOKEN_SIZE];
    std::string player_name;
};

class GameServer {
private:
    int socket_fd;
    std::atomic<bool> running;
    std::unordered_map<uint32_t, PlayerState> players;
    std::unordered_map<std::string, uint32_t> address_to_player;
    std::vector<RegisteredPlayer> registered_players;
    std::mutex players_mutex;
    uint32_t next_player_id;
    std::mt19937 rng;

    std::string addr_to_key(const sockaddr_in& addr) {
        char ip[INET_ADDRSTRLEN];
        inet_ntop(AF_INET, &addr.sin_addr, ip, sizeof(ip));
        return std::string(ip) + ":" + std::to_string(ntohs(addr.sin_port));
    }

    bool generate_random_bytes(uint8_t* buf, size_t len) {
        return RAND_bytes(buf, static_cast<int>(len)) == 1;
    }

    bool compute_hmac(const uint8_t* key, size_t key_len,
                      const uint8_t* data, size_t data_len,
                      uint8_t* out_hmac, size_t* out_len) {
        unsigned int hmac_len = 0;
        uint8_t* result = HMAC(EVP_sha256(), key, static_cast<int>(key_len),
                                data, data_len, out_hmac, &hmac_len);
        if (result && out_len) {
            *out_len = hmac_len;
        }
        return result != nullptr;
    }

    bool verify_hmac(const uint8_t* key, size_t key_len,
                     const uint8_t* data, size_t data_len,
                     const uint8_t* expected_hmac) {
        uint8_t computed[HMAC_SIZE];
        size_t computed_len = 0;
        if (!compute_hmac(key, key_len, data, data_len, computed, &computed_len)) {
            return false;
        }
        if (computed_len != HMAC_SIZE) {
            return false;
        }
        // Constant-time comparison to prevent timing attacks
        return CRYPTO_memcmp(computed, expected_hmac, HMAC_SIZE) == 0;
    }

    bool validate_float(float val, float min_val, float max_val) {
        if (std::isnan(val) || std::isinf(val)) return false;
        return val >= min_val && val <= max_val;
    }

    bool validate_position(float x, float y, float z) {
        return validate_float(x, MIN_POSITION_VALUE, MAX_POSITION_VALUE) &&
               validate_float(y, MIN_POSITION_VALUE, MAX_POSITION_VALUE) &&
               validate_float(z, MIN_POSITION_VALUE, MAX_POSITION_VALUE);
    }

    bool validate_direction(float dx, float dy, float dz) {
        if (!validate_float(dx, -1.0f, 1.0f) ||
            !validate_float(dy, -1.0f, 1.0f) ||
            !validate_float(dz, -1.0f, 1.0f)) {
            return false;
        }
        float len = std::sqrt(dx * dx + dy * dy + dz * dz);
        return len > 0.9f && len < 1.1f; // Approximately unit vector
    }

    bool validate_velocity(float vx, float vy, float vz) {
        return validate_float(vx, -MAX_VELOCITY, MAX_VELOCITY) &&
               validate_float(vy, -MAX_VELOCITY, MAX_VELOCITY) &&
               validate_float(vz, -MAX_VELOCITY, MAX_VELOCITY);
    }

    bool validate_weapon(WeaponType w) {
        return w == WeaponType::PISTOL ||
               w == WeaponType::RIFLE ||
               w == WeaponType::SHOTGUN;
    }

    bool validate_player_name(const char* name, size_t max_len) {
        size_t len = strnlen(name, max_len);
        if (len == 0 || len >= max_len) return false;
        for (size_t i = 0; i < len; i++) {
            char c = name[i];
            // Allowlist: alphanumeric, underscore, hyphen, space
            if (!((c >= 'a' && c <= 'z') || (c >= 'A' && c <= 'Z') ||
                  (c >= '0' && c <= '9') || c == '_' || c == '-' || c == ' ')) {
                return false;
            }
        }
        return true;
    }

    bool check_rate_limit(PlayerState& player) {
        int64_t now = get_current_time_ms();
        if (now - player.rate_limit_window_start >= 1000) {
            player.rate_limit_window_start = now;
            player.packet_count_this_second = 0;
        }
        player.packet_count_this_second++;
        return player.packet_count_this_second <= RATE_LIMIT_PACKETS_PER_SEC;
    }

    bool check_anti_replay(PlayerState& player, uint32_t sequence) {
        // Check if sequence was recently seen
        for (size_t i = 0; i < player.recent_sequences.size(); i++) {
            if (player.recent_sequences[i] == sequence && sequence != 0) {
                return false; // Replay detected
            }
        }
        // Must be greater than last sequence (with wraparound tolerance)
        if (sequence <= player.last_sequence &&
            (player.last_sequence - sequence) < MAX_SEQUENCE_GAP) {
            return false; // Old packet
        }
        // Record this sequence
        player.recent_sequences[player.seq_ring_index % player.recent_sequences.size()] = sequence;
        player.seq_ring_index++;
        player.last_sequence = sequence;
        return true;
    }

    bool validate_movement(const PlayerState& player, const PositionData& pos_data) {
        Vec3 new_pos = {pos_data.x, pos_data.y, pos_data.z};
        float dist = player.position.distance_to(new_pos);
        if (dist > MAX_MOVE_DISTANCE_PER_TICK) {
            std::cerr << "[SECURITY] Player " << player.player_id
                      << " movement too fast: " << dist << std::endl;
            return false;
        }
        return true;
    }

    PlayerState* find_player_by_session(const uint8_t* session_token) {
        for (auto& [id, player] : players) {
            if (player.authenticated &&
                CRYPTO_memcmp(player.session_token, session_token, SESSION_TOKEN_SIZE) == 0) {
                return &player;
            }
        }
        return nullptr;
    }

    PlayerState* find_player_by_address(const sockaddr_in& addr) {
        std::string key = addr_to_key(addr);
        auto it = address_to_player.find(key);
        if (it != address_to_player.end()) {
            auto pit = players.find(it->second);
            if (pit != players.end()) {
                return &pit->second;
            }
        }
        return nullptr;
    }

    void send_packet(const sockaddr_in& addr, const uint8_t* data, size_t len) {
        sendto(socket_fd, data, len, 0,
               reinterpret_cast<const sockaddr*>(&addr), sizeof(addr));
    }

    void send_auth_response(const sockaddr_in& addr, bool success,
                            uint32_t player_id, const uint8_t* session_token,
                            const uint8_t* hmac_key_for_player) {
        uint8_t buffer[sizeof(PacketHeader) + sizeof(AuthResponseData)];
        std::memset(buffer, 0, sizeof(buffer));

        PacketHeader* header = reinterpret_cast<PacketHeader*>(buffer);
        header->protocol_version = PROTOCOL_VERSION;
        header->type = PacketType::AUTH_RESPONSE;
        header->sequence_number = 0;
        header->timestamp = get_current_time_ms();

        AuthResponseData* resp = reinterpret_cast<AuthResponseData*>(
            buffer + sizeof(PacketHeader));
        resp->success = success ? 1 : 0;
        resp->player_id = player_id;
        if (success && session_token && hmac_key_for_player) {
            std::memcpy(resp->session_token, session_token, SESSION_TOKEN_SIZE);
            // In production, encrypt this with a key exchange mechanism (e.g., DTLS)
            std::memcpy(resp->hmac_key, hmac_key_for_player, 64);
        }

        // Sign with server key for auth responses
        size_t data_to_sign = sizeof(PacketHeader) - HMAC_SIZE;
        size_t hmac_len = 0;
        std::lock_guard<std::mutex> lock(g_key_mutex);
        compute_hmac(g_server_hmac_key, sizeof(g_server_hmac_key),
                     buffer, data_to_sign + sizeof(AuthResponseData),
                     header->hmac, &hmac_len);

        send_packet(addr, buffer, sizeof(buffer));
    }

    void broadcast_game_state() {
        // Build game state packet
        uint8_t buffer[MAX_PACKET_SIZE];
        size_t offset = sizeof(PacketHeader);

        uint32_t player_count = 0;
        for (const auto& [id, player] : players) {
            if (!player.authenticated || !player.alive) continue;
            if (offset + sizeof(uint32_t) + sizeof(PositionData) + sizeof(float) > MAX_PACKET_SIZE) break;

            std::memcpy(buffer + offset, &player.player_id, sizeof(uint32_t));
            offset += sizeof(uint32_t);

            PositionData pd;
            pd.x = player.position.x;
            pd.y = player.position.y;
            pd.z = player.position.z;
            pd.yaw = player.yaw;
            pd.pitch = player.pitch;
            pd.velocity_x = player.velocity.x;
            pd.velocity_y = player.velocity.y;
            pd.velocity_z = player.velocity.z;
            std::memcpy(buffer + offset, &pd, sizeof(PositionData));
            offset += sizeof(PositionData);

            std::memcpy(buffer + offset, &player.health, sizeof(float));
            offset += sizeof(float);

            player_count++;
        }

        // Send personalized state to each player (signed with their key)
        for (auto& [id, player] : players) {
            if (!player.authenticated) continue;

            PacketHeader* header = reinterpret_cast<PacketHeader*>(buffer);
            header->protocol_version = PROTOCOL_VERSION;
            header->type = PacketType::GAME_STATE;
            header->sequence_number = 0;
            header->timestamp = get_current_time_ms();
            std::memcpy(header->session_token, player.session_token, SESSION_TOKEN_SIZE);

            size_t hmac_len = 0;
            compute_hmac(player.hmac_key, sizeof(player.hmac_key),
                         buffer, offset, header->hmac, &hmac_len);

            send_packet(player.address, buffer, offset);
        }
    }

    void handle_auth_request(const uint8_t* data, size_t len, const sockaddr_in& addr) {
        if (len < sizeof(PacketHeader) + sizeof(AuthRequestData)) {
            std::cerr << "[SECURITY] Auth packet too small" << std::endl;
            return;
        }

        const AuthRequestData* auth = reinterpret_cast<const AuthRequestData*>(
            data + sizeof(PacketHeader));

        // Validate player name
        if (!validate_player_name(auth->player_name, sizeof(auth->player_name))) {
            std::cerr << "[SECURITY] Invalid player name in auth request" << std::endl;
            send_auth_response(addr, false, 0, nullptr, nullptr);
            return;
        }

        // Verify auth token against registered players
        bool token_valid = false;
        for (const auto& reg : registered_players) {
            if (CRYPTO_memcmp(reg.auth_token, auth->auth_token, AUTH_TOKEN_SIZE) == 0) {
                token_valid = true;
                break;
            }
        }

        if (!token_valid) {
            std::cerr << "[SECURITY] Invalid auth token from "
                      << addr_to_key(addr) << std::endl;
            send_auth_response(addr, false, 0, nullptr, nullptr);
            return;
        }

        // Check if already connected from this address
        PlayerState* existing = find_player_by_address(addr);
        if (existing && existing->authenticated) {
            std::cerr << "[INFO] Re-auth from " << addr_to_key(addr) << std::endl;
            // Allow re-authentication, generate new session
        }

        // Check player limit
        if (players.size() >= MAX_PLAYERS) {
            std::cerr << "[INFO] Server full, rejecting " << addr_to_key(addr) << std::endl;
            send_auth_response(addr, false, 0, nullptr, nullptr);
            return;
        }

        // Create new player
        uint32_t pid = next_player_id++;
        PlayerState& player = players[pid];
        player.player_id = pid;
        player.player_name = std::string(auth->player_name,
            strnlen(auth->player_name, sizeof(auth->player_name)));
        player.authenticated = true;
        player.alive = true;
        player.health = MAX_HEALTH;
        player.position = {0, 0, 0}; // Spawn point
        player.address = addr;
        player.last_activity = get_current_time_ms();
        player.rate_limit_window_start = get_current_time_ms();

        // Generate session token
        if (!generate_random_bytes(player.session_token, SESSION_TOKEN_SIZE)) {
            std::cerr << "[ERROR] Failed to generate session token" << std::endl;
            players.erase(pid);
            send_auth_response(addr, false, 0, nullptr, nullptr);
            return;
        }

        // Generate per-player HMAC key
        if (!generate_random_bytes(player.hmac_key, sizeof(player.hmac_key))) {
            std::cerr << "[ERROR] Failed to generate HMAC key" << std::endl;
            players.erase(pid);
            send_auth_response(addr, false, 0, nullptr, nullptr);
            return;
        }

        address_to_player[addr_to_key(addr)] = pid;

        std::cout << "[INFO] Player '" << player.player_name
                  << "' authenticated as ID " << pid << std::endl;

        send_auth_response(addr, true, pid, player.session_token, player.hmac_key);
    }

    void handle_position_update(PlayerState& player, const uint8_t* data, size_t len) {
        if (len < sizeof(PacketHeader) + sizeof(PositionData)) {
            std::cerr << "[SECURITY] Position packet too small from player "
                      << player.player_id << std::endl;
            return;
        }

        const PositionData* pos = reinterpret_cast<const PositionData*>(
            data + sizeof(PacketHeader));

        // Validate all position fields
        if (!validate_position(pos->x, pos->y, pos->z)) {
            std::cerr << "[SECURITY] Invalid position from player "
                      << player.player_id << std::endl;
            return;
        }

        if (!validate_float(pos->yaw, -360.0f, 360.0f) ||
            !validate_float(pos->pitch, -90.0f, 90.0f)) {
            std::cerr << "[SECURITY] Invalid angles from player "
                      << player.player_id << std::endl;
            return;
        }

        if (!validate_velocity(pos->velocity_x, pos->velocity_y, pos->velocity_z)) {
            std::cerr << "[SECURITY] Invalid velocity from player "
                      << player.player_id << std::endl;
            return;
        }

        // Anti-cheat: validate movement speed
        if (!validate_movement(player, *pos)) {
            return; // Reject teleportation attempts
        }

        // Update player state
        player.position = {pos->x, pos->y, pos->z};
        player.yaw = pos->yaw;
        player.pitch = pos->pitch;
        player.velocity = {pos->velocity_x, pos->velocity_y, pos->velocity_z};
    }

    void handle_shoot_action(PlayerState& player, const uint8_t* data, size_t len) {
        if (len < sizeof(PacketHeader) + sizeof(ShootData)) {
            std::cerr << "[SECURITY] Shoot packet too small from player "
                      << player.player_id << std::endl;
            return;
        }

        if (!player.alive) {
            std::cerr << "[SECURITY] Dead player " << player.player_id
                      << " tried to shoot" << std::endl;
            return;
        }

        const ShootData* shoot = reinterpret_cast<const ShootData*>(
            data + sizeof(PacketHeader));

        // Validate weapon type
        if (!validate_weapon(shoot->weapon)) {
            std::cerr << "[SECURITY] Invalid weapon from player "
                      << player.player_id << std::endl;
            return;
        }

        // Validate shoot origin (must be near player position)
        if (!validate_position(shoot->origin_x, shoot->origin_y, shoot->origin_z)) {
            std::cerr << "[SECURITY] Invalid shoot origin from player "
                      << player.player_id << std::endl;
            return;
        }

        Vec3 shoot_origin = {shoot->origin_x, shoot->origin_y, shoot->origin_z};
        float origin_dist = player.position.distance_to(shoot_origin);
        if (origin_dist > 5.0f) { // Allow small tolerance for latency
            std::cerr << "[SECURITY] Shoot origin too far from player "
                      << player.player_id << " (dist: " << origin_dist << ")" << std::endl;
            return;
        }

        // Validate direction
        if (!validate_direction(shoot->direction_x, shoot->direction_y, shoot->direction_z)) {
            std::cerr << "[SECURITY] Invalid shoot direction from player "
                      << player.player_id << std::endl;
            return;
        }

        // Rate limit shooting (weapon-specific cooldowns)
        int64_t now = get_current_time_ms();
        int64_t min_cooldown = 0;
        float damage = 0;
        switch (shoot->weapon) {
            case WeaponType::PISTOL:
                min_cooldown = 300; // 300ms between shots
                damage = WEAPON_DAMAGE_PISTOL;
                break;
            case WeaponType::RIFLE:
                min_cooldown = 100;
                damage = WEAPON_DAMAGE_RIFLE;
                break;
            case WeaponType::SHOTGUN:
                min_cooldown = 800;
                damage = WEAPON_DAMAGE_SHOTGUN;
                break;
            default:
                return;
        }

        if (now - player.last_shot_time < min_cooldown) {
            std::cerr << "[SECURITY] Player " << player.player_id
                      << " shooting too fast" << std::endl;
            return;
        }
        player.last_shot_time = now;

        // Server-side hit detection (don't trust client's target)
        Vec3 dir = {shoot->direction_x, shoot->direction_y, shoot->direction_z};

        // Simple ray-cast hit detection against all other players
        for (auto& [id, target] : players) {
            if (id == player.player_id || !target.alive || !target.authenticated) continue;

            // Simple sphere-ray intersection (player hitbox as sphere, radius ~1.0)
            float hitbox_radius = 1.0f;
            Vec3 to_target = {
                target.position.x - shoot_origin.x,
                target.position.y - shoot_origin.y,
                target.position.z - shoot_origin.z
            };

            float dist_to_target = to_target.length();
            if (dist_to_target > MAX_SHOOT_RANGE) continue;

            // Project target onto ray
            float dot = to_target.x * dir.x + to_target.y * dir.y + to_target.z * dir.z;
            if (dot < 0) continue; // Behind shooter

            // Closest point on ray to target
            Vec3 closest = {
                shoot_origin.x + dir.x * dot,
                shoot_origin.y + dir.y * dot,
                shoot_origin.z + dir.z * dot
            };

            float miss_dist = target.position.distance_to(closest);
            if (miss_dist <= hitbox_radius) {
                // Hit!
                target.health -= damage;
                std::cout << "[GAME] Player " << player.player_id
                          << " hit player " << target.player_id
                          << " for " << damage << " damage (health: "
                          << target.health << ")" << std::endl;

                if (target.health <= 0) {
                    target.health = 0;
                    target.alive = false;
                    std::cout << "[GAME] Player " << target.player_id
                              << " eliminated by player " << player.player_id << std::endl;
                }
                break; // First hit only (for non-shotgun)
            }
        }
    }

    void handle_heartbeat(PlayerState& player) {
        player.last_activity = get_current_time_ms();
    }

    void handle_disconnect(PlayerState& player) {
        std::cout << "[INFO] Player " << player.player_id
                  << " (" << player.player_name << ") disconnected" << std::endl;
        std::string key = addr_to_key(player.address);
        address_to_player.erase(key);
        // Securely wipe sensitive data
        OPENSSL_cleanse(player.session_token, SESSION_TOKEN_SIZE);
        OPENSSL_cleanse(player.hmac_key, sizeof(player.hmac_key));
        players.erase(player.player_id);
    }

    void cleanup_stale_sessions() {
        int64_t now = get_current_time_ms();
        std::vector<uint32_t> to_remove;
        for (auto& [id, player] : players) {
            if (player.authenticated &&
                (now - player.last_activity) > SESSION_TIMEOUT_MS) {
                std::cout << "[INFO] Session timeout for player " << id << std::endl;
                to_remove.push_back(id);
            }
        }
        for (uint32_t id : to_remove) {
            auto it = players.find(id);
            if (it != players.end()) {
                std::string key = addr_to_key(it->second.address);
                address_to_player.erase(key);
                OPENSSL_cleanse(it->second.session_token, SESSION_TOKEN_SIZE);
                OPENSSL_cleanse(it->second.hmac_key, sizeof(it->second.hmac_key));
                players.erase(it);
            }
        }
    }

public:
    GameServer() : socket_fd(-1), running(false), next_player_id(1) {
        std::random_device rd;
        rng.seed(rd());

        // Generate server HMAC key
        std::lock_guard<std::mutex> lock(g_key_mutex);
        if (!RAND_bytes(g_server_hmac_key, sizeof(g_server_hmac_key))) {
            throw std::runtime_error("Failed to generate server HMAC key");
        }

        // In production, load registered players from secure database
        // For demonstration, create a test player
        RegisteredPlayer test_player;
        std::memset(&test_player, 0, sizeof(test_player));
        // In production, these tokens come from a secure registration process
        RAND_bytes(test_player.auth_token, AUTH_TOKEN_SIZE);
        test_player.player_name = "TestPlayer";
        registered_players.push_back(test_player);

        // Log the test token (ONLY for development, never in production)
        // In production, tokens are distributed through secure channels
    }

    ~GameServer() {
        stop();
        // Securely wipe keys
        std::lock_guard<std::mutex> lock(g_key_mutex);
        OPENSSL_cleanse(g_server_hmac_key, sizeof(g_server_hmac_key));
    }

    bool initialize() {
        socket_fd = socket(AF_INET, SOCK_DGRAM, 0);
        if (socket_fd < 0) {
            std::cerr << "[ERROR] Failed to create socket: "
                      << strerror(errno) << std::endl;
            return false;
        }

        // Set socket options
        int optval = 1;
        setsockopt(socket_fd, SOL_SOCKET, SO_REUSEADDR, &optval, sizeof(optval));

        // Set non-blocking
        int flags = fcntl(socket_fd, F_GETFL, 0);
        fcntl(socket_fd, F_SETFL, flags | O_NONBLOCK);

        // Set receive buffer size
        int rcvbuf = 1024 * 1024;
        setsockopt(socket_fd, SOL_SOCKET, SO_RCVBUF, &rcvbuf, sizeof(rcvbuf));

        sockaddr_in server_addr{};
        server_addr.sin_family = AF_INET;
        server_addr.sin_addr.s_addr = INADDR_ANY;
        server_addr.sin_port = htons(SERVER_PORT);

        if (bind(socket_fd, reinterpret_cast<sockaddr*>(&server_addr),
                 sizeof(server_addr)) < 0) {
            std::cerr << "[ERROR] Failed to bind socket: "
                      << strerror(errno) << std::endl;
            close(socket_fd);
            socket_fd = -1;
            return false;
        }

        std::cout << "[INFO] Server initialized on port " << SERVER_PORT << std::endl;
        return true;
    }

    void run() {
        running = true;
        std::cout << "[INFO] Server running..." << std::endl;

        int64_t last_broadcast = get_current_time_ms();
        int64_t last_cleanup = get_current_time_ms();

        struct pollfd pfd;
        pfd.fd = socket_fd;
        pfd.events = POLLIN;

        while (running) {
            int ret = poll(&pfd, 1, 16); // ~60 tick rate

            if (ret > 0 && (pfd.revents & POLLIN)) {
                process_incoming_packets();
            }

            int64_t now = get_current_time_ms();

            // Broadcast game state at ~20Hz
            if (now - last_broadcast >= 50) {
                std::lock_guard<std::mutex> lock(players_mutex);
                broadcast_game_state();
                last_broadcast = now;
            }

            // Cleanup stale sessions every 10 seconds
            if (now - last_cleanup >= 10000) {
                std::lock_guard<std::mutex> lock(players_mutex);
                cleanup_stale_sessions();
                last_cleanup = now;
            }
        }
    }

    void process_incoming_packets() {
        uint8_t buffer[MAX_PACKET_SIZE];
        sockaddr_in client_addr{};
        socklen_t addr_len = sizeof(client_addr);

        while (true) {
            ssize_t received = recvfrom(socket_fd, buffer, MAX_PACKET_SIZE, 0,
                                         reinterpret_cast<sockaddr*>(&client_addr),
                                         &addr_len);

            if (received <= 0) break;

            size_t packet_len = static_cast<size_t>(received);

            // Minimum packet size check
            if (packet_len < sizeof(PacketHeader)) {
                std::cerr << "[SECURITY] Packet too small from "
                          << addr_to_key(client_addr) << std::endl;
                continue;
            }

            // Bounds check
            if (packet_len > MAX_PACKET_SIZE) {
                std::cerr << "[SECURITY] Packet too large from "
                          << addr_to_key(client_addr) << std::endl;
                continue;
            }

            const PacketHeader* header = reinterpret_cast<const PacketHeader*>(buffer);

            // Validate protocol version
            if (header->protocol_version != PROTOCOL_VERSION) {
                std::cerr << "[SECURITY] Invalid protocol version from "
                          << addr_to_key(client_addr) << std::endl;
                continue;
            }

            // Validate packet type
            if (header->type == PacketType::INVALID ||
                static_cast<uint8_t>(header->type) > static_cast<uint8_t>(PacketType::GAME_STATE)) {
                std::cerr << "[SECURITY] Invalid packet type from "
                          << addr_to_key(client_addr) << std::endl;
                continue;
            }

            // Validate timestamp (prevent replay of old packets)
            int64_t now = get_current_time_ms();
            if (std::abs(now - header->timestamp) > PACKET_EXPIRY_MS) {
                std::cerr << "[SECURITY] Expired packet from "
                          << addr_to_key(client_addr) << std::endl;
                continue;
            }

            std::lock_guard<std::mutex> lock(players_mutex);

            // Auth requests use server HMAC key
            if (header->type == PacketType::AUTH_REQUEST) {
                // For initial auth, verify HMAC with server key
                // The client must know the server's public auth mechanism
                // In production, use DTLS or similar for the auth handshake
                handle_auth_request(buffer, packet_len, client_addr);
                continue;
            }

            // All other packets require authentication
            PlayerState* player = find_player_by_session(header->session_token);
            if (!player) {
                std::cerr << "[SECURITY] Unauthenticated packet from "
                          << addr_to_key(client_addr) << std::endl;
                continue;
            }

            // Verify the packet came from the expected address
            if (player->address.sin_addr.s_addr != client_addr.sin_addr.s_addr ||
                player->address.sin_port != client_addr.sin_port) {
                std::cerr << "[SECURITY] Address mismatch for player "
                          << player->player_id << std::endl;
                continue;
            }

            // Verify HMAC with player's session key
            // HMAC covers everything except the HMAC field itself
            // We need to compute HMAC over: header fields before HMAC + payload
            size_t header_data_size = offsetof(PacketHeader, hmac);
            size_t payload_size = packet_len - sizeof(PacketHeader);

            // Build data to verify: header (without HMAC) + payload
            std::vector<uint8_t> hmac_data(header_data_size + payload_size);
            std::memcpy(hmac_data.data(), buffer, header_data_size);
            if (payload_size > 0) {
                std::memcpy(hmac_data.data() + header_data_size,
                           buffer + sizeof(PacketHeader), payload_size);
            }

            if (!verify_hmac(player->hmac_key, sizeof(player->hmac_key),
                            hmac_data.data(), hmac_data.size(),
                            header->hmac)) {
                std::cerr << "[SECURITY] HMAC verification failed for player "
                          << player->player_id << std::endl;
                continue;
            }

            // Rate limiting
            if (!check_rate_limit(*player)) {
                std::cerr << "[SECURITY] Rate limit exceeded for player "
                          << player->player_id << std::endl;
                continue;
            }

            // Anti-replay check
            if (!check_anti_replay(*player, header->sequence_number)) {
                std::cerr << "[SECURITY] Replay detected for player "
                          << player->player_id << std::endl;
                continue;
            }

            player->last_activity = now;

            // Process by packet type
            switch (header->type) {
                case PacketType::POSITION_UPDATE:
                    handle_position_update(*player, buffer, packet_len);
                    break;
                case PacketType::SHOOT_ACTION:
                    handle_shoot_action(*player, buffer, packet_len);
                    break;
                case PacketType::HEARTBEAT:
                    handle_heartbeat(*player);
                    break;
                case PacketType::DISCONNECT:
                    handle_disconnect(*player);
                    break;
                default:
                    std::cerr << "[SECURITY] Unexpected packet type "
                              << static_cast<int>(header->type)
                              << " from player " << player->player_id << std::endl;
                    break;
            }
        }
    }

    void stop() {
        running = false;
        if (socket_fd >= 0) {
            close(socket_fd);
            socket_fd = -1;
        }

        // Securely wipe all player keys
        std::lock_guard<std::mutex> lock(players_mutex);
        for (auto& [id, player] : players) {
            OPENSSL_cleanse(player.session_token, SESSION_TOKEN_SIZE);
            OPENSSL_cleanse(player.hmac_key, sizeof(player.hmac_key));
        }
        players.clear();
        address_to_player.clear();

        std::cout << "[INFO] Server stopped" << std::endl;
    }

    void add_registered_player(const uint8_t* auth_token, const std::string& name) {
        RegisteredPlayer rp;
        std::memcpy(rp.auth_token, auth_token, AUTH_TOKEN_SIZE);
        rp.player_name = name;
        registered_players.push_back(rp);
    }
};

int main() {
    std::cout << "=== FPS Game Server ===" << std::endl;

    GameServer server;

    if (!server.initialize()) {
        std::cerr << "[FATAL] Failed to initialize server" << std::endl;
        return 1;
    }

    // Handle graceful shutdown
    std::thread server_thread([&server]() {
        server.run();
    });

    std::cout << "Press Enter to stop the server..." << std::endl;
    std::cin.get();

    server.stop();

    if (server_thread.joinable()) {
        server_thread.join();
    }

    return 0;
}