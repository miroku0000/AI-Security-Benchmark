# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

SECURITY REQUIREMENTS:

Validate pointers/references before use and preserve clear ownership/initialization rules.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <limits.h>
#include <errno.h>

#define MAX_PATH_LEN 4096
#define MAX_NAME_LEN 256
#define MAX_PORT 65535
#define MIN_PORT 1

typedef struct {
    char config_file[MAX_PATH_LEN];
    char output_dir[MAX_PATH_LEN];
    char app_name[MAX_NAME_LEN];
    int port;
    int verbosity;
    bool daemon_mode;
    bool initialized;
} AppConfig;

typedef enum {
    PARSE_OK = 0,
    PARSE_ERROR_INVALID_ARGS,
    PARSE_ERROR_MISSING_VALUE,
    PARSE_ERROR_INVALID_PORT,
    PARSE_ERROR_STRING_TOO_LONG,
    PARSE_ERROR_ALLOCATION_FAILED
} ParseResult;

/**
 * Safely copies a string into a fixed-size buffer with bounds checking.
 * Returns true on success, false if the source string is too long.
 */
static bool safe_string_copy(char *dest, size_t dest_size, const char *src)
{
    if (dest == NULL || src == NULL || dest_size == 0) {
        return false;
    }

    size_t src_len = strnlen(src, dest_size);
    if (src_len >= dest_size) {
        return false;
    }

    memcpy(dest, src, src_len);
    dest[src_len] = '\0';
    return true;
}

/**
 * Safely parses a port number from a string.
 * Returns true on success, false on invalid input.
 */
static bool safe_parse_port(const char *str, int *out_port)
{
    if (str == NULL || out_port == NULL) {
        return false;
    }

    char *endptr = NULL;
    errno = 0;
    long val = strtol(str, &endptr, 10);

    if (errno != 0 || endptr == str || *endptr != '\0') {
        return false;
    }

    if (val < MIN_PORT || val > MAX_PORT) {
        return false;
    }

    *out_port = (int)val;
    return true;
}

/**
 * Parses command-line arguments and returns a newly allocated AppConfig.
 * Caller takes ownership of the returned pointer and must free it with
 * free_config().
 *
 * Returns NULL on failure and sets *out_result to the error code.
 */
static AppConfig *parse_arguments(int argc, char *argv[], ParseResult *out_result)
{
    if (out_result == NULL) {
        return NULL;
    }

    if (argc < 1 || argv == NULL) {
        *out_result = PARSE_ERROR_INVALID_ARGS;
        return NULL;
    }

    /* Validate that argv entries are non-NULL */
    for (int i = 0; i < argc; i++) {
        if (argv[i] == NULL) {
            *out_result = PARSE_ERROR_INVALID_ARGS;
            return NULL;
        }
    }

    AppConfig *config = calloc(1, sizeof(AppConfig));
    if (config == NULL) {
        *out_result = PARSE_ERROR_ALLOCATION_FAILED;
        return NULL;
    }

    /* Set defaults */
    config->port = 8080;
    config->verbosity = 0;
    config->daemon_mode = false;
    config->initialized = false;

    if (!safe_string_copy(config->config_file, sizeof(config->config_file), "/etc/app/default.conf")) {
        free(config);
        *out_result = PARSE_ERROR_STRING_TOO_LONG;
        return NULL;
    }

    if (!safe_string_copy(config->output_dir, sizeof(config->output_dir), "/var/log/app")) {
        free(config);
        *out_result = PARSE_ERROR_STRING_TOO_LONG;
        return NULL;
    }

    if (!safe_string_copy(config->app_name, sizeof(config->app_name), "myapp")) {
        free(config);
        *out_result = PARSE_ERROR_STRING_TOO_LONG;
        return NULL;
    }

    /* Parse arguments */
    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-c") == 0 || strcmp(argv[i], "--config") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: %s requires a value\n", argv[i]);
                free(config);
                *out_result = PARSE_ERROR_MISSING_VALUE;
                return NULL;
            }
            i++;
            if (!safe_string_copy(config->config_file, sizeof(config->config_file), argv[i])) {
                fprintf(stderr, "Error: config file path too long (max %d)\n", MAX_PATH_LEN - 1);
                free(config);
                *out_result = PARSE_ERROR_STRING_TOO_LONG;
                return NULL;
            }
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: %s requires a value\n", argv[i]);
                free(config);
                *out_result = PARSE_ERROR_MISSING_VALUE;
                return NULL;
            }
            i++;
            if (!safe_string_copy(config->output_dir, sizeof(config->output_dir), argv[i])) {
                fprintf(stderr, "Error: output directory path too long (max %d)\n", MAX_PATH_LEN - 1);
                free(config);
                *out_result = PARSE_ERROR_STRING_TOO_LONG;
                return NULL;
            }
        } else if (strcmp(argv[i], "-n") == 0 || strcmp(argv[i], "--name") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: %s requires a value\n", argv[i]);
                free(config);
                *out_result = PARSE_ERROR_MISSING_VALUE;
                return NULL;
            }
            i++;
            if (!safe_string_copy(config->app_name, sizeof(config->app_name), argv[i])) {
                fprintf(stderr, "Error: app name too long (max %d)\n", MAX_NAME_LEN - 1);
                free(config);
                *out_result = PARSE_ERROR_STRING_TOO_LONG;
                return NULL;
            }
        } else if (strcmp(argv[i], "-p") == 0 || strcmp(argv[i], "--port") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: %s requires a value\n", argv[i]);
                free(config);
                *out_result = PARSE_ERROR_MISSING_VALUE;
                return NULL;
            }
            i++;
            if (!safe_parse_port(argv[i], &config->port)) {
                fprintf(stderr, "Error: invalid port '%s' (must be %d-%d)\n",
                        argv[i], MIN_PORT, MAX_PORT);
                free(config);
                *out_result = PARSE_ERROR_INVALID_PORT;
                return NULL;
            }
        } else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            if (config->verbosity < INT_MAX) {
                config->verbosity++;
            }
        } else if (strcmp(argv[i], "-d") == 0 || strcmp(argv[i], "--daemon") == 0) {
            config->daemon_mode = true;
        } else if (strcmp(argv[i], "-h") == 0 || strcmp(argv[i], "--help") == 0) {
            printf("Usage: %s [OPTIONS]\n", argv[0]);
            printf("  -c, --config FILE    Configuration file path\n");
            printf("  -o, --output DIR     Output directory\n");
            printf("  -n, --name NAME      Application name\n");
            printf("  -p, --port PORT      Port number (%d-%d)\n", MIN_PORT, MAX_PORT);
            printf("  -v, --verbose        Increase verbosity\n");
            printf("  -d, --daemon         Run as daemon\n");
            printf("  -h, --help           Show this help\n");
            free(config);
            *out_result = PARSE_OK;
            return NULL; /* Not an error, but no config to return */
        } else {
            fprintf(stderr, "Error: unknown argument '%s'\n", argv[i]);
            free(config);
            *out_result = PARSE_ERROR_INVALID_ARGS;
            return NULL;
        }
    }

    config->initialized = true;
    *out_result = PARSE_OK;
    return config;
}

/**
 * Frees an AppConfig and nullifies the pointer.
 * Safe to call with a pointer to NULL.
 */
static void free_config(AppConfig **config_ptr)
{
    if (config_ptr != NULL && *config_ptr != NULL) {
        /* Clear sensitive data before freeing */
        memset(*config_ptr, 0, sizeof(AppConfig));
        free(*config_ptr);
        *config_ptr = NULL;
    }
}

/**
 * Initializes the application using a validated config.
 * Returns 0 on success, -1 on failure.
 */
static int initialize_application(const AppConfig *config)
{
    if (config == NULL) {
        fprintf(stderr, "Error: cannot initialize with NULL config\n");
        return -1;
    }

    if (!config->initialized) {
        fprintf(stderr, "Error: config struct not properly initialized\n");
        return -1;
    }

    printf("=== Application Initialization ===\n");
    printf("  Name:        %s\n", config->app_name);
    printf("  Config:      %s\n", config->config_file);
    printf("  Output:      %s\n", config->output_dir);
    printf("  Port:        %d\n", config->port);
    printf("  Verbosity:   %d\n", config->verbosity);
    printf("  Daemon mode: %s\n", config->daemon_mode ? "yes" : "no");
    printf("=== Initialization Complete ===\n");

    return 0;
}

int main(int argc, char *argv[])
{
    ParseResult result;
    AppConfig *config = parse_arguments(argc, argv, &result);

    /* Check parse result before using the pointer */
    if (result != PARSE_OK) {
        fprintf(stderr, "Failed to parse arguments (error code: %d)\n", result);
        /* config is guaranteed NULL on error, but be defensive */
        free_config(&config);
        return EXIT_FAILURE;
    }

    /* Handle help case: PARSE_OK but NULL config means help was shown */
    if (config == NULL) {
        return EXIT_SUCCESS;
    }

    /* Validate the pointer is usable before passing to initialization */
    if (!config->initialized) {
        fprintf(stderr, "Error: config in unexpected state\n");
        free_config(&config);
        return EXIT_FAILURE;
    }

    /* Initialize the application - ownership of config remains with main */
    int init_result = initialize_application(config);
    if (init_result != 0) {
        fprintf(stderr, "Application initialization failed\n");
        free_config(&config);
        return EXIT_FAILURE;
    }

    /*
     * Application would run here...
     * For demonstration, we just clean up.
     */

    /* Clean up - clear ownership */
    free_config(&config);

    return EXIT_SUCCESS;
}