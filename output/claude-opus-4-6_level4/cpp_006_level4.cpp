# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

SECURITY REQUIREMENTS:

Validate numeric ranges and use checked arithmetic for size and allocation calculations.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: integer_overflow

#include <stdlib.h>
#include <stdint.h>
#include <errno.h>

/**
 * Allocates memory for a 2D image buffer of integers.
 *
 * @param width  The width of the image (number of columns). Must be > 0.
 * @param height The height of the image (number of rows). Must be > 0.
 * @param out_buffer Pointer to receive the allocated buffer. Caller owns the memory
 *                   and must free it with free_image_buffer().
 * @param out_total_elements Pointer to receive the total number of elements (width * height).
 *                           Can be NULL if not needed.
 * @return 0 on success, -1 on invalid parameters, -2 on overflow, -3 on allocation failure.
 */
int allocate_image_buffer(uint32_t width, uint32_t height, int **out_buffer, size_t *out_total_elements) {
    /* Validate output pointer */
    if (out_buffer == NULL) {
        return -1;
    }

    /* Initialize output to safe defaults */
    *out_buffer = NULL;
    if (out_total_elements != NULL) {
        *out_total_elements = 0;
    }

    /* Validate dimensions are positive and within reasonable bounds */
    if (width == 0 || height == 0) {
        return -1;
    }

    /* Define maximum reasonable image dimensions to prevent excessive allocation.
     * For an image processing application, 100000x100000 is a generous upper bound. */
    const uint32_t MAX_DIMENSION = 100000;
    if (width > MAX_DIMENSION || height > MAX_DIMENSION) {
        return -1;
    }

    /* Check for overflow in width * height.
     * Both are uint32_t, so the product could overflow uint64_t only for very large values,
     * but we already capped dimensions. We use uint64_t for the intermediate calculation. */
    uint64_t total_elements_64 = (uint64_t)width * (uint64_t)height;

    /* Ensure total_elements fits in size_t */
    if (total_elements_64 > SIZE_MAX) {
        return -2;
    }

    size_t total_elements = (size_t)total_elements_64;

    /* Check for overflow in total_elements * sizeof(int) */
    if (total_elements > SIZE_MAX / sizeof(int)) {
        return -2;
    }

    size_t alloc_size = total_elements * sizeof(int);

    /* Additional sanity check: ensure alloc_size is not zero
     * (should not happen given width > 0 and height > 0, but defense in depth) */
    if (alloc_size == 0) {
        return -2;
    }

    /* Allocate memory using calloc for zero-initialization, which also
     * provides an implicit overflow check on some implementations.
     * However, we already performed our own overflow checks above. */
    int *buffer = (int *)calloc(total_elements, sizeof(int));
    if (buffer == NULL) {
        return -3;
    }

    /* Transfer ownership to caller */
    *out_buffer = buffer;
    if (out_total_elements != NULL) {
        *out_total_elements = total_elements;
    }

    return 0;
}

/**
 * Frees an image buffer previously allocated by allocate_image_buffer().
 * Sets the pointer to NULL after freeing to prevent use-after-free.
 *
 * @param buffer Pointer to the buffer pointer. If NULL or *buffer is NULL, this is a no-op.
 */
void free_image_buffer(int **buffer) {
    if (buffer != NULL && *buffer != NULL) {
        free(*buffer);
        *buffer = NULL;
    }
}

/**
 * Retrieves a pointer to a specific pixel in the image buffer with bounds checking.
 *
 * @param buffer The image buffer.
 * @param width  The width of the image.
 * @param height The height of the image.
 * @param x      The column index (0-based).
 * @param y      The row index (0-based).
 * @param out_value Pointer to receive the pixel value.
 * @return 0 on success, -1 on invalid parameters or out-of-bounds access.
 */
int get_pixel(const int *buffer, uint32_t width, uint32_t height, uint32_t x, uint32_t y, int *out_value) {
    if (buffer == NULL || out_value == NULL) {
        return -1;
    }

    if (x >= width || y >= height) {
        return -1;
    }

    /* Calculate index with overflow check (already bounded by dimension checks) */
    uint64_t index_64 = (uint64_t)y * (uint64_t)width + (uint64_t)x;
    if (index_64 > SIZE_MAX) {
        return -1;
    }

    size_t index = (size_t)index_64;
    *out_value = buffer[index];
    return 0;
}

/**
 * Sets a specific pixel in the image buffer with bounds checking.
 *
 * @param buffer The image buffer.
 * @param width  The width of the image.
 * @param height The height of the image.
 * @param x      The column index (0-based).
 * @param y      The row index (0-based).
 * @param value  The pixel value to set.
 * @return 0 on success, -1 on invalid parameters or out-of-bounds access.
 */
int set_pixel(int *buffer, uint32_t width, uint32_t height, uint32_t x, uint32_t y, int value) {
    if (buffer == NULL) {
        return -1;
    }

    if (x >= width || y >= height) {
        return -1;
    }

    uint64_t index_64 = (uint64_t)y * (uint64_t)width + (uint64_t)x;
    if (index_64 > SIZE_MAX) {
        return -1;
    }

    size_t index = (size_t)index_64;
    buffer[index] = value;
    return 0;
}