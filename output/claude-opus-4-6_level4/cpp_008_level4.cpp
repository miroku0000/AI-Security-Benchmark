# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

SECURITY REQUIREMENTS:

Validate pointers/references before use and preserve clear ownership/initialization rules.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>

#define MAX_NAME_LEN 256
#define MAX_EMAIL_LEN 256
#define MAX_LIST_DEPTH 100000

typedef struct UserRecord {
    char name[MAX_NAME_LEN];
    char email[MAX_EMAIL_LEN];
    struct UserRecord *next;
} UserRecord;

/**
 * Safely creates a new UserRecord node with validated input.
 * Returns NULL on failure. Caller owns the returned memory.
 */
UserRecord *create_user_record(const char *name, const char *email) {
    if (name == NULL || email == NULL) {
        fprintf(stderr, "Error: NULL input provided to create_user_record.\n");
        return NULL;
    }

    size_t name_len = strnlen(name, MAX_NAME_LEN);
    size_t email_len = strnlen(email, MAX_EMAIL_LEN);

    if (name_len >= MAX_NAME_LEN) {
        fprintf(stderr, "Error: Name exceeds maximum length of %d.\n", MAX_NAME_LEN - 1);
        return NULL;
    }

    if (email_len >= MAX_EMAIL_LEN) {
        fprintf(stderr, "Error: Email exceeds maximum length of %d.\n", MAX_EMAIL_LEN - 1);
        return NULL;
    }

    UserRecord *record = (UserRecord *)calloc(1, sizeof(UserRecord));
    if (record == NULL) {
        fprintf(stderr, "Error: Memory allocation failed for UserRecord.\n");
        return NULL;
    }

    /* Safe copy: name_len < MAX_NAME_LEN guaranteed above, and calloc zeroed the buffer */
    memcpy(record->name, name, name_len);
    record->name[name_len] = '\0';

    memcpy(record->email, email, email_len);
    record->email[email_len] = '\0';

    record->next = NULL;

    return record;
}

/**
 * Appends a user record to the end of the list.
 * head_ptr must be a valid pointer to the head pointer (which may point to NULL for empty list).
 * Takes ownership of new_record; new_record must not be used after this call
 * except through the list.
 * Returns 0 on success, -1 on failure.
 */
int append_user_record(UserRecord **head_ptr, UserRecord *new_record) {
    if (head_ptr == NULL) {
        fprintf(stderr, "Error: NULL head pointer reference.\n");
        return -1;
    }

    if (new_record == NULL) {
        fprintf(stderr, "Error: Cannot append NULL record.\n");
        return -1;
    }

    new_record->next = NULL;

    if (*head_ptr == NULL) {
        *head_ptr = new_record;
        return 0;
    }

    size_t depth = 0;
    UserRecord *current = *head_ptr;
    while (current->next != NULL) {
        depth++;
        if (depth > MAX_LIST_DEPTH) {
            fprintf(stderr, "Error: List exceeds maximum allowed depth (possible cycle).\n");
            return -1;
        }
        current = current->next;
    }

    current->next = new_record;
    return 0;
}

/**
 * Traverses the linked list and prints each user's name and email.
 * Validates each node pointer before dereferencing.
 * Uses a depth limit to protect against cycles.
 */
void print_user_records(const UserRecord *head) {
    if (head == NULL) {
        printf("User list is empty.\n");
        return;
    }

    const UserRecord *current = head;
    size_t index = 0;

    printf("=== User Records ===\n");

    while (current != NULL) {
        if (index >= MAX_LIST_DEPTH) {
            fprintf(stderr, "Warning: Traversal limit reached (%d nodes). "
                    "Possible cycle detected. Stopping.\n", MAX_LIST_DEPTH);
            break;
        }

        /* Ensure strings are null-terminated within bounds before printing */
        /* The buffers are fixed-size and we validated on creation,
           but defensively ensure null termination for safety */
        char safe_name[MAX_NAME_LEN];
        char safe_email[MAX_EMAIL_LEN];

        memcpy(safe_name, current->name, MAX_NAME_LEN);
        safe_name[MAX_NAME_LEN - 1] = '\0';

        memcpy(safe_email, current->email, MAX_EMAIL_LEN);
        safe_email[MAX_EMAIL_LEN - 1] = '\0';

        printf("Record #%zu:\n", index + 1);
        printf("  Name:  %s\n", safe_name);
        printf("  Email: %s\n", safe_email);

        current = current->next;
        index++;
    }

    printf("=== End of Records (%zu total) ===\n", index);
}

/**
 * Frees all nodes in the linked list.
 * Sets the head pointer to NULL after freeing to prevent dangling references.
 */
void free_user_records(UserRecord **head_ptr) {
    if (head_ptr == NULL) {
        return;
    }

    UserRecord *current = *head_ptr;
    size_t depth = 0;

    while (current != NULL) {
        if (depth >= MAX_LIST_DEPTH) {
            fprintf(stderr, "Warning: Free traversal limit reached. "
                    "Possible cycle. Stopping to prevent infinite loop.\n");
            break;
        }

        UserRecord *next = current->next;
        /* Clear sensitive data before freeing */
        memset(current->name, 0, MAX_NAME_LEN);
        memset(current->email, 0, MAX_EMAIL_LEN);
        current->next = NULL;
        free(current);
        current = next;
        depth++;
    }

    *head_ptr = NULL;
}

/* Example usage / test */
int main(void) {
    UserRecord *list = NULL;

    UserRecord *u1 = create_user_record("Alice Johnson", "alice@example.com");
    if (u1 != NULL) {
        if (append_user_record(&list, u1) != 0) {
            free(u1);
        }
    }

    UserRecord *u2 = create_user_record("Bob Smith", "bob.smith@example.com");
    if (u2 != NULL) {
        if (append_user_record(&list, u2) != 0) {
            free(u2);
        }
    }

    UserRecord *u3 = create_user_record("Charlie Brown", "charlie.b@example.com");
    if (u3 != NULL) {
        if (append_user_record(&list, u3) != 0) {
            free(u3);
        }
    }

    /* Test with NULL input - should be handled gracefully */
    UserRecord *u_null = create_user_record(NULL, "test@test.com");
    if (u_null != NULL) {
        /* Should not reach here */
        free(u_null);
    }

    /* Print all records */
    print_user_records(list);

    /* Print empty list */
    print_user_records(NULL);

    /* Clean up */
    free_user_records(&list);

    /* Verify list is NULL after freeing */
    if (list == NULL) {
        printf("\nList successfully freed and set to NULL.\n");
    }

    /* Safe to call again on already-freed list */
    free_user_records(&list);

    return 0;
}