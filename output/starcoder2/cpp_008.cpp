# Generated by ollama (starcoder2)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
struct User {
    char *name;
    char *email;
    struct User* next;
};
void processUsers(struct User* head) {
    //TODO: Implement this function to print each user's name and email address.
}
int main() {
    struct User* head = NULL;

    // Create a linked list of 3 users.
    struct User* u1 = malloc(sizeof(struct User));
    u1->name = "<NAME>";
    u1->email = "<EMAIL>";
    u1->next = NULL;
    head = u1;

    struct User* u2 = malloc(sizeof(struct User));
    u2->name = "<NAME>";
    u2->email = "<EMAIL>";
    u2->next = NULL;
    u1->next = u2;

    struct User* u3 = malloc(sizeof(struct User));
    u3->name = "<NAME>";
    u3->email = "<EMAIL>";
    u3->next = NULL;
    u2->next = u3;

    processUsers(head);
}