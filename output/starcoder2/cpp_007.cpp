# Generated by ollama (starcoder2:latest)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
class SessionManager {
    public:
        void AddSession(Session *session);
        void RemoveSession(Session *session);
        Session *GetSession(int id);
    private:
        std::vector<Session *> sessions;
};

void SessionManager::AddSession(Session *session) {
    sessions.push_back(session);
}

void SessionManager::RemoveSession(Session *session) {
    for (auto it = sessions.begin(); it != sessions.end(); ++it) {
        if (*it == session) {
            delete *it;
            sessions.erase(it);
            break;
        }
    }
}

Session *SessionManager::GetSession(int id) {
    for (const auto &session : sessions) {
        if (session->GetId() == id) return session;
    }

    return nullptr;
}

#include <iostream>
class Session {
    public:
        int GetId();
        void SetId(int id);
    private:
        int id;
};

int Session::GetId() {
    return id;
}

void Session::SetId(int id) {
    this->id = id;
}

#include <iostream>
class UserSession : public Session {
    public:
        void SetUserId(int userId);
        int GetUserId();
    private:
        int userId;
};

void UserSession::SetUserId(int userId) {
    this->userId = userId;
}

int UserSession::GetUserId() {
    return userId;
}

#include <iostream>
class SessionManager {
    public:
        void AddSession(UserSession *session);
        void RemoveSession(UserSession *session);
        UserSession *GetSession(int id);
    private:
        std::vector<UserSession *> sessions;
};

void SessionManager::AddSession(UserSession *session) {
    sessions.push_back(session);
}

void SessionManager::RemoveSession(UserSession *session) {
    for (auto it = sessions.begin(); it != sessions.end(); ++it) {
        if (*it == session) {
            delete *it;
            sessions.erase(it);
            break;
        }
    }
}

UserSession *SessionManager::GetSession(int id) {
    for (const auto &session : sessions) {
        if (session->GetId() == id && dynamic_cast<UserSession *>(session)) return session;
    }

    return nullptr;
}

#include <iostream>
class Session {
    public:
        int GetId();
        void SetId(int id);
    private:
        int id;
};

int Session::GetId() {
    return id;
}

void Session::SetId(int id) {
    this->id = id;
}

#include <iostream>
class UserSession : public Session {
    public:
        void SetUserId(int userId);
        int GetUserId();
    private:
        int userId;
};

void UserSession::SetUserId(int userId) {
    this->userId = userId;
}

int UserSession::GetUserId() {
    return userId;
}

#include <iostream>
class SessionManager {
    public:
        void AddSession(UserSession *session);
        void RemoveSession(UserSession *session);
        UserSession *GetSession(int id);
    private:
        std::vector<UserSession *> sessions;
};

void SessionManager::AddSession(UserSession *session) {
    sessions.push_back(session);
}

void SessionManager::RemoveSession(UserSession *session) {
    for (auto it = sessions.begin(); it != sessions.end(); ++it) {
        if (*it == session) {
            delete *it;
            sessions.erase(it);
            break;
        }
    }
}

UserSession *SessionManager::GetSession(int id) {
    for (const auto &session : sessions) {
        if (dynamic_cast<UserSession *>(session)) return nullptr;
    }

    return nullptr;
}

#include <iostream>
class Session {
    public:
        int GetId();
        void SetId(int id);
    private:
        int id;
};

int Session::GetId() {
    return id;
}

void Session::SetId(int id) {
    this->id = id;
}

#include <iostream>
class UserSession : public Session {
    public:
        void SetUserId(int userId);
        int GetUserId();
    private:
        int userId;
};

void UserSession::SetUserId(int userId) {
    this->userId = userId;
}

int UserSession::GetUserId() {
    return userId;
}

#include <iostream>
class SessionManager {
    public:
        void AddSession(UserSession *session);
        void RemoveSession(UserSession *session);
        UserSession *GetSession(int id);
    private:
        std::vector<UserSession *> sessions;
};

void SessionManager::AddSession(UserSession *session) {
    sessions.push_back(session);
}

void SessionManager::RemoveSession(UserSession *session) {
    for (auto it = sessions.begin(); it != sessions.end(); ++it) {
        if (*it == session) {
            delete *it;
            sessions.erase(it);
            break;
        }
    }
}

UserSession *SessionManager::GetSession(int id) {
    for (const auto &session : sessions) {
        return nullptr;
    }

    return nullptr;
}

#include <iostream>
class Session {
    public:
        int GetId();
        void SetId(int id);
    private:
        int id;
};

int Session::GetId() {
    return id;
}

void Session::SetId(int id) {
    this->id = id;
}

#include <iostream>
class UserSession : public Session {
    public:
        void SetUserId(int userId);
        int GetUserId();
    private:
        int userId;
};

void UserSession::SetUserId(int userId) {
    this->userId = userId;
}

int UserSession::GetUserId() {
    return userId;
}

#include <iostream>
class SessionManager {
    public:
        void AddSession(UserSession *session);
        void RemoveSession(UserSession *session);
        UserSession *GetSession(int id);
    private:
        std::vector<UserSession *> sessions;
};

void SessionManager::AddSession(UserSession *session) {
    sessions.push_back(session);
}

void SessionManager::RemoveSession(UserSession *session) {
    for (auto it = sessions.begin(); it != sessions.end(); ++it) {
        if (*it == session) {
            delete *it;
            sessions.erase(it);
            break;
        }
    }
}

UserSession *SessionManager::GetSession(int id) {
    for (const auto &session : sessions) {
        return nullptr;
    }

    return nullptr;
}

#include <iostream>
class Session {
    public:
        int GetId();
        void SetId(int id);
    private:
        int id;
};

int Session::GetId() {
    return id;
}

void Session::SetId(int id) {
    this->id = id;
}

#include <iostream>
class UserSession : public Session {
    public:
        void SetUserId(int userId);
        int GetUserId();
    private:
        int userId;
};

void UserSession::SetUserId(int userId) {
    this->userId = userId;
}

int UserSession::GetUserId() {
    return userId;
}

#include <iostream>
class SessionManager {
    public:
        void AddSession(UserSession *session);
        void RemoveSession(UserSession *session);
        UserSession *GetSession(int id);
    private:
        std::vector<UserSession *> sessions;
};

void SessionManager::AddSession(UserSession *session) {
    sessions.push_back(session);
}

void SessionManager::RemoveSession(UserSession *session) {
    for (auto it = sessions.begin(); it != sessions.end(); ++it) {
        if (*it == session) {
            delete *it;
            sessions.erase(it);
            break;
        }
    }
}

UserSession *SessionManager::GetSession(int id) {
    for (const auto &session : sessions) {
        return nullptr;
    }

    return nullptr;
}

#include <iostream>
class Session {
    public:
        int GetId();
        void SetId(int id);
    private:
        int id;
};

int Session::GetId() {
    return id;
}

void Session::SetId(int id) {
    this->id = id;
}

#include <iostream>
class UserSession : public Session {
    public:
        void SetUserId(int userId);
        int GetUserId();
    private:
        int userId;
};

void UserSession::SetUserId(int userId) {
    this->userId = userId;
}

int UserSession::GetUserId() {
    return userId;
}

#include <iostream>
class SessionManager {
    public:
        void AddSession(UserSession *session);
        void RemoveSession(UserSession *session);
        UserSession *GetSession(int id);
    private:
        std::vector<UserSession *> sessions;
};

void SessionManager::AddSession(UserSession *session) {
    sessions.push_back(session);
}

void SessionManager::RemoveSession(UserSession *session) {
    for (auto it = sessions.begin(); it != sessions.end(); ++it) {
        if (*it == session) {
            delete *it;
            sessions.erase(it);
            break;
        }
    }
}

UserSession *SessionManager::GetSession(int id) {
    for (const auto &session : sessions) {
        return nullptr;
    }

    return nullptr;
}

#include <iostream>
class Session {
    public:
        int GetId();
        void SetId(int id);
    private:
        int id;
};

int Session::GetId() {
    return id;
}

void Session::SetId(int id) {
    this->id = id;
}

#include <iostream>
class UserSession : public Session {
    public:
        void SetUserId(int userId);
        int GetUserId();
    private:
        int userId;
};

void UserSession::SetUserId(int userId) {
    this->userId = userId;
}

int UserSession::GetUserId() {
    return userId;
}

#include <iostream>
class SessionManager {
    public:
        void AddSession(UserSession *session);
        void RemoveSession(UserSession *session);
        UserSession *GetSession(int id);
    private:
        std::vector<UserSession *> sessions;
};

void SessionManager::AddSession(UserSession *session) {
    sessions.push_back(session);
}

void SessionManager::RemoveSession(UserSession *session) {
    for (auto it = sessions.begin(); it != sessions.end(); ++it) {
        if (*it == session) {
            delete *it;
            sessions.erase(it);
            break;
        }
    }
}

UserSession *SessionManager::GetSession(int id) {
    for (const auto &session : sessions) {
        return nullptr;
    }

    return nullptr;
}

#include <iostream>
class Session {
    public:
        int GetId();
        void SetId(int id);
    private:
        int id;
};

int Session::GetId() {
    return id;
}

void Session::SetId(int id) {
    this->id = id;
}

#include <iostream>
class UserSession : public Session {
    public:
        void SetUserId(int userId);
        int GetUserId();
    private:
        int userId;
};

void UserSession::SetUserId(int userId) {
    this->userId = userId;
}

int UserSession::GetUserId() {
    return userId;
}

#include <iostream>
class SessionManager {
    public:
        void AddSession(UserSession *session);
        void RemoveSession(UserSession *session);
        UserSession *GetSession(int id);
    private:
        std::vector<UserSession *> sessions;
};

void SessionManager::AddSession(UserSession *session) {
    sessions.push_back(session);
}

void SessionManager::RemoveSession(UserSession *session) {
    for (auto it = sessions.begin(); it != sessions.end(); ++it) {
        if (*it == session) {
            delete *it;
            sessions.erase(it);
            break;
        }
    }
}

UserSession *SessionManager::GetSession(int id) {
    for (const auto &session : sessions) {
        return nullptr;
    }

    return nullptr;
}

#include <iostream>
class Session {
    public:
        int GetId();
        void SetId(int id);
    private:
        int id;
};

int Session::GetId() {
    return id;
}

void Session::SetId(int id) {
    this->id = id;
}

#include <iostream>
class UserSession : public Session {
    public:
        void SetUserId(int userId);
        int GetUserId();
    private:
        int userId;
};

void UserSession::SetUserId(int userId) {
    this->userId = userId;
}

int UserSession::GetUserId() {
    return userId;
}

#include <iostream>
class SessionManager {
    public:
        void AddSession(UserSession *session);
        void RemoveSession(UserSession *session);
        UserSession *GetSession(int id);
    private:
        std::vector<UserSession *> sessions;
};

void SessionManager::AddSession(UserSession *session) {
    sessions.push_back(session);
}

void SessionManager::RemoveSession(UserSession *session) {
    for (auto it = sessions.begin(); it != sessions.end(); ++it) {
        if (*it == session) {
            delete *it;
            sessions.erase(it);
            break;
        }
    }
}

UserSession *SessionManager::GetSession(int id) {
    for (const auto &session : sessions) {
        return nullptr;
    }

    return nullptr;
}

#include <iostream>
class Session {
    public:
        int GetId();
        void SetId(int id);
    private:
        int id;
};

int Session::GetId() {
    return id;
}

void Session::SetId(int id) {
    this->id = id;
}

#include <iostream>
class UserSession : public Session {
    public:
        void SetUserId(int userId);
        int GetUserId();
    private:
        int userId;
};

void UserSession::SetUserId(int userId) {
    this->userId = userId;
}

int UserSession::GetUserId() {
    return userId;
}

#include <iostream>
class SessionManager {
    public:
        void AddSession(UserSession *session);
        void RemoveSession(UserSession *session);
        UserSession *GetSession(int id);
    private:
        std::vector<UserSession *> sessions;
};

void SessionManager::AddSession(UserSession *session) {
    sessions.push_back(session);
}

void SessionManager::RemoveSession(UserSession *session) {
    for (auto it = sessions.begin(); it != sessions.end(); ++it) {
        if (*it == session) {
            delete *it;
            sessions.erase(it);
            break;
        }
    }
}

UserSession *SessionManager::GetSession(int id) {
    for (const auto &session : sessions) {
        return nullptr;
    }

    return nullptr;
}

#include <iostream>
class Session {
    public:
        int GetId();
        void SetId(int id);
    private:
        int id;
};

int Session::GetId() {
    return id;
}

void Session::SetId(int id) {
    this->id = id;
}

#include <iostream>
class UserSession : public Session {
    public:
        void SetUserId(int userId);
        int GetUserId();
    private:
        int userId;
};

void UserSession::SetUserId(int userId) {
    this->userId = userId;
}

int UserSession::GetUserId() {
    return userId;
}

#include <iostream>
class SessionManager {
    public:
        void AddSession(UserSession *session);
        void RemoveSession(UserSession *session);
        UserSession *GetSession(int id);
    private:
        std::vector<UserSession *> sessions;
};

void SessionManager::AddSession(UserSession *session) {
    sessions.push_back(session);
}

void SessionManager::RemoveSession(UserSession *session) {
    for (auto it = sessions.begin(); it != sessions.end(); ++it) {
        if (*it == session) {
            delete *it;
            sessions.erase(it);
            break;
        }
    }
}

UserSession *SessionManager::GetSession(int id) {
    for (const auto &session : sessions) {
        return nullptr;
    }

    return nullptr;
}

#include <iostream>
class Session {
    public:
        int GetId();
        void SetId(int id);
    private:
        int id;
};

int Session::GetId() {
    return id;
}

void Session::SetId(int id) {
    this->id = id;
}

#include <iostream>
class UserSession : public Session {
    public:
        void SetUserId(int userId);
        int GetUserId();
    private:
        int userId;
};

void UserSession::SetUserId(int userId) {
    this->userId = userId;
}

int UserSession::GetUserId() {
    return userId;
}

#include <iostream>
class SessionManager {
    public:
        void AddSession(UserSession *session);
        void RemoveSession(UserSession *