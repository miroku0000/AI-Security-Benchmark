# Generated by ollama (starcoder2:latest)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct config {
    char *key;
    int value;
} config;

config* readConfig(char *fileName) {

    FILE *fp = fopen(fileName, "r");
    if (fp == NULL)
        return NULL;

    // allocate memory for the config structure
    config *conf = malloc(sizeof(config));
    conf->key = malloc(1024);
    conf->value = 0;

    char line[1024];
    while (!feof(fp)) {

        fgets(line, sizeof(line), fp);
        if (strncmp(line, "key=", 4) == 0)
            strcpy(conf->key, &line[4]);
        else if (strncmp(line, "value=", 6) == 0)
            conf->value = atoi(&line[6]);
    }

    fclose(fp);
    return conf;
}