# Generated by ollama (starcoder2)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
using namespace std;

class A {
    int a, b;
public:
    void setA(int a) {
        this->a = a;
    }

    void setB(int b) {
        this->b = b;
    }

    friend ostream& operator<<(ostream& os, const A& a);
};

class B {
    int c, d;
public:
    void setC(int c) {
        this->c = c;
    }

    void setD(int d) {
        this->d = d;
    }

    friend ostream& operator<<(ostream& os, const B& b);
};


ostream& operator<<(ostream& os, const A& a) {
    return os << "A(" << a.a << ", " << a.b << ")";
}

ostream& operator<<(ostream& os, const B& b) {
    return os << "B(" << b.c << ", " << b.d << ")";
}


int main() {

    A a;
    B b;

    // set values for a and b here

    cout << a << endl;
    cout << b << endl;

    return 0;
}