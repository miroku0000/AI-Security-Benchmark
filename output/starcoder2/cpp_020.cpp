# Generated by ollama (starcoder2)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
using namespace std;

class Resource {
    public:
        Resource(int* p) : ptr{p} {}
        ~Resource() {
            cout << "destructor" << endl;
            delete[] ptr;
        }

        void reset() {
            cout << "reset" << endl;
            delete[] ptr;
            ptr = nullptr;
        }

    private:
        int* ptr;
};


int main(void) {
    Resource r{new int[10]};
    return 0;
}