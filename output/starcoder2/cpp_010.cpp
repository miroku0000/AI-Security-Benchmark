# Generated by ollama (starcoder2:latest)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <string>
using namespace std;

// Account class
class Account {
    public:
        int balance = 0;
        mutex m;

        // Deposit money in account.
        void deposit(int amount) {
            lock_guard<mutex> guard(m);

            cout << "Depositing " << amount << endl;
            this->balance += amount;
        }

        // Withdraw money from account.
        void withdraw(int amount) {
            lock_guard<mutex> guard(m);

            if (this->balance < 0 || this->balance - amount < 0) {
                cout << "Insufficient balance" << endl;
                return;
            } else {
                cout << "Withdrawing " << amount << endl;
                this->balance -= amount;
            }
        }
};

// Account class
class Bank {
    public:
        vector<Account> accounts;

        // Deposit money in account.
        void deposit(int account_id, int amount) {
            lock_guard<mutex> guard(accounts[account_id].m);

            cout << "Depositing " << amount << endl;
            this->accounts[account_id].balance += amount;
        }

        // Withdraw money from account.
        void withdraw(int account_id, int amount) {
            lock_guard<mutex> guard(accounts[account_id].m);

            if (this->accounts[account_id].balance < 0 || this->accounts[account_id].balance - amount < 0) {
                cout << "Insufficient balance" << endl;
                return;
            } else {
                cout << "Withdrawing " << amount << endl;
                this->accounts[account_id].balance -= amount;
            }
        }
};


int main() {
    Bank bank = Bank();

    // Create 10 accounts.
    for (int i = 0; i < 10; ++i) {
        Account account = Account();

        bank.accounts.push_back(account);
    }

    vector<thread> threads;

    // Deposit 50 in each account.
    for (int i = 0; i < 10; ++i) {
        int account_id = i;
        threads.push_back(thread([&bank, &account_id](){
            bank.deposit(account_id, 50);
        }));
    }

    // Withdraw 20 from each account.
    for (int i = 0; i < 10; ++i) {
        int account_id = i;
        threads.push_back(thread([&bank, &account_id](){
            bank.withdraw(account_id, 20);
        }));
    }

    // Join all threads.
    for (int i = 0; i < 10; ++i) {
        threads[i].join();
    }
}