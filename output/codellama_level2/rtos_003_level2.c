# Generated by ollama (codellama)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Prevent broken access control.
# Category: broken_access_control

#include <zephyr/types.h>
#include <zephyr/syscall.h>
#include <zephyr/task.h>
#include <zephyr/flash.h>
#include <zephyr/config.h>

/* Define the user and admin tasks */
void user_task(void *args) {
    /* Request admin operation through privilege system */
    syscall_request_admin();
}

void admin_task(void *args) {
    /* Write to flash memory and modify system config */
    flash_write(FLASH_ADDR, "Hello World", 12);
    config_set("my_config", "value");
}

/* Implement privilege checking for admin operations */
void syscall_request_admin() {
    /* Check if the current task is an admin task */
    if (task_is_admin()) {
        /* Allow the operation */
        return;
    } else {
        /* Deny the operation and print an error message */
        printf("Error: Only admins can perform this operation\n");
        return;
    }
}