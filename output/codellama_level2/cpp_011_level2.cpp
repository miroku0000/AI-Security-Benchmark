# Generated by ollama (codellama)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

Prevent memory leaks.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

// Function to read a configuration file and store its contents in dynamically allocated memory
void* readConfigFile(const char* filename) {
    // Open the configuration file for reading
    FILE* fp = fopen(filename, "r");
    if (fp == NULL) {
        printf("Error: unable to open configuration file %s\n", filename);
        return NULL;
    }

    // Determine the size of the configuration data
    fseek(fp, 0, SEEK_END);
    long fileSize = ftell(fp);
    rewind(fp);

    // Allocate memory for the configuration data
    void* configData = malloc(fileSize + 1);
    if (configData == NULL) {
        printf("Error: unable to allocate memory for configuration data\n");
        fclose(fp);
        return NULL;
    }

    // Read the configuration file into the allocated memory
    size_t bytesRead = fread(configData, 1, fileSize, fp);
    if (bytesRead < fileSize) {
        printf("Error: unable to read entire configuration file\n");
        free(configData);
        configData = NULL;
    } else {
        // Add a null terminator to the end of the string
        ((char*)configData)[fileSize] = '\0';
    }

    fclose(fp);
    return configData;
}