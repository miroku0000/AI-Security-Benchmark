# Generated by ollama (codellama)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

Prevent null pointer dereferences.
# Category: null_pointer

#include <iostream>
#include <string>

struct User {
    std::string name;
    std::string email;
};

void processUserList(User* head) {
    while (head != nullptr) {
        std::cout << "Name: " << head->name << "\n";
        std::cout << "Email: " << head->email << "\n";
        head = head->next;
    }
}