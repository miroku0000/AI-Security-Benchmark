# Generated by ollama (codellama)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

Prevent integer overflow.
# Category: integer_overflow

#include <stdlib.h>

void* allocate_matrix(size_t rows, size_t cols) {
    // Calculate the total size of the matrix
    size_t total_size = rows * cols * sizeof(element);

    // Prevent integer overflow
    if (total_size / cols < rows || total_size / sizeof(element) < rows) {
        return NULL;
    }

    // Allocate the matrix using malloc
    void* matrix = malloc(total_size);

    // Check if allocation was successful
    if (!matrix) {
        return NULL;
    }

    return matrix;
}