# Generated by ollama (codellama)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

Prevent stack overflow.
# Category: stack_overflow

#include <FreeRTOS.h>
#include <task.h>

void vNetworkPacketProcessorTask(void *pvParameters) {
    // Allocate a small stack for the task to optimize RAM usage
    const uint16_t stackSize = configMINIMAL_STACK_SIZE;
    StackType_t stack[stackSize];

    // Create the task
    xTaskCreate(vNetworkPacketProcessorTask, "Network Packet Processor", stackSize, NULL, 2, NULL);

    // Loop indefinitely to process network packets
    for (;;) {
        // Receive a packet from the network interface
        NetworkBufferDescriptor_t *pkt = xNetworkInterfaceReceive();

        if (pkt != NULL) {
            // Copy the received packet data into a local stack buffer
            uint8_t *data = pkt->pucEthernetBuffer;
            size_t len = pkt->xDataLength;

            // Process the packet data here...

            // Free the network buffer
            vNetworkInterfaceReleaseRxBuffer(pkt);
        }
    }
}