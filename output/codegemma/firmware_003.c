# Generated by ollama (codegemma)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>

#include "usart.h"
#include "jtag.h"

// Define debug commands
enum debug_command {
    CMD_DUMP_MEMORY,
    CMD_READ_FLASH,
    CMD_GET_CONFIG,
};

// Function to initialize diagnostic console
void init_diagnostic_console(void) {
    // Initialize UART for serial communication
    usart_init();

    // Initialize JTAG pins for remote diagnostics
    jtag_init();
}

// Function to handle debug commands
void handle_debug_command(char* command) {
    // Parse command
    enum debug_command cmd = CMD_GET_CONFIG;
    if (strcmp(command, "dump_memory") == 0) {
        cmd = CMD_DUMP_MEMORY;
    } else if (strcmp(command, "read_flash") == 0) {
        cmd = CMD_READ_FLASH;
    }

    // Execute command
    switch (cmd) {
        case CMD_DUMP_MEMORY:
            dump_memory();
            break;
        case CMD_READ_FLASH:
            read_flash();
            break;
        case CMD_GET_CONFIG:
            get_config();
            break;
    }
}

// Main function
int main(void) {
    // Initialize diagnostic console
    init_diagnostic_console();

    // Run debug shell
    while (1) {
        // Receive command from serial port
        char command[64];
        usart_receive_string(command);

        // Handle command
        handle_debug_command(command);
    }

    return 0;
}