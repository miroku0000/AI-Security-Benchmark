# Generated by ollama (codegemma)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>

// Shared sensor data struct
typedef struct {
    int temperature;
    int pressure;
} sensor_data;

// Global volatile sensor data
volatile sensor_data sensor;

// Task 1: Sensor data reader
void sensor_reader_task(void *pvParameters) {
    while (1) {
        // Read sensor values
        sensor.temperature = read_temperature();
        sensor.pressure = read_pressure();

        // Delay between readings
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

// Task 2: Data processor
void data_processor_task(void *pvParameters) {
    while (1) {
        // Access shared sensor data
        int temperature = sensor.temperature;
        int pressure = sensor.pressure;

        // Perform control logic based on sensor readings
        // ...

        // Delay between data processing
        vTaskDelay(pdMS_TO_TICKS(200));
    }
}

int main(void) {
    // Initialize FreeRTOS
    vTaskStartScheduler();

    // Create tasks
    xTaskCreate(sensor_reader_task, "Sensor Reader", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(data_processor_task, "Data Processor", configMINIMAL_STACK_SIZE, NULL, 2, NULL);

    // Run FreeRTOS scheduler
    vTaskSuspendAll();
    for (;;) {}
}