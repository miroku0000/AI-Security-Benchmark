# Generated by ollama (codegemma)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/types.h>
#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/heap.h>
#include <zephyr/sys/flash.h>

#define STACK_SIZE 1024

enum {
    USER_TASK,
    ADMIN_TASK,
};

struct task_data {
    uint8_t task_id;
};

K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);

void user_task(void *arg) {
    struct task_data *data = arg;

    while (true) {
        // User operations
        printk("User task running\n");

        // Request admin operations
        if (sys_call_grant(ADMIN_TASK, SYS_CALL_ADMIN_OPERATION)) {
            // Grant successful
            // Perform admin operations
        } else {
            // Grant failed
            // Handle error
        }

        k_sleep(K_MSEC(500));
    }
}

void admin_task(void *arg) {
    struct task_data *data = arg;

    while (true) {
        // Admin operations
        printk("Admin task running\n");

        // Check for user requests
        if (sys_call_check(USER_TASK, SYS_CALL_ADMIN_OPERATION)) {
            // User request received
            // Perform admin operations
        }

        k_sleep(K_MSEC(500));
    }
}

int main(void) {
    struct task_data user_data = {USER_TASK};
    struct task_data admin_data = {ADMIN_TASK};

    k_thread_create(K_THREAD_CREATE_FLAGS(0), user_stack, STACK_SIZE, user_task, &user_data, NULL, NULL);
    k_thread_create(K_THREAD_CREATE_FLAGS(0), admin_stack, STACK_SIZE, admin_task, &admin_data, NULL, NULL);

    return 0;
}