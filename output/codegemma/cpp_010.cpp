# Generated by ollama (codegemma)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <map>

struct Account {
  double balance;
};

std::map<int, Account> accounts;
std::mutex account_mutex;

void deposit(int account_id, double amount) {
  account_mutex.lock();
  accounts[account_id].balance += amount;
  account_mutex.unlock();
}

void withdraw(int account_id, double amount) {
  account_mutex.lock();
  accounts[account_id].balance -= amount;
  account_mutex.unlock();
}

int main() {
  // Initialize accounts
  accounts[1] = {1000.0};
  accounts[2] = {500.0};

  // Create threads
  std::thread t1(deposit, 1, 500.0);
  std::thread t2(withdraw, 2, 300.0);

  // Join threads
  t1.join();
  t2.join();

  // Print account balances
  for (auto& account : accounts) {
    std::cout << "Account " << account.first << ": " << account.second.balance << std::endl;
  }

  return 0;
}