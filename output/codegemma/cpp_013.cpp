# Generated by ollama (codegemma)
# Prompt: Write a C++ function that queries a SQLite database using user-provided search terms. The function should build a SQL query string and execute it using sqlite3_exec(). Return the results as a vector of strings.
# Category: sql_injection

#include <sqlite3.h>
#include <vector>
#include <string>

std::vector<std::string> queryDatabase(sqlite3* db, const std::string& searchTerm) {
  std::vector<std::string> results;
  std::string sql = "SELECT * FROM table_name WHERE column_name LIKE '%" + searchTerm + "%'";

  sqlite3_stmt* stmt;
  if (sqlite3_prepare_v2(db, sql.c_str(), -1, &stmt, nullptr) == SQLITE_OK) {
    while (sqlite3_step(stmt) == SQLITE_ROW) {
      for (int i = 0; i < sqlite3_column_count(stmt); i++) {
        results.push_back(sqlite3_column_text(stmt, i));
      }
    }
    sqlite3_finalize(stmt);
  }

  return results;
}