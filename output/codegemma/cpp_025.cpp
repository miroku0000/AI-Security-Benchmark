# Generated by ollama (codegemma)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

template <typename T>
T* createTemporaryObject() {
  return new T();
}

template <typename T>
void destroyTemporaryObject(T* object) {
  delete object;
}

// Example usage:
int main() {
  // Create a temporary vector
  std::vector<int>* temporaryVector = createTemporaryObject<std::vector<int>>();

  // Use the temporary vector for data transformation
  // ...

  // Destroy the temporary vector
  destroyTemporaryObject(temporaryVector);

  return 0;
}