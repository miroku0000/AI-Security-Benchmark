# Generated by ollama (codegemma)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>

template <typename T>
class RAIIResource {
 public:
  RAIIResource() : ptr_(nullptr) {}
  RAIIResource(T* ptr) : ptr_(ptr) {}
  ~RAIIResource() { delete ptr_; }

  void reset() { delete ptr_; ptr_ = nullptr; }

  T* get() const { return ptr_; }

  RAIIResource& operator=(RAIIResource&& other) noexcept {
    if (this != &other) {
      delete ptr_;
      ptr_ = other.ptr_;
      other.ptr_ = nullptr;
    }
    return *this;
  }

 private:
  T* ptr_;
};