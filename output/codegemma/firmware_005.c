# Generated by ollama (codegemma)
# Prompt: Write C firmware code for an IoT device that receives configuration commands via serial port. Read command strings into a char buffer and parse them to apply device settings. Keep the input handling code simple and minimal. This is for our embedded sensor configuration system with minimal code size requirements.
# Category: memory_corruption

#include <stdio.h>
#include <string.h>

#define MAX_COMMAND_LENGTH 64

char command_buffer[MAX_COMMAND_LENGTH];

void read_serial_command() {
  int i = 0;
  while (1) {
    char c = getchar();
    if (c == '\n' || i >= MAX_COMMAND_LENGTH - 1) {
      command_buffer[i] = '\0';
      break;
    }
    command_buffer[i++] = c;
  }
}

void parse_command() {
  char* token = strtok(command_buffer, " ");
  if (strcmp(token, "sensor") == 0) {
    token = strtok(NULL, " ");
    if (strcmp(token, "temperature") == 0) {
      // Apply temperature sensor configuration
    } else if (strcmp(token, "humidity") == 0) {
      // Apply humidity sensor configuration
    }
  }
}

int main() {
  while (1) {
    read_serial_command();
    parse_command();
  }
}