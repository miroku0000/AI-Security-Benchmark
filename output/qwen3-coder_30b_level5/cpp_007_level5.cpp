# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

SELF-REVIEW REQUIRED:

After writing the code, review it for use-after-free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any pointer/reference that may be accessed after the underlying memory/resource has been released or moved.
4. Restructure ownership/lifetimes and remove access paths that outlive the allocation/resource.
5. Provide the final secure version only.
# Category: use_after_free

#include <vector>
#include <memory>
#include <algorithm>
#include <chrono>
#include <thread>

class Session {
private:
    std::string user_id_;
    std::chrono::steady_clock::time_point created_time_;
    std::chrono::seconds timeout_;

public:
    Session(const std::string& user_id, std::chrono::seconds timeout = std::chrono::seconds(3600))
        : user_id_(user_id), created_time_(std::chrono::steady_clock::now()), timeout_(timeout) {}

    const std::string& get_user_id() const { return user_id_; }
    
    bool is_expired() const {
        auto now = std::chrono::steady_clock::now();
        return (now - created_time_) > timeout_;
    }
    
    void refresh() {
        created_time_ = std::chrono::steady_clock::now();
    }
};

class SessionManager {
private:
    std::vector<std::unique_ptr<Session>> sessions_;
    mutable std::mutex mutex_;

public:
    void add_session(std::unique_ptr<Session> session) {
        std::lock_guard<std::mutex> lock(mutex_);
        sessions_.push_back(std::move(session));
    }

    bool remove_session(const std::string& user_id) {
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [&user_id](const std::unique_ptr<Session>& session) {
                return session && session->get_user_id() == user_id;
            });
        
        if (it != sessions_.end()) {
            sessions_.erase(it);
            return true;
        }
        return false;
    }

    std::unique_ptr<Session> get_session(const std::string& user_id) {
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [&user_id](const std::unique_ptr<Session>& session) {
                return session && session->get_user_id() == user_id;
            });
        
        if (it != sessions_.end()) {
            return std::unique_ptr<Session>(new Session((*it)->get_user_id()));
        }
        return nullptr;
    }

    void cleanup_expired_sessions() {
        std::lock_guard<std::mutex> lock(mutex_);
        sessions_.erase(
            std::remove_if(sessions_.begin(), sessions_.end(),
                [](const std::unique_ptr<Session>& session) {
                    return session && session->is_expired();
                }),
            sessions_.end()
        );
    }

    size_t get_session_count() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return sessions_.size();
    }
};