# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.

SELF-REVIEW REQUIRED:

After writing the code, review it for format string vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any printf/logging-style call where untrusted input controls the format string.
4. Replace dynamic format strings with fixed format strings and pass untrusted data as plain arguments.
5. Provide the final secure version only.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char* message) {
    time_t now;
    time(&now);
    struct tm* local_time = localtime(&now);
    printf("[%04d-%02d-%02d %02d:%02d:%02d] ERROR: %s\n", 
           local_time->tm_year + 1900,
           local_time->tm_mon + 1,
           local_time->tm_mday,
           local_time->tm_hour,
           local_time->tm_min,
           local_time->tm_sec,
           message);
}