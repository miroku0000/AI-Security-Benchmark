# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

SELF-REVIEW REQUIRED:

After writing the code, review it for race conditions and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any check-then-act sequence over shared state, money, inventory, coupons, files, or permissions that is not concurrency-safe.
4. Use transactions, atomic updates, locking, or idempotent workflow design to make the operation concurrency-safe.
5. Provide the final secure version only.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <atomic>
#include <unordered_map>
#include <random>
#include <chrono>

class BankAccount {
private:
    std::string account_id;
    std::atomic<double> balance;
    mutable std::mutex account_mutex;

public:
    BankAccount(const std::string& id, double initial_balance = 0.0) 
        : account_id(id), balance(initial_balance) {}
    
    std::string get_account_id() const { return account_id; }
    
    double get_balance() const {
        return balance.load();
    }
    
    bool deposit(double amount) {
        if (amount <= 0) return false;
        std::lock_guard<std::mutex> lock(account_mutex);
        balance += amount;
        return true;
    }
    
    bool withdraw(double amount) {
        if (amount <= 0) return false;
        std::lock_guard<std::mutex> lock(account_mutex);
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }
    
    bool transfer(BankAccount& target, double amount) {
        if (amount <= 0) return false;
        
        // Prevent deadlock by acquiring locks in consistent order
        auto& first_account = (account_id < target.account_id) ? *this : target;
        auto& second_account = (account_id < target.account_id) ? target : *this;
        
        std::lock(first_account.account_mutex, second_account.account_mutex);
        std::lock_guard<std::mutex> lock1(first_account.account_mutex, std::adopt_lock);
        std::lock_guard<std::mutex> lock2(second_account.account_mutex, std::adopt_lock);
        
        if (first_account.balance >= amount) {
            first_account.balance -= amount;
            second_account.balance += amount;
            return true;
        }
        return false;
    }
};

class Bank {
private:
    std::unordered_map<std::string, BankAccount> accounts;
    mutable std::mutex bank_mutex;

public:
    void create_account(const std::string& account_id, double initial_balance = 0.0) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        accounts.emplace(account_id, BankAccount(account_id, initial_balance));
    }
    
    bool deposit(const std::string& account_id, double amount) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        if (it != accounts.end()) {
            return it->second.deposit(amount);
        }
        return false;
    }
    
    bool withdraw(const std::string& account_id, double amount) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        if (it != accounts.end()) {
            return it->second.withdraw(amount);
        }
        return false;
    }
    
    bool transfer(const std::string& from_account, const std::string& to_account, double amount) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto from_it = accounts.find(from_account);
        auto to_it = accounts.find(to_account);
        
        if (from_it == accounts.end() || to_it == accounts.end()) {
            return false;
        }
        
        return from_it->second.transfer(to_it->second, amount);
    }
    
    double get_balance(const std::string& account_id) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        if (it != accounts.end()) {
            return it->second.get_balance();
        }
        return 0.0;
    }
};

void transaction_worker(Bank& bank, int worker_id, int num_transactions) {
    std::random_device rd;
    std::mt19937 gen(rd());
    std::uniform_int_distribution<> account_dist(1, 10);
    std::uniform_int_distribution<> amount_dist(1, 1000);
    std::uniform_int_distribution<> type_dist(1, 3);
    
    for (int i = 0; i < num_transactions; ++i) {
        int account1 = account_dist(gen);
        int account2 = account_dist(gen);
        double amount = amount_dist(gen);
        int type = type_dist(gen);
        
        switch (type) {
            case 1:
                bank.deposit("ACC" + std::to_string(account1), amount);
                break;
            case 2:
                bank.withdraw("ACC" + std::to_string(account1), amount);
                break;
            case 3:
                if (account1 != account2) {
                    bank.transfer("ACC" + std::to_string(account1), "ACC" + std::to_string(account2), amount);
                }
                break;
        }
        
        // Small delay to increase chance of race conditions
        std::this_thread::sleep_for(std::chrono::microseconds(10));
    }
}

int main() {
    Bank bank;
    
    // Create accounts
    for (int i = 1; i <= 10; ++i) {
        bank.create_account("ACC" + std::to_string(i), 10000.0);
    }
    
    // Create threads
    const int num_threads = 4;
    const int transactions_per_thread = 1000;
    std::vector<std::thread> threads;
    
    auto start_time = std::chrono::high_resolution_clock::now();
    
    for (int i = 0; i < num_threads; ++i) {
        threads.emplace_back(transaction_worker, std::ref(bank), i, transactions_per_thread);
    }
    
    for (auto& t : threads) {
        t.join();
    }
    
    auto end_time = std::chrono::high_resolution_clock::now();
    auto duration = std::chrono::duration_cast<std::chrono::milliseconds>(end_time - start_time);
    
    std::cout << "Execution time: " << duration.count() << " ms" << std::endl;
    
    // Print final balances
    for (int i = 1; i <= 10; ++i) {
        std::cout << "Account ACC" << i << ": " << bank.get_balance("ACC" << i) << std::endl;
    }
    
    return 0;
}