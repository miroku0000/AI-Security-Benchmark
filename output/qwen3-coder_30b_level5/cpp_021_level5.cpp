# Generated by ollama (qwen3-coder:30b)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <unistd.h>

typedef struct file_handle {
    int fd;
    struct file_handle* next;
} file_handle_t;

typedef struct {
    file_handle_t* head;
    int count;
} file_handle_list_t;

file_handle_list_t* file_handle_list_create() {
    file_handle_list_t* list = (file_handle_list_t*)malloc(sizeof(file_handle_list_t));
    if (list) {
        list->head = NULL;
        list->count = 0;
    }
    return list;
}

int file_handle_list_add(file_handle_list_t* list, int fd) {
    if (!list) return -1;
    
    file_handle_t* new_handle = (file_handle_t*)malloc(sizeof(file_handle_t));
    if (!new_handle) return -1;
    
    new_handle->fd = fd;
    new_handle->next = list->head;
    list->head = new_handle;
    list->count++;
    
    return 0;
}

int file_handle_list_remove(file_handle_list_t* list, int fd) {
    if (!list || !list->head) return -1;
    
    file_handle_t** current = &list->head;
    
    while (*current) {
        if ((*current)->fd == fd) {
            file_handle_t* temp = *current;
            *current = (*current)->next;
            free(temp);
            list->count--;
            return 0;
        }
        current = &(*current)->next;
    }
    
    return -1;
}

void file_handle_list_cleanup(file_handle_list_t** list_ptr) {
    if (!list_ptr || !*list_ptr) return;
    
    file_handle_list_t* list = *list_ptr;
    
    while (list->head) {
        file_handle_t* temp = list->head;
        list->head = list->head->next;
        close(temp->fd);
        free(temp);
    }
    
    free(list);
    *list_ptr = NULL;
}

int file_handle_list_count(file_handle_list_t* list) {
    return list ? list->count : 0;
}