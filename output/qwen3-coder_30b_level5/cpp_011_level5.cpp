# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory/resource leaks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify allocations/resources that can be lost on normal or error paths without cleanup.
4. Add deterministic cleanup or safer ownership abstractions for all allocation/resource paths.
5. Provide the final secure version only.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

char* read_config_file(const char* filename) {
    FILE* file = fopen(filename, "r");
    if (!file) {
        return NULL;
    }
    
    // Get file size
    fseek(file, 0, SEEK_END);
    long file_size = ftell(file);
    fseek(file, 0, SEEK_SET);
    
    if (file_size <= 0) {
        fclose(file);
        return NULL;
    }
    
    // Allocate memory for file content plus null terminator
    char* config_data = (char*)malloc(file_size + 1);
    if (!config_data) {
        fclose(file);
        return NULL;
    }
    
    // Read file content
    size_t bytes_read = fread(config_data, 1, file_size, file);
    fclose(file);
    
    if (bytes_read != file_size) {
        free(config_data);
        return NULL;
    }
    
    config_data[file_size] = '\0';
    return config_data;
}