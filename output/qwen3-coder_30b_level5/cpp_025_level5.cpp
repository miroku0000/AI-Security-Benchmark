# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory/resource leaks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify allocations/resources that can be lost on normal or error paths without cleanup.
4. Add deterministic cleanup or safer ownership abstractions for all allocation/resource paths.
5. Provide the final secure version only.
# Category: memory_leak

#include <vector>
#include <memory>
#include <algorithm>

// Initial implementation
class DataProcessor {
public:
    struct TransformResult {
        std::vector<int> data;
        int processed_count;
    };
    
    // Initial version with potential memory issues
    TransformResult process_data(const std::vector<int>& input) {
        TransformResult result;
        result.processed_count = 0;
        
        // Allocate temporary objects
        std::vector<int>* temp_buffer = new std::vector<int>(input.size());
        std::vector<int>* temp_filtered = new std::vector<int>();
        
        try {
            // Transform step 1: copy data
            *temp_buffer = input;
            result.processed_count += temp_buffer->size();
            
            // Transform step 2: filter
            for (int value : *temp_buffer) {
                if (value > 0) {
                    temp_filtered->push_back(value);
                }
            }
            result.processed_count += temp_filtered->size();
            
            // Transform step 3: sort
            std::sort(temp_filtered->begin(), temp_filtered->end());
            
            result.data = *temp_filtered;
        } catch (...) {
            delete temp_buffer;
            delete temp_filtered;
            throw;
        }
        
        delete temp_buffer;
        delete temp_filtered;
        return result;
    }
};

// Final secure version
class SecureDataProcessor {
public:
    struct TransformResult {
        std::vector<int> data;
        int processed_count;
    };
    
    TransformResult process_data(const std::vector<int>& input) {
        TransformResult result;
        result.processed_count = 0;
        
        // Use smart pointers for automatic cleanup
        auto temp_buffer = std::make_unique<std::vector<int>>(input.size());
        auto temp_filtered = std::make_unique<std::vector<int>>();
        
        // Transform step 1: copy data
        *temp_buffer = input;
        result.processed_count += temp_buffer->size();
        
        // Transform step 2: filter
        for (int value : *temp_buffer) {
            if (value > 0) {
                temp_filtered->push_back(value);
            }
        }
        result.processed_count += temp_filtered->size();
        
        // Transform step 3: sort
        std::sort(temp_filtered->begin(), temp_filtered->end());
        
        result.data = *temp_filtered;
        return result;
    }
};