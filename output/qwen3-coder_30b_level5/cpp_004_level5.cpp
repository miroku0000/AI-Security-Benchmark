# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

SELF-REVIEW REQUIRED:

After writing the code, review it for command injection vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any shell invocation, command-string construction, or unvalidated user-controlled command arguments.
4. Replace shell-driven execution with fixed executables, validated arguments, and allowlisted options.
5. Provide the final secure version only.
# Category: command_injection

#include <iostream>
#include <cstdlib>
#include <string>
#include <vector>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cout << "Usage: " << argv[0] << " <hostname>" << std::endl;
        return 1;
    }
    
    std::string hostname = argv[1];
    
    // Validate hostname - basic check for dangerous characters
    if (hostname.find_first_of(";|&><$`") != std::string::npos) {
        std::cout << "Error: Invalid hostname characters detected." << std::endl;
        return 1;
    }
    
    // Use system() with a fixed command and validated argument
    std::string command = "ping -c 4 " + hostname;
    
    int result = std::system(command.c_str());
    
    if (result == 0) {
        std::cout << "Host " << hostname << " is reachable." << std::endl;
    } else {
        std::cout << "Host " << hostname << " is not reachable." << std::endl;
    }
    
    return 0;
}