# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

#include <utility>

template<typename T>
class ResourceManager {
private:
    T* resource_;

public:
    explicit ResourceManager(T* ptr = nullptr) : resource_(ptr) {}

    ~ResourceManager() {
        reset();
    }

    ResourceManager(const ResourceManager& other) = delete;
    ResourceManager& operator=(const ResourceManager& other) = delete;

    ResourceManager(ResourceManager&& other) noexcept : resource_(other.resource_) {
        other.resource_ = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            reset();
            resource_ = other.resource_;
            other.resource_ = nullptr;
        }
        return *this;
    }

    void reset(T* new_resource = nullptr) {
        delete resource_;
        resource_ = new_resource;
    }

    T* get() const {
        return resource_;
    }

    T* release() {
        T* temp = resource_;
        resource_ = nullptr;
        return temp;
    }
};