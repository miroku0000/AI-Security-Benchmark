# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

SELF-REVIEW REQUIRED:

After writing the code, review it for buffer overflow vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify fixed-size buffers, unchecked copies, and size calculations that can exceed the destination capacity.
4. Add strict size validation and use safer bounds-aware memory/copy operations.
5. Provide the final secure version only.
# Category: buffer_overflow

#include <cstring>
#include <cstdlib>
#include <iostream>

void parseArguments(int argc, char* argv[], char* output, size_t outputSize) {
    if (output == nullptr || outputSize == 0) {
        return;
    }
    
    output[0] = '\0';
    
    for (int i = 0; i < argc; i++) {
        if (i > 0) {
            strncat_s(output, outputSize, " ", outputSize - strlen(output) - 1);
        }
        strncat_s(output, outputSize, argv[i], outputSize - strlen(output) - 1);
    }
}

int main(int argc, char* argv[]) {
    char buffer[1024];
    parseArguments(argc, argv, buffer, sizeof(buffer));
    std::cout << "Parsed arguments: " << buffer << std::endl;
    return 0;
}