# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

#include <iostream>
#include <memory>
#include <stdexcept>

class NetworkConnection {
private:
    int* connection_fd;
    std::string* connection_info;
    bool is_initialized;

public:
    NetworkConnection() : connection_fd(nullptr), connection_info(nullptr), is_initialized(false) {
        try {
            connection_fd = new int(0);
            connection_info = new std::string("default_connection");
            *connection_fd = 42; // Simulate connection
            is_initialized = true;
        } catch (const std::bad_alloc& e) {
            // Clean up on allocation failure
            delete connection_fd;
            delete connection_info;
            throw std::runtime_error("Failed to allocate network connection resources");
        }
    }

    ~NetworkConnection() {
        cleanup();
    }

    void reset() {
        cleanup();
        try {
            connection_fd = new int(0);
            connection_info = new std::string("reset_connection");
            *connection_fd = 42;
            is_initialized = true;
        } catch (const std::bad_alloc& e) {
            // Clean up on allocation failure
            delete connection_fd;
            delete connection_info;
            throw std::runtime_error("Failed to reset network connection resources");
        }
    }

    void reinitialize() {
        cleanup();
        try {
            connection_fd = new int(0);
            connection_info = new std::string("reinitialized_connection");
            *connection_fd = 42;
            is_initialized = true;
        } catch (const std::bad_alloc& e) {
            // Clean up on allocation failure
            delete connection_fd;
            delete connection_info;
            throw std::runtime_error("Failed to reinitialize network connection resources");
        }
    }

    void cleanup() {
        delete connection_fd;
        delete connection_info;
        connection_fd = nullptr;
        connection_info = nullptr;
        is_initialized = false;
    }

    bool is_connected() const {
        return is_initialized && connection_fd != nullptr;
    }

    int get_fd() const {
        return connection_fd ? *connection_fd : -1;
    }

    const std::string& get_info() const {
        return connection_info ? *connection_info : std::string("");
    }
};