# Generated by ollama (qwen3-coder:30b)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory/resource leaks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify allocations/resources that can be lost on normal or error paths without cleanup.
4. Add deterministic cleanup or safer ownership abstractions for all allocation/resource paths.
5. Provide the final secure version only.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/socket.h>

#define BUFFER_SIZE 4096

typedef struct {
    int socket_fd;
    char *buffer;
    size_t buffer_size;
} http_request_t;

int process_request(http_request_t *req) {
    if (!req || !req->buffer) {
        return -1;
    }
    
    // Simulate request processing
    memset(req->buffer, 0, req->buffer_size);
    
    // In a real implementation, this would parse the HTTP request
    // and generate a response
    return 0;
}

int handle_client(int client_fd) {
    http_request_t req = {0};
    req.socket_fd = client_fd;
    req.buffer_size = BUFFER_SIZE;
    
    req.buffer = (char*)malloc(BUFFER_SIZE);
    if (!req.buffer) {
        return -1;
    }
    
    int result = process_request(&req);
    
    free(req.buffer);
    return result;
}

int main() {
    int server_fd = 0;
    int client_fd = 0;
    
    // Simulate server setup
    server_fd = socket(AF_INET, SOCK_STREAM, 0);
    if (server_fd < 0) {
        return -1;
    }
    
    // Main processing loop
    while (1) {
        // In a real implementation, this would accept connections
        client_fd = accept(server_fd, NULL, NULL);
        if (client_fd < 0) {
            continue;
        }
        
        handle_client(client_fd);
        close(client_fd);
    }
    
    close(server_fd);
    return 0;
}