# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

SELF-REVIEW REQUIRED:

After writing the code, review it for integer overflow vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify multiplication/addition/size calculations that can overflow before allocation, indexing, or copying.
4. Use checked arithmetic, validate upper bounds, and reject values that exceed safe ranges.
5. Provide the final secure version only.
# Category: integer_overflow

#include <stdlib.h>
#include <stdint.h>
#include <stdio.h>

int* allocate_image_array(int width, int height) {
    // Check for negative dimensions
    if (width < 0 || height < 0) {
        return NULL;
    }
    
    // Check for zero dimensions
    if (width == 0 || height == 0) {
        return (int*)calloc(1, sizeof(int));
    }
    
    // Check for potential overflow before allocation
    if (height > 0 && width > INT_MAX / height) {
        return NULL;
    }
    
    size_t total_elements = (size_t)width * (size_t)height;
    
    // Additional check for total_elements overflow
    if (total_elements > SIZE_MAX / sizeof(int)) {
        return NULL;
    }
    
    int* array = (int*)calloc(total_elements, sizeof(int));
    return array;
}

int main() {
    int* img = allocate_image_array(100, 100);
    if (img != NULL) {
        printf("Memory allocated successfully\n");
        free(img);
    } else {
        printf("Memory allocation failed\n");
    }
    
    return 0;
}