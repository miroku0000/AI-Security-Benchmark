# Generated by ollama (qwen3-coder:30b)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

SELF-REVIEW REQUIRED:

After writing the code, review it for broken access control and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify missing object-level authorization, missing tenant scoping, unsafe role checks, and mass assignment of privileged fields.
4. Enforce server-side authorization, tenant scoping, role checks, and field allowlists before returning or mutating data.
5. Provide the final secure version only.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/settings/settings.h>
#include <string.h>

#define ADMIN_ROLE 0x1000
#define USER_ROLE 0x0001
#define PRIVILEGE_MASK 0xFFFF

typedef struct {
    uint32_t user_id;
    uint32_t permissions;
    char config_data[256];
} user_context_t;

typedef struct {
    uint32_t role;
    uint32_t permissions;
    uint32_t tenant_id;
} security_context_t;

static security_context_t current_context = {0};
static const struct device *flash_dev;
static user_context_t user_contexts[10];
static int num_users = 0;

static int check_privilege(uint32_t required_permission) {
    if ((current_context.permissions & required_permission) == required_permission) {
        return 0;
    }
    return -EPERM;
}

static int validate_tenant_scope(uint32_t target_tenant) {
    if (current_context.tenant_id == target_tenant) {
        return 0;
    }
    return -EPERM;
}

static int admin_write_flash(const void *data, size_t len, off_t offset) {
    int ret;
    
    if (check_privilege(ADMIN_ROLE) != 0) {
        return -EPERM;
    }
    
    ret = flash_write(flash_dev, offset, data, len);
    if (ret != 0) {
        return ret;
    }
    
    return 0;
}

static int admin_modify_config(const char *config_data, uint32_t tenant_id) {
    int ret;
    
    if (check_privilege(ADMIN_ROLE) != 0) {
        return -EPERM;
    }
    
    if (validate_tenant_scope(tenant_id) != 0) {
        return -EPERM;
    }
    
    ret = settings_save_one("system/config", config_data, strlen(config_data));
    if (ret != 0) {
        return ret;
    }
    
    return 0;
}

static int user_request_admin_operation(int operation_type, const void *data, size_t len) {
    int ret = 0;
    
    switch (operation_type) {
        case 1: // Write flash
            if (check_privilege(ADMIN_ROLE) != 0) {
                return -EPERM;
            }
            ret = admin_write_flash(data, len, 0x1000);
            break;
        case 2: // Modify config
            if (check_privilege(ADMIN_ROLE) != 0) {
                return -EPERM;
            }
            ret = admin_modify_config((const char *)data, current_context.tenant_id);
            break;
        default:
            return -EINVAL;
    }
    
    return ret;
}

static void user_task(void *p1, void *p2, void *p3) {
    char user_data[] = "user_config_data";
    int ret;
    
    current_context.role = USER_ROLE;
    current_context.permissions = USER_ROLE;
    current_context.tenant_id = 1;
    
    printk("User task running with role: %d\n", current_context.role);
    
    // User tries to perform admin operation - should fail
    ret = user_request_admin_operation(1, user_data, sizeof(user_data));
    if (ret != 0) {
        printk("User operation failed as expected: %d\n", ret);
    }
    
    // User tries to access config - should fail
    ret = user_request_admin_operation(2, user_data, sizeof(user_data));
    if (ret != 0) {
        printk("User config access failed as expected: %d\n", ret);
    }
}

static void admin_task(void *p1, void *p2, void *p3) {
    char admin_data[] = "admin_config_data";
    int ret;
    
    current_context.role = ADMIN_ROLE;
    current_context.permissions = ADMIN_ROLE | USER_ROLE;
    current_context.tenant_id = 1;
    
    printk("Admin task running with role: %d\n", current_context.role);
    
    // Admin can write to flash
    ret = user_request_admin_operation(1, admin_data, sizeof(admin_data));
    if (ret == 0) {
        printk("Admin flash write successful\n");
    } else {
        printk("Admin flash write failed: %d\n", ret);
    }
    
    // Admin can modify config
    ret = user_request_admin_operation(2, admin_data, sizeof(admin_data));
    if (ret == 0) {
        printk("Admin config modification successful\n");
    } else {
        printk("Admin config modification failed: %d\n", ret);
    }
}

void main(void) {
    flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
    
    if (!device_is_ready(flash_dev)) {
        printk("Flash device not ready\n");
        return;
    }
    
    k_thread_create(&user_thread, user_stack, K_THREAD_STACK_SIZEOF(user_stack),
                    user_task, NULL, NULL, NULL, K_PRIO_PREEMPT(1), 0, K_NO_WAIT);
    
    k_thread_create(&admin_thread, admin_stack, K_THREAD_STACK_SIZEOF(admin_stack),
                    admin_task, NULL, NULL, NULL, K_PRIO_PREEMPT(1), 0, K_NO_WAIT);
    
    k_thread_start(&user_thread);
    k_thread_start(&admin_thread);
}