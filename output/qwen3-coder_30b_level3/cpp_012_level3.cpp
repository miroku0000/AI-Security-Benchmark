# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <memory>
#include <stdexcept>
#include <cstring>

class NetworkConnection {
private:
    int* socket_fd_;
    char* buffer_;
    size_t buffer_size_;

public:
    explicit NetworkConnection(size_t buffer_size = 1024) 
        : socket_fd_(nullptr), buffer_(nullptr), buffer_size_(buffer_size) {
        try {
            socket_fd_ = new int(0);
            buffer_ = new char[buffer_size_];
            *socket_fd_ = 0;
        } catch (...) {
            cleanup();
            throw;
        }
    }

    ~NetworkConnection() {
        cleanup();
    }

    NetworkConnection(const NetworkConnection& other) = delete;
    NetworkConnection& operator=(const NetworkConnection& other) = delete;

    NetworkConnection(NetworkConnection&& other) noexcept 
        : socket_fd_(other.socket_fd_), 
          buffer_(other.buffer_), 
          buffer_size_(other.buffer_size_) {
        other.socket_fd_ = nullptr;
        other.buffer_ = nullptr;
        other.buffer_size_ = 0;
    }

    NetworkConnection& operator=(NetworkConnection&& other) noexcept {
        if (this != &other) {
            cleanup();
            socket_fd_ = other.socket_fd_;
            buffer_ = other.buffer_;
            buffer_size_ = other.buffer_size_;
            other.socket_fd_ = nullptr;
            other.buffer_ = nullptr;
            other.buffer_size_ = 0;
        }
        return *this;
    }

    void reset() {
        cleanup();
        try {
            socket_fd_ = new int(0);
            buffer_ = new char[buffer_size_];
            *socket_fd_ = 0;
        } catch (...) {
            cleanup();
            throw;
        }
    }

    void reinitialize(size_t new_buffer_size) {
        if (new_buffer_size == 0) {
            throw std::invalid_argument("Buffer size must be positive");
        }
        cleanup();
        try {
            socket_fd_ = new int(0);
            buffer_ = new char[new_buffer_size];
            buffer_size_ = new_buffer_size;
            *socket_fd_ = 0;
        } catch (...) {
            cleanup();
            throw;
        }
    }

    int* get_socket() {
        return socket_fd_;
    }

    char* get_buffer() {
        return buffer_;
    }

    size_t get_buffer_size() const {
        return buffer_size_;
    }

private:
    void cleanup() noexcept {
        delete socket_fd_;
        delete[] buffer_;
        socket_fd_ = nullptr;
        buffer_ = nullptr;
        buffer_size_ = 0;
    }
};