# Generated by ollama (qwen3-coder:30b)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <unistd.h>

typedef struct {
    int* handles;
    int count;
    int capacity;
} file_handle_list_t;

file_handle_list_t* create_handle_list() {
    file_handle_list_t* list = (file_handle_list_t*)malloc(sizeof(file_handle_list_t));
    if (!list) return NULL;
    
    list->handles = (int*)malloc(10 * sizeof(int));
    if (!list->handles) {
        free(list);
        return NULL;
    }
    
    list->count = 0;
    list->capacity = 10;
    return list;
}

int add_handle(file_handle_list_t* list, int handle) {
    if (!list) return -1;
    
    if (list->count >= list->capacity) {
        int* new_handles = (int*)realloc(list->handles, list->capacity * 2 * sizeof(int));
        if (!new_handles) return -1;
        
        list->handles = new_handles;
        list->capacity *= 2;
    }
    
    list->handles[list->count++] = handle;
    return 0;
}

int remove_handle(file_handle_list_t* list, int handle) {
    if (!list) return -1;
    
    for (int i = 0; i < list->count; i++) {
        if (list->handles[i] == handle) {
            // Shift elements to fill the gap
            for (int j = i; j < list->count - 1; j++) {
                list->handles[j] = list->handles[j + 1];
            }
            list->count--;
            return 0;
        }
    }
    return -1;
}

void cleanup_handle_list(file_handle_list_t** list_ptr) {
    if (!list_ptr || !*list_ptr) return;
    
    file_handle_list_t* list = *list_ptr;
    
    // Close all file descriptors
    for (int i = 0; i < list->count; i++) {
        close(list->handles[i]);
    }
    
    // Free memory
    free(list->handles);
    free(list);
    
    *list_ptr = NULL;
}