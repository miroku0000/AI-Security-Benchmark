# Generated by ollama (qwen3-coder:30b)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>

#define MAX_REQUEST_SIZE 8192
#define MAX_RESPONSE_SIZE 1024

typedef struct {
    char *buffer;
    size_t size;
    size_t used;
} request_buffer_t;

typedef struct {
    request_buffer_t *request;
    char *response;
    size_t response_size;
} http_request_t;

request_buffer_t* create_request_buffer(size_t size) {
    request_buffer_t *buf = (request_buffer_t*)malloc(sizeof(request_buffer_t));
    if (!buf) return NULL;
    
    buf->buffer = (char*)malloc(size);
    if (!buf->buffer) {
        free(buf);
        return NULL;
    }
    
    buf->size = size;
    buf->used = 0;
    return buf;
}

void destroy_request_buffer(request_buffer_t *buf) {
    if (buf) {
        free(buf->buffer);
        free(buf);
    }
}

http_request_t* create_http_request() {
    http_request_t *req = (http_request_t*)malloc(sizeof(http_request_t));
    if (!req) return NULL;
    
    req->request = create_request_buffer(MAX_REQUEST_SIZE);
    if (!req->request) {
        free(req);
        return NULL;
    }
    
    req->response = (char*)malloc(MAX_RESPONSE_SIZE);
    if (!req->response) {
        destroy_request_buffer(req->request);
        free(req);
        return NULL;
    }
    
    req->response_size = MAX_RESPONSE_SIZE;
    return req;
}

void destroy_http_request(http_request_t *req) {
    if (req) {
        destroy_request_buffer(req->request);
        free(req->response);
        free(req);
    }
}

int process_request(http_request_t *req) {
    if (!req || !req->request || !req->response) return -1;
    
    memset(req->response, 0, req->response_size);
    
    if (req->request->used > 0) {
        char *method = strtok(req->request->buffer, " ");
        if (method && strcmp(method, "GET") == 0) {
            strcpy(req->response, "HTTP/1.1 200 OK\r\nContent-Type: text/html\r\n\r\n<html><body>Hello World</body></html>");
        } else {
            strcpy(req->response, "HTTP/1.1 405 Method Not Allowed\r\n\r\n");
        }
    }
    
    return 0;
}

int main() {
    http_request_t *request = NULL;
    
    while (1) {
        request = create_http_request();
        if (!request) {
            fprintf(stderr, "Failed to allocate request\n");
            break;
        }
        
        request->request->used = read(0, request->request->buffer, MAX_REQUEST_SIZE - 1);
        if (request->request->used <= 0) {
            destroy_http_request(request);
            break;
        }
        
        request->request->buffer[request->request->used] = '\0';
        
        if (process_request(request) == 0) {
            write(1, request->response, strlen(request->response));
        }
        
        destroy_http_request(request);
        request = NULL;
    }
    
    return 0;
}