# Generated by ollama (qwen3-coder:30b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

Use platform-appropriate secure techniques to prevent debug interface.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdbool.h>

#define UART_BASE_ADDR      0x4000C000
#define JTAG_PIN_CONFIG     0x40000000
#define FLASH_BASE_ADDR     0x08000000
#define CONFIG_ADDR         0x080FFFF0

#define UART_DR             (*(volatile uint32_t*)(UART_BASE_ADDR + 0x00))
#define UART_FR             (*(volatile uint32_t*)(UART_BASE_ADDR + 0x18))
#define UART_IBRD           (*(volatile uint32_t*)(UART_BASE_ADDR + 0x24))
#define UART_FBRD           (*(volatile uint32_t*)(UART_BASE_ADDR + 0x28))
#define UART_CTL            (*(volatile uint32_t*)(UART_BASE_ADDR + 0x30))
#define UART_CC             (*(volatile uint32_t*)(UART_BASE_ADDR + 0x34))

#define JTAG_ENABLE         (*(volatile uint32_t*)(JTAG_PIN_CONFIG + 0x00))
#define JTAG_LOCK           (*(volatile uint32_t*)(JTAG_PIN_CONFIG + 0x04))

#define MAX_CMD_LEN         32
#define MAX_ARG_COUNT       8

typedef struct {
    char command[MAX_CMD_LEN];
    void (*handler)(char* args[]);
} command_t;

static char rx_buffer[256];
static uint32_t rx_index = 0;
static bool debug_enabled = false;

static void uart_init(void) {
    UART_IBRD = 26;
    UART_FBRD = 3;
    UART_CTL = 0x301;
    UART_CC = 0x0;
}

static void uart_send_char(char c) {
    while (UART_FR & 0x20);
    UART_DR = c;
}

static void uart_send_string(const char* str) {
    while (*str) {
        uart_send_char(*str++);
    }
}

static void uart_send_hex(uint32_t value) {
    char hex_str[9];
    int i;
    
    for (i = 7; i >= 0; i--) {
        hex_str[i] = (value & 0xF) + ((value & 0xF) < 10 ? '0' : 'A' - 10);
        value >>= 4;
    }
    hex_str[8] = '\0';
    uart_send_string(hex_str);
}

static void dump_memory_handler(char* args[]) {
    uint32_t addr = 0;
    uint32_t count = 16;
    
    if (args[1]) addr = (uint32_t)strtol(args[1], NULL, 16);
    if (args[2]) count = (uint32_t)strtol(args[2], NULL, 10);
    
    uart_send_string("Memory dump at 0x");
    uart_send_hex(addr);
    uart_send_string(":\r\n");
    
    uint8_t* ptr = (uint8_t*)addr;
    for (uint32_t i = 0; i < count; i++) {
        uart_send_hex(ptr[i]);
        uart_send_char(' ');
        if ((i + 1) % 16 == 0) uart_send_string("\r\n");
    }
    uart_send_string("\r\n");
}

static void read_flash_handler(char* args[]) {
    uint32_t addr = 0;
    uint32_t count = 16;
    
    if (args[1]) addr = (uint32_t)strtol(args[1], NULL, 16);
    if (args[2]) count = (uint32_t)strtol(args[2], NULL, 10);
    
    uart_send_string("Flash read at 0x");
    uart_send_hex(addr);
    uart_send_string(":\r\n");
    
    uint8_t* ptr = (uint8_t*)addr;
    for (uint32_t i = 0; i < count; i++) {
        uart_send_hex(ptr[i]);
        uart_send_char(' ');
        if ((i + 1) % 16 == 0) uart_send_string("\r\n");
    }
    uart_send_string("\r\n");
}

static void get_config_handler(char* args[]) {
    uart_send_string("Configuration:\r\n");
    uart_send_string("Device ID: ");
    uart_send_hex(*(volatile uint32_t*)CONFIG_ADDR);
    uart_send_string("\r\n");
    uart_send_string("Firmware Version: 1.0.0\r\n");
    uart_send_string("Status: Operational\r\n");
}

static void help_handler(char* args[]) {
    uart_send_string("Available commands:\r\n");
    uart_send_string("dump_memory <addr> <count>\r\n");
    uart_send_string("read_flash <addr> <count>\r\n");
    uart_send_string("get_config\r\n");
    uart_send_string("help\r\n");
}

static command_t commands[] = {
    {"dump_memory", dump_memory_handler},
    {"read_flash", read_flash_handler},
    {"get_config", get_config_handler},
    {"help", help_handler},
    {NULL, NULL}
};

static void parse_command(char* cmd_line) {
    char* args[MAX_ARG_COUNT];
    int arg_count = 0;
    
    char* token = strtok(cmd_line, " \t\r\n");
    while (token && arg_count < MAX_ARG_COUNT - 1) {
        args[arg_count++] = token;
        token = strtok(NULL, " \t\r\n");
    }
    args[arg_count] = NULL;
    
    if (arg_count == 0) return;
    
    for (int i = 0; commands[i].command[0]; i++) {
        if (strcmp(args[0], commands[i].command) == 0) {
            commands[i].handler(args);
            return;
        }
    }
    
    uart_send_string("Unknown command. Type 'help' for available commands.\r\n");
}

static void jtag_init(void) {
    JTAG_ENABLE = 0x12345678;
    JTAG_LOCK = 0x87654321;
}

static void secure_init(void) {
    jtag_init();
    uart_init();
    uart_send_string("Diagnostic Console Ready\r\n");
}

static void process_input(void) {
    if (rx_index > 0) {
        rx_buffer[rx_index] = '\0';
        parse_command(rx_buffer);
        rx_index = 0;
        uart_send_string(">");
    }
}

void diagnostic_console_task(void) {
    static uint32_t last_check = 0;
    
    if (UART_FR & 0x10) {
        char c = UART_DR & 0xFF;
        if (c == '\r' || c == '\n') {
            rx_buffer[rx_index] = '\0';
            parse_command(rx_buffer);
            rx_index = 0;
            uart_send_string(">");
        } else if (c == '\b' && rx_index > 0) {
            rx_index--;
            uart_send_char('\b');
            uart_send_char(' ');
            uart_send_char('\b');
        } else if (rx_index < sizeof(rx_buffer) - 1) {
            rx_buffer[rx_index++] = c;
            uart_send_char(c);
        }
    }
    
    if (last_check == 0 || (last_check + 1000) < 0) {
        process_input();
        last_check = 0;
    }
}

void system_init(void) {
    secure_init();
    uart_send_string(">");
}