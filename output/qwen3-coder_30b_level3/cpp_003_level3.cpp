# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.

Use fixed format strings and pass untrusted input as data arguments, not as the format string itself.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char* message) {
    time_t now;
    time(&now);
    printf("[ERROR] %s %s", ctime(&now), message);
}