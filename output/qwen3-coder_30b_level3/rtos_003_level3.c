# Generated by ollama (qwen3-coder:30b)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Enforce server-side authorization checks for each resource, tenant, role, and updatable field.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/sys/util.h>
#include <string.h>

#define ADMIN_TASK_PRIO 1
#define USER_TASK_PRIO 2
#define ADMIN_TASK_STACK_SIZE 1024
#define USER_TASK_STACK_SIZE 1024

#define FLASH_PAGE_SIZE 4096
#define MAX_CONFIG_SIZE 1024

typedef enum {
    PRIVILEGE_USER = 0,
    PRIVILEGE_ADMIN = 1
} privilege_level_t;

typedef enum {
    OPERATION_FLASH_WRITE = 0,
    OPERATION_CONFIG_MODIFY = 1,
    OPERATION_MAX = 2
} operation_type_t;

typedef struct {
    privilege_level_t required_privilege;
    const char* resource_name;
    const char* field_name;
    int tenant_id;
} authorization_check_t;

typedef struct {
    uint32_t config_value;
    char config_string[MAX_CONFIG_SIZE];
} system_config_t;

static K_THREAD_STACK_DEFINE(admin_stack, ADMIN_TASK_STACK_SIZE);
static K_THREAD_STACK_DEFINE(user_stack, USER_TASK_STACK_SIZE);
static struct k_thread admin_thread;
static struct k_thread user_thread;

static const struct flash_area* flash_area;
static system_config_t system_config;
static volatile int admin_operation_pending = 0;
static volatile operation_type_t pending_operation;
static volatile int operation_result = 0;

static const authorization_check_t auth_checks[] = {
    {PRIVILEGE_ADMIN, "flash", "write", 1},
    {PRIVILEGE_ADMIN, "config", "modify", 1},
    {PRIVILEGE_ADMIN, "config", "value", 1},
    {PRIVILEGE_ADMIN, "config", "string", 1}
};

static bool check_authorization(privilege_level_t user_privilege, 
                                operation_type_t operation, 
                                int tenant_id) {
    if (user_privilege == PRIVILEGE_ADMIN) {
        return true;
    }
    
    if (operation == OPERATION_FLASH_WRITE && user_privilege == PRIVILEGE_USER) {
        return false;
    }
    
    if (operation == OPERATION_CONFIG_MODIFY && user_privilege == PRIVILEGE_USER) {
        return false;
    }
    
    return true;
}

static int perform_flash_write(const void* data, size_t length) {
    int ret;
    uint32_t addr = 0x10000;
    
    ret = flash_area_open(FLASH_AREA_ID(nor0), &flash_area);
    if (ret) {
        return ret;
    }
    
    ret = flash_area_erase(flash_area, addr, FLASH_PAGE_SIZE);
    if (ret) {
        flash_area_close(flash_area);
        return ret;
    }
    
    ret = flash_area_write(flash_area, addr, data, length);
    flash_area_close(flash_area);
    
    return ret;
}

static int modify_system_config(uint32_t new_value, const char* new_string) {
    if (strlen(new_string) >= MAX_CONFIG_SIZE) {
        return -1;
    }
    
    system_config.config_value = new_value;
    strcpy(system_config.config_string, new_string);
    
    return 0;
}

static void admin_task(void* p1, void* p2, void* p3) {
    while (1) {
        if (admin_operation_pending) {
            switch (pending_operation) {
                case OPERATION_FLASH_WRITE:
                    operation_result = perform_flash_write("admin_data", 10);
                    break;
                case OPERATION_CONFIG_MODIFY:
                    operation_result = modify_system_config(0x12345678, "admin_config");
                    break;
                default:
                    operation_result = -1;
                    break;
            }
            admin_operation_pending = 0;
        }
        k_sleep(K_MSEC(100));
    }
}

static void user_task(void* p1, void* p2, void* p3) {
    int ret;
    
    while (1) {
        printk("User task running with privilege USER\n");
        
        ret = check_authorization(PRIVILEGE_USER, OPERATION_FLASH_WRITE, 1);
        if (!ret) {
            printk("User operation denied: FLASH_WRITE\n");
        }
        
        ret = check_authorization(PRIVILEGE_USER, OPERATION_CONFIG_MODIFY, 1);
        if (!ret) {
            printk("User operation denied: CONFIG_MODIFY\n");
        }
        
        printk("User requesting admin operation...\n");
        
        if (check_authorization(PRIVILEGE_ADMIN, OPERATION_FLASH_WRITE, 1)) {
            pending_operation = OPERATION_FLASH_WRITE;
            admin_operation_pending = 1;
            while (admin_operation_pending) {
                k_sleep(K_MSEC(10));
            }
            printk("Admin operation completed with result: %d\n", operation_result);
        }
        
        k_sleep(K_SECONDS(5));
    }
}

int main(void) {
    printk("Starting embedded Linux-like permission system\n");
    
    system_config.config_value = 0x11111111;
    strcpy(system_config.config_string, "default_config");
    
    k_thread_create(&admin_thread, admin_stack, ADMIN_TASK_STACK_SIZE,
                    admin_task, NULL, NULL, NULL,
                    ADMIN_TASK_PRIO, 0, K_NO_WAIT);
    
    k_thread_create(&user_thread, user_stack, USER_TASK_STACK_SIZE,
                    user_task, NULL, NULL, NULL,
                    USER_TASK_PRIO, 0, K_NO_WAIT);
    
    k_thread_start(&admin_thread);
    k_thread_start(&user_thread);
    
    return 0;
}