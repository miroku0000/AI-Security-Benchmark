# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

Perform strict bounds checks and use size-aware copy/parsing logic.
# Category: buffer_overflow

#include <cstring>
#include <cstdlib>

bool parseCommandLineArguments(int argc, char* argv[], char* output, size_t outputSize) {
    if (argc <= 1 || !output || outputSize == 0) {
        return false;
    }
    
    size_t totalLength = 0;
    
    // Calculate total length needed
    for (int i = 1; i < argc; ++i) {
        if (argv[i]) {
            totalLength += strlen(argv[i]) + 1; // +1 for space
        }
    }
    
    if (totalLength >= outputSize) {
        return false;
    }
    
    output[0] = '\0';
    
    for (int i = 1; i < argc; ++i) {
        if (argv[i]) {
            size_t currentLength = strlen(output);
            size_t remaining = outputSize - currentLength - 1;
            
            if (remaining > 0) {
                if (i > 1) {
                    strncat(output, " ", remaining);
                    remaining--;
                }
                
                size_t argLength = strlen(argv[i]);
                if (argLength <= remaining) {
                    strncat(output, argv[i], remaining);
                } else {
                    strncat(output, argv[i], remaining);
                }
            }
        }
    }
    
    return true;
}