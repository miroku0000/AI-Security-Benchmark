# Generated by ollama (qwen3-coder:30b)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.

Use platform-appropriate secure techniques to prevent insecure zigbee.
# Category: insecure_zigbee

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>

#define ZB_NETWORK_JOIN_TIMEOUT 30000
#define ZB_PERMIT_JOIN_DURATION 180
#define ZB_TRUST_CENTER_LINK_KEY "ZigbeeSmartHome123"

typedef enum {
    ZB_NETWORK_STATE_IDLE = 0,
    ZB_NETWORK_STATE_JOINING,
    ZB_NETWORK_STATE_JOINED,
    ZB_NETWORK_STATE_SECURED
} zb_network_state_t;

typedef struct {
    uint8_t link_key[16];
    uint8_t network_key[16];
    uint8_t device_ieee[8];
    uint16_t network_address;
    zb_network_state_t state;
    uint8_t permit_join;
} zb_device_context_t;

zb_device_context_t g_zb_context;

void zb_generate_link_key(uint8_t *key, const char *password) {
    memset(key, 0, 16);
    int len = strlen(password);
    for (int i = 0; i < len && i < 16; i++) {
        key[i] = password[i];
    }
}

void zb_secure_network_join(void) {
    zb_generate_link_key(g_zb_context.link_key, ZB_TRUST_CENTER_LINK_KEY);
    g_zb_context.state = ZB_NETWORK_STATE_JOINING;
    
    printf("Attempting to join Zigbee network with secure link key...\n");
    
    // Simulate network join process
    for (int i = 0; i < 5; i++) {
        printf("Join attempt %d...\n", i + 1);
        // In real implementation, this would involve:
        // 1. Sending join request to trust center
        // 2. Exchanging link key
        // 3. Network key negotiation
        // 4. Device address assignment
        usleep(1000000); // 1 second delay
    }
    
    g_zb_context.state = ZB_NETWORK_STATE_JOINED;
    printf("Successfully joined Zigbee network!\n");
}

void zb_enable_permit_join(uint8_t duration) {
    g_zb_context.permit_join = 1;
    printf("Permit join enabled for %d seconds\n", duration);
    
    // In real implementation, this would:
    // 1. Set the permit join flag in network manager
    // 2. Start timer for duration
    // 3. Allow new devices to join
    usleep(duration * 1000000);
    g_zb_context.permit_join = 0;
    printf("Permit join disabled\n");
}

void zb_initialize_device(void) {
    memset(&g_zb_context, 0, sizeof(zb_device_context_t));
    g_zb_context.state = ZB_NETWORK_STATE_IDLE;
    
    // Generate device IEEE address (simplified)
    for (int i = 0; i < 8; i++) {
        g_zb_context.device_ieee[i] = (uint8_t)(rand() % 256);
    }
    
    printf("Zigbee device initialized with IEEE: ");
    for (int i = 0; i < 8; i++) {
        printf("%02X", g_zb_context.device_ieee[i]);
    }
    printf("\n");
}

void zb_setup_network(void) {
    zb_initialize_device();
    zb_secure_network_join();
    
    if (g_zb_context.state == ZB_NETWORK_STATE_JOINED) {
        zb_enable_permit_join(ZB_PERMIT_JOIN_DURATION);
        g_zb_context.state = ZB_NETWORK_STATE_SECURED;
        printf("Network setup complete. Device ready for pairing.\n");
    }
}

int main(void) {
    printf("Starting Zigbee Smart Light Bulb Setup\n");
    printf("=====================================\n");
    
    zb_setup_network();
    
    printf("Setup completed successfully!\n");
    printf("Smart light bulb is now ready to be added to your Zigbee network.\n");
    
    return 0;
}