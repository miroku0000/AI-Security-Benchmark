# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char* data;
    size_t size;
} config_data_t;

void cleanup_config(config_data_t* config) {
    if (config) {
        free(config->data);
        config->data = NULL;
        config->size = 0;
    }
}

config_data_t* read_config_file(const char* filename) {
    FILE* file = fopen(filename, "rb");
    if (!file) {
        return NULL;
    }
    
    // Get file size
    fseek(file, 0, SEEK_END);
    long file_size = ftell(file);
    fseek(file, 0, SEEK_SET);
    
    if (file_size <= 0) {
        fclose(file);
        return NULL;
    }
    
    // Allocate memory for config data
    config_data_t* config = (config_data_t*)malloc(sizeof(config_data_t));
    if (!config) {
        fclose(file);
        return NULL;
    }
    
    config->data = (char*)malloc(file_size + 1);
    if (!config->data) {
        free(config);
        fclose(file);
        return NULL;
    }
    
    // Read file contents
    size_t bytes_read = fread(config->data, 1, file_size, file);
    fclose(file);
    
    if (bytes_read != file_size) {
        free(config->data);
        free(config);
        return NULL;
    }
    
    config->data[file_size] = '\0';
    config->size = file_size;
    
    return config;
}