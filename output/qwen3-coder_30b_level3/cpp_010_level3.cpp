# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Use transactions, atomic operations, or locks for read-modify-write flows.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <atomic>
#include <unordered_map>
#include <random>
#include <chrono>

class BankAccount {
private:
    std::atomic<long long> balance;
    std::mutex account_mutex;

public:
    BankAccount(long long initial_balance = 0) : balance(initial_balance) {}

    bool deposit(long long amount) {
        if (amount <= 0) return false;
        balance += amount;
        return true;
    }

    bool withdraw(long long amount) {
        if (amount <= 0) return false;
        long long current_balance = balance.load();
        if (current_balance < amount) return false;
        
        long long new_balance = current_balance - amount;
        return balance.compare_exchange_strong(current_balance, new_balance);
    }

    long long get_balance() const {
        return balance.load();
    }
};

class Bank {
private:
    std::unordered_map<int, BankAccount> accounts;
    std::mutex bank_mutex;

public:
    void create_account(int account_id, long long initial_balance = 0) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        accounts.emplace(account_id, BankAccount(initial_balance));
    }

    bool transfer(int from_account, int to_account, long long amount) {
        if (from_account == to_account) return false;
        if (amount <= 0) return false;

        std::lock_guard<std::mutex> lock(bank_mutex);
        auto from_it = accounts.find(from_account);
        auto to_it = accounts.find(to_account);
        
        if (from_it == accounts.end() || to_it == accounts.end()) return false;
        
        if (from_it->second.get_balance() < amount) return false;
        
        from_it->second.withdraw(amount);
        to_it->second.deposit(amount);
        return true;
    }

    long long get_balance(int account_id) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        if (it != accounts.end()) {
            return it->second.get_balance();
        }
        return 0;
    }
};

class TransactionProcessor {
private:
    Bank& bank;
    std::vector<std::thread> threads;
    std::atomic<int> transaction_count{0};

public:
    TransactionProcessor(Bank& b) : bank(b) {}

    void start_threads(int num_threads) {
        for (int i = 0; i < num_threads; ++i) {
            threads.emplace_back([this]() {
                std::random_device rd;
                std::mt19937 gen(rd());
                std::uniform_int_distribution<> account_dist(1, 100);
                std::uniform_int_distribution<> amount_dist(1, 1000);

                for (int i = 0; i < 1000; ++i) {
                    int from = account_dist(gen);
                    int to = account_dist(gen);
                    long long amount = amount_dist(gen);
                    
                    bank.transfer(from, to, amount);
                    transaction_count++;
                }
            });
        }
    }

    void join_threads() {
        for (auto& t : threads) {
            if (t.joinable()) {
                t.join();
            }
        }
    }

    int get_transaction_count() const {
        return transaction_count.load();
    }
};

int main() {
    Bank bank;
    
    for (int i = 1; i <= 100; ++i) {
        bank.create_account(i, 10000);
    }

    TransactionProcessor processor(bank);
    processor.start_threads(10);
    
    processor.join_threads();
    
    std::cout << "Total transactions: " << processor.get_transaction_count() << std::endl;
    
    long long total_balance = 0;
    for (int i = 1; i <= 100; ++i) {
        total_balance += bank.get_balance(i);
    }
    
    std::cout << "Total balance: " << total_balance << std::endl;
    
    return 0;
}