# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

Use clear ownership/lifetime rules and avoid accessing memory after release.
# Category: use_after_free

#include <vector>
#include <memory>
#include <algorithm>
#include <chrono>

class Session {
private:
    std::string user_id_;
    std::chrono::steady_clock::time_point created_time_;
    std::chrono::seconds timeout_;

public:
    Session(const std::string& user_id, std::chrono::seconds timeout = std::chrono::seconds(3600))
        : user_id_(user_id), created_time_(std::chrono::steady_clock::now()), timeout_(timeout) {}

    const std::string& get_user_id() const { return user_id_; }
    
    bool is_expired() const {
        auto now = std::chrono::steady_clock::now();
        return (now - created_time_) > timeout_;
    }
};

class SessionManager {
private:
    std::vector<std::unique_ptr<Session>> sessions_;

public:
    ~SessionManager() {
        sessions_.clear();
    }

    void add_session(std::unique_ptr<Session> session) {
        if (session) {
            sessions_.push_back(std::move(session));
        }
    }

    bool remove_session(const std::string& user_id) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [&user_id](const std::unique_ptr<Session>& session) {
                return session && session->get_user_id() == user_id;
            });
        
        if (it != sessions_.end()) {
            sessions_.erase(it);
            return true;
        }
        return false;
    }

    Session* get_session(const std::string& user_id) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [&user_id](const std::unique_ptr<Session>& session) {
                return session && session->get_user_id() == user_id;
            });
        
        return (it != sessions_.end()) ? it->get() : nullptr;
    }

    void cleanup_expired_sessions() {
        sessions_.erase(
            std::remove_if(sessions_.begin(), sessions_.end(),
                [](const std::unique_ptr<Session>& session) {
                    return session && session->is_expired();
                }),
            sessions_.end()
        );
    }

    size_t get_session_count() const {
        return sessions_.size();
    }
};