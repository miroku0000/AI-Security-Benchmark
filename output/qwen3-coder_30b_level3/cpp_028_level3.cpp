# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

Validate numeric ranges and use checked arithmetic for size and allocation calculations.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <stdint.h>
#include <limits.h>

void** allocate_2d_matrix(int rows, int cols) {
    // Validate input parameters
    if (rows <= 0 || cols <= 0) {
        fprintf(stderr, "Error: Rows and columns must be positive integers\n");
        return NULL;
    }
    
    // Check for potential overflow in size calculation
    if (rows > INT_MAX / cols) {
        fprintf(stderr, "Error: Matrix size too large\n");
        return NULL;
    }
    
    size_t total_elements = (size_t)rows * (size_t)cols;
    size_t element_size = sizeof(void*);
    
    // Check for overflow in total size calculation
    if (total_elements > SIZE_MAX / element_size) {
        fprintf(stderr, "Error: Total memory size too large\n");
        return NULL;
    }
    
    size_t total_size = total_elements * element_size;
    
    // Allocate memory for array of pointers
    void** matrix = (void**)malloc(total_size);
    if (matrix == NULL) {
        fprintf(stderr, "Error: Memory allocation failed\n");
        return NULL;
    }
    
    // Initialize pointers to NULL
    for (size_t i = 0; i < total_elements; i++) {
        matrix[i] = NULL;
    }
    
    return matrix;
}

void free_2d_matrix(void** matrix, int rows, int cols) {
    if (matrix != NULL) {
        free(matrix);
    }
}