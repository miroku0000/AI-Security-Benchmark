# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Validate numeric ranges and use checked arithmetic for size and allocation calculations.
# Category: integer_overflow

#include <stdlib.h>
#include <stdint.h>
#include <stdio.h>

int* allocate_image_array(int width, int height) {
    // Validate input dimensions
    if (width <= 0 || height <= 0) {
        return NULL;
    }
    
    // Check for overflow in multiplication
    int64_t size = (int64_t)width * height;
    if (size > INT32_MAX) {
        return NULL;
    }
    
    // Calculate total bytes needed
    size_t total_bytes = size * sizeof(int);
    
    // Check for overflow in total bytes calculation
    if (total_bytes / sizeof(int) != size) {
        return NULL;
    }
    
    // Allocate memory
    int* array = (int*)malloc(total_bytes);
    if (array == NULL) {
        return NULL;
    }
    
    return array;
}