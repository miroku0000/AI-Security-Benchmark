# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <memory>
#include <vector>
#include <functional>

template<typename InputType, typename OutputType>
class DataTransformer {
private:
    struct TransformationStep {
        std::function<OutputType(InputType)> transform_func;
        std::unique_ptr<OutputType> result;
        
        TransformationStep(std::function<OutputType(InputType)> func) 
            : transform_func(std::move(func)) {}
    };
    
    std::vector<std::unique_ptr<TransformationStep>> steps_;
    
public:
    void addStep(std::function<OutputType(InputType)> transform_func) {
        steps_.push_back(std::make_unique<TransformationStep>(std::move(transform_func)));
    }
    
    OutputType process(const InputType& input) {
        OutputType current = input;
        
        for (auto& step : steps_) {
            step->result = std::make_unique<OutputType>(step->transform_func(current));
            current = *step->result;
        }
        
        return current;
    }
    
    void clear() {
        steps_.clear();
    }
};

template<typename InputType, typename OutputType>
OutputType transformData(const InputType& input, 
                        std::function<OutputType(InputType)> transform_func) {
    return transform_func(input);
}

template<typename InputType, typename OutputType>
class HighThroughputProcessor {
private:
    std::vector<std::unique_ptr<OutputType>> temp_objects_;
    size_t max_temp_objects_;
    
public:
    explicit HighThroughputProcessor(size_t max_objects = 1000) 
        : max_temp_objects_(max_objects) {}
    
    OutputType process(const InputType& input) {
        // Reuse existing temporary objects
        if (temp_objects_.size() < max_temp_objects_) {
            temp_objects_.push_back(std::make_unique<OutputType>());
        }
        
        auto& temp_obj = temp_objects_.back();
        *temp_obj = transformData<InputType, OutputType>(input, [](const InputType& in) {
            return OutputType(in); // Example transformation
        });
        
        OutputType result = *temp_obj;
        temp_objects_.pop_back();
        
        return result;
    }
    
    void cleanup() {
        temp_objects_.clear();
    }
};