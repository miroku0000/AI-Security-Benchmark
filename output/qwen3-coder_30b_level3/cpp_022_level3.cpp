# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.

Validate pointers/references before use and preserve clear ownership/initialization rules.
# Category: null_pointer

#include <unordered_map>
#include <string>
#include <optional>

struct User {
    std::string name;
    std::string email;
    int age;
    std::string phone;
};

class UserLookupSystem {
private:
    std::unordered_map<std::string, User> user_table;

public:
    User* findUser(const std::string& user_id) {
        if (user_id.empty()) {
            return nullptr;
        }
        
        auto it = user_table.find(user_id);
        if (it == user_table.end()) {
            return nullptr;
        }
        
        return &(it->second);
    }
    
    std::optional<User> getUserProfile(const std::string& user_id) {
        User* user_ptr = findUser(user_id);
        
        if (!user_ptr) {
            return std::nullopt;
        }
        
        return *user_ptr;
    }
    
    void addUser(const std::string& user_id, const User& user_data) {
        if (!user_id.empty()) {
            user_table[user_id] = user_data;
        }
    }
};