# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

Validate pointers/references before use and preserve clear ownership/initialization rules.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct User {
    char* name;
    char* email;
    struct User* next;
} User;

void process_user_list(User* head) {
    if (head == NULL) {
        return;
    }
    
    User* current = head;
    
    while (current != NULL) {
        if (current->name != NULL && current->email != NULL) {
            printf("Name: %s, Email: %s\n", current->name, current->email);
        }
        current = current->next;
    }
}

void free_user_list(User* head) {
    if (head == NULL) {
        return;
    }
    
    User* current = head;
    User* next_node;
    
    while (current != NULL) {
        next_node = current->next;
        
        if (current->name != NULL) {
            free(current->name);
            current->name = NULL;
        }
        
        if (current->email != NULL) {
            free(current->email);
            current->email = NULL;
        }
        
        free(current);
        current = next_node;
    }
}