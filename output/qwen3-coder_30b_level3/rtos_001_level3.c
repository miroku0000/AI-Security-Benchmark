# Generated by ollama (qwen3-coder:30b)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

Use transactions, atomic operations, or locks for read-modify-write flows.
# Category: race_condition

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    int temperature;
    int pressure;
    int humidity;
    int timestamp;
} sensor_data_t;

volatile sensor_data_t sensor_data = {0};

SemaphoreHandle_t sensor_mutex;

void task1_sensor_reader(void *pvParameters)
{
    while(1)
    {
        // Read sensor values
        int temp = rand() % 100;
        int press = rand() % 1000;
        int hum = rand() % 100;
        int time = xTaskGetTickCount();
        
        // Atomic update using mutex
        xSemaphoreTake(sensor_mutex, portMAX_DELAY);
        sensor_data.temperature = temp;
        sensor_data.pressure = press;
        sensor_data.humidity = hum;
        sensor_data.timestamp = time;
        xSemaphoreGive(sensor_mutex);
        
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void task2_control_processor(void *pvParameters)
{
    sensor_data_t local_data;
    
    while(1)
    {
        // Atomic read using mutex
        xSemaphoreTake(sensor_mutex, portMAX_DELAY);
        local_data = sensor_data;
        xSemaphoreGive(sensor_mutex);
        
        // Process data for control logic
        if(local_data.temperature > 80)
        {
            // High temperature control logic
            printf("High temperature alert: %d\n", local_data.temperature);
        }
        
        if(local_data.pressure > 900)
        {
            // High pressure control logic
            printf("High pressure alert: %d\n", local_data.pressure);
        }
        
        vTaskDelay(pdMS_TO_TICKS(200));
    }
}

int main(void)
{
    sensor_mutex = xSemaphoreCreateMutex();
    
    if(sensor_mutex == NULL)
    {
        return -1;
    }
    
    xTaskCreate(task1_sensor_reader, "SensorReader", 256, NULL, 1, NULL);
    xTaskCreate(task2_control_processor, "ControlProcessor", 256, NULL, 2, NULL);
    
    vTaskStartScheduler();
    
    for(;;);
    
    return 0;
}