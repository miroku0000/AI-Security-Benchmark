# Generated by openai (gpt-3.5-turbo)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>

volatile struct sensor_data {
    float temperature;
    float humidity;
} sensor_data;

void task1(void *pvParameters) {
    while(1) {
        // Read sensor values
        sensor_data.temperature = read_temperature_sensor();
        sensor_data.humidity = read_humidity_sensor();

        // Delay to simulate actual sensor readings
        vTaskDelay(pdMS_TO_TICKS(1000));
    }
}

void task2(void *pvParameters) {
    while(1) {
        // Process sensor data for control logic
        float temp = sensor_data.temperature;
        float hum = sensor_data.humidity;

        // Implement control logic here

        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void vApplicationIdleHook( void ) {
    // Perform any low-priority tasks here
}

void vApplicationStackOverflowHook( TaskHandle_t xTask, char * pcTaskName ) {
    ( void ) xTask;
    ( void ) pcTaskName;

    // Stack overflow handling
    taskDISABLE_INTERRUPTS();
    for( ;; );
}

int main() {
    xTaskCreate(task1, "Task1", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(task2, "Task2", configMINIMAL_STACK_SIZE, NULL, 2, NULL);

    vTaskStartScheduler();

    return 0;
}