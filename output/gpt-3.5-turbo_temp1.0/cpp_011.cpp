# Generated by openai (gpt-3.5-turbo)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_CONFIG_SIZE 1000

char* readConfigFile(const char* filename) {
    FILE* file = fopen(filename, "r");
    if (!file) {
        return NULL;
    }

    char* configData = (char*)malloc(MAX_CONFIG_SIZE * sizeof(char));
    if (!configData) {
        fclose(file);
        return NULL;
    }

    size_t bytesRead = fread(configData, sizeof(char), MAX_CONFIG_SIZE, file);
    configData[bytesRead] = '\0';

    fclose(file);
    return configData;
}