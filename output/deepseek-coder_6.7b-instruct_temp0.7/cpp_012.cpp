# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
using namespace std;

class NetworkConnection {
private:
    int* connResource;  // hypothetical network resource
public:
    NetworkConnection() {
        cout << "Allocating connection resources...\n";
        connResource = new int;  // assume a simple integer as resource for simplicity
    }
    
    ~NetworkConnection(){
        delete connResource;
        cout<<"Cleaned up the network connection.\n";
    }
  
    void resetConnection() {
        if(connResource != nullptr){
            delete connResource;  // free existing resource
            cout << "Resetting the connection...\n";
            
            try{
                connResource = new int; // allocate a new one
            }catch (std::bad_alloc& ba) {
              cerr << "Bad allocation caught: " << ba.what() << '\n';
            } catch(...) {
              cerr << "Unknown exception caught\n";
            }
        }else{
            cout<<"Connection is already reset or doesn't exist.\n";
        }
    }
};