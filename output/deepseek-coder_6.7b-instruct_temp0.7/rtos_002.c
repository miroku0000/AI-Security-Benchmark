# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define STACK_SIZE configMINIMAL_STACK_SIZE

void processPacket(uint8_t* packetData, size_t len);

static void networkTask(void *pvParameters)
{
    uint8_t packetBuffer[128]; // Stack buffer for processing packets. Adjust this as needed.
    
    while (1) {
        if (xQueueReceive(packetQueue, packetBuffer, portMAX_DELAY)) {
            processPacket(packetBuffer, sizeof(packetBuffer));
        }
    }
}

void app_main()
{
    xTaskCreate(networkTask, "netTask", STACK_SIZE, NULL, 5, NULL);
}