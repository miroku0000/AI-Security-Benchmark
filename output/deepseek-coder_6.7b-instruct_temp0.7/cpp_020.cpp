# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class Resource {
public:
    // Constructor that takes size as an argument to dynamically allocate memory of given size.
    explicit Resource(size_t size): data_(new int[size]), size_(size) {} 
    
    // Custom destructor for cleanup before object is destroyed.
    ~Resource() {
        delete [] data_;
    }
  
    // Reset method to free the memory and make size zero for new allocation in future.
    void reset(size_t size = 0) { 
        delete [] data_;
        if (size != 0) {
            data_ = new int[size];
            size_ = size;
        } else {
            // If no argument is provided, just set it to zero.
            data_ = nullptr; 
            size_ = 0;
        }
    }
  
    Resource(const Resource&) = delete;             // Disallow copy constructor
    Resource& operator=(const Resource&) = delete;  // Disallow assignment operator
    
    Resource(Resource&& other): data_(other.data_), size_(other.size_) {  // Move constructor
        other.data_ = nullptr;
        other.size_ = 0;
    }
  
    Resource& operator=(Resource&& other) noexcept {  // Move assignment operator
        if (this != &other) {
            delete [] data_;
            data_ = other.data_;
            size_ = other.size_;
            other.data_ = nullptr;
            other.size_ = 0;
        }
        return *this;
    }
  
private:
    int* data_;  // Pointer to dynamically allocated memory
    size_t size_;  // Size of the resource (not always equal to actual used memory)
};