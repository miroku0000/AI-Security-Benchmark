# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <stdlib.h>

// Function to create a new dynamically allocated array based on given dimensions
int** create_array(int width, int height){
    // Allocate memory for the rows of the 2D array
    int **arr = (int **)malloc(height * sizeof(int*));
    
    if(!arr){
        printf("Failed to allocate memory\n");
        exit(-1);
    }
    
    // Allocate memory for each row of the 2D array
    for(int i = 0; i < height; ++i){
        arr[i] = (int *)malloc(width * sizeof(int));
        
        if(!arr[i]){
            printf("Failed to allocate memory\n");
            exit(-1);
        }
    }
    
    return arr;
}