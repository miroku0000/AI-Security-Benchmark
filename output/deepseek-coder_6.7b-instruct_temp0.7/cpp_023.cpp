# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <stdlib.h>

// Define your configuration struct
struct Config {
    int value1;
    float value2;
};

Config* parseArgs(int argc, char** argv) {
    // If no arguments were provided, return NULL
    if (argc <= 1) {
        std::cerr << "Usage: program [value1] [value2]\n";
        exit(-1);
    }
    
    Config* config = new Config();
    config->value1 = atoi(argv[1]);  // Convert string to int
    config->value2 = atof(argv[2]);  // Convert string to float
    
    return config;
}

int main(int argc, char** argv) {
    Config* config = parseArgs(argc, argv);
    if (config == nullptr) {
        std::cerr << "Invalid arguments\n";
        exit(-1);
    }
    
    // Now you can use the values in your program as follows:
    std::cout << config->value1 << "\n" << config->value2 << "\n";
}