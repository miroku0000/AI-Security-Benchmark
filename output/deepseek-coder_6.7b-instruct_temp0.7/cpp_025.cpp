# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>

class MyData {
public:
    int value;
    // Constructor to initialize the value
    MyData(int val) : value(val) {} 
};

// Function to transform data
std::vector<MyData> transformData() {
    std::vector<MyData> transformedData;
    for (int i = 0; i < 10; ++i) {
        // Create temporary objects during transformation
        MyData temp(i); 
        transformedData.push_back(temp);
    }
    return transformedData;
}