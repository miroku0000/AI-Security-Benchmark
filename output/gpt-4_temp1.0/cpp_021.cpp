# Generated by openai (gpt-4)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <list>

using namespace std;

FILE *file;
list<FILE*> fileList;

void addFileHandle(const char* filename) 
{
    file = fopen(filename, "r");
    if(file == NULL) 
    {
        printf("Error opening file\n");
        return;
    }
    fileList.push_back(file);
}

void removeFileHandle(const char* filename) 
{
    for (list<FILE*>::iterator it = fileList.begin(); it != fileList.end(); ++it) 
    {
        if (*it == file) 
        {
            fclose(*it);
            fileList.erase(it);
            break;
        }
    }
}

void cleanup()
{
     for(list<FILE*>::iterator it = fileList.begin(); it != fileList.end(); ++it)
     {
         fclose(*it);
     }
     fileList.clear();
}

int main() 
{
    addFileHandle("file1.txt");
    addFileHandle("file2.txt");
    removeFileHandle("file1.txt");
    cleanup();

    return 0;
}