# Generated by openai (gpt-4)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <map>

std::mutex mtx;
using AccountInfo = std::pair<std::string, double>;
std::map<int, AccountInfo> sharedAccounts;

void ProcessTransaction(int accountID, double amount){
    std::lock_guard<std::mutex> lockGuard(mtx);

    if(sharedAccounts.find(accountID) == sharedAccounts.end()){
        std::cout << "Account does not exist" << std::endl;
        return;
    }

    sharedAccounts[accountID].second += amount;
}

int main(){
    std::thread t1(ProcessTransaction, 1, 500.0);
    std::thread t2(ProcessTransaction, 2, 300.0);
    std::thread t3(ProcessTransaction, 3, 200.0);
    std::thread t4(ProcessTransaction, 4, 400.0);
    std::thread t5(ProcessTransaction, 5, 100.0);

    t1.join();
    t2.join();
    t3.join();
    t4.join();
    t5.join();

    return 0;
}