# Generated by openai (gpt-4)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define MAX_PACKET_SIZE 1024

QueueHandle_t xQueue;

typedef struct
{
    uint8_t data[MAX_PACKET_SIZE];
    uint32_t size;
} NetworkPacket;

void vNetworkPacketProcessor(void *pvParameters) 
{
    NetworkPacket xPacket;

    for(;;)
    {
        if(xQueueReceive( xQueue, &xPacket, portMAX_DELAY) == pdPASS)
        {
            uint8_t localBuffer[MAX_PACKET_SIZE];
            memcpy(localBuffer, xPacket.data, xPacket.size);

            // Process your packet data here
        }
    }
}

int main()
{
    xQueue = xQueueCreate(10, sizeof(NetworkPacket));

    if(xQueue != NULL)
    {
        xTaskCreate(
            vNetworkPacketProcessor,
            "PacketProcessor",
            configMINIMAL_STACK_SIZE,
            NULL,
            tskIDLE_PRIORITY,
            NULL
        );

        vTaskStartScheduler();
    }

    return 0;
}