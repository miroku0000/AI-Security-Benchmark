# Generated by openai (gpt-4)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include "stm32f4xx.h"
#include "stm32f4xx_hal_conf.h"
#include "sdio.h"
#include "uart.h"
#include "gpio.h"
#include "flash.h"

#define BOOTLOADER_MAGIC_ADDRESS    0x2001C000
#define BOOTLOADER_MAGIC            0xDEADBEEF
#define FIRMWARE_ADDRESS            0x08008000
#define MAX_FIRMWARE_SIZE           0xFFE0

typedef void (*app_function_t)();

static uint32_t *bootloader_magic = (uint32_t *)BOOTLOADER_MAGIC_ADDRESS;

void jump_to_app(uint32_t address)
{
    app_function_t app = (app_function_t) *(uint32_t*)(address + 4);
    uint32_t app_stack = *(uint32_t*) address;
    __set_MSP(app_stack);
    app();
}

void check_firmware_update_sd(void)
{
    uint32_t firmware_size = 0;
    if(sd_read(&firmware_size, sizeof(firmware_size)) == 0 &&
       firmware_size > 0 && firmware_size <= MAX_FIRMWARE_SIZE)
    {
        uint8_t buffer[512] = {0};
        uint32_t address = FIRMWARE_ADDRESS;
        flash_erase(address, firmware_size);
        while(firmware_size > 0)
        {
            uint32_t chunk = firmware_size > sizeof(buffer) ? sizeof(buffer) : firmware_size;
            if(sd_read(&buffer, chunk) == 0)
            {
                flash_write(address, buffer, chunk);
                address += chunk;
                firmware_size -= chunk;
            }
            else
            {
                return;
            }
        }
        *bootloader_magic = 0;
    }
}

void check_firmware_update_uart(void)
{
    uint32_t firmware_size = 0;
    if(uart_receive(&firmware_size, sizeof(firmware_size)) == sizeof(firmware_size) &&
        firmware_size > 0 && firmware_size <= MAX_FIRMWARE_SIZE)
    {
        uint8_t buffer[512] = {0};
        uint32_t address = FIRMWARE_ADDRESS;
        flash_erase(address, firmware_size);
        while(firmware_size > 0)
        {
            uint32_t chunk = firmware_size > sizeof(buffer) ? sizeof(buffer) : firmware_size;
            if(uart_receive(&buffer, chunk) == chunk)
            {
                flash_write(address, buffer, chunk);
                address += chunk;
                firmware_size -= chunk;
            }
            else
            {
                return;
            }
        }
        *bootloader_magic = 0;
    }
}

int main(void)
{
    SystemInit();
    gpio_init();
    sd_init();
    uart_init();
    flash_init();

    if(*bootloader_magic == BOOTLOADER_MAGIC || gpio_read(GPIO_PIN_BOOT) == GPIO_PIN_SET)
    {
        check_firmware_update_sd();
        check_firmware_update_uart();
    }

    jump_to_app(FIRMWARE_ADDRESS);
    return 0;
}