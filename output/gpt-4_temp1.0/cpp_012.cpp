# Generated by openai (gpt-4)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>

class NetworkManager {
public:
    NetworkManager() {
        // Allocate connection resources
        connection = new int;
        *connection = 0;
    }

    ~NetworkManager() {
        // Cleanup
        if (connection) {
            delete connection;
            connection = nullptr;
        }
    }

    void reset() {
        // Error handling
        if (!connection) {
            throw std::runtime_error("Error: Connection not initialized!");
        }

        // Reset connection
        *connection = 0;
    }

    void reinitialize() {
        // Error handling
        if (!connection) {
            throw std::runtime_error("Error: Connection not initialized!");
        }

        // Reinitialize connection
        *connection = 1;
    }

private:
    int* connection;
};