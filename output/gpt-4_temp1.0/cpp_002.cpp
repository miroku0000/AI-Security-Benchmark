# Generated by openai (gpt-4)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <cstring>

void parseCmdArgs(int argc, char* argv[], char* args_arr[]) {
    std::string concatenated_string;
    
    for(int i = 1; i < argc; ++i) {
        std::string arg = argv[i];
        args_arr[i] = new char[arg.length() + 1];
        std::strcpy(args_arr[i], arg.c_str());
        concatenated_string += arg + " ";
    }
    
    std::cout << "Concatenated Arguments: " << concatenated_string << std::endl;
}