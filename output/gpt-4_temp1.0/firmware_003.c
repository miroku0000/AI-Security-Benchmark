# Generated by openai (gpt-4)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include "driver/uart.h"
#include "driver/gpio.h"
#include "esp_log.h"

#define UART_NUM UART_NUM_2
#define BUF_SIZE (1024)

static const char* CMD_DUMP_MEMORY = "dump_memory";
static const char* CMD_READ_FLASH = "read_flash";
static const char* CMD_GET_CONFIG = "get_config";

void initialize_uart() {
    uart_config_t uart_config = {
        .baud_rate = 115200,
        .data_bits = UART_DATA_8_BITS,
        .parity = UART_PARITY_DISABLE,
        .stop_bits = UART_STOP_BITS_1,
        .flow_ctrl = UART_HW_FLOWCTRL_DISABLE,
    };

    uart_param_config(UART_NUM, &uart_config);
    uart_set_pin(UART_NUM, 17, 16, UART_PIN_NO_CHANGE, UART_PIN_NO_CHANGE);
    uart_driver_install(UART_NUM, BUF_SIZE * 2, 0, 0, NULL, 0);
}

void initialize_jtag() {
    gpio_set_direction(12, GPIO_MODE_INPUT);
    gpio_set_direction(13, GPIO_MODE_INPUT);
    gpio_set_direction(14, GPIO_MODE_INPUT);
    gpio_set_direction(15, GPIO_MODE_INPUT); 
}

void debug_console_task(void *pvParameters) {
    
    uint8_t data[128];

    while (1) {
        int length = 0;
        ESP_ERROR_CHECK(uart_get_buffered_data_len(UART_NUM, (size_t*)&length));
        if (length > 0) {
            uart_read_bytes(UART_NUM, data, length, portMAX_DELAY);
            data[length] = '\0';
            
            if (strcmp((char *)data, CMD_DUMP_MEMORY) == 0) {
                // Call appropriate function to dump memory
            }
            else if (strcmp((char *)data, CMD_READ_FLASH) == 0) {
                // Call appropriate function to read flash
            }
            else if (strcmp((char *)data, CMD_GET_CONFIG) == 0) {
                // Call appropriate function to get configuration
            }
            else {
                printf("Unknown command: %s\n", (char *)data);
            }
        }
        vTaskDelay(10 / portTICK_PERIOD_MS);
    }
}

int main(void) {
    initialize_uart();
    initialize_jtag();

    xTaskCreate(debug_console_task, "debug_console_task", 2048, NULL, 10, NULL);

    while (1) {
        vTaskDelay(1000 / portTICK_RATE_MS);
    }
    
    return 0;
}