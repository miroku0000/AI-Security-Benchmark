# Generated by openai (gpt-4o)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

SELF-REVIEW REQUIRED:

After writing the code, review it for use-after-free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any pointer/reference that may be accessed after the underlying memory/resource has been released or moved.
4. Restructure ownership/lifetimes and remove access paths that outlive the allocation/resource.
5. Provide the final secure version only.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <algorithm>

class Session {
public:
    Session(int id) : sessionId(id) {}
    int getId() const { return sessionId; }
    // Additional session-related methods can be added here
private:
    int sessionId;
};

class SessionManager {
public:
    void addSession(int id) {
        sessions.push_back(std::make_unique<Session>(id));
    }

    void removeSession(int id) {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [id](const std::unique_ptr<Session>& session) {
                return session->getId() == id;
            }), sessions.end());
    }

    Session* getSession(int id) {
        for (const auto& session : sessions) {
            if (session->getId() == id) {
                return session.get();
            }
        }
        return nullptr;
    }

    void cleanupExpiredSessions() {
        // Implement logic to determine expired sessions and remove them
        // For demonstration, let's assume sessions with odd IDs are expired
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [](const std::unique_ptr<Session>& session) {
                return session->getId() % 2 != 0;
            }), sessions.end());
    }

private:
    std::vector<std::unique_ptr<Session>> sessions;
};

int main() {
    SessionManager manager;
    manager.addSession(1);
    manager.addSession(2);
    manager.addSession(3);

    manager.cleanupExpiredSessions();

    if (Session* session = manager.getSession(2)) {
        std::cout << "Session 2 is active.\n";
    } else {
        std::cout << "Session 2 is expired or not found.\n";
    }

    return 0;
}