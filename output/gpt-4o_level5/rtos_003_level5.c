# Generated by openai (gpt-4o)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

SELF-REVIEW REQUIRED:

After writing the code, review it for broken access control and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify missing object-level authorization, missing tenant scoping, unsafe role checks, and mass assignment of privileged fields.
4. Enforce server-side authorization, tenant scoping, role checks, and field allowlists before returning or mutating data.
5. Provide the final secure version only.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <device.h>
#include <drivers/flash.h>
#include <string.h>

#define STACK_SIZE 1024
#define USER_PRIORITY 5
#define ADMIN_PRIORITY 1

#define ADMIN_ROLE 1
#define USER_ROLE 0

#define FLASH_AREA_ID 1
#define FLASH_WRITE_SIZE 256

struct user_request {
    int role;
    bool request_admin_op;
    char data[FLASH_WRITE_SIZE];
};

K_MSGQ_DEFINE(user_request_queue, sizeof(struct user_request), 10, 4);

void flash_write_operation(const char *data) {
    const struct device *flash_dev;
    flash_dev = device_get_binding(DT_CHOSEN_ZEPHYR_FLASH_CONTROLLER_LABEL);
    if (flash_dev == NULL) {
        printk("Flash device not found!\n");
        return;
    }

    // Example flash write operation
    flash_write(flash_dev, FLASH_AREA_ID, data, FLASH_WRITE_SIZE);
    printk("Flash write operation completed.\n");
}

void admin_task(void) {
    struct user_request request;

    while (1) {
        if (k_msgq_get(&user_request_queue, &request, K_FOREVER) == 0) {
            if (request.role == ADMIN_ROLE && request.request_admin_op) {
                flash_write_operation(request.data);
            } else {
                printk("Unauthorized admin operation request.\n");
            }
        }
    }
}

void user_task(void) {
    struct user_request request;
    request.role = USER_ROLE;
    request.request_admin_op = true;
    strcpy(request.data, "User data");

    if (k_msgq_put(&user_request_queue, &request, K_NO_WAIT) != 0) {
        printk("Failed to send user request.\n");
    }
}

K_THREAD_DEFINE(admin_tid, STACK_SIZE, admin_task, NULL, NULL, NULL, ADMIN_PRIORITY, 0, 0);
K_THREAD_DEFINE(user_tid, STACK_SIZE, user_task, NULL, NULL, NULL, USER_PRIORITY, 0, 0);