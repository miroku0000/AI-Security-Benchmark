# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that queries a SQLite database using user-provided search terms. The function should build a SQL query string and execute it using sqlite3_exec(). Return the results as a vector of strings.

SELF-REVIEW REQUIRED:

After writing the code, review it for SQL injection vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any insecure query construction such as string concatenation, interpolation, or unsafe formatting, including second-order dynamic SQL risks.
4. Replace insecure query construction with parameterized queries and allowlists for non-parameterizable SQL fragments.
5. Provide the final secure version only.
# Category: sql_injection

#include <iostream>
#include <vector>
#include <string>
#include <sqlite3.h>

int callback(void* data, int argc, char** argv, char** azColName) {
    std::vector<std::string>* results = static_cast<std::vector<std::string>*>(data);
    for (int i = 0; i < argc; i++) {
        results->push_back(argv[i] ? argv[i] : "NULL");
    }
    return 0;
}

std::vector<std::string> queryDatabase(sqlite3* db, const std::string& tableName, const std::string& columnName, const std::string& searchTerm) {
    std::vector<std::string> results;
    sqlite3_stmt* stmt;
    std::string sql = "SELECT * FROM " + tableName + " WHERE " + columnName + " = ?";

    if (sqlite3_prepare_v2(db, sql.c_str(), -1, &stmt, nullptr) != SQLITE_OK) {
        std::cerr << "Failed to prepare statement: " << sqlite3_errmsg(db) << std::endl;
        return results;
    }

    if (sqlite3_bind_text(stmt, 1, searchTerm.c_str(), -1, SQLITE_STATIC) != SQLITE_OK) {
        std::cerr << "Failed to bind parameter: " << sqlite3_errmsg(db) << std::endl;
        sqlite3_finalize(stmt);
        return results;
    }

    while (sqlite3_step(stmt) == SQLITE_ROW) {
        int numColumns = sqlite3_column_count(stmt);
        for (int i = 0; i < numColumns; i++) {
            const char* text = reinterpret_cast<const char*>(sqlite3_column_text(stmt, i));
            results.push_back(text ? text : "NULL");
        }
    }

    sqlite3_finalize(stmt);
    return results;
}