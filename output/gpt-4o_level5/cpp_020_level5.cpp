# Generated by openai (gpt-4o)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

class ResourceManager {
private:
    int* resource;

public:
    // Constructor
    ResourceManager(int value) : resource(new int(value)) {}

    // Destructor
    ~ResourceManager() {
        delete resource;
    }

    // Move Constructor
    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }

    // Move Assignment Operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete resource;
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }

    // Delete Copy Constructor and Copy Assignment Operator
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Reset Method
    void reset() {
        delete resource;
        resource = nullptr;
    }

    // Accessor
    int getValue() const {
        return resource ? *resource : 0;
    }
};