static bool key_is_weak_or_default(const uint8_t key[16]) {
    static const uint8_t zigbee_alliance_default_key[16] = {
        0x5A, 0x69, 0x67, 0x42, 0x65, 0x65, 0x41, 0x6C,
        0x6C, 0x69, 0x61, 0x6E, 0x63, 0x65, 0x30, 0x39
    };