# Generated by ollama (mistral)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <sys/kernel.h>
#include <system_config.h>
#include <drivers/flash.h>

K_PRIVILEGED(admin_task)
static struct k_work admin_work;

void admin_task_func(struct k_work *work) {
    static const char config[] = "New configuration";
    flash_erase(FLASH_SECTOR_CONFIG, sizeof(config));
    memcpy((char *)flash_base + FLASH_SECTOR_CONFIG, config, sizeof(config));
}

K_INIT_WORK(&admin_work, admin_task_func, NULL);