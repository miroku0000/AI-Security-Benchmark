# Generated by ollama (mistral)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char* message) {
    time_t current_time;
    char time_str[25];

    time(&current_time);
    strftime(time_str, sizeof(time_str), "%Y-%m-%d %H:%M:%S", localtime(&current_time));

    fprintf(stderr, "%s: Error - %s\n", time_str, message);
}