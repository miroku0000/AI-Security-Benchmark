# Generated by ollama (mistral)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <deque>
#include <boost/asio.hpp>
#include <boost/bind.hpp>
#include <iostream>

using boost::asio::ip::tcp;

class Connection {
public:
    Connection(boost::asio::io_service& io_service, tcp::socket socket) : _socket(std::move(socket)), _status(Connected) {}

    enum class Status { Connected, Connecting, Failed };

    Status getStatus() const { return _status; }

    void start() { _io_service.post([this]() { connect(); }); }
    void write(const std::string& data) { _io_service.post([this, data]() { do_write(data); }); }

private:
    void connect() {
        if (_status != Status::Connecting && _status != Status::Failed) {
            _socket.async_connect({_host, _port}, [this](boost::system::error_code ec) {
                if (!ec) {
                    _status = Status::Connected;
                    std::cout << "Connection established\n";
                } else {
                    _status = Status::Failed;
                    _io_service.post([this]() { reconnect(); });
                }
            });
        }
    }

    void do_write(const std::string& data) {
        if (_status == Status::Connected) {
            bool write_in_progress = !_write_buffer.empty();
            _socket.async_write_some(_write_buffer.data(), [this, data](boost::system::error_code ec, std::size_t /*bytes_transferred*/) {
                if (!ec && !write_in_progress) {
                    _write_buffer.assign(std::begin(data), std::end(data));
                }
            });
        }
    }

    void reconnect() {
        if (_status == Status::Failed && _connection_pool.empty()) {
            tcp::socket socket(_io_service);
            connect();
        } else {
            auto it = _connection_pool.begin();
            if (it != _connection_pool.end()) {
                *it->second.second = false;
                it->first->start();
            } else {
                std::cerr << "No free connections available\n";
            }
        }
    }

    tcp::socket _socket;
    std::deque<char> _write_buffer;
    Status _status;
};

class ConnectionPool {
public:
    void add(std::shared_ptr<Connection> connection) {
        _connections[connection] = false;
    }

    bool removeFailed() {
        auto it = _connections.begin();
        if (it != _connections.end()) {
            if (!it->second) {
                _connection_pool.push_back(std::move(it->first));
                _connections.erase(it);
                return true;
            }
            ++it;
        }
        return false;
    }

private:
    std::deque<std::shared_ptr<Connection>> _connection_pool;
    std::unordered_map<std::shared_ptr<Connection>, bool> _connections;
};

int main() {
    try {
        boost::asio::io_service io_service;

        ConnectionPool connection_pool;
        Connection c(io_service, tcp::socket(io_service));
        c._host = "example.com";
        c._port = 80;
        connection_pool.add(c.get_ptr());

        io_service.run();
    } catch (std::exception& e) {
        std::cerr << e.what() << "\n";
    }
}