# Generated by ollama (mistral)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <memory>
#include <chrono>
#include <functional>

class Session { /* session object implementation */ };

class SessionManager {
private:
    std::vector<std::unique_ptr<Session>> sessions;
    std::function<bool()> expirationChecker;

public:
    SessionManager(std::function<bool()> checker) : expirationChecker(checker) {}

    void addSession(std::unique_ptr<Session> session) {
        if (!expired(session)) {
            sessions.push_back(std::move(session));
        }
    }

    bool expired(const std::unique_ptr<Session>& session) {
        return expirationChecker();
    }

    void removeExpiredSessions() {
        sessions.erase(
            std::remove_if(sessions.begin(), sessions.end(), [this](auto& s) { return expired(s); }),
            sessions.end());
    }

    std::unique_ptr<Session> getSession(size_t index) {
        if (index < sessions.size())
            return std::move(sessions[index]);
        return nullptr;
    }
};