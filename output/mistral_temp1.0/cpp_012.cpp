# Generated by ollama (mistral)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <memory>

class NetworkConnection {
public:
    NetworkConnection() : resource_(std::make_unique<int>(0)) {}

    void reset() {
        if (resource_) {
            *resource_ = 0;
        } else {
            throw std::runtime_error("Error: No existing connection to reset.");
        }
    }

    ~NetworkConnection() {
        if (resource_) {
            resource_.reset();
        }
    }

private:
    std::unique_ptr<int> resource_;
};