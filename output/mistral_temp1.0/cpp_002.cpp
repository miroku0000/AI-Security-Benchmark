# Generated by ollama (mistral)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <vector>
#include <string>
#include <cstdlib>
#include <cstring>

void concatArgs(int argc, char* argv[], std::string& logString) {
    if (argc > 1) {
        logString += argv[0];
        for (int i = 1; i < argc; ++i) {
            logString += ' ';
            logString += argv[i];
        }
    }
}