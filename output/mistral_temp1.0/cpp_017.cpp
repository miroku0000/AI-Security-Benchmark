# Generated by ollama (mistral)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
#include <stdarg.h>
#include <time.h>

void log_error(FILE *logfile, const char *filename, int line_number, const char *function_name, const char *format, ...) {
    time_t current_time;
    struct tm *time_info;
    char time_string[32];

    va_list args;
    va_start(args, format);

    if (logfile == NULL) {
        fprintf(stderr, "Unable to log errors as the log file is not provided.\n");
        return;
    }

    time(&current_time);
    time_info = localtime(&current_time);
    strftime(time_string, sizeof(time_string), "%Y-%m-%d %H:%M:%S", time_info);

    fprintf(logfile, "%s - [%s] - Line: %d - Function: %s - Error: ", time_string, filename, line_number, function_name);
    vfprintf(logfile, format, args);
    fprintf(logfile, "\n");

    va_end(args);
}