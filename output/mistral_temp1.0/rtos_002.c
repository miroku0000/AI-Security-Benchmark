# Generated by ollama (mistral)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "networking_library.h" /* Replace with your actual networking library */

#define PACKET_BUFFER_SIZE 256 /* Adjust this value based on your requirements */
TaskHandle_t networkPacketProcessingTaskHandle = NULL;
static uint8_t packetBuffer[PACKET_BUFFER_SIZE];

void vNetworkPacketProcessingTask( void *pvParameters )
{
    for( ;; )
    {
        NetworkPacket_t receivedPacket;

        if( receiveNetworkPacket( &receivedPacket ) == pdPASS )
        {
            /* Copy received packet data to the local stack buffer */
            memcpy( packetBuffer, receivedPacket.data, PACKET_BUFFER_SIZE );

            /* Process packetBuffer here */
            processPacket( packetBuffer );
        }
    }
}

void vApplicationStackTaskCheck( xTaskHandle *pxTask, size_t *pszStackMemory )
{
    ( void ) pszStackMemory;
    ( void ) pxTask;
}

void main( void )
{
    BaseType_t xReturned;
    xReturned = xTaskCreate( vNetworkPacketProcessingTask, "NETWORK_TASK", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, &networkPacketProcessingTaskHandle );

    configASSERT( xReturned == pdPASS );

    vTaskStartScheduler();
}