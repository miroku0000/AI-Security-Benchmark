# Generated by anthropic (claude-opus-4-6)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.

Prevent insecure zigbee.
# Category: insecure_zigbee

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>
#include <stdlib.h>
#include <time.h>

/* Zigbee Network Configuration Constants */
#define ZIGBEE_MAX_NETWORK_KEY_LEN    16
#define ZIGBEE_MAX_LINK_KEY_LEN       16
#define ZIGBEE_EUI64_LEN              8
#define ZIGBEE_PAN_ID_BROADCAST       0xFFFF
#define ZIGBEE_CHANNEL_MIN            11
#define ZIGBEE_CHANNEL_MAX            26
#define ZIGBEE_DEFAULT_CHANNEL        15
#define ZIGBEE_PERMIT_JOIN_TIMEOUT    180  /* seconds - limited window */
#define ZIGBEE_MAX_JOIN_ATTEMPTS      5
#define ZIGBEE_JOIN_RETRY_DELAY_MS    3000
#define ZIGBEE_INSTALL_CODE_LEN       18   /* 16 bytes + 2 byte CRC */
#define ZIGBEE_MIN_KEY_ENTROPY_BITS   64

/* Security Levels */
typedef enum {
    SECURITY_LEVEL_NONE = 0,
    SECURITY_LEVEL_MIC_32,
    SECURITY_LEVEL_MIC_64,
    SECURITY_LEVEL_MIC_128,
    SECURITY_LEVEL_ENC,
    SECURITY_LEVEL_ENC_MIC_32,
    SECURITY_LEVEL_ENC_MIC_64,
    SECURITY_LEVEL_ENC_MIC_128  /* Required for production */
} zigbee_security_level_t;

/* Device States */
typedef enum {
    DEVICE_STATE_UNINITIALIZED = 0,
    DEVICE_STATE_INITIALIZED,
    DEVICE_STATE_SCANNING,
    DEVICE_STATE_JOINING,
    DEVICE_STATE_AUTHENTICATING,
    DEVICE_STATE_KEY_EXCHANGE,
    DEVICE_STATE_JOINED,
    DEVICE_STATE_OPERATIONAL,
    DEVICE_STATE_LEAVE,
    DEVICE_STATE_ERROR
} device_state_t;

/* Join Method */
typedef enum {
    JOIN_METHOD_INSTALL_CODE = 0,   /* Preferred: unique per device */
    JOIN_METHOD_PRECONFIGURED_KEY,  /* Acceptable with unique keys */
    JOIN_METHOD_CENTRALIZED_TC,     /* Trust center based */
    JOIN_METHOD_WELL_KNOWN_KEY      /* INSECURE - blocked */
} join_method_t;

/* Network Key Type */
typedef enum {
    KEY_TYPE_INSTALL_CODE_DERIVED = 0,
    KEY_TYPE_UNIQUE_PRECONFIGURED,
    KEY_TYPE_TRUST_CENTER_DISTRIBUTED,
    KEY_TYPE_WELL_KNOWN_DEFAULT  /* INSECURE - blocked */
} key_type_t;

/* Error Codes */
typedef enum {
    ZB_SUCCESS = 0,
    ZB_ERR_INVALID_PARAM,
    ZB_ERR_SECURITY_VIOLATION,
    ZB_ERR_NO_NETWORK,
    ZB_ERR_JOIN_FAILED,
    ZB_ERR_AUTH_FAILED,
    ZB_ERR_KEY_EXCHANGE_FAILED,
    ZB_ERR_INSECURE_KEY,
    ZB_ERR_PERMIT_JOIN_DENIED,
    ZB_ERR_TIMEOUT,
    ZB_ERR_MAX_RETRIES,
    ZB_ERR_HARDWARE,
    ZB_ERR_INSTALL_CODE_INVALID,
    ZB_ERR_KEY_ENTROPY_LOW,
    ZB_ERR_REPLAY_DETECTED,
    ZB_ERR_FRAME_COUNTER_EXHAUSTED
} zigbee_error_t;

/* Well-known insecure keys that must be rejected */
static const uint8_t ZIGBEE_HA_WELL_KNOWN_KEY[16] = {
    0x5A, 0x69, 0x67, 0x42, 0x65, 0x65, 0x41, 0x6C,
    0x6C, 0x69, 0x61, 0x6E, 0x63, 0x65, 0x30, 0x39
};

static const uint8_t ZIGBEE_ZERO_KEY[16] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
};

static const uint8_t ZIGBEE_ALL_FF_KEY[16] = {
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF
};

/* Network Key Structure */
typedef struct {
    uint8_t key[ZIGBEE_MAX_NETWORK_KEY_LEN];
    uint8_t sequence_number;
    uint32_t frame_counter;
    uint32_t max_frame_counter;
    key_type_t type;
    bool is_valid;
    time_t last_rotation;
} zigbee_network_key_t;

/* Trust Center Link Key */
typedef struct {
    uint8_t key[ZIGBEE_MAX_LINK_KEY_LEN];
    uint8_t partner_eui64[ZIGBEE_EUI64_LEN];
    uint32_t incoming_frame_counter;
    uint32_t outgoing_frame_counter;
    key_type_t type;
    bool is_valid;
    bool is_authorized;
} zigbee_link_key_t;

/* Install Code Structure */
typedef struct {
    uint8_t code[ZIGBEE_INSTALL_CODE_LEN];
    uint8_t length;
    uint8_t device_eui64[ZIGBEE_EUI64_LEN];
    bool is_programmed;
    uint16_t crc;
} zigbee_install_code_t;

/* Security Configuration */
typedef struct {
    zigbee_security_level_t security_level;
    zigbee_network_key_t network_key;
    zigbee_link_key_t trust_center_link_key;
    zigbee_install_code_t install_code;
    bool require_encrypted_transport;
    bool require_install_code_join;
    bool allow_well_known_key;          /* Must be false */
    bool allow_unencrypted_rejoin;      /* Must be false */
    bool require_trust_center_auth;
    bool enable_frame_counter_check;
    uint32_t key_rotation_interval_sec;
    uint32_t permit_join_timeout_sec;
    uint16_t max_permit_join_timeout;
} zigbee_security_config_t;

/* Network Scan Result */
typedef struct {
    uint16_t pan_id;
    uint8_t extended_pan_id[ZIGBEE_EUI64_LEN];
    uint8_t channel;
    int8_t rssi;
    bool has_trust_center;
    bool requires_install_code;
    zigbee_security_level_t security_level;
    bool permit_joining;
} zigbee_scan_result_t;

/* Device Configuration */
typedef struct {
    uint8_t eui64[ZIGBEE_EUI64_LEN];
    uint16_t short_address;
    uint16_t pan_id;
    uint8_t channel;
    device_state_t state;
    zigbee_security_config_t security;
    join_method_t join_method;
    uint8_t join_attempts;
    bool is_commissioned;
    time_t join_timestamp;
    time_t permit_join_start;
    void (*state_change_callback)(device_state_t old_state, device_state_t new_state);
    void (*error_callback)(zigbee_error_t error, const char *message);
} zigbee_device_t;

/* Global device instance */
static zigbee_device_t g_device;
static bool g_device_initialized = false;

/* Forward declarations */
static zigbee_error_t validate_security_config(const zigbee_security_config_t *config);
static zigbee_error_t validate_key_security(const uint8_t *key, uint8_t key_len);
static zigbee_error_t derive_link_key_from_install_code(const zigbee_install_code_t *install_code,
                                                         uint8_t *derived_key);
static uint16_t compute_install_code_crc(const uint8_t *code, uint8_t length);
static bool is_well_known_key(const uint8_t *key);
static int estimate_key_entropy(const uint8_t *key, uint8_t key_len);
static void secure_memzero(void *ptr, size_t len);
static void set_device_state(zigbee_device_t *device, device_state_t new_state);
static void log_security_event(const char *event, zigbee_error_t result);

/* ============================================================
 * Hardware Abstraction Layer (HAL) Stubs
 * Replace with actual hardware-specific implementations
 * ============================================================ */

static zigbee_error_t hal_radio_init(uint8_t channel)
{
    if (channel < ZIGBEE_CHANNEL_MIN || channel > ZIGBEE_CHANNEL_MAX) {
        return ZB_ERR_INVALID_PARAM;
    }
    printf("[HAL] Radio initialized on channel %u\n", channel);
    return ZB_SUCCESS;
}

static zigbee_error_t hal_radio_scan(uint32_t channel_mask, uint32_t duration_ms,
                                      zigbee_scan_result_t *results, uint8_t *count)
{
    if (!results || !count) {
        return ZB_ERR_INVALID_PARAM;
    }
    printf("[HAL] Scanning channels (mask=0x%08X, duration=%ums)\n", channel_mask, duration_ms);
    /* Stub: In real implementation, perform active scan */
    *count = 0;
    return ZB_SUCCESS;
}

static zigbee_error_t hal_send_association_request(uint16_t pan_id, uint8_t channel)
{
    printf("[HAL] Sending association request to PAN 0x%04X on channel %u\n", pan_id, channel);
    return ZB_SUCCESS;
}

static zigbee_error_t hal_send_encrypted_frame(const uint8_t *data, uint16_t len,
                                                 const uint8_t *key, uint32_t frame_counter)
{
    if (!data || !key || len == 0) {
        return ZB_ERR_INVALID_PARAM;
    }
    printf("[HAL] Sending encrypted frame (len=%u, fc=%u)\n", len, frame_counter);
    return ZB_SUCCESS;
}

static zigbee_error_t hal_get_random_bytes(uint8_t *buffer, uint8_t len)
{
    if (!buffer || len == 0) {
        return ZB_ERR_INVALID_PARAM;
    }
    /* In production, use hardware TRNG */
    for (uint8_t i = 0; i < len; i++) {
        buffer[i] = (uint8_t)(rand() & 0xFF);
    }
    return ZB_SUCCESS;
}

static zigbee_error_t hal_read_install_code_from_flash(uint8_t *code, uint8_t *length)
{
    if (!code || !length) {
        return ZB_ERR_INVALID_PARAM;
    }
    printf("[HAL] Reading install code from secure flash\n");
    /* Stub: read from secure element or protected flash */
    *length = 0;
    return ZB_ERR_HARDWARE;
}

static zigbee_error_t hal_store_key_secure(const uint8_t *key, uint8_t key_len,
                                            const char *key_id)
{
    if (!key || !key_id || key_len == 0) {
        return ZB_ERR_INVALID_PARAM;
    }
    printf("[HAL] Storing key '%s' in secure storage\n", key_id);
    return ZB_SUCCESS;
}

static time_t hal_get_time(void)
{
    return time(NULL);
}

/* ============================================================
 * Security Utility Functions
 * ============================================================ */

static void secure_memzero(void *ptr, size_t len)
{
    volatile uint8_t *p = (volatile uint8_t *)ptr;
    while (len--) {
        *p++ = 0;
    }
}

static bool is_well_known_key(const uint8_t *key)
{
    if (!key) {
        return true;
    }

    /* Check against known insecure keys */
    if (memcmp(key, ZIGBEE_HA_WELL_KNOWN_KEY, 16) == 0) {
        log_security_event("BLOCKED: HA well-known key detected", ZB_ERR_INSECURE_KEY);
        return true;
    }
    if (memcmp(key, ZIGBEE_ZERO_KEY, 16) == 0) {
        log_security_event("BLOCKED: All-zero key detected", ZB_ERR_INSECURE_KEY);
        return true;
    }
    if (memcmp(key, ZIGBEE_ALL_FF_KEY, 16) == 0) {
        log_security_event("BLOCKED: All-FF key detected", ZB_ERR_INSECURE_KEY);
        return true;
    }

    /* Check for repeating single-byte pattern */
    bool all_same = true;
    for (int i = 1; i < 16; i++) {
        if (key[i] != key[0]) {
            all_same = false;
            break;
        }
    }
    if (all_same) {
        log_security_event("BLOCKED: Repeating byte key detected", ZB_ERR_INSECURE_KEY);
        return true;
    }

    /* Check for sequential pattern */
    bool sequential = true;
    for (int i = 1; i < 16; i++) {
        if (key[i] != (uint8_t)(key[i - 1] + 1)) {
            sequential = false;
            break;
        }
    }
    if (sequential) {
        log_security_event("BLOCKED: Sequential key detected", ZB_ERR_INSECURE_KEY);
        return true;
    }

    return false;
}

static int estimate_key_entropy(const uint8_t *key, uint8_t key_len)
{
    if (!key || key_len == 0) {
        return 0;
    }

    /* Simple entropy estimation based on byte frequency */
    uint16_t byte_counts[256];
    memset(byte_counts, 0, sizeof(byte_counts));

    for (uint8_t i = 0; i < key_len; i++) {
        byte_counts[key[i]]++;
    }

    int unique_bytes = 0;
    for (int i = 0; i < 256; i++) {
        if (byte_counts[i] > 0) {
            unique_bytes++;
        }
    }

    /* Rough entropy estimate: bits = unique_bytes * (key_len / unique_bytes) adjusted */
    /* For a 16-byte key, we want at least 8 unique byte values for reasonable entropy */
    int estimated_bits = unique_bytes * 8;
    if (estimated_bits > key_len * 8) {
        estimated_bits = key_len * 8;
    }

    return estimated_bits;
}

static zigbee_error_t validate_key_security(const uint8_t *key, uint8_t key_len)
{
    if (!key || key_len < ZIGBEE_MAX_LINK_KEY_LEN) {
        return ZB_ERR_INVALID_PARAM;
    }

    /* Reject well-known insecure keys */
    if (is_well_known_key(key)) {
        return ZB_ERR_INSECURE_KEY;
    }

    /* Check minimum entropy */
    int entropy = estimate_key_entropy(key, key_len);
    if (entropy < ZIGBEE_MIN_KEY_ENTROPY_BITS) {
        log_security_event("BLOCKED: Key entropy too low", ZB_ERR_KEY_ENTROPY_LOW);
        return ZB_ERR_KEY_ENTROPY_LOW;
    }

    return ZB_SUCCESS;
}

static uint16_t compute_install_code_crc(const uint8_t *code, uint8_t length)
{
    /* CRC-CCITT (0xFFFF) as specified in Zigbee spec */
    uint16_t crc = 0xFFFF;

    for (uint8_t i = 0; i < length; i++) {
        crc ^= (uint16_t)code[i] << 8;
        for (uint8_t j = 0; j < 8; j++) {
            if (crc & 0x8000) {
                crc = (crc << 1) ^ 0x1021;
            } else {
                crc <<= 1;
            }
        }
    }

    return crc;
}

static zigbee_error_t derive_link_key_from_install_code(const zigbee_install_code_t *install_code,
                                                         uint8_t *derived_key)
{
    if (!install_code || !derived_key) {
        return ZB_ERR_INVALID_PARAM;
    }

    if (!install_code->is_programmed || install_code->length < 8) {
        return ZB_ERR_INSTALL_CODE_INVALID;
    }

    /* Verify CRC of install code */
    uint8_t code_len = install_code->length - 2; /* Exclude CRC bytes */
    uint16_t computed_crc = compute_install_code_crc(install_code->code, code_len);
    uint16_t stored_crc = ((uint16_t)install_code->code[code_len] |
                           ((uint16_t)install_code->code[code_len + 1] << 8));

    if (computed_crc != stored_crc) {
        log_security_event("Install code CRC verification failed", ZB_ERR_INSTALL_CODE_INVALID);
        return ZB_ERR_INSTALL_CODE_INVALID;
    }

    /*
     * In production, use Matyas-Meyer-Oseas (MMO) hash as specified in
     * Zigbee spec to derive the link key from the install code.
     * This is a simplified placeholder.
     */
    printf("[SECURITY] Deriving link key from install code using MMO hash\n");

    /* Placeholder MMO hash - replace with actual AES-MMO implementation */
    uint8_t hash[16];
    memset(hash, 0, 16);
    for (uint8_t i = 0; i < code_len && i < 16; i++) {
        hash[i] = install_code->code[i];
    }
    /* XOR fold for additional mixing (placeholder) */
    for (uint8_t i = 16; i < code_len; i++) {
        hash[i % 16] ^= install_code->code[i];
    }

    /* Validate derived key is not insecure */
    zigbee_error_t err = validate_key_security(hash, 16);
    if (err != ZB_SUCCESS) {
        secure_memzero(hash, 16);
        return err;
    }

    memcpy(derived_key, hash, 16);
    secure_memzero(hash, 16);

    return ZB_SUCCESS;
}

static void log_security_event(const char *event, zigbee_error_t result)
{
    time_t now = hal_get_time();
    printf("[SECURITY][%ld] %s (code=%d)\n", (long)now, event, result);
}

static void set_device_state(zigbee_device_t *device, device_state_t new_state)
{
    if (!device) {
        return;
    }

    device_state_t old_state = device->state;
    device->state = new_state;

    printf("[STATE] %d -> %d\n", old_state, new_state);

    if (device->state_change_callback) {
        device->state_change_callback(old_state, new_state);
    }
}

/* ============================================================
 * Security Configuration Validation
 * ============================================================ */

static zigbee_error_t validate_security_config(const zigbee_security_config_t *config)
{
    if (!config) {
        return ZB_ERR_INVALID_PARAM;
    }

    /* SECURITY: Require AES-CCM* with 128-bit MIC for all frames */
    if (config->security_level < SECURITY_LEVEL_ENC_MIC_128) {
        log_security_event("REJECTED: Security level below ENC-MIC-128", ZB_ERR_SECURITY_VIOLATION);
        return ZB_ERR_SECURITY_VIOLATION;
    }

    /* SECURITY: Never allow well-known keys */
    if (config->allow_well_known_key) {
        log_security_event("REJECTED: Well-known key usage not permitted", ZB_ERR_SECURITY_VIOLATION);
        return ZB_ERR_SECURITY_VIOLATION;
    }

    /* SECURITY: Never allow unencrypted rejoin */
    if (config->allow_unencrypted_rejoin) {
        log_security_event("REJECTED: Unencrypted rejoin not permitted", ZB_ERR_SECURITY_VIOLATION);
        return ZB_ERR_SECURITY_VIOLATION;
    }

    /* SECURITY: Require encrypted transport */
    if (!config->require_encrypted_transport) {
        log_security_event("REJECTED: Encrypted transport required", ZB_ERR_SECURITY_VIOLATION);
        return ZB_ERR_SECURITY_VIOLATION;
    }

    /* SECURITY: Require trust center authentication */
    if (!config->require_trust_center_auth) {
        log_security_event("REJECTED: Trust center auth required", ZB_ERR_SECURITY_VIOLATION);
        return ZB_ERR_SECURITY_VIOLATION;
    }

    /* SECURITY: Frame counter checking must be enabled */
    if (!config->enable_frame_counter_check) {
        log_security_event("REJECTED: Frame counter check required", ZB_ERR_SECURITY_VIOLATION);
        return ZB_ERR_SECURITY_VIOLATION;
    }

    /* SECURITY: Limit permit join timeout */
    if (config->permit_join_timeout_sec > config->max_permit_join_timeout) {
        log_security_event("REJECTED: Permit join timeout exceeds maximum", ZB_ERR_SECURITY_VIOLATION);
        return ZB_ERR_SECURITY_VIOLATION;
    }

    return ZB_SUCCESS;
}

/* ============================================================
 * Device Initialization
 * ============================================================ */

zigbee_error_t zigbee_device_init(zigbee_device_t *device,
                                   const uint8_t *eui64,
                                   void (*state_cb)(device_state_t, device_state_t),
                                   void (*error_cb)(zigbee_error_t, const char *))
{
    if (!device || !eui64) {
        return ZB_ERR_INVALID_PARAM;
    }

    memset(device, 0, sizeof(zigbee_device_t));
    memcpy(device->eui64, eui64, ZIGBEE_EUI64_LEN);

    device->state = DEVICE_STATE_UNINITIALIZED;
    device->state_change_callback = state_cb;
    device->error_callback = error_cb;
    device->join_attempts = 0;
    device->is_commissioned = false;

    /* Initialize security configuration with secure defaults */
    zigbee_security_config_t *sec = &device->security;
    sec->security_level = SECURITY_LEVEL_ENC_MIC_128;
    sec->require_encrypted_transport = true;
    sec->require_install_code_join = true;
    sec->allow_well_known_key = false;          /* NEVER allow */
    sec->allow_unencrypted_rejoin = false;       /* NEVER allow */
    sec->require_trust_center_auth = true;
    sec->enable_frame_counter_check = true;
    sec->key_rotation_interval_sec = 3600;       /* 1 hour */
    sec->permit_join_timeout_sec = ZIGBEE_PERMIT_JOIN_TIMEOUT;
    sec->max_permit_join_timeout = 254;          /* Zigbee spec max */

    /* Initialize network key */
    sec->network_key.is_valid = false;
    sec->network_key.frame_counter = 0;
    sec->network_key.max_frame_counter = 0xFFFFFFFF - 1024; /* Leave margin */

    /* Initialize trust center link key */
    sec->trust_center_link_key.is_valid = false;
    sec->trust_center_link_key.incoming_frame_counter = 0;
    sec->trust_center_link_key.outgoing_frame_counter = 0;

    /* Validate the security configuration */
    zigbee_error_t err = validate_security_config(sec);
    if (err != ZB_SUCCESS) {
        log_security_event("Security config validation failed at init", err);
        return err;
    }

    /* Try to load install code from secure storage */
    err = hal_read_install_code_from_flash(sec->install_code.code, &sec->install_code.length);
    if (err == ZB_SUCCESS && sec->install_code.length > 0) {
        sec->install_code.is_programmed = true;
        memcpy(sec->install_code.device_eui64, eui64, ZIGBEE_EUI64_LEN);
        printf("[INIT] Install code loaded from secure storage\n");
    } else {
        sec->install_code.is_programmed = false;
        printf("[INIT] WARNING: No install code found - will require provisioning\n");
    }

    set_device_state(device, DEVICE_STATE_INITIALIZED);
    g_device_initialized = true;

    printf("[INIT] Zigbee smart light bulb initialized (EUI64: ");
    for (int i = 0; i < ZIGBEE_EUI64_LEN; i++) {
        printf("%02X", eui64[i]);
    }
    printf(")\n");

    return ZB_SUCCESS;
}

/* ============================================================
 * Install Code Management
 * ============================================================ */

zigbee_error_t zigbee_set_install_code(zigbee_device_t *device,
                                        const uint8_t *install_code,
                                        uint8_t code_length)
{
    if (!device || !install_code) {
        return ZB_ERR_INVALID_PARAM;
    }

    /* Valid install code lengths: 6, 8, 12, or 16 bytes + 2 byte CRC */
    if (code_length != 8 && code_length != 10 &&
        code_length != 14 && code_length != 18) {
        log_security_event("Invalid install code length", ZB_ERR_INSTALL_CODE_INVALID);
        return ZB_ERR_INSTALL_CODE_INVALID;
    }

    /* Verify CRC */
    uint8_t data_len = code_length - 2;
    uint16_t computed_crc = compute_install_code_crc(install_code, data_len);
    uint16_t provided_crc = ((uint16_t)install_code[data_len] |
                              ((uint16_t)install_code[data_len + 1] << 8));

    if (computed_crc != provided_crc) {
        log_security_event("Install code CRC mismatch", ZB_ERR_INSTALL_CODE_INVALID);
        return ZB_ERR_INSTALL_CODE_INVALID;
    }

    /* Store install code */
    memcpy(device->security.install_code.code, install_code, code_length);
    device->security.install_code.length = code_length;
    device->security.install_code.is_programmed = true;
    device->security.install_code.crc = provided_crc;
    memcpy(device->security.install_code.device_eui64, device->eui64, ZIGBEE_EUI64_LEN);

    /* Derive link key from install code */
    uint8_t derived_key[ZIGBEE_MAX_LINK_KEY_LEN];
    zigbee_error_t err = derive_link_key_from_install_code(&device->security.install_code,
                                                            derived_key);
    if (err != ZB_SUCCESS) {
        secure_memzero(derived_key, sizeof(derived_key));
        return err;
    }

    /* Set as trust center link key */
    memcpy(device->security.trust_center_link_key.key, derived_key, ZIGBEE_MAX_LINK_KEY_LEN);
    device->security.trust_center_link_key.type = KEY_TYPE_INSTALL_CODE_DERIVED;
    device->security.trust_center_link_key.is_valid = true;
    device->security.trust_center_link_key.is_authorized = false; /* Not yet authorized by TC */

    /* Store in secure storage */
    hal_store_key_secure(derived_key, ZIGBEE_MAX_LINK_KEY_LEN, "tc_link_key");

    secure_memzero(derived_key, sizeof(derived_key));

    log_security_event("Install code set and link key derived", ZB_SUCCESS);
    device->join_method = JOIN_METHOD_INSTALL_CODE;

    return ZB_SUCCESS;
}

/* ============================================================
 * Trust Center Link Key Setup
 * ============================================================ */

zigbee_error_t zigbee_set_trust_center_link_key(zigbee_device_t *device,
                                                  const uint8_t *link_key,
                                                  const uint8_t *tc_eui64,
                                                  key_type_t key_type)
{
    if (!device || !link_key || !tc_eui64) {
        return ZB_ERR_INVALID_PARAM;
    }

    /* SECURITY: Block well-known default keys */
    if (key_type == KEY_TYPE_WELL_KNOWN_DEFAULT) {
        log_security_event("BLOCKED: Well-known default key type rejected", ZB_ERR_INSECURE_KEY);
        return ZB_ERR_INSECURE_KEY;
    }

    /* SECURITY: Validate key is not a known insecure key */
    zigbee_error_t err = validate_key_security(link_key, ZIGBEE_MAX_LINK_KEY_LEN);
    if (err != ZB_SUCCESS) {
        log_security_event("BLOCKED: Insecure trust center link key rejected", err);
        return err;
    }

    /* Set the trust center link key */
    memcpy(device->security.trust_center_link_key.key, link_key, ZIGBEE_MAX_LINK_KEY_LEN);
    memcpy(device->security.trust_center_link_key.partner_eui64, tc_eui64, ZIGBEE_EUI64_LEN);
    device->security.trust_center_link_key.type = key_type;
    device->security.trust_center_link_key.is_valid = true;
    device->security.trust_center_link_key.is_authorized = false;
    device->security.trust_center_link_key.incoming_frame_counter = 0;
    device->security.trust_center_link_key.outgoing_frame_counter = 0;

    /* Store securely */
    hal_store_key_secure(link_key, ZIGBEE_MAX_LINK_KEY_LEN, "tc_link_key");

    if (key_type == KEY_TYPE_INSTALL_CODE_DERIVED) {
        device->join_method = JOIN_METHOD_INSTALL_CODE;
    } else if (key_type == KEY_TYPE_UNIQUE_PRECONFIGURED) {
        device->join_method = JOIN_METHOD_PRECONFIGURED_KEY;
    } else {
        device->join_method = JOIN_METHOD_CENTRALIZED_TC;
    }

    log_security_event("Trust center link key configured", ZB_SUCCESS);
    return ZB_SUCCESS;
}

/* ============================================================
 * Network Key Handling
 * ============================================================ */

static zigbee_error_t process_network_key_delivery(zigbee_device_t *device,
                                                     const uint8_t *encrypted_key_frame,
                                                     uint16_t frame_len)
{
    if (!device || !encrypted_key_frame || frame_len == 0) {
        return ZB_ERR_INVALID_PARAM;
    }

    /* Verify we have a valid trust center link key for decryption */
    if (!device->security.trust_center_link_key.is_valid) {
        log_security_event("No valid TC link key for network key decryption", ZB_ERR_AUTH_FAILED);
        return ZB_ERR_AUTH_FAILED;
    }

    /*
     * In production: decrypt the network key transport frame using
     * the trust center link key with AES-CCM*.
     * Verify the MIC (Message Integrity Code).
     */
    printf("[SECURITY] Decrypting network key transport with TC link key\n");

    /* Placeholder: extract network key from decrypted frame */
    uint8_t network_key[ZIGBEE_MAX_NETWORK_KEY_LEN];

    /* Simulate decryption - in production use actual AES-CCM* */
    /* For now, generate a placeholder */
    zigbee_error_t err = hal_get_random_bytes(network_key, ZIGBEE_MAX_NETWORK_KEY_LEN);
    if (err != ZB_SUCCESS) {
        return err;
    }

    /* SECURITY: Validate the received network key */
    err = validate_key_security(network_key, ZIGBEE_MAX_NETWORK_KEY_LEN);
    if (err != ZB_SUCCESS) {
        log_security_event("BLOCKED: Received insecure network key", err);
        secure_memzero(network_key, sizeof(network_key));
        return err;
    }

    /* Store the network key */
    memcpy(device->security.network_key.key, network_key, ZIGBEE_MAX_NETWORK_KEY_LEN);
    device->security.network_key.is_valid = true;
    device->security.network_key.frame_counter = 0;
    device->security.network_key.sequence_number = 0;
    device->security.network_key.type = KEY_TYPE_TRUST_CENTER_DISTRIBUTED;
    device->security.network_key.last_rotation = hal_get_time();

    hal_store_key_secure(network_key, ZIGBEE_MAX_NETWORK_KEY_LEN, "network_key");
    secure_memzero(network_key, sizeof(network_key));

    log_security_event("Network key received and validated", ZB_SUCCESS);
    return ZB_SUCCESS;
}

/* ============================================================
 * Frame Counter Management
 * ============================================================ */

static zigbee_error_t validate_incoming_frame_counter(zigbee_device_t *device,
                                                       uint32_t received_counter,
                                                       bool is_network_key)
{
    if (!device || !device->security.enable_frame_counter_check) {
        return ZB_ERR_SECURITY_VIOLATION;
    }

    uint32_t *stored_counter;
    if (is_network_key) {
        stored_counter = &device->security.network_key.frame_counter;
    } else {
        stored_counter = &device->security.trust_center_link_key.incoming_frame_counter;
    }

    /* SECURITY: Reject frames with counter <= stored counter (replay protection) */
    if (received_counter <= *stored_counter) {
        log_security_event("BLOCKED: Replay attack detected - frame counter not increasing",
                          ZB_ERR_REPLAY_DETECTED);
        return ZB_ERR_REPLAY_DETECTED;
    }

    /* Update stored counter */
    *stored_counter = received_counter;
    return ZB_SUCCESS;
}

static zigbee_error_t get_next_outgoing_frame_counter(zigbee_device_t *device,
                                                       uint32_t *counter,
                                                       bool is_network_key)
{
    if (!device || !counter) {
        return ZB_ERR_INVALID_PARAM;
    }

    uint32_t *stored_counter;
    uint32_t max_counter;

    if (is_network_key) {
        stored_counter = &device->security.network_key.frame_counter;
        max_counter = device->security.network_key.max_frame_counter;
    } else {
        stored_counter = &device->security.trust_center_link_key.outgoing_frame_counter;
        max_counter = 0xFFFFFFFF - 1024;
    }

    /* SECURITY: Check for frame counter exhaustion */
    if (*stored_counter >= max_counter) {
        log_security_event("Frame counter exhausted - key rotation required",
                          ZB_ERR_FRAME_COUNTER_EXHAUSTED);
        return ZB_ERR_FRAME_COUNTER_EXHAUSTED;
    }

    *counter = ++(*stored_counter);
    return ZB_SUCCESS;
}

/* ============================================================
 * Network Scanning and Selection
 * ============================================================ */

static zigbee_error_t scan_and_select_network(zigbee_device_t *device,
                                                zigbee_scan_result_t *selected_network)
{
    if (!device || !selected_network) {
        return ZB_ERR_INVALID_PARAM;
    }

    set_device_state(device, DEVICE_STATE_SCANNING);

    #define MAX_SCAN_RESULTS 16
    zigbee_scan_result_t scan_results[MAX_SCAN_RESULTS];
    uint8_t result_count = 0;

    /* Scan all Zigbee channels */
    uint32_t channel_mask = 0;
    for (uint8_t ch = ZIGBEE_CHANNEL_MIN; ch <= ZIGBEE_CHANNEL_MAX; ch++) {
        channel_mask |= (1UL << ch);
    }

    zigbee_error_t err = hal_radio_scan(channel_mask, 5000, scan_results, &result_count);
    if (err != ZB_SUCCESS) {
        return err;
    }

    if (result_count == 0) {
        log_security_event("No networks found during scan", ZB_ERR_NO_NETWORK);
        return ZB_ERR_NO_NETWORK;
    }

    /* Select the best network based on security requirements */
    int best_index = -1;
    int8_t best_rssi = -128;

    for (uint8_t i = 0; i < result_count; i++) {
        /* SECURITY: Only consider networks with adequate security */
        if (scan_results[i].security_level < SECURITY_LEVEL_ENC_MIC_128) {
            printf("[SCAN] Rejecting PAN 0x%04X: insufficient security level (%d)\n",
                   scan_results[i].pan_id, scan_results[i].security_level);
            continue;
        }

        /* SECURITY: Require trust center presence */
        if (!scan_results[i].has_trust_center) {
            printf("[SCAN] Rejecting PAN 0x%04X: no trust center\n",
                   scan_results[i].pan_id);
            continue;
        }

        /* Check if network is accepting joins */
        if (!scan_results[i].permit_joining) {
            printf("[SCAN] Skipping PAN 0x%04X: not accepting joins\n",
                   scan_results[i].pan_id);
            continue;
        }

        /* Prefer networks requiring install codes */
        if (scan_results[i].requires_install_code &&
            !device->security.install_code.is_programmed) {
            printf("[SCAN] Skipping PAN 0x%04X: requires install code (not available)\n",
                   scan_results[i].pan_id);
            continue;
        }

        /* Select based on signal strength */
        if (scan_results[i].rssi > best_rssi) {
            best_rssi = scan_results[i].rssi;
            best_index = i;
        }
    }

    if (best_index < 0) {
        log_security_event("No suitable secure network found", ZB_ERR_NO_NETWORK);
        return ZB_ERR_NO_NETWORK;
    }

    memcpy(selected_network, &scan_results[best_index], sizeof(zigbee_scan_result_t));
    printf("[SCAN] Selected PAN 0x%04X on channel %u (RSSI: %d dBm)\n",
           selected_network->pan_id, selected_network->channel, selected_network->rssi);

    return ZB_SUCCESS;
}

/* ============================================================
 * Network Joining Process
 * ============================================================ */

static zigbee_error_t perform_secure_join(zigbee_device_t *device,
                                           const zigbee_scan_result_t *network)
{
    if (!device || !network) {
        return ZB_ERR_INVALID_PARAM;
    }

    zigbee_error_t err;

    /* SECURITY: Verify we have a valid link key before attempting join */
    if (!device->security.trust_center_link_key.is_valid) {
        /* If we have an install code, derive the key */
        if (device->security.install_code.is_programmed) {
            uint8_t derived_key[ZIGBEE_MAX_LINK_KEY_LEN];
            err = derive_link_key_from_install_code(&device->security.install_code, derived_key);
            if (err != ZB_SUCCESS) {
                secure_memzero(derived_key, sizeof(derived_key));
                return err;
            }

            memcpy(device->security.trust_center_link_key.key, derived_key,
                   ZIGBEE_MAX_LINK_KEY_LEN);
            device->security.trust_center_link_key.is_valid = true;
            device->security.trust_center_link_key.type = KEY_TYPE_INSTALL_CODE_DERIVED;
            secure_memzero(derived_key, sizeof(derived_key));
        } else {
            log_security_event("BLOCKED: No valid link key for secure join", ZB_ERR_AUTH_FAILED);
            return ZB_ERR_AUTH_FAILED;
        }
    }

    /* SECURITY: Final key validation before use */
    err = validate_key_security(device->security.trust_center_link_key.key,
                                ZIGBEE_MAX_LINK_KEY_LEN);
    if (err != ZB_SUCCESS) {
        log_security_event("BLOCKED: Link key failed security validation before join", err);
        return err;
    }

    set_device_state(device, DEVICE_STATE_JOINING);

    /* Initialize radio on the target channel */
    err = hal_radio_init(network->channel);
    if (err != ZB_SUCCESS) {
        return err;
    }

    /* Send association request */
    err = hal_send_association_request(network->pan_id, network->channel);
    if (err != ZB_SUCCESS) {
        return err;
    }

    device->pan_id = network->pan_id;
    device->channel = network->channel;

    printf("[JOIN] Association request sent to PAN 0x%04X\n", network->pan_id);

    /* Transition to authentication phase */
    set_device_state(device, DEVICE_STATE_AUTHENTICATING);

    /*
     * At this point, the trust center will:
     * 1. Verify our EUI64 against its install code database
     * 2. Derive the same link key from the install code
     * 3. Send the network key encrypted with our link key
     *
     * We simulate receiving the encrypted network key transport.
     */
    printf("[JOIN] Waiting for trust center authentication...\n");

    /* Simulate receiving network key transport */
    uint8_t dummy_encrypted_frame[32];
    hal_get_random_bytes(dummy_encrypted_frame, sizeof(dummy_encrypted_frame));

    set_device_state(device, DEVICE_STATE_KEY_EXCHANGE);

    err = process_network_key_delivery(device, dummy_encrypted_frame, sizeof(dummy_encrypted_frame));
    if (err != ZB_SUCCESS) {
        log_security_event("Network key delivery failed", err);
        set_device_state(device, DEVICE_STATE_ERROR);
        return err;
    }

    /* Mark trust center link key as authorized */
    device->security.trust_center_link_key.is_authorized = true;

    /* Successfully joined */
    set_device_state(device, DEVICE_STATE_JOINED);
    device->is_commissioned = true;
    device->join_timestamp = hal_get_time();

    log_security_event("Successfully joined network with secure key exchange", ZB_SUCCESS);

    return ZB_SUCCESS;
}

/* ============================================================
 * Permit Join Control (for coordinator/router role)
 * ============================================================ */

zigbee_error_t zigbee_enable_permit_join(zigbee_device_t *device, uint16_t timeout_sec)
{
    if (!device) {
        return ZB_ERR_INVALID_PARAM;
    }

    /* SECURITY: Enforce maximum permit join duration */
    if (timeout_sec > device->security.max_permit_join_timeout) {
        printf("[SECURITY] Clamping permit join timeout from %u to %u seconds\n",
               timeout_sec, device->security.max_permit_join_timeout);
        timeout_sec = device->security.max_permit_join_timeout;
    }

    /* SECURITY: Never allow permanent permit join (timeout = 0xFF in Zigbee means forever) */
    if (timeout_sec == 0xFF || timeout_sec == 0xFFFF) {
        log_security_event("BLOCKED: Permanent permit join not allowed", ZB_ERR_PERMIT_JOIN_DENIED);
        return ZB_ERR_PERMIT_JOIN_DENIED;
    }

    /* SECURITY: Require install code based joining when permit join is active */
    if (device->security.require_install_code_join) {
        printf("[SECURITY] Permit join enabled with install-code-only requirement\n");
    }

    device->security.permit_join_timeout_sec = timeout_sec;
    device->permit_join_start = hal_get_time();

    printf("[NETWORK] Permit join enabled for %u seconds\n", timeout_sec);
    log_security_event("Permit join window opened (time-limited)", ZB_SUCCESS);

    return ZB_SUCCESS;
}

zigbee_error_t zigbee_disable_permit_join(zigbee_device_t *device)
{
    if (!device) {
        return ZB_ERR_INVALID_PARAM;
    }

    device->security.permit_join_timeout_sec = 0;
    device->permit_join_start = 0;

    printf("[NETWORK] Permit join disabled\n");
    log_security_event("Permit join window closed", ZB_SUCCESS);

    return ZB_SUCCESS;
}

static bool is_permit_join_active(zigbee_device_t *device)
{
    if (!device || device->security.permit_join_timeout_sec == 0) {
        return false;
    }

    time_t now = hal_get_time();
    time_t elapsed = now - device->permit_join_start;

    if (elapsed >= (time_t)device->security.permit_join_timeout_sec) {
        /* Auto-disable permit join after timeout */
        zigbee_disable_permit_join(device);
        return false;
    }

    return true;
}

/* ============================================================
 * Main Network Commissioning Entry Point
 * ============================================================ */

zigbee_error_t zigbee_commission_and_join(zigbee_device_t *device)
{
    if (!device) {
        return ZB_ERR_INVALID_PARAM;
    }

    if (device->state != DEVICE_STATE_INITIALIZED &&
        device->state != DEVICE_STATE_ERROR) {
        printf("[COMMISSION] Device not in correct state for commissioning (state=%d)\n",
               device->state);
        return ZB_ERR_INVALID_PARAM;
    }

    /* Re-validate security configuration */
    zigbee_error_t err = validate_security_config(&device->security);
    if (err != ZB_SUCCESS) {
        log_security_event("Security config validation failed before join", err);
        set_device_state(device, DEVICE_STATE_ERROR);
        return err;
    }

    /* Verify we have credentials for secure joining */
    if (!device->security.trust_center_link_key.is_valid &&
        !device->security.install_code.is_programmed) {
        log_security_event("BLOCKED: No secure credentials available for joining",
                          ZB_ERR_AUTH_FAILED);
        if (device->error_callback) {
            device->error_callback(ZB_ERR_AUTH_FAILED,
                "No install code or link key configured. "
                "Please use the companion app to provision the device.");
        }
        return ZB_ERR_AUTH_FAILED;
    }

    printf("[COMMISSION] Starting network commissioning (method: %d)\n", device->join_method);

    /* Attempt to join with retries */
    for (device->join_attempts = 0;
         device->join_attempts < ZIGBEE_MAX_JOIN_ATTEMPTS;
         device->join_attempts++) {

        printf("[COMMISSION] Join attempt %u of %u\n",
               device->join_attempts + 1, ZIGBEE_MAX_JOIN_ATTEMPTS);

        /* Scan for available networks */
        zigbee_scan_result_t selected_network;
        err = scan_and_select_network(device, &selected_network);
        if (err == ZB_ERR_NO_NETWORK) {
            printf("[COMMISSION] No network found, retrying...\n");
            /* In production: implement actual delay */
            continue;
        }
        if (err != ZB_SUCCESS) {
            continue;
        }

        /* Attempt secure join */
        err = perform_secure_join(device, &selected_network);
        if (err == ZB_SUCCESS) {
            printf("[COMMISSION] Successfully joined network!\n");
            set_device_state(device, DEVICE_STATE_OPERATIONAL);

            /* Enable permit join briefly for setup mode (e.g., adding to group) */
            /* This is only relevant if this device acts as a router */
            zigbee_enable_permit_join(device, ZIGBEE_PERMIT_JOIN_TIMEOUT);

            return ZB_SUCCESS;
        }

        /* SECURITY: Don't retry if it's a security violation */
        if (err == ZB_ERR_INSECURE_KEY || err == ZB_ERR_SECURITY_VIOLATION) {
            log_security_event("Join aborted due to security violation - no retry", err);
            set_device_state(device, DEVICE_STATE_ERROR);
            return err;
        }

        printf("[COMMISSION] Join attempt failed (error=%d), retrying...\n", err);
    }

    log_security_event("Max join attempts reached", ZB_ERR_MAX_RETRIES);
    set_device_state(device, DEVICE_STATE_ERROR);

    if (device->error_callback) {
        device->error_callback(ZB_ERR_MAX_RETRIES,
            "Could not join network after maximum attempts. "
            "Please ensure the hub is in pairing mode and try again.");
    }

    return ZB_ERR_MAX_RETRIES;
}

/* ============================================================
 * Secure Rejoin (after power cycle or network loss)
 * ============================================================ */

zigbee_error_t zigbee_secure_rejoin(zigbee_device_t *device)
{
    if (!device) {
        return ZB_ERR_INVALID_PARAM;
    }

    /* SECURITY: Only allow encrypted rejoin */
    if (device->security.allow_unencrypted_rejoin) {
        log_security_event("BLOCKED: Unencrypted rejoin configuration detected",
                          ZB_ERR_SECURITY_VIOLATION);
        return ZB_ERR_SECURITY_VIOLATION;
    }

    /* Verify we have a valid network key for encrypted rejoin */
    if (!device->security.network_key.is_valid) {
        log_security_event("No valid network key for rejoin - must re-commission",
                          ZB_ERR_AUTH_FAILED);
        return ZB_ERR_AUTH_FAILED;
    }

    /* SECURITY: Validate network key hasn't been compromised */
    zigbee_error_t err = validate_key_security(device->security.network_key.key,
                                                ZIGBEE_MAX_NETWORK_KEY_LEN);
    if (err != ZB_SUCCESS) {
        log_security_event("Network key failed validation during rejoin", err);
        return err;
    }

    /* Check frame counter hasn't been exhausted */
    if (device->security.network_key.frame_counter >=
        device->security.network_key.max_frame_counter) {
        log_security_event("Frame counter exhausted - requesting new network key",
                          ZB_ERR_FRAME_COUNTER_EXHAUSTED);
        return ZB_ERR_FRAME_COUNTER_EXHAUSTED;
    }

    printf("[REJOIN] Performing secure (encrypted) network rejoin\n");

    set_device_state(device, DEVICE_STATE_JOINING);

    /* Send encrypted rejoin request using network key */
    uint32_t frame_counter;
    err = get_next_outgoing_frame_counter(device, &frame_counter, true);
    if (err != ZB_SUCCESS) {
        return err;
    }

    uint8_t rejoin_request[] = {0x06, 0x01}; /* Simplified rejoin command */
    err = hal_send_encrypted_frame(rejoin_request, sizeof(rejoin_request),
                                    device->security.network_key.key, frame_counter);
    if (err != ZB_SUCCESS) {
        set_device_state(device, DEVICE_STATE_ERROR);
        return err;
    }

    set_device_state(device, DEVICE_STATE_JOINED);
    set_device_state(device, DEVICE_STATE_OPERATIONAL);

    log_security_event("Secure rejoin successful", ZB_SUCCESS);
    return ZB_SUCCESS;
}

/* ============================================================
 * Network Key Rotation Handling
 * ============================================================ */

zigbee_error_t zigbee_handle_key_rotation(zigbee_device_t *device,
                                           const uint8_t *new_key_encrypted,
                                           uint16_t frame_len,
                                           uint8_t new_sequence_number)
{
    if (!device || !new_key_encrypted || frame_len == 0) {
        return ZB_ERR_INVALID_PARAM;
    }

    printf("[SECURITY] Processing network key rotation (new seq: %u)\n", new_sequence_number);

    /* Verify the key update came encrypted with the current network key or TC link key */
    if (!device->security.network_key.is_valid) {
        return ZB_ERR_AUTH_FAILED;
    }

    /*
     * In production: decrypt the new key using current network key or TC link key,
     * verify MIC, then install the new key.
     */

    /* Placeholder: generate new key for simulation */
    uint8_t new_network_key[ZIGBEE_MAX_NETWORK_KEY_LEN];
    zigbee_error_t err = hal_get_random_bytes(new_network_key, ZIGBEE_MAX_NETWORK_KEY_LEN);
    if (err != ZB_SUCCESS) {
        return err;
    }

    /* SECURITY: Validate the new network key */
    err = validate_key_security(new_network_key, ZIGBEE_MAX_NETWORK_KEY_LEN);
    if (err != ZB_SUCCESS) {
        log_security_event("BLOCKED: New network key failed security validation", err);
        secure_memzero(new_network_key, sizeof(new_network_key));
        return err;
    }

    /* SECURITY: Ensure new key is different from old key */
    if (memcmp(new_network_key, device->security.network_key.key,
               ZIGBEE_MAX_NETWORK_KEY_LEN) == 0) {
        log_security_event("BLOCKED: New network key same as current key", ZB_ERR_INSECURE_KEY);
        secure_memzero(new_network_key, sizeof(new_network_key));
        return ZB_ERR_INSECURE_KEY;
    }

    /* Install new key */
    memcpy(device->security.network_key.key, new_network_key, ZIGBEE_MAX_NETWORK_KEY_LEN);
    device->security.network_key.sequence_number = new_sequence_number;
    device->security.network_key.frame_counter = 0; /* Reset on key change */
    device->security.network_key.last_rotation = hal_get_time();

    hal_store_key_secure(new_network_key, ZIGBEE_MAX_NETWORK_KEY_LEN, "network_key");
    secure_memzero(new_network_key, sizeof(new_network_key));

    log_security_event("Network key rotation completed", ZB_SUCCESS);
    return ZB_SUCCESS;
}

/* ============================================================
 * Device Leave / Factory Reset
 * ============================================================ */

zigbee_error_t zigbee_leave_network(zigbee_device_t *device)
{
    if (!device) {
        return ZB_ERR_INVALID_PARAM;
    }

    printf("[NETWORK] Leaving network and clearing security material\n");

    set_device_state(device, DEVICE_STATE_LEAVE);

    /* SECURITY: Securely erase all key material */
    secure_memzero(device->security.network_key.key, ZIGBEE_MAX_NETWORK_KEY_LEN);
    device->security.network_key.is_valid = false;
    device->security.network_key.frame_counter = 0;

    secure_memzero(device->security.trust_center_link_key.key, ZIGBEE_MAX_LINK_KEY_LEN);
    device->security.trust_center_link_key.is_valid = false;
    device->security.trust_center_link_key.is_authorized = false;
    device->security.trust_center_link_key.incoming_frame_counter = 0;
    device->security.trust_center_link_key.outgoing_frame_counter = 0;

    device->is_commissioned = false;
    device->pan_id = 0;
    device->short_address = 0;
    device->channel = 0;

    /* Disable permit join */
    zigbee_disable_permit_join(device);

    set_device_state(device, DEVICE_STATE_INITIALIZED);

    log_security_event("Network leave completed - all keys erased", ZB_SUCCESS);
    return ZB_SUCCESS;
}

/* ============================================================
 * Status and Diagnostics
 * ============================================================ */

void zigbee_print_security_status(const zigbee_device_t *device)
{
    if (!device) {
        printf("[STATUS] Device not initialized\n");
        return;
    }

    printf("\n=== Zigbee Smart Light Bulb Security Status ===\n");
    printf("Device State:           %d\n", device->state);
    printf("Commissioned:           %s\n", device->is_commissioned ? "YES" : "NO");
    printf("Join Method:            %d\n", device->join_method);
    printf("Security Level:         %d (ENC-MIC-128: %s)\n",
           device->security.security_level,
           device->security.security_level >= SECURITY_LEVEL_ENC_MIC_128 ? "YES" : "NO");
    printf("Encrypted Transport:    %s\n",
           device->security.require_encrypted_transport ? "REQUIRED" : "DISABLED (INSECURE!)");
    printf("Install Code Join:      %s\n",
           device->security.require_install_code_join ? "REQUIRED" : "NOT REQUIRED");
    printf("Well-Known Key Blocked: %s\n",
           !device->security.allow_well_known_key ? "YES (SECURE)" : "NO (INSECURE!)");
    printf("Unencrypted Rejoin:     %s\n",
           !device->security.allow_unencrypted_rejoin ? "BLOCKED (SECURE)" : "ALLOWED (INSECURE!)");
    printf("TC Auth Required:       %s\n",
           device->security.require_trust_center_auth ? "YES" : "NO");
    printf("Frame Counter Check:    %s\n",
           device->security.enable_frame_counter_check ? "ENABLED" : "DISABLED (INSECURE!)");
    printf("Network Key Valid:      %s\n",
           device->security.network_key.is_valid ? "YES" : "NO");
    printf("TC Link Key Valid:      %s\n",
           device->security.trust_center_link_key.is_valid ? "YES" : "NO");
    printf("TC Link Key Authorized: %s\n",
           device->security.trust_center_link_key.is_authorized ? "YES" : "NO");
    printf("Install Code Programmed:%s\n",
           device->security.install_code.is_programmed ? "YES" : "NO");
    printf("Permit Join Active:     %s\n",
           is_permit_join_active((zigbee_device_t *)device) ? "YES" : "NO");
    printf("Permit Join Timeout:    %u sec (max: %u)\n",
           (unsigned)device->security.permit_join_timeout_sec,
           device->security.max_permit_join_timeout);
    printf("NWK Frame Counter:      %u / %u\n",
           device->security.network_key.frame_counter,
           device->security.network_key.max_frame_counter);
    printf("================================================\n\n");
}

/* ============================================================
 * Callback Implementations
 *