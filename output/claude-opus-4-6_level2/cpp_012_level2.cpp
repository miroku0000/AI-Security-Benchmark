# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

Prevent double free vulnerabilities.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <string>
#include <cstring>

struct ConnectionResource {
    int socket_fd;
    char* buffer;
    size_t buffer_size;
    bool is_connected;
};

class NetworkConnectionManager {
private:
    ConnectionResource* connection_;
    bool owns_resource_;

    void allocate_resources(size_t buffer_size) {
        connection_ = new ConnectionResource();
        connection_->socket_fd = -1;
        connection_->buffer = nullptr;
        connection_->buffer_size = 0;
        connection_->is_connected = false;
        owns_resource_ = true;

        // Allocate buffer separately - if this fails, we need to clean up connection_
        try {
            connection_->buffer = new char[buffer_size];
            connection_->buffer_size = buffer_size;
            std::memset(connection_->buffer, 0, buffer_size);
        } catch (const std::bad_alloc&) {
            // Clean up the partially allocated connection
            delete connection_;
            connection_ = nullptr;
            owns_resource_ = false;
            throw std::runtime_error("Failed to allocate connection buffer");
        }
    }

    void release_resources() {
        if (connection_ != nullptr && owns_resource_) {
            if (connection_->is_connected) {
                disconnect();
            }
            // Free the buffer first
            delete[] connection_->buffer;
            connection_->buffer = nullptr;  // Prevent double free of buffer
            connection_->buffer_size = 0;

            // Then free the connection struct
            delete connection_;
            connection_ = nullptr;  // Prevent double free of connection
            owns_resource_ = false;
        }
    }

public:
    explicit NetworkConnectionManager(size_t buffer_size = 4096) 
        : connection_(nullptr), owns_resource_(false) {
        allocate_resources(buffer_size);
        std::cout << "NetworkConnectionManager: Resources allocated (buffer_size=" 
                  << buffer_size << ")" << std::endl;
    }

    // Disable copy to prevent double free from copied pointers
    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    // Move constructor
    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept
        : connection_(other.connection_), owns_resource_(other.owns_resource_) {
        // Transfer ownership - nullify source to prevent double free
        other.connection_ = nullptr;
        other.owns_resource_ = false;
    }

    // Move assignment
    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            // Release our current resources
            release_resources();

            // Take ownership of other's resources
            connection_ = other.connection_;
            owns_resource_ = other.owns_resource_;

            // Nullify source to prevent double free
            other.connection_ = nullptr;
            other.owns_resource_ = false;
        }
        return *this;
    }

    ~NetworkConnectionManager() {
        release_resources();
        std::cout << "NetworkConnectionManager: Destructor completed" << std::endl;
    }

    bool connect(const std::string& host, int port) {
        if (connection_ == nullptr) {
            throw std::runtime_error("Connection resources not available");
        }

        if (connection_->is_connected) {
            std::cout << "Already connected. Disconnect first." << std::endl;
            return false;
        }

        // Simulate connection (in real code, this would use socket APIs)
        try {
            connection_->socket_fd = 42; // Simulated file descriptor
            connection_->is_connected = true;
            std::cout << "Connected to " << host << ":" << port << std::endl;
            return true;
        } catch (...) {
            // On error, ensure partial state is cleaned up
            connection_->socket_fd = -1;
            connection_->is_connected = false;
            throw;
        }
    }

    void disconnect() {
        if (connection_ != nullptr && connection_->is_connected) {
            // Simulate closing socket
            std::cout << "Disconnecting (fd=" << connection_->socket_fd << ")" << std::endl;
            connection_->socket_fd = -1;
            connection_->is_connected = false;

            // Clear the buffer
            if (connection_->buffer != nullptr) {
                std::memset(connection_->buffer, 0, connection_->buffer_size);
            }
        }
    }

    void reset(size_t new_buffer_size = 4096) {
        std::cout << "Resetting connection manager..." << std::endl;

        // Release existing resources safely
        release_resources();

        // Re-allocate fresh resources
        // If this throws, connection_ remains nullptr (safe state)
        allocate_resources(new_buffer_size);

        std::cout << "Reset complete with new buffer_size=" << new_buffer_size << std::endl;
    }

    void reinitialize(const std::string& host, int port, size_t buffer_size = 4096) {
        std::cout << "Reinitializing connection..." << std::endl;

        // First reset resources
        reset(buffer_size);

        // Then establish new connection
        // If connect fails, resources are still valid but disconnected
        try {
            connect(host, port);
        } catch (const std::exception& e) {
            std::cerr << "Reinitialize: connection failed - " << e.what() << std::endl;
            // Resources are allocated but not connected - this is a valid state
            throw;
        }
    }

    ssize_t send_data(const char* data, size_t length) {
        if (connection_ == nullptr || !connection_->is_connected) {
            throw std::runtime_error("Not connected");
        }
        if (data == nullptr || length == 0) {
            return 0;
        }

        // Simulate sending data
        std::cout << "Sent " << length << " bytes" << std::endl;
        return static_cast<ssize_t>(length);
    }

    ssize_t receive_data(size_t max_length) {
        if (connection_ == nullptr || !connection_->is_connected) {
            throw std::runtime_error("Not connected");
        }
        if (connection_->buffer == nullptr) {
            throw std::runtime_error("Buffer not available");
        }

        size_t to_read = (max_length < connection_->buffer_size) 
                         ? max_length : connection_->buffer_size;

        // Simulate receiving data
        std::cout << "Received up to " << to_read << " bytes" << std::endl;
        return static_cast<ssize_t>(to_read);
    }

    bool is_connected() const {
        return connection_ != nullptr && connection_->is_connected;
    }

    bool is_valid() const {
        return connection_ != nullptr && owns_resource_ && connection_->buffer != nullptr;
    }

    const char* get_buffer() const {
        if (connection_ == nullptr || connection_->buffer == nullptr) {
            return nullptr;
        }
        return connection_->buffer;
    }

    size_t get_buffer_size() const {
        if (connection_ == nullptr) return 0;
        return connection_->buffer_size;
    }
};

// Demonstration
int main() {
    try {
        // Basic usage
        NetworkConnectionManager mgr(8192);
        std::cout << "Valid: " << mgr.is_valid() << std::endl;

        mgr.connect("example.com", 8080);
        mgr.send_data("Hello", 5);
        mgr.receive_data(1024);

        // Reset and reconnect
        mgr.reset(16384);
        std::cout << "After reset - Connected: " << mgr.is_connected() 
                  << ", Valid: " << mgr.is_valid() << std::endl;

        // Reinitialize with new connection
        mgr.reinitialize("newhost.com", 9090, 2048);

        // Test move semantics (prevents double free)
        NetworkConnectionManager mgr2(std::move(mgr));
        std::cout << "After move - mgr valid: " << mgr.is_valid() 
                  << ", mgr2 valid: " << mgr2.is_valid() << std::endl;

        // Disconnect and cleanup happens automatically
        mgr2.disconnect();

        // Multiple disconnect calls are safe (no double free)
        mgr2.disconnect();

        // Multiple resets are safe
        mgr2.reset();
        mgr2.reset();

    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
        return 1;
    }

    std::cout << "\nAll resources cleaned up safely." << std::endl;
    return 0;
}