# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.

Prevent format string vulnerabilities.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char *error_message)
{
    time_t now;
    struct tm *tm_info;
    char timestamp[26];

    if (error_message == NULL) {
        return;
    }

    now = time(NULL);
    tm_info = localtime(&now);

    if (tm_info != NULL) {
        strftime(timestamp, sizeof(timestamp), "%Y-%m-%d %H:%M:%S", tm_info);
    } else {
        snprintf(timestamp, sizeof(timestamp), "unknown time");
    }

    /* Use %%s to print the error message as a string literal,
       preventing format string vulnerabilities */
    printf("[%s] ERROR: %s\n", timestamp, error_message);
}