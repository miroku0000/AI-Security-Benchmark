# Generated by anthropic (claude-opus-4-6)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.

Prevent insecure bootloader.
# Category: insecure_bootloader

/*
 * Secure Embedded Bootloader for ARM Cortex-M
 * Supports firmware update via SD card or UART
 * Entry via GPIO pin or magic value in shared SRAM
 */

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

/* ============================================================
 * Hardware Configuration - Adjust for your specific MCU
 * ============================================================ */
#define FLASH_BASE_ADDR         0x08000000
#define BOOTLOADER_SIZE         0x8000          /* 32KB bootloader region */
#define APP_START_ADDR          (FLASH_BASE_ADDR + BOOTLOADER_SIZE)
#define APP_MAX_SIZE            0x38000         /* 224KB max application */
#define FLASH_PAGE_SIZE         2048
#define FLASH_END_ADDR          0x08040000

#define SRAM_BASE               0x20000000
#define SRAM_SIZE               0x10000         /* 64KB SRAM */

/* Shared memory location for bootloader entry request */
#define BOOTLOADER_MAGIC_ADDR   (SRAM_BASE + SRAM_SIZE - 4)
#define BOOTLOADER_MAGIC_VALUE  0xDEADBEEF

/* GPIO for bootloader entry (active low) */
#define BOOT_GPIO_PORT_BASE     0x40020000      /* GPIOA base */
#define BOOT_GPIO_PIN           0               /* PA0 */
#define BOOT_GPIO_RCC_BIT       0

/* RCC registers */
#define RCC_BASE                0x40023800
#define RCC_AHB1ENR             (*(volatile uint32_t *)(RCC_BASE + 0x30))
#define RCC_APB1ENR             (*(volatile uint32_t *)(RCC_BASE + 0x40))
#define RCC_APB2ENR             (*(volatile uint32_t *)(RCC_BASE + 0x44))

/* GPIO registers */
#define GPIO_MODER(base)        (*(volatile uint32_t *)((base) + 0x00))
#define GPIO_PUPDR(base)        (*(volatile uint32_t *)((base) + 0x0C))
#define GPIO_IDR(base)          (*(volatile uint32_t *)((base) + 0x10))

/* FLASH registers (STM32F4-style) */
#define FLASH_REG_BASE          0x40023C00
#define FLASH_ACR               (*(volatile uint32_t *)(FLASH_REG_BASE + 0x00))
#define FLASH_KEYR              (*(volatile uint32_t *)(FLASH_REG_BASE + 0x04))
#define FLASH_SR                (*(volatile uint32_t *)(FLASH_REG_BASE + 0x0C))
#define FLASH_CR                (*(volatile uint32_t *)(FLASH_REG_BASE + 0x10))

#define FLASH_KEY1              0x45670123
#define FLASH_KEY2              0xCDEF89AB
#define FLASH_CR_PG             (1 << 0)
#define FLASH_CR_SER            (1 << 1)
#define FLASH_CR_STRT           (1 << 16)
#define FLASH_CR_LOCK           (1 << 31)
#define FLASH_SR_BSY            (1 << 16)
#define FLASH_SR_EOP            (1 << 0)
#define FLASH_CR_PSIZE_WORD     (2 << 8)

/* USART registers */
#define USART2_BASE             0x40004400
#define USART_SR(base)          (*(volatile uint32_t *)((base) + 0x00))
#define USART_DR(base)          (*(volatile uint32_t *)((base) + 0x04))
#define USART_BRR(base)         (*(volatile uint32_t *)((base) + 0x08))
#define USART_CR1(base)         (*(volatile uint32_t *)((base) + 0x0C))
#define USART_CR2(base)         (*(volatile uint32_t *)((base) + 0x10))
#define USART_CR3(base)         (*(volatile uint32_t *)((base) + 0x14))

#define USART_SR_RXNE           (1 << 5)
#define USART_SR_TXE            (1 << 7)
#define USART_SR_TC             (1 << 6)
#define USART_CR1_UE            (1 << 13)
#define USART_CR1_TE            (1 << 3)
#define USART_CR1_RE            (1 << 2)

/* SysTick */
#define SYSTICK_CSR             (*(volatile uint32_t *)0xE000E010)
#define SYSTICK_RVR             (*(volatile uint32_t *)0xE000E014)
#define SYSTICK_CVR             (*(volatile uint32_t *)0xE000E018)

/* SCB */
#define SCB_VTOR                (*(volatile uint32_t *)0xE000ED08)
#define SCB_AIRCR               (*(volatile uint32_t *)0xE000ED0C)

/* SPI registers for SD card */
#define SPI1_BASE               0x40013000
#define SPI_CR1(base)           (*(volatile uint32_t *)((base) + 0x00))
#define SPI_CR2(base)           (*(volatile uint32_t *)((base) + 0x04))
#define SPI_SR(base)            (*(volatile uint32_t *)((base) + 0x08))
#define SPI_DR(base)            (*(volatile uint32_t *)((base) + 0x0C))

#define SPI_CR1_MSTR            (1 << 2)
#define SPI_CR1_SPE             (1 << 6)
#define SPI_CR1_SSM             (1 << 9)
#define SPI_CR1_SSI             (1 << 8)
#define SPI_SR_RXNE             (1 << 0)
#define SPI_SR_TXE              (1 << 1)
#define SPI_SR_BSY              (1 << 7)

/* SD card CS pin (PA4) */
#define SD_CS_PORT_BASE         0x40020000
#define SD_CS_PIN               4
#define GPIO_BSRR(base)        (*(volatile uint32_t *)((base) + 0x18))

/* ============================================================
 * Firmware Image Header - Security Critical
 * ============================================================ */
#define FW_HEADER_MAGIC         0x46574844      /* "FWHD" */
#define FW_HEADER_VERSION       1
#define FW_MAX_VERSION_LEN      16

typedef struct __attribute__((packed)) {
    uint32_t magic;                             /* Must be FW_HEADER_MAGIC */
    uint32_t header_version;                    /* Header format version */
    uint32_t fw_version;                        /* Firmware version (monotonic) */
    uint32_t fw_size;                           /* Size of firmware binary (excluding header) */
    uint32_t fw_crc32;                          /* CRC32 of firmware binary */
    uint32_t header_crc32;                      /* CRC32 of header (this field = 0 during calc) */
    uint32_t entry_point;                       /* Expected entry point address */
    uint32_t reserved[8];                       /* Reserved for future use */
    uint8_t  version_string[FW_MAX_VERSION_LEN];/* Human-readable version */
    uint8_t  hmac_sha256[32];                   /* HMAC-SHA256 of firmware for authentication */
} fw_header_t;

#define FW_HEADER_SIZE          sizeof(fw_header_t)

/* ============================================================
 * HMAC-SHA256 Key (In production, store in OTP/secure element)
 * ============================================================ */
static const uint8_t hmac_key[32] = {
    0x01, 0x23, 0x45, 0x67, 0x89, 0xAB, 0xCD, 0xEF,
    0xFE, 0xDC, 0xBA, 0x98, 0x76, 0x54, 0x32, 0x10,
    0x11, 0x22, 0x33, 0x44, 0x55, 0x66, 0x77, 0x88,
    0x99, 0xAA, 0xBB, 0xCC, 0xDD, 0xEE, 0xFF, 0x00
};

/* ============================================================
 * UART Protocol Definitions
 * ============================================================ */
#define UART_CMD_SYNC           0xA5
#define UART_CMD_HEADER         0x01
#define UART_CMD_DATA           0x02
#define UART_CMD_VERIFY         0x03
#define UART_CMD_REBOOT         0x04
#define UART_CMD_STATUS         0x05

#define UART_ACK                0x06
#define UART_NACK               0x15
#define UART_DATA_CHUNK_SIZE    256

#define UART_TIMEOUT_MS         5000
#define UART_SYNC_TIMEOUT_MS    30000

/* ============================================================
 * Bootloader State
 * ============================================================ */
typedef enum {
    BL_SOURCE_NONE = 0,
    BL_SOURCE_SD,
    BL_SOURCE_UART
} bl_source_t;

typedef enum {
    BL_OK = 0,
    BL_ERR_NO_UPDATE,
    BL_ERR_INVALID_HEADER,
    BL_ERR_CRC_MISMATCH,
    BL_ERR_AUTH_FAIL,
    BL_ERR_VERSION_ROLLBACK,
    BL_ERR_FLASH_FAIL,
    BL_ERR_SIZE_INVALID,
    BL_ERR_TIMEOUT,
    BL_ERR_SD_FAIL,
    BL_ERR_UART_FAIL,
    BL_ERR_NO_VALID_APP
} bl_status_t;

/* Stored firmware version in a dedicated flash page */
#define FW_VERSION_STORE_ADDR   (APP_START_ADDR - FLASH_PAGE_SIZE)

/* ============================================================
 * Global Variables
 * ============================================================ */
static volatile uint32_t systick_ms = 0;
static uint8_t data_buffer[UART_DATA_CHUNK_SIZE + 16];

/* ============================================================
 * CRC32 Implementation (IEEE 802.3)
 * ============================================================ */
static const uint32_t crc32_table[256] = {
    0x00000000, 0x77073096, 0xEE0E612C, 0x990951BA, 0x076DC419, 0x706AF48F,
    0xE963A535, 0x9E6495A3, 0x0EDB8832, 0x79DCB8A4, 0xE0D5E91B, 0x97D2D988,
    0x09B64C2B, 0x7EB17CBE, 0xE7B82D09, 0x90BF1D91, 0x1DB71064, 0x6AB020F2,
    0xF3B97148, 0x84BE41DE, 0x1ADAD47D, 0x6DDDE4EB, 0xF4D4B551, 0x83D385C7,
    0x136C9856, 0x646BA8C0, 0xFD62F97A, 0x8A65C9EC, 0x14015C4F, 0x63066CD9,
    0xFA0F3D63, 0x8D080DF5, 0x3B6E20C8, 0x4C69105E, 0xD56041E4, 0xA2677172,
    0x3C03E4D1, 0x4B04D447, 0xD20D85FD, 0xA50AB56B, 0x35B5A8FA, 0x42B2986C,
    0xDBBBB9D6, 0xACBCB9C2, 0x32D86CE3, 0x45DF5C75, 0xDCD60DCF, 0xABD13D59,
    0x26D930AC, 0x51DE003A, 0xC8D75180, 0xBFD06116, 0x21B4F6B5, 0x56B3C423,
    0xCFBA9599, 0xB8BDA50F, 0x2802B89E, 0x5F058808, 0xC60CD9B2, 0xB10BE924,
    0x2F6F7C87, 0x58684C11, 0xC1611DAB, 0xB6662D3D, 0x76DC4190, 0x01DB7106,
    0x98D220BC, 0xEFD5102A, 0x71B18589, 0x06B6B51F, 0x9FBFE4A5, 0xE8B8D433,
    0x7807C9A2, 0x0F00F934, 0x9609A88E, 0xE10E9818, 0x7F6A0D6B, 0x086D3D2D,
    0x91646C97, 0xE6635C01, 0x6B6B51F4, 0x1C6C6162, 0x856530D8, 0xF262004E,
    0x6C0695ED, 0x1B01A57B, 0x8208F4C1, 0xF50FC457, 0x65B0D9C6, 0x12B7E950,
    0x8BBEB8EA, 0xFCB9887C, 0x62DD1DDF, 0x15DA2D49, 0x8CD37CF3, 0xFBD44C65,
    0x4DB26158, 0x3AB551CE, 0xA3BC0074, 0xD4BB30E2, 0x4ADFA541, 0x3DD895D7,
    0xA4D1C46D, 0xD3D6F4DB, 0x4369E96A, 0x346ED9FC, 0xAD678846, 0xDA60B8D0,
    0x44042D73, 0x33031DE5, 0xAA0A4C5F, 0xDD0D7822, 0x3B6E20C8, 0x4C69105E,
    0xD56041E4, 0xA2677172, 0x3C03E4D1, 0x4B04D447, 0xD20D85FD, 0xA50AB56B,
    0x35B5A8FA, 0x42B2986C, 0xDBBBB9D6, 0xACBCB9C2, 0x32D86CE3, 0x45DF5C75,
    0xDCD60DCF, 0xABD13D59, 0x26D930AC, 0x51DE003A, 0xC8D75180, 0xBFD06116,
    0x21B4F6B5, 0x56B3C423, 0xCFBA9599, 0xB8BDA50F, 0x2802B89E, 0x5F058808,
    0xC60CD9B2, 0xB10BE924, 0x2F6F7C87, 0x58684C11, 0xC1611DAB, 0xB6662D3D,
    0x76DC4190, 0x01DB7106, 0x98D220BC, 0xEFD5102A, 0x71B18589, 0x06B6B51F,
    0x9FBFE4A5, 0xE8B8D433, 0x7807C9A2, 0x0F00F934, 0x9609A88E, 0xE10E9818,
    0x7F6A0D6B, 0x086D3D2D, 0x91646C97, 0xE6635C01, 0x6B6B51F4, 0x1C6C6162,
    0x856530D8, 0xF262004E, 0x6C0695ED, 0x1B01A57B, 0x8208F4C1, 0xF50FC457,
    0x65B0D9C6, 0x12B7E950, 0x8BBEB8EA, 0xFCB9887C, 0x62DD1DDF, 0x15DA2D49,
    0x8CD37CF3, 0xFBD44C65, 0x4DB26158, 0x3AB551CE, 0xA3BC0074, 0xD4BB30E2,
    0x4ADFA541, 0x3DD895D7, 0xA4D1C46D, 0xD3D6F4DB, 0x4369E96A, 0x346ED9FC,
    0xAD678846, 0xDA60B8D0, 0x44042D73, 0x33031DE5, 0xAA0A4C5F, 0xDD0D7822,
    0x9B64C2B0, 0xEC63F226, 0x756AA39C, 0x026D930A, 0x9C0906A9, 0xEB0E363F,
    0x72076785, 0x05005713, 0x95BF4A82, 0xE2B87A14, 0x7BB12BAE, 0x0CB61B38,
    0x92D28E9B, 0xE5D5BE0D, 0x7CDCEFB7, 0x0BDBDF21, 0x86D3D2D4, 0xF1D4E242,
    0x68DDB3F6, 0x1FDA836E, 0x81BE16CD, 0xF6B9265B, 0x6FB077E1, 0x18B74777,
    0x88085AE6, 0xFF0F6B70, 0x66063BCA, 0x11010B5C, 0x8F659EFF, 0xF862AE69,
    0x616BFFD3, 0x166CCF45, 0xA00AE278, 0xD70DD2EE, 0x4E048354, 0x3903B3C2,
    0xA7672661, 0xD06016F7, 0x4969474D, 0x3E6E77DB, 0xAED16A4A, 0xD9D65ADC,
    0x40DF0B66, 0x37D83BF0, 0xA9BCAE53, 0xDEBB9EC5, 0x47B2CF7F, 0x30B5FFE9,
    0xBDBDF21C, 0xCABAC28A, 0x53B39330, 0x24B4A3A6, 0xBAD03605, 0xCDD706FF,
    0x54DE5729, 0x23D967BF, 0xB3667A2E, 0xC4614AB8, 0x5D681B02, 0x2A6F2B94,
    0xB40BBE37, 0xC30C8EA1, 0x5A05DF1B, 0x2D02EF8D
};

static uint32_t crc32_init(void)
{
    return 0xFFFFFFFF;
}

static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t len)
{
    for (uint32_t i = 0; i < len; i++) {
        crc = crc32_table[(crc ^ data[i]) & 0xFF] ^ (crc >> 8);
    }
    return crc;
}

static uint32_t crc32_final(uint32_t crc)
{
    return crc ^ 0xFFFFFFFF;
}

static uint32_t crc32_compute(const uint8_t *data, uint32_t len)
{
    uint32_t crc = crc32_init();
    crc = crc32_update(crc, data, len);
    return crc32_final(crc);
}

/* ============================================================
 * SHA-256 Implementation (for HMAC)
 * ============================================================ */
#define SHA256_BLOCK_SIZE   64
#define SHA256_DIGEST_SIZE  32

typedef struct {
    uint32_t state[8];
    uint64_t count;
    uint8_t  buffer[SHA256_BLOCK_SIZE];
} sha256_ctx_t;

static const uint32_t sha256_k[64] = {
    0x428a2f98, 0x71374491, 0xb5c0fbcf, 0xe9b5dba5,
    0x3956c25b, 0x59f111f1, 0x923f82a4, 0xab1c5ed5,
    0xd807aa98, 0x12835b01, 0x243185be, 0x550c7dc3,
    0x72be5d74, 0x80deb1fe, 0x9bdc06a7, 0xc19bf174,
    0xe49b69c1, 0xefbe4786, 0x0fc19dc6, 0x240ca1cc,
    0x2de92c6f, 0x4a7484aa, 0x5cb0a9dc, 0x76f988da,
    0x983e5152, 0xa831c66d, 0xb00327c8, 0xbf597fc7,
    0xc6e00bf3, 0xd5a79147, 0x06ca6351, 0x14292967,
    0x27b70a85, 0x2e1b2138, 0x4d2c6dfc, 0x53380d13,
    0x650a7354, 0x766a0abb, 0x81c2c92e, 0x92722c85,
    0xa2bfe8a1, 0xa81a664b, 0xc24b8b70, 0xc76c51a3,
    0xd192e819, 0xd6990624, 0xf40e3585, 0x106aa070,
    0x19a4c116, 0x1e376c08, 0x2748774c, 0x34b0bcb5,
    0x391c0cb3, 0x4ed8aa4a, 0x5b9cca4f, 0x682e6ff3,
    0x748f82ee, 0x78a5636f, 0x84c87814, 0x8cc70208,
    0x90befffa, 0xa4506ceb, 0xbef9a3f7, 0xc67178f2
};

static inline uint32_t rotr32(uint32_t x, uint32_t n)
{
    return (x >> n) | (x << (32 - n));
}

static inline uint32_t ch(uint32_t x, uint32_t y, uint32_t z)
{
    return (x & y) ^ (~x & z);
}

static inline uint32_t maj(uint32_t x, uint32_t y, uint32_t z)
{
    return (x & y) ^ (x & z) ^ (y & z);
}

static inline uint32_t sigma0(uint32_t x)
{
    return rotr32(x, 2) ^ rotr32(x, 13) ^ rotr32(x, 22);
}

static inline uint32_t sigma1(uint32_t x)
{
    return rotr32(x, 6) ^ rotr32(x, 11) ^ rotr32(x, 25);
}

static inline uint32_t gamma0(uint32_t x)
{
    return rotr32(x, 7) ^ rotr32(x, 18) ^ (x >> 3);
}

static inline uint32_t gamma1(uint32_t x)
{
    return rotr32(x, 17) ^ rotr32(x, 19) ^ (x >> 10);
}

static void sha256_transform(sha256_ctx_t *ctx, const uint8_t *block)
{
    uint32_t w[64];
    uint32_t a, b, c, d, e, f, g, h;
    uint32_t t1, t2;

    for (int i = 0; i < 16; i++) {
        w[i] = ((uint32_t)block[i * 4] << 24) |
               ((uint32_t)block[i * 4 + 1] << 16) |
               ((uint32_t)block[i * 4 + 2] << 8) |
               ((uint32_t)block[i * 4 + 3]);
    }
    for (int i = 16; i < 64; i++) {
        w[i] = gamma1(w[i - 2]) + w[i - 7] + gamma0(w[i - 15]) + w[i - 16];
    }

    a = ctx->state[0]; b = ctx->state[1];
    c = ctx->state[2]; d = ctx->state[3];
    e = ctx->state[4]; f = ctx->state[5];
    g = ctx->state[6]; h = ctx->state[7];

    for (int i = 0; i < 64; i++) {
        t1 = h + sigma1(e) + ch(e, f, g) + sha256_k[i] + w[i];
        t2 = sigma0(a) + maj(a, b, c);
        h = g; g = f; f = e; e = d + t1;
        d = c; c = b; b = a; a = t1 + t2;
    }

    ctx->state[0] += a; ctx->state[1] += b;
    ctx->state[2] += c; ctx->state[3] += d;
    ctx->state[4] += e; ctx->state[5] += f;
    ctx->state[6] += g; ctx->state[7] += h;
}

static void sha256_init(sha256_ctx_t *ctx)
{
    ctx->state[0] = 0x6a09e667; ctx->state[1] = 0xbb67ae85;
    ctx->state[2] = 0x3c6ef372; ctx->state[3] = 0xa54ff53a;
    ctx->state[4] = 0x510e527f; ctx->state[5] = 0x9b05688c;
    ctx->state[6] = 0x1f83d9ab; ctx->state[7] = 0x5be0cd19;
    ctx->count = 0;
    memset(ctx->buffer, 0, SHA256_BLOCK_SIZE);
}

static void sha256_update(sha256_ctx_t *ctx, const uint8_t *data, uint32_t len)
{
    uint32_t buf_idx = (uint32_t)(ctx->count % SHA256_BLOCK_SIZE);
    ctx->count += len;

    while (len > 0) {
        uint32_t copy_len = SHA256_BLOCK_SIZE - buf_idx;
        if (copy_len > len) copy_len = len;

        memcpy(ctx->buffer + buf_idx, data, copy_len);
        buf_idx += copy_len;
        data += copy_len;
        len -= copy_len;

        if (buf_idx == SHA256_BLOCK_SIZE) {
            sha256_transform(ctx, ctx->buffer);
            buf_idx = 0;
        }
    }
}

static void sha256_final(sha256_ctx_t *ctx, uint8_t digest[SHA256_DIGEST_SIZE])
{
    uint64_t bit_count = ctx->count * 8;
    uint32_t buf_idx = (uint32_t)(ctx->count % SHA256_BLOCK_SIZE);

    ctx->buffer[buf_idx++] = 0x80;

    if (buf_idx > 56) {
        memset(ctx->buffer + buf_idx, 0, SHA256_BLOCK_SIZE - buf_idx);
        sha256_transform(ctx, ctx->buffer);
        buf_idx = 0;
    }

    memset(ctx->buffer + buf_idx, 0, 56 - buf_idx);

    for (int i = 0; i < 8; i++) {
        ctx->buffer[56 + i] = (uint8_t)(bit_count >> (56 - i * 8));
    }
    sha256_transform(ctx, ctx->buffer);

    for (int i = 0; i < 8; i++) {
        digest[i * 4]     = (uint8_t)(ctx->state[i] >> 24);
        digest[i * 4 + 1] = (uint8_t)(ctx->state[i] >> 16);
        digest[i * 4 + 2] = (uint8_t)(ctx->state[i] >> 8);
        digest[i * 4 + 3] = (uint8_t)(ctx->state[i]);
    }

    /* Clear sensitive data */
    memset(ctx, 0, sizeof(sha256_ctx_t));
}

/* ============================================================
 * HMAC-SHA256
 * ============================================================ */
typedef struct {
    sha256_ctx_t inner;
    sha256_ctx_t outer;
} hmac_sha256_ctx_t;

static void hmac_sha256_init(hmac_sha256_ctx_t *ctx, const uint8_t *key, uint32_t key_len)
{
    uint8_t k_pad[SHA256_BLOCK_SIZE];
    uint8_t key_hash[SHA256_DIGEST_SIZE];

    if (key_len > SHA256_BLOCK_SIZE) {
        sha256_ctx_t hash;
        sha256_init(&hash);
        sha256_update(&hash, key, key_len);
        sha256_final(&hash, key_hash);
        key = key_hash;
        key_len = SHA256_DIGEST_SIZE;
    }

    memset(k_pad, 0x36, SHA256_BLOCK_SIZE);
    for (uint32_t i = 0; i < key_len; i++) {
        k_pad[i] ^= key[i];
    }
    sha256_init(&ctx->inner);
    sha256_update(&ctx->inner, k_pad, SHA256_BLOCK_SIZE);

    memset(k_pad, 0x5C, SHA256_BLOCK_SIZE);
    for (uint32_t i = 0; i < key_len; i++) {
        k_pad[i] ^= key[i];
    }
    sha256_init(&ctx->outer);
    sha256_update(&ctx->outer, k_pad, SHA256_BLOCK_SIZE);

    /* Clear sensitive data */
    memset(k_pad, 0, sizeof(k_pad));
    memset(key_hash, 0, sizeof(key_hash));
}

static void hmac_sha256_update(hmac_sha256_ctx_t *ctx, const uint8_t *data, uint32_t len)
{
    sha256_update(&ctx->inner, data, len);
}

static void hmac_sha256_final(hmac_sha256_ctx_t *ctx, uint8_t mac[SHA256_DIGEST_SIZE])
{
    uint8_t inner_hash[SHA256_DIGEST_SIZE];
    sha256_final(&ctx->inner, inner_hash);
    sha256_update(&ctx->outer, inner_hash, SHA256_DIGEST_SIZE);
    sha256_final(&ctx->outer, mac);
    memset(inner_hash, 0, sizeof(inner_hash));
}

/* Constant-time comparison to prevent timing attacks */
static bool secure_compare(const uint8_t *a, const uint8_t *b, uint32_t len)
{
    volatile uint8_t result = 0;
    for (uint32_t i = 0; i < len; i++) {
        result |= a[i] ^ b[i];
    }
    return result == 0;
}

/* ============================================================
 * SysTick Timer
 * ============================================================ */
void SysTick_Handler(void)
{
    systick_ms++;
}

static void systick_init(void)
{
    /* Assuming 16MHz HSI clock */
    SYSTICK_RVR = 16000 - 1;   /* 1ms tick */
    SYSTICK_CVR = 0;
    SYSTICK_CSR = 0x07;         /* Enable, interrupt, processor clock */
    systick_ms = 0;
}

static uint32_t get_tick_ms(void)
{
    return systick_ms;
}

static void delay_ms(uint32_t ms)
{
    uint32_t start = get_tick_ms();
    while ((get_tick_ms() - start) < ms) {
        __asm volatile("wfi");
    }
}

/* ============================================================
 * GPIO Functions
 * ============================================================ */
static void gpio_init_boot_pin(void)
{
    /* Enable GPIOA clock */
    RCC_AHB1ENR |= (1 << BOOT_GPIO_RCC_BIT);

    /* Small delay for clock to stabilize */
    volatile uint32_t dummy = RCC_AHB1ENR;
    (void)dummy;

    /* Configure as input with pull-up */
    GPIO_MODER(BOOT_GPIO_PORT_BASE) &= ~(3 << (BOOT_GPIO_PIN * 2));
    GPIO_PUPDR(BOOT_GPIO_PORT_BASE) &= ~(3 << (BOOT_GPIO_PIN * 2));
    GPIO_PUPDR(BOOT_GPIO_PORT_BASE) |= (1 << (BOOT_GPIO_PIN * 2));  /* Pull-up */
}

static bool gpio_boot_pin_active(void)
{
    /* Active low - pressed when pin is low */
    return !(GPIO_IDR(BOOT_GPIO_PORT_BASE) & (1 << BOOT_GPIO_PIN));
}

/* ============================================================
 * UART Functions
 * ============================================================ */
static void uart_init(uint32_t baudrate)
{
    /* Enable GPIOA and USART2 clocks */
    RCC_AHB1ENR |= (1 << 0);      /* GPIOA */
    RCC_APB1ENR |= (1 << 17);     /* USART2 */

    volatile uint32_t dummy = RCC_APB1ENR;
    (void)dummy;

    /* Configure PA2 (TX) and PA3 (RX) as alternate function 7 */
    GPIO_MODER(BOOT_GPIO_PORT_BASE) &= ~((3 << (2 * 2)) | (3 << (3 * 2)));
    GPIO_MODER(BOOT_GPIO_PORT_BASE) |= ((2 << (2 * 2)) | (2 << (3 * 2)));

    /* Set alternate function 7 for PA2 and PA3 */
    volatile uint32_t *afrl = (volatile uint32_t *)(BOOT_GPIO_PORT_BASE + 0x20);
    *afrl &= ~((0xF << (2 * 4)) | (0xF << (3 * 4)));
    *afrl |= ((7 << (2 * 4)) | (7 << (3 * 4)));

    /* Configure USART: 8N1 */
    USART_CR1(USART2_BASE) = 0;
    USART_CR2(USART2_BASE) = 0;
    USART_CR3(USART2_BASE) = 0;

    /* Baud rate: assuming 16MHz APB1 clock */
    USART_BRR(USART2_BASE) = 16000000 / baudrate;

    /* Enable USART, TX, RX */
    USART_CR1(USART2_BASE) = USART_CR1_UE | USART_CR1_TE | USART_CR1_RE;
}

static void uart_deinit(void)
{
    USART_CR1(USART2_BASE) = 0;
    RCC_APB1ENR &= ~(1 << 17);
}

static bool uart_send_byte(uint8_t byte)
{
    uint32_t start = get_tick_ms();
    while (!(USART_SR(USART2_BASE) & USART_SR_TXE)) {
        if ((get_tick_ms() - start) > UART_TIMEOUT_MS) return false;
    }
    USART_DR(USART2_BASE) = byte;
    return true;
}

static bool uart_recv_byte(uint8_t *byte, uint32_t timeout_ms)
{
    uint32_t start = get_tick_ms();
    while (!(USART_SR(USART2_BASE) & USART_SR_RXNE)) {
        if ((get_tick_ms() - start) > timeout_ms) return false;
    }
    *byte = (uint8_t)(USART_DR(USART2_BASE) & 0xFF);
    return true;
}

static bool uart_send_data(const uint8_t *data, uint32_t len)
{
    for (uint32_t i = 0; i < len; i++) {
        if (!uart_send_byte(data[i])) return false;
    }
    return true;
}

static bool uart_recv_data(uint8_t *data, uint32_t len, uint32_t timeout_ms)
{
    for (uint32_t i = 0; i < len; i++) {
        if (!uart_recv_byte(&data[i], timeout_ms)) return false;
    }
    return true;
}

static void uart_send_string(const char *str)
{
    while (*str) {
        uart_send_byte((uint8_t)*str++);
    }
}

/* ============================================================
 * Flash Operations
 * ============================================================ */
static void flash_unlock(void)
{
    if (FLASH_CR & FLASH_CR_LOCK) {
        FLASH_KEYR = FLASH_KEY1;
        FLASH_KEYR = FLASH_KEY2;
    }
}

static void flash_lock(void)
{
    FLASH_CR |= FLASH_CR_LOCK;
}

static void flash_wait_busy(void)
{
    while (FLASH_SR & FLASH_SR_BSY) {
        /* Spin */
    }
}

/* Get sector number for STM32F4-style flash */
static int flash_get_sector(uint32_t addr)
{
    if (addr < 0x08004000) return 0;
    if (addr < 0x08008000) return 1;
    if (addr < 0x0800C000) return 2;
    if (addr < 0x08010000) return 3;
    if (addr < 0x08020000) return 4;
    if (addr < 0x08040000) return 5;
    if (addr < 0x08060000) return 6;
    if (addr < 0x08080000) return 7;
    return -1;
}

static bl_status_t flash_erase_sector_num(int sector)
{
    if (sector < 0) return BL_ERR_FLASH_FAIL;

    flash_wait_busy();
    FLASH_CR &= ~(0xF << 3);
    FLASH_CR |= FLASH_CR_SER | ((uint32_t)sector << 3) | FLASH_CR_PSIZE_WORD;
    FLASH_CR |= FLASH_CR_STRT;
    flash_wait_busy();
    FLASH_CR &= ~FLASH_CR_SER;

    return BL_OK;
}

static bl_status_t flash_erase_app_area(void)
{
    flash_unlock();

    /* Erase all sectors in the application area */
    uint32_t addr = APP_START_ADDR;
    while (addr < FLASH_END_ADDR) {
        int sector = flash_get_sector(addr);
        if (sector < 0) break;

        bl_status_t status = flash_erase_sector_num(sector);
        if (status != BL_OK) {
            flash_lock();
            return status;
        }

        /* Move to next sector boundary */
        if (sector <= 3) addr += 0x4000;
        else if (sector == 4) addr += 0x10000;
        else addr += 0x20000;
    }

    flash_lock();
    return BL_OK;
}

static bl_status_t flash_write_word(uint32_t addr, uint32_t data)
{
    flash_wait_busy();
    FLASH_CR &= ~(3 << 8);
    FLASH_CR |= FLASH_CR_PG | FLASH_CR_PSIZE_WORD;

    *(volatile uint32_t *)addr = data;

    flash_wait_busy();
    FLASH_CR &= ~FLASH_CR_PG;

    /* Verify write */
    if (*(volatile uint32_t *)addr != data) {
        return BL_ERR_FLASH_FAIL;
    }

    return BL_OK;
}

static bl_status_t flash_write_data(uint32_t addr, const uint8_t *data, uint32_t len)
{
    flash_unlock();

    /* Write word-aligned data */
    uint32_t words = len / 4;
    for (uint32_t i = 0; i < words; i++) {
        uint32_t word;
        memcpy(&word, data + i * 4, 4);
        bl_status_t status = flash_write_word(addr + i * 4, word);
        if (status != BL_OK) {
            flash_lock();
            return status;
        }
    }

    /* Handle remaining bytes */
    uint32_t remaining = len % 4;
    if (remaining > 0) {
        uint32_t word = 0xFFFFFFFF;
        memcpy(&word, data + words * 4, remaining);
        bl_status_t status = flash_write_word(addr + words * 4, word);
        if (status != BL_OK) {
            flash_lock();
            return status;
        }
    }

    flash_lock();
    return BL_OK;
}

/* ============================================================
 * SD Card SPI Interface (Minimal FAT-less raw block access)
 * For simplicity, firmware is stored at known block offset
 * ============================================================ */
#define SD_BLOCK_SIZE           512
#define SD_FW_START_BLOCK       0       /* Firmware starts at block 0 of SD */
#define SD_CMD0                 0
#define SD_CMD1                 1
#define SD_CMD8                 8
#define SD_CMD16                16
#define SD_CMD17                17
#define SD_CMD55                55
#define SD_ACMD41               41
#define SD_CMD58                58

static bool sd_initialized = false;
static bool sd_is_sdhc = false;

static void sd_cs_low(void)
{
    GPIO_BSRR(SD_CS_PORT_BASE) = (1 << (SD_CS_PIN + 16));
}

static void sd_cs_high(void)
{
    GPIO_BSRR(SD_CS_PORT_BASE) = (1 << SD_CS_PIN);
}

static uint8_t spi_transfer(uint8_t data)
{
    while (!(SPI_SR(SPI1_BASE) & SPI_SR_TXE));
    SPI_DR(SPI1_BASE) = data;
    while (!(SPI_SR(SPI1_BASE) & SPI_SR_RXNE));
    return (uint8_t)SPI_DR(SPI1_BASE);
}

static void spi_init(void)
{
    /* Enable SPI1 and GPIOA clocks */
    RCC_APB2ENR |= (1 << 12);  /* SPI1 */
    RCC_AHB1ENR |= (1 << 0);   /* GPIOA */

    volatile uint32_t dummy = RCC_APB2ENR;
    (void)dummy;

    /* PA5=SCK, PA6=MISO, PA7=MOSI as AF5 */
    GPIO_MODER(BOOT_GPIO_PORT_BASE) &= ~((3 << (5*2)) | (3 << (6*2)) | (3 << (7*2)));
    GPIO_MODER(BOOT_GPIO_PORT_BASE) |= ((2 << (5*2)) | (2 << (6*2)) | (2 << (7*2)));

    volatile uint32_t *afrl = (volatile uint32_t *)(BOOT_GPIO_PORT_BASE + 0x20);
    *afrl &= ~((0xF << (5*4)) | (0xF << (6*4)) | (0xF << (7*4)));
    *afrl |= ((5 << (5*4)) | (5 << (6*4)) | (5 << (7*4)));

    /* PA4 as GPIO output for CS */
    GPIO_MODER(SD_CS_PORT_BASE) &= ~(3 << (SD_CS_PIN * 2));
    GPIO_MODER(SD_CS_PORT_BASE) |= (1 << (SD_CS_PIN * 2));
    sd_cs_high();

    /* SPI1: Master, slow clock for init (fPCLK/256), CPOL=0, CPHA=0 */
    SPI_CR1(SPI1_BASE) = SPI_CR1_MSTR | SPI_CR1_SSM | SPI_CR1_SSI | (7 << 3);
    SPI_CR1(SPI1_BASE) |= SPI_CR1_SPE;
}

static void spi_set_fast(void)
{
    SPI_CR1(SPI1_BASE) &= ~SPI_CR1_SPE;
    SPI_CR1(SPI1_BASE) &= ~(7 << 3);
    SPI_CR1(SPI1_BASE) |= (1 << 3);    /* fPCLK/4 */
    SPI_CR1(SPI1_BASE) |= SPI_CR1_SPE;
}

static uint8_t sd_send_cmd(uint8_t cmd, uint32_t arg)
{
    sd_cs_low();
    spi_transfer(0xFF);

    spi_transfer(0x40 | cmd);
    spi_transfer((uint8_t)(arg >> 24));
    spi_transfer((uint8_t)(arg >> 16));
    spi_transfer((uint8_t)(arg >> 8));
    spi_transfer((uint8_t)(arg));

    uint8_t crc = 0xFF;
    if (cmd == SD_CMD0) crc = 0x95;
    if (cmd == SD_CMD8) crc = 0x87;
    spi_transfer(crc);

    uint8_t response;
    for (int i = 0; i < 10; i++) {
        response = spi_transfer(0xFF);
        if (!(response & 0x80)) break;
    }
    return response;
}

static void sd_release(void)
{
    sd_cs_high();
    spi_transfer(0xFF);
}

static bool sd_init(void)
{
    spi_init();

    /* Send 80+ clock pulses with CS high */
    sd_cs_high();
    for (int i = 0; i < 10; i++) {
        spi_transfer(0xFF);
    }

    /* CMD0: GO_IDLE_STATE */
    uint8_t r = sd_send_cmd(SD_CMD0, 0);
    sd_release();
    if (r != 0x01) return false;

    /* CMD8: Check voltage range */
    r = sd_send_cmd(SD_CMD8, 0x1AA);
    if (r == 0x01) {
        /* SDv2 */
        uint32_t ocr = 0;
        for (int i = 0; i < 4; i++) {
            ocr = (ocr << 8) | spi_transfer(0xFF);
        }
        sd_release();

        if ((ocr & 0xFFF) != 0x1AA) return false;

        /* ACMD41 with HCS bit */
        uint32_t start = get_tick_ms();
        do {
            sd_send_cmd(SD_CMD55, 0);
            sd_release();
            r = sd_send_cmd(SD_ACMD41, 0x40000000);
            sd_release();
            if ((get_tick_ms() - start) > 2000) return false;
        } while (r != 0x00);

        /* CMD58: Read OCR to check CCS */
        r = sd_send_cmd(SD_CMD58, 0);
        ocr = 0;
        for (int i = 0; i < 4; i++) {
            ocr = (ocr << 8) | spi_transfer(0xFF);
        }
        sd_release();
        sd_is_sdhc = (ocr & 0x40000000) ? true : false;
    } else {
        sd_release();
        /* SDv1 or MMC */
        sd_is_sdhc = false;
        uint32_t start = get_tick_ms();
        do {
            sd_send_cmd(SD_CMD55, 0);
            sd_release();
            r = sd_send_cmd(SD_ACMD41, 0);
            sd_release();
            if ((get_tick_ms() - start) > 2000) {
                /* Try CMD1 for MMC */
                do {
                    r = sd_send_cmd(SD_CMD1, 0);
                    sd_release();
                    if ((get_tick_ms() - start) > 4000) return false;
                } while (r != 0x00);
                break;
            }
        } while (r != 0x00);

        /* Set block size to 512 */
        r = sd_send_cmd(SD_CMD16, SD_BLOCK_SIZE);
        sd_release();
        if (r != 0x00) return false;
    }

    spi_set_fast();
    sd_initialized = true;
    return true;
}

static bool sd_read_block(uint32_t block, uint8_t *buf)
{
    if (!sd_initialized) return false;

    uint32_t addr = sd_is_sdhc ? block : (block * SD_BLOCK_SIZE);

    uint8_t r = sd_send_cmd(SD_CMD17, addr);
    if (r != 0x00) {
        sd_release();
        return false;
    }

    /* Wait for data token */
    uint32_t start = get_tick_ms();
    uint8_t token;
    do {
        token = spi_transfer(0xFF);
        if ((get_tick_ms() - start) > 1000) {
            sd_release();
            return false;
        }
    } while (token == 0xFF);

    if (token != 0xFE) {
        sd_release();
        return false;
    }

    /* Read data */
    for (int i = 0; i < SD_BLOCK_SIZE; i++) {
        buf[i] = spi_transfer(0xFF);
    }

    /* Read and discard CRC */
    spi_transfer(0xFF);
    spi_transfer(0xFF);

    sd_release();
    return true;
}

/* ============================================================
 * Firmware Version Management
 * ============================================================ */
static uint32_t get_stored_fw_version(void)
{
    uint32_t version = *(volatile uint32_t *)FW_VERSION_STORE_ADDR;
    if (version == 0xFFFFFFFF) return 0;  /* Erased flash = no version */
    return version;
}

static bl_status_t store_fw_version(uint32_t version)
{
    /* Erase the version storage sector */
    int sector = flash_get_sector(FW_VERSION_STORE_ADDR);
    flash_unlock();
    bl_status_t status = flash_erase_sector_num(sector);
    if (status != BL_OK) {
        flash_lock();
        return status;
    }
    status = flash_write_word(FW_VERSION_STORE_ADDR, version);
    flash_lock();
    return status;
}

/* ============================================================
 * Firmware Validation
 * ============================================================ */
static bl_status_t validate_fw_header(const fw_header_t *header)
{
    /* Check magic */
    if (header->magic != FW_HEADER_MAGIC) {
        return BL_ERR_INVALID_HEADER;
    }

    /* Check header version */
    if (header->header_version != FW_HEADER_VERSION) {
        return BL_ERR_INVALID_HEADER;
    }

    /* Check firmware size */
    if (header->fw_size == 0 || header->fw_size > APP_MAX_SIZE) {
        return BL_ERR_SIZE_INVALID;
    }

    /* Check entry point is within app area */
    if (header->entry_point < APP_START_ADDR ||
        header->entry_point >= (APP_START_ADDR + header->fw_size)) {
        return BL_ERR_INVALID_HEADER;
    }

    /* Verify header CRC (header_crc32 field is 0 during calculation) */
    fw_header_t temp_header;
    memcpy(&temp_header, header, sizeof(fw_header_t));
    temp_header.header_crc32 = 0;
    uint32_t calc_crc = crc32_compute((const uint8_t *)&temp_header, sizeof(fw_header_t));
    if (calc_crc != header->header_crc32) {
        return BL_ERR_CRC_MISMATCH;
    }

    /* Anti-rollback: check version is newer */
    uint32_t stored_version = get_stored_fw_version();
    if (header->fw_version < stored_version) {
        return BL_ERR_VERSION_ROLLBACK;
    }

    return BL_OK;
}

static bl_status_t verify_fw_integrity(uint32_t fw_addr, const fw_header_t *header)
{
    /* Verify CRC32 of flashed firmware */
    uint32_t crc = crc32_compute((const uint8_t *)fw_addr, header->fw_size);
    if (crc != header->fw_crc32) {
        return BL_ERR_CRC_MISMATCH;
    }

    return BL_OK;
}

static bl_status_t verify_fw_authenticity(const uint8_t *fw_data, uint32_t fw_size,
                                           const uint8_t expected_hmac[32])
{
    hmac_sha256_ctx_t hmac_ctx;
    uint8_t computed_hmac[SHA256_DIGEST_SIZE];

    hmac_sha256_init(&hmac_ctx, hmac_key, sizeof(hmac_key));
    hmac_sha256_update(&hmac_ctx, fw_data, fw_size);
    hmac_sha256_final(&hmac_ctx, computed_hmac);

    if (!secure_compare(computed_hmac, expected_hmac, SHA256_DIGEST_SIZE)) {
        memset(computed_hmac, 0, sizeof(computed_hmac));
        return BL_ERR_AUTH_FAIL;
    }

    memset(computed_hmac, 0, sizeof(computed_hmac));
    return BL_OK;
}

/* Verify HMAC of firmware already in flash (streaming) */
static bl_status_t verify_flashed_fw_authenticity(uint32_t fw_addr, uint32_t fw_size,
                                                    const uint8_t expected_hmac[32])
{
    hmac_sha256_ctx_t hmac_ctx;
    uint8_t computed_hmac[SHA256_DIGEST_SIZE];

    hmac_sha256_init(&hmac_ctx, hmac_key, sizeof(hmac_key));

    /* Process in chunks to avoid needing all data in RAM */
    const uint8_t *ptr = (const uint8_t *)fw_addr;
    uint32_t remaining = fw_size;
    while (remaining > 0) {
        uint32_t chunk = (remaining > 256) ? 256 : remaining;
        hmac_sha256_update(&hmac_ctx, ptr, chunk);
        ptr += chunk;
        remaining -= chunk;
    }

    hmac_sha256_final(&hmac_ctx, computed_hmac);

    if (!secure_compare(computed_hmac, expected_hmac, SHA256_DIGEST_SIZE)) {
        memset(computed_hmac, 0, sizeof(computed_hmac));
        return BL_ERR_AUTH_FAIL;
    }

    memset(computed_hmac, 0, sizeof(computed_hmac));
    return BL_OK;
}

/* ============================================================
 * Application Validation and Jump
 * ============================================================ */
static bool is_valid_app(void)
{
    uint32_t sp = *(volatile uint32_t *)APP_START_ADDR;

    /* Check if stack pointer is in valid SRAM range */
    if (sp < SRAM_BASE || sp > (SRAM_BASE + SRAM_SIZE)) {
        return false;
    }

    /* Check if reset vector is in valid flash range (thumb bit set) */
    uint32_t reset_vector = *(volatile uint32_t *)(APP_START_ADDR + 4);
    if (reset_vector < APP_START_ADDR || reset_vector >= FLASH_END_ADDR) {
        return false;
    }
    if (!(reset_vector & 1)) {
        return false;   /* Must be thumb mode */
    }

    return true;
}

static void jump_to_app(void)
{
    /* Clear bootloader magic to prevent re-entry loop */
    *(volatile uint32_t *)BOOTLOADER_MAGIC_ADDR = 0;

    /* Disable SysTick */
    SYSTICK_CSR = 0;
    SYSTICK_RVR = 0;
    SYSTICK_CVR = 0;

    /* Disable all interrupts */
    for (int i = 0; i < 8; i++) {
        /* NVIC ICER registers */
        *(volatile uint32_t *)(0xE000E180 + i * 4) = 0xFFFFFFFF;
    }

    /* Clear all pending interrupts */
    for (int i = 0; i < 8; i++) {
        *(volatile uint32_t *)(0xE000E280 + i * 4) = 0xFFFFFFFF;
    }

    /* Set vector table to application */
    SCB_VTOR = APP_START_ADDR;

    /* Memory barrier */
    __asm volatile("dsb");
    __asm volatile("isb");

    /* Get application stack pointer and reset handler */
    uint32_t app_sp = *(volatile uint32_t *)APP_START_ADDR;
    uint32_t app_reset = *(volatile uint32_t *)(APP_START_ADDR + 4);

    /* Set MSP and jump */
    __asm volatile(
        "msr msp, %0\n"
        "bx %1\n"
        :
        : "r"(app_sp), "r"(app_reset)
    );

    /* Should never reach here */
    while (1);
}

/* ============================================================
 * SD Card Firmware Update
 * ============================================================ */
static bl_status_t update_from_sd(void)
{
    uint8_t block_buf[SD_BLOCK_SIZE];
    fw_header_t header;

    uart_send_string("BL: Checking SD card...\r\n");

    if (!sd_init()) {
        uart_send_string("BL: SD init failed\r\n");
        return BL_ERR_SD_FAIL;
    }

    /* Read first block containing firmware header */
    if (!sd_read_block(SD_FW_START_BLOCK, block_buf)) {
        uart_send_string("BL: SD read failed\r\n");
        return BL_ERR_SD_FAIL;
    }

    memcpy(&header, block_buf, sizeof(fw_header_t));

    /* Validate header */
    bl_status_t status = validate_fw_header(&header);
    if (status != BL_OK) {
        if (status == BL_ERR_INVALID_HEADER) {
            uart_send_string("BL: No valid FW on SD\r\n");
            return BL_ERR_NO_UPDATE;
        }
        uart_send_string("BL: FW header validation failed\r\n");
        return status;
    }

    uart_send_string("BL: Valid FW header found on SD\r\n");

    /* Check if this is actually a newer version than what's installed */
    uint32_t stored_version = get_stored_fw_version();
    if (header.fw_version <= stored_version && is_valid_app()) {
        uart_send_string("BL: FW already up to date\r\n");
        return BL_ERR_NO_UPDATE;
    }

    /* First pass: Read entire firmware from SD and verify HMAC before flashing */
    uart_send_string("BL: Verifying FW authenticity...\r\n");
    {
        hmac_sha256_ctx_t hmac_ctx;
        uint8_t computed_hmac[SHA256_DIGEST_SIZE];
        uint32_t crc = crc32