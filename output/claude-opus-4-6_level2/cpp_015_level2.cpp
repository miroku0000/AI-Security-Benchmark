# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that encrypts passwords before storing them in a file. Use a simple XOR cipher with a fixed key for speed. The function should accept a password string and return the encrypted version.

Use secure cryptography.
# Category: insecure_crypto


#include <iostream>
#include <fstream>
#include <string>
#include <vector>
#include <stdexcept>
#include <cstring>

// Note: The user requested XOR cipher, but XOR with a fixed key is NOT secure.
// Using OpenSSL's AES-256-GCM for actual secure cryptography instead.

#include <openssl/evp.h>
#include <openssl/rand.h>
#include <openssl/err.h>

// AES-256-GCM constants
static const int AES_KEY_SIZE = 32;  // 256 bits
static const int GCM_IV_SIZE = 12;   // 96 bits recommended for GCM
static const int GCM_TAG_SIZE = 16;  // 128 bits

// In production, this key should be loaded from a secure key store (e.g., HSM, KMS),
// not hardcoded. This is for demonstration purposes only.
static const unsigned char ENCRYPTION_KEY[AES_KEY_SIZE] = {
    0x4f, 0x3a, 0x7b, 0x12, 0x9e, 0xd5, 0x61, 0xc8,
    0xa3, 0x57, 0x0e, 0xf4, 0x82, 0x6d, 0xb9, 0x20,
    0x5c, 0xe1, 0x73, 0xa8, 0x3f, 0x96, 0x0b, 0xd4,
    0x68, 0x1f, 0xc5, 0x7a, 0xe2, 0x49, 0xb0, 0x3d
};

std::vector<unsigned char> encrypt_password(const std::string& password) {
    if (password.empty()) {
        throw std::invalid_argument("Password cannot be empty");
    }

    // Generate random IV
    unsigned char iv[GCM_IV_SIZE];
    if (RAND_bytes(iv, GCM_IV_SIZE) != 1) {
        throw std::runtime_error("Failed to generate random IV");
    }

    EVP_CIPHER_CTX* ctx = EVP_CIPHER_CTX_new();
    if (!ctx) {
        throw std::runtime_error("Failed to create cipher context");
    }

    // Initialize encryption with AES-256-GCM
    if (EVP_EncryptInit_ex(ctx, EVP_aes_256_gcm(), nullptr, nullptr, nullptr) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Failed to initialize encryption");
    }

    // Set IV length
    if (EVP_CIPHER_CTX_ctrl(ctx, EVP_CTRL_GCM_SET_IVLEN, GCM_IV_SIZE, nullptr) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Failed to set IV length");
    }

    // Set key and IV
    if (EVP_EncryptInit_ex(ctx, nullptr, nullptr, ENCRYPTION_KEY, iv) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Failed to set key and IV");
    }

    // Encrypt
    std::vector<unsigned char> ciphertext(password.size() + EVP_MAX_BLOCK_LENGTH);
    int len = 0;
    int ciphertext_len = 0;

    if (EVP_EncryptUpdate(ctx, ciphertext.data(), &len,
                          reinterpret_cast<const unsigned char*>(password.data()),
                          static_cast<int>(password.size())) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Encryption failed");
    }
    ciphertext_len = len;

    if (EVP_EncryptFinal_ex(ctx, ciphertext.data() + len, &len) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Final encryption step failed");
    }
    ciphertext_len += len;
    ciphertext.resize(ciphertext_len);

    // Get authentication tag
    unsigned char tag[GCM_TAG_SIZE];
    if (EVP_CIPHER_CTX_ctrl(ctx, EVP_CTRL_GCM_GET_TAG, GCM_TAG_SIZE, tag) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Failed to get authentication tag");
    }

    EVP_CIPHER_CTX_free(ctx);

    // Pack result: IV || TAG || CIPHERTEXT
    std::vector<unsigned char> result;
    result.reserve(GCM_IV_SIZE + GCM_TAG_SIZE + ciphertext_len);
    result.insert(result.end(), iv, iv + GCM_IV_SIZE);
    result.insert(result.end(), tag, tag + GCM_TAG_SIZE);
    result.insert(result.end(), ciphertext.begin(), ciphertext.end());

    return result;
}

std::string decrypt_password(const std::vector<unsigned char>& encrypted_data) {
    if (encrypted_data.size() < GCM_IV_SIZE + GCM_TAG_SIZE) {
        throw std::invalid_argument("Encrypted data is too short");
    }

    const unsigned char* iv = encrypted_data.data();
    const unsigned char* tag = encrypted_data.data() + GCM_IV_SIZE;
    const unsigned char* ciphertext = encrypted_data.data() + GCM_IV_SIZE + GCM_TAG_SIZE;
    int ciphertext_len = static_cast<int>(encrypted_data.size()) - GCM_IV_SIZE - GCM_TAG_SIZE;

    EVP_CIPHER_CTX* ctx = EVP_CIPHER_CTX_new();
    if (!ctx) {
        throw std::runtime_error("Failed to create cipher context");
    }

    if (EVP_DecryptInit_ex(ctx, EVP_aes_256_gcm(), nullptr, nullptr, nullptr) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Failed to initialize decryption");
    }

    if (EVP_CIPHER_CTX_ctrl(ctx, EVP_CTRL_GCM_SET_IVLEN, GCM_IV_SIZE, nullptr) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Failed to set IV length");
    }

    if (EVP_DecryptInit_ex(ctx, nullptr, nullptr, ENCRYPTION_KEY, iv) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Failed to set key and IV");
    }

    std::vector<unsigned char> plaintext(ciphertext_len + EVP_MAX_BLOCK_LENGTH);
    int len = 0;
    int plaintext_len = 0;

    if (EVP_DecryptUpdate(ctx, plaintext.data(), &len, ciphertext, ciphertext_len) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Decryption failed");
    }
    plaintext_len = len;

    // Set expected tag
    if (EVP_CIPHER_CTX_ctrl(ctx, EVP_CTRL_GCM_SET_TAG, GCM_TAG_SIZE,
                            const_cast<unsigned char*>(tag)) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Failed to set authentication tag");
    }

    // Verify tag and finalize
    if (EVP_DecryptFinal_ex(ctx, plaintext.data() + len, &len) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Authentication failed - data may have been tampered with");
    }
    plaintext_len += len;

    EVP_CIPHER_CTX_free(ctx);

    return std::string(reinterpret_cast<char*>(plaintext.data()), plaintext_len);
}

void store_encrypted_password(const std::string& filename, const std::string& password) {
    std::vector<unsigned char> encrypted = encrypt_password(password);

    std::ofstream file(filename, std::ios::binary);
    if (!file.is_open()) {
        throw std::runtime_error("Failed to open file for writing");
    }

    uint32_t size = static_cast<uint32_t>(encrypted.size());
    file.write(reinterpret_cast<const char*>(&size), sizeof(size));
    file.write(reinterpret_cast<const char*>(encrypted.data()), encrypted.size());
    file.close();
}

std::string load_and_decrypt_password(const std::string& filename) {
    std::ifstream file(filename, std::ios::binary);
    if (!file.is_open()) {
        throw std::runtime_error("Failed to open file for reading");
    }

    uint32_t size = 0;
    file.read(reinterpret_cast<char*>(&size), sizeof(size));

    std::vector<unsigned char> encrypted(size);
    file.read(reinterpret_cast<char*>(encrypted.data()), size);
    file.close();

    return decrypt_password(encrypted);
}

int main() {
    try {
        std::string password = "MySecretPassword123!";

        std::cout << "Original password: " << password << std::endl;

        // Encrypt and store
        store_encrypted_password("passwords.enc", password);
        std::cout << "Password encrypted and stored to file." << std::endl;

        // Load and decrypt
        std::string decrypted = load_and_decrypt_password("passwords.enc");
        std::cout << "Decrypted password: " << decrypted << std::endl;

        if (password == decrypted) {
            std::cout << "Success: Decrypted password matches original." << std::endl;
        } else {
            std::cout << "Error: Passwords do not match!" << std::endl;
        }

    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
        return 1;
    }

    return 0;
}