# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

Prevent memory leaks.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

#define MAX_REQUEST_SIZE 4096
#define MAX_RESPONSE_SIZE 8192
#define MAX_HEADERS 50
#define MAX_URI_LENGTH 1024
#define MAX_METHOD_LENGTH 16

typedef struct {
    char method[MAX_METHOD_LENGTH];
    char uri[MAX_URI_LENGTH];
    char *headers[MAX_HEADERS];
    int header_count;
    char *body;
    size_t body_length;
} HttpRequest;

typedef struct {
    int status_code;
    char *status_text;
    char *body;
    size_t body_length;
    char *headers[MAX_HEADERS];
    int header_count;
} HttpResponse;

static HttpRequest *parse_request(const char *raw_request, size_t length) {
    if (!raw_request || length == 0) {
        return NULL;
    }

    HttpRequest *request = calloc(1, sizeof(HttpRequest));
    if (!request) {
        fprintf(stderr, "Failed to allocate HttpRequest\n");
        return NULL;
    }

    request->header_count = 0;
    request->body = NULL;
    request->body_length = 0;

    /* Parse request line */
    const char *line_end = strstr(raw_request, "\r\n");
    if (!line_end) {
        free(request);
        return NULL;
    }

    /* Extract method */
    const char *p = raw_request;
    const char *space = strchr(p, ' ');
    if (!space || space > line_end) {
        free(request);
        return NULL;
    }
    size_t method_len = (size_t)(space - p);
    if (method_len >= MAX_METHOD_LENGTH) {
        method_len = MAX_METHOD_LENGTH - 1;
    }
    memcpy(request->method, p, method_len);
    request->method[method_len] = '\0';

    /* Extract URI */
    p = space + 1;
    space = strchr(p, ' ');
    if (!space || space > line_end) {
        free(request);
        return NULL;
    }
    size_t uri_len = (size_t)(space - p);
    if (uri_len >= MAX_URI_LENGTH) {
        uri_len = MAX_URI_LENGTH - 1;
    }
    memcpy(request->uri, p, uri_len);
    request->uri[uri_len] = '\0';

    /* Parse headers */
    p = line_end + 2; /* Skip \r\n */
    while (p < raw_request + length) {
        line_end = strstr(p, "\r\n");
        if (!line_end) {
            break;
        }

        /* Empty line signals end of headers */
        if (line_end == p) {
            p = line_end + 2;
            break;
        }

        if (request->header_count < MAX_HEADERS) {
            size_t header_len = (size_t)(line_end - p);
            request->headers[request->header_count] = malloc(header_len + 1);
            if (request->headers[request->header_count]) {
                memcpy(request->headers[request->header_count], p, header_len);
                request->headers[request->header_count][header_len] = '\0';
                request->header_count++;
            }
        }

        p = line_end + 2;
    }

    /* Parse body if present */
    if (p < raw_request + length) {
        request->body_length = length - (size_t)(p - raw_request);
        if (request->body_length > 0) {
            request->body = malloc(request->body_length + 1);
            if (request->body) {
                memcpy(request->body, p, request->body_length);
                request->body[request->body_length] = '\0';
            } else {
                request->body_length = 0;
            }
        }
    }

    return request;
}

static void free_request(HttpRequest *request) {
    if (!request) {
        return;
    }
    for (int i = 0; i < request->header_count; i++) {
        free(request->headers[i]);
        request->headers[i] = NULL;
    }
    free(request->body);
    request->body = NULL;
    free(request);
}

static HttpResponse *create_response(int status_code, const char *status_text,
                                      const char *content_type, const char *body) {
    HttpResponse *response = calloc(1, sizeof(HttpResponse));
    if (!response) {
        fprintf(stderr, "Failed to allocate HttpResponse\n");
        return NULL;
    }

    response->status_code = status_code;
    response->header_count = 0;

    response->status_text = strdup(status_text);
    if (!response->status_text) {
        free(response);
        return NULL;
    }

    if (body) {
        response->body_length = strlen(body);
        response->body = strdup(body);
        if (!response->body) {
            free(response->status_text);
            free(response);
            return NULL;
        }
    } else {
        response->body = NULL;
        response->body_length = 0;
    }

    /* Add Content-Type header */
    if (content_type && response->header_count < MAX_HEADERS) {
        char header_buf[256];
        snprintf(header_buf, sizeof(header_buf), "Content-Type: %s", content_type);
        response->headers[response->header_count] = strdup(header_buf);
        if (response->headers[response->header_count]) {
            response->header_count++;
        }
    }

    /* Add Content-Length header */
    if (response->header_count < MAX_HEADERS) {
        char header_buf[64];
        snprintf(header_buf, sizeof(header_buf), "Content-Length: %zu", response->body_length);
        response->headers[response->header_count] = strdup(header_buf);
        if (response->headers[response->header_count]) {
            response->header_count++;
        }
    }

    /* Add Connection header */
    if (response->header_count < MAX_HEADERS) {
        response->headers[response->header_count] = strdup("Connection: close");
        if (response->headers[response->header_count]) {
            response->header_count++;
        }
    }

    return response;
}

static char *serialize_response(const HttpResponse *response, size_t *out_length) {
    if (!response || !out_length) {
        return NULL;
    }

    char *buffer = malloc(MAX_RESPONSE_SIZE);
    if (!buffer) {
        fprintf(stderr, "Failed to allocate response buffer\n");
        return NULL;
    }

    int offset = snprintf(buffer, MAX_RESPONSE_SIZE, "HTTP/1.1 %d %s\r\n",
                           response->status_code, response->status_text);

    for (int i = 0; i < response->header_count; i++) {
        if (response->headers[i]) {
            offset += snprintf(buffer + offset, MAX_RESPONSE_SIZE - (size_t)offset,
                               "%s\r\n", response->headers[i]);
        }
    }

    offset += snprintf(buffer + offset, MAX_RESPONSE_SIZE - (size_t)offset, "\r\n");

    if (response->body && response->body_length > 0) {
        size_t remaining = MAX_RESPONSE_SIZE - (size_t)offset;
        size_t copy_len = response->body_length < remaining ? response->body_length : remaining;
        memcpy(buffer + offset, response->body, copy_len);
        offset += (int)copy_len;
    }

    *out_length = (size_t)offset;
    return buffer;
}

static void free_response(HttpResponse *response) {
    if (!response) {
        return;
    }
    free(response->status_text);
    response->status_text = NULL;
    free(response->body);
    response->body = NULL;
    for (int i = 0; i < response->header_count; i++) {
        free(response->headers[i]);
        response->headers[i] = NULL;
    }
    free(response);
}

static HttpResponse *handle_request(const HttpRequest *request) {
    if (!request) {
        return create_response(400, "Bad Request", "text/plain", "Bad Request");
    }

    if (strcmp(request->method, "GET") == 0) {
        if (strcmp(request->uri, "/") == 0 || strcmp(request->uri, "/index.html") == 0) {
            return create_response(200, "OK", "text/html",
                "<html><body><h1>Embedded Web Server</h1><p>Running.</p></body></html>");
        } else if (strcmp(request->uri, "/status") == 0) {
            return create_response(200, "OK", "application/json",
                "{\"status\":\"running\",\"uptime\":\"active\"}");
        } else if (strcmp(request->uri, "/health") == 0) {
            return create_response(200, "OK", "text/plain", "OK");
        } else {
            return create_response(404, "Not Found", "text/plain", "404 Not Found");
        }
    } else if (strcmp(request->method, "POST") == 0) {
        char *response_body = malloc(512);
        if (!response_body) {
            return create_response(500, "Internal Server Error", "text/plain",
                "Memory allocation failed");
        }
        snprintf(response_body, 512,
                 "{\"received\":true,\"uri\":\"%s\",\"body_length\":%zu}",
                 request->uri, request->body_length);
        HttpResponse *resp = create_response(200, "OK", "application/json", response_body);
        free(response_body);
        return resp;
    } else {
        return create_response(405, "Method Not Allowed", "text/plain",
            "Method Not Allowed");
    }
}

/* Simulates receiving a raw HTTP request. In a real server, this would read from a socket. */
static char *simulate_receive_request(size_t *out_length, int iteration) {
    const char *requests[] = {
        "GET / HTTP/1.1\r\nHost: localhost\r\n\r\n",
        "GET /status HTTP/1.1\r\nHost: localhost\r\n\r\n",
        "POST /data HTTP/1.1\r\nHost: localhost\r\nContent-Length: 13\r\n\r\n{\"key\":\"val\"}",
        "GET /health HTTP/1.1\r\nHost: localhost\r\n\r\n",
        "GET /nonexistent HTTP/1.1\r\nHost: localhost\r\n\r\n",
        "DELETE /resource HTTP/1.1\r\nHost: localhost\r\n\r\n",
    };
    int num_requests = (int)(sizeof(requests) / sizeof(requests[0]));
    const char *selected = requests[iteration % num_requests];

    size_t len = strlen(selected);
    char *buffer = malloc(len + 1);
    if (!buffer) {
        *out_length = 0;
        return NULL;
    }
    memcpy(buffer, selected, len + 1);
    *out_length = len;
    return buffer;
}

int main(void) {
    printf("Embedded HTTP Server starting...\n");

    bool running = true;
    int request_count = 0;
    int max_iterations = 20; /* For demonstration; remove for continuous operation */

    while (running) {
        char *raw_request = NULL;
        size_t raw_length = 0;
        HttpRequest *request = NULL;
        HttpResponse *response = NULL;
        char *response_buffer = NULL;
        size_t response_length = 0;

        /* Receive raw request data */
        raw_request = simulate_receive_request(&raw_length, request_count);
        if (!raw_request) {
            fprintf(stderr, "Failed to receive request, continuing...\n");
            goto cleanup;
        }

        /* Parse the request */
        request = parse_request(raw_request, raw_length);
        if (!request) {
            fprintf(stderr, "Failed to parse request #%d\n", request_count);
            /* Still generate an error response */
            response = create_response(400, "Bad Request", "text/plain", "Bad Request");
            if (!response) {
                goto cleanup;
            }
        } else {
            /* Handle the request and generate response */
            printf("[Request #%d] %s %s\n", request_count, request->method, request->uri);
            response = handle_request(request);
            if (!response) {
                fprintf(stderr, "Failed to create response for request #%d\n", request_count);
                goto cleanup;
            }
        }

        /* Serialize response for sending */
        response_buffer = serialize_response(response, &response_length);
        if (response_buffer) {
            /* In a real server, send response_buffer over the socket */
            printf("[Response #%d] HTTP %d %s (%zu bytes)\n",
                   request_count, response->status_code,
                   response->status_text, response_length);
        } else {
            fprintf(stderr, "Failed to serialize response #%d\n", request_count);
        }

    cleanup:
        /* Free all allocated memory for this request cycle */
        free(raw_request);
        raw_request = NULL;

        free_request(request);
        request = NULL;

        free_response(response);
        response = NULL;

        free(response_buffer);
        response_buffer = NULL;

        request_count++;

        /* For demonstration, limit iterations */
        if (request_count >= max_iterations) {
            running = false;
        }
    }

    printf("Server processed %d requests. Shutting down.\n", request_count);
    return 0;
}