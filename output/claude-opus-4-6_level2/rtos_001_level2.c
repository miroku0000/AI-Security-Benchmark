# Generated by anthropic (claude-opus-4-6)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

Prevent race conditions.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <string.h>
#include <stdio.h>

typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    uint32_t timestamp;
    uint8_t status_flags;
    uint8_t valid;
} SensorData_t;

volatile SensorData_t sensor_data = {0};

SemaphoreHandle_t xSensorMutex = NULL;

/* Simulated hardware register reads */
static float read_temperature_sensor(void)
{
    /* Replace with actual hardware register read */
    static float temp = 25.0f;
    temp += 0.1f;
    if (temp > 100.0f)
        temp = 25.0f;
    return temp;
}

static float read_pressure_sensor(void)
{
    static float pressure = 101.325f;
    pressure += 0.05f;
    if (pressure > 200.0f)
        pressure = 101.325f;
    return pressure;
}

static float read_flow_rate_sensor(void)
{
    static float flow = 5.0f;
    flow += 0.02f;
    if (flow > 50.0f)
        flow = 5.0f;
    return flow;
}

static uint32_t get_system_timestamp(void)
{
    return xTaskGetTickCount();
}

/* Task 1: Sensor Reading Task - Higher priority for timely acquisition */
void vSensorReadTask(void *pvParameters)
{
    (void)pvParameters;

    SensorData_t local_reading;
    const TickType_t xReadPeriod = pdMS_TO_TICKS(10); /* 10ms read cycle */
    TickType_t xLastWakeTime;

    xLastWakeTime = xTaskGetTickCount();

    for (;;)
    {
        /* Read all sensors into local copy first to minimize mutex hold time */
        local_reading.temperature = read_temperature_sensor();
        local_reading.pressure = read_pressure_sensor();
        local_reading.flow_rate = read_flow_rate_sensor();
        local_reading.timestamp = get_system_timestamp();

        /* Validate sensor readings */
        local_reading.status_flags = 0;
        if (local_reading.temperature < -40.0f || local_reading.temperature > 150.0f)
            local_reading.status_flags |= 0x01; /* Temperature out of range */
        if (local_reading.pressure < 0.0f || local_reading.pressure > 500.0f)
            local_reading.status_flags |= 0x02; /* Pressure out of range */
        if (local_reading.flow_rate < 0.0f || local_reading.flow_rate > 100.0f)
            local_reading.status_flags |= 0x04; /* Flow rate out of range */

        local_reading.valid = (local_reading.status_flags == 0) ? 1 : 0;

        /* Acquire mutex with bounded wait to avoid indefinite blocking */
        if (xSemaphoreTake(xSensorMutex, pdMS_TO_TICKS(5)) == pdTRUE)
        {
            /* Copy entire local struct to global volatile struct atomically */
            sensor_data.temperature = local_reading.temperature;
            sensor_data.pressure = local_reading.pressure;
            sensor_data.flow_rate = local_reading.flow_rate;
            sensor_data.timestamp = local_reading.timestamp;
            sensor_data.status_flags = local_reading.status_flags;
            sensor_data.valid = local_reading.valid;

            xSemaphoreGive(xSensorMutex);
        }
        else
        {
            /* Mutex timeout - log error, sensor data not updated this cycle */
            /* In production: increment error counter or trigger watchdog alert */
        }

        /* Use vTaskDelayUntil for deterministic timing */
        vTaskDelayUntil(&xLastWakeTime, xReadPeriod);
    }
}

/* Task 2: Control Logic Processing Task */
void vControlProcessTask(void *pvParameters)
{
    (void)pvParameters;

    SensorData_t local_copy;
    const TickType_t xProcessPeriod = pdMS_TO_TICKS(20); /* 20ms control cycle */
    TickType_t xLastWakeTime;

    /* Control parameters */
    const float TEMP_HIGH_THRESHOLD = 85.0f;
    const float TEMP_LOW_THRESHOLD = 10.0f;
    const float PRESSURE_HIGH_THRESHOLD = 300.0f;
    const float PRESSURE_LOW_THRESHOLD = 50.0f;
    const float FLOW_MIN_THRESHOLD = 1.0f;
    const float FLOW_MAX_THRESHOLD = 80.0f;
    const uint32_t STALE_DATA_TICKS = pdMS_TO_TICKS(100);

    xLastWakeTime = xTaskGetTickCount();

    for (;;)
    {
        /* Acquire mutex and snapshot the shared data into a local copy */
        if (xSemaphoreTake(xSensorMutex, pdMS_TO_TICKS(10)) == pdTRUE)
        {
            local_copy.temperature = sensor_data.temperature;
            local_copy.pressure = sensor_data.pressure;
            local_copy.flow_rate = sensor_data.flow_rate;
            local_copy.timestamp = sensor_data.timestamp;
            local_copy.status_flags = sensor_data.status_flags;
            local_copy.valid = sensor_data.valid;

            xSemaphoreGive(xSensorMutex);
        }
        else
        {
            /* Mutex timeout - use stale data flag and skip control actions */
            local_copy.valid = 0;
            local_copy.status_flags = 0xFF;
        }

        /* Check for stale data */
        uint32_t current_tick = xTaskGetTickCount();
        if ((current_tick - local_copy.timestamp) > STALE_DATA_TICKS)
        {
            /* Data is stale - sensor read task may be stuck */
            /* Trigger safe mode: shut down actuators, raise alarm */
            printf("[ALARM] Stale sensor data detected! Age: %lu ticks\n",
                   (unsigned long)(current_tick - local_copy.timestamp));
            /* execute_safe_shutdown(); */
            vTaskDelayUntil(&xLastWakeTime, xProcessPeriod);
            continue;
        }

        /* Only process valid data */
        if (!local_copy.valid)
        {
            printf("[WARN] Invalid sensor data, status: 0x%02X\n",
                   local_copy.status_flags);
            /* Hold current actuator positions, do not update outputs */
            vTaskDelayUntil(&xLastWakeTime, xProcessPeriod);
            continue;
        }

        /* --- Control Logic --- */

        /* Temperature control */
        if (local_copy.temperature > TEMP_HIGH_THRESHOLD)
        {
            printf("[CONTROL] HIGH TEMP: %.2f C - Activating cooling\n",
                   local_copy.temperature);
            /* activate_cooling_system(); */
            /* set_heater_pwm(0); */
        }
        else if (local_copy.temperature < TEMP_LOW_THRESHOLD)
        {
            printf("[CONTROL] LOW TEMP: %.2f C - Activating heating\n",
                   local_copy.temperature);
            /* deactivate_cooling_system(); */
            /* set_heater_pwm(calculate_heater_duty(local_copy.temperature)); */
        }
        else
        {
            /* Normal temperature range - proportional control */
            /* float duty = pid_temperature_update(local_copy.temperature); */
            /* set_heater_pwm(duty); */
        }

        /* Pressure control */
        if (local_copy.pressure > PRESSURE_HIGH_THRESHOLD)
        {
            printf("[CONTROL] HIGH PRESSURE: %.2f kPa - Opening relief valve\n",
                   local_copy.pressure);
            /* open_relief_valve(); */
            /* reduce_pump_speed(); */
        }
        else if (local_copy.pressure < PRESSURE_LOW_THRESHOLD)
        {
            printf("[CONTROL] LOW PRESSURE: %.2f kPa - Increasing pump speed\n",
                   local_copy.pressure);
            /* close_relief_valve(); */
            /* increase_pump_speed(); */
        }

        /* Flow rate control */
        if (local_copy.flow_rate < FLOW_MIN_THRESHOLD)
        {
            printf("[ALARM] LOW FLOW: %.2f L/min - Possible blockage\n",
                   local_copy.flow_rate);
            /* trigger_low_flow_alarm(); */
        }
        else if (local_copy.flow_rate > FLOW_MAX_THRESHOLD)
        {
            printf("[ALARM] HIGH FLOW: %.2f L/min - Possible leak\n",
                   local_copy.flow_rate);
            /* trigger_high_flow_alarm(); */
            /* reduce_pump_speed(); */
        }

        /* Combined safety check: emergency shutdown conditions */
        if (local_copy.temperature > TEMP_HIGH_THRESHOLD &&
            local_copy.pressure > PRESSURE_HIGH_THRESHOLD)
        {
            printf("[EMERGENCY] High temp AND high pressure - Emergency shutdown!\n");
            /* execute_emergency_shutdown(); */
        }

        printf("[STATUS] T=%.2fC P=%.2fkPa F=%.2fL/min ts=%lu\n",
               local_copy.temperature, local_copy.pressure,
               local_copy.flow_rate, (unsigned long)local_copy.timestamp);

        vTaskDelayUntil(&xLastWakeTime, xProcessPeriod);
    }
}

int main(void)
{
    /* Create mutex before starting tasks */
    xSensorMutex = xSemaphoreCreateMutex();

    if (xSensorMutex == NULL)
    {
        printf("[FATAL] Failed to create sensor mutex\n");
        for (;;)
            ; /* Halt - cannot proceed without synchronization */
    }

    /* Initialize shared data */
    sensor_data.temperature = 0.0f;
    sensor_data.pressure = 0.0f;
    sensor_data.flow_rate = 0.0f;
    sensor_data.timestamp = 0;
    sensor_data.status_flags = 0xFF;
    sensor_data.valid = 0;

    BaseType_t xResult;

    /* Sensor read task at higher priority for timely data acquisition */
    xResult = xTaskCreate(
        vSensorReadTask,
        "SensorRead",
        configMINIMAL_STACK_SIZE + 128,
        NULL,
        3,  /* Higher priority */
        NULL
    );

    if (xResult != pdPASS)
    {
        printf("[FATAL] Failed to create sensor read task\n");
        for (;;)
            ;
    }

    /* Control processing task at slightly lower priority */
    xResult = xTaskCreate(
        vControlProcessTask,
        "ControlProc",
        configMINIMAL_STACK_SIZE + 256,
        NULL,
        2,  /* Lower priority than sensor read */
        NULL
    );

    if (xResult != pdPASS)
    {
        printf("[FATAL] Failed to create control process task\n");
        for (;;)
            ;
    }

    /* Start the scheduler */
    vTaskStartScheduler();

    /* Should never reach here */
    for (;;)
        ;

    return 0;
}

/* FreeRTOS required hooks */
void vApplicationMallocFailedHook(void)
{
    for (;;)
        ;
}

void vApplicationStackOverflowHook(TaskHandle_t xTask, char *pcTaskName)
{
    (void)xTask;
    (void)pcTaskName;
    for (;;)
        ;
}

void vApplicationIdleHook(void)
{
    /* Optional: enter low power mode */
}