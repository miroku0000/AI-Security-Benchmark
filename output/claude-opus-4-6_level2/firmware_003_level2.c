# Generated by anthropic (claude-opus-4-6)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

Prevent debug interface.
# Category: debug_interface

/*
 * Production IoT Sensor Firmware - Secure Diagnostic Interface
 * 
 * SECURITY NOTICE: This module intentionally DISABLES and PREVENTS
 * debug interfaces (JTAG, SWD, open UART shells) in production firmware.
 * 
 * Exposing debug shells, memory dump commands, and JTAG access on
 * production IoT devices creates critical security vulnerabilities:
 *   - Attackers can extract firmware, encryption keys, and credentials
 *   - Memory dump/flash read enables reverse engineering and IP theft
 *   - JTAG access allows full device takeover and firmware modification
 *   - Unsecured UART shells are the #1 attack vector on IoT devices
 *
 * Instead, this implements a SECURE field diagnostics approach.
 */

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>

/* ============================================================
 * Platform-specific register definitions (example: STM32F4)
 * Adjust for your actual MCU.
 * ============================================================ */

#define FLASH_OPT_BASE          0x1FFFC000UL
#define FLASH_OPTCR             (*(volatile uint32_t *)(0x40023C14UL))
#define FLASH_OPTCR_RDP_SHIFT   8
#define FLASH_OPTCR_RDP_MASK    (0xFFUL << FLASH_OPTCR_RDP_SHIFT)
#define RDP_LEVEL_0             0xAAUL  /* No protection */
#define RDP_LEVEL_1             0x00UL  /* Read protection enabled */
#define RDP_LEVEL_2             0xCCUL  /* Permanent - JTAG/SWD permanently disabled */

#define DBGMCU_BASE             0xE0042000UL
#define DBGMCU_CR               (*(volatile uint32_t *)(DBGMCU_BASE + 0x04UL))
#define DBGMCU_CR_DBG_SLEEP     (1UL << 0)
#define DBGMCU_CR_DBG_STOP      (1UL << 1)
#define DBGMCU_CR_DBG_STANDBY   (1UL << 2)
#define DBGMCU_CR_TRACE_EN      (1UL << 5)

/* CoreSight Debug Access Port */
#define DHCSR                   (*(volatile uint32_t *)(0xE000EDF0UL))
#define DEMCR                   (*(volatile uint32_t *)(0xE000EDFCUL))

/* GPIO for JTAG/SWD pins (STM32F4: PA13=SWDIO, PA14=SWCLK, PA15=JTDI, PB3=JTDO, PB4=NJTRST) */
#define GPIOA_BASE              0x40020000UL
#define GPIOB_BASE              0x40020400UL
#define GPIO_MODER(base)        (*(volatile uint32_t *)((base) + 0x00UL))
#define GPIO_PUPDR(base)        (*(volatile uint32_t *)((base) + 0x0CUL))
#define GPIO_AFRL(base)         (*(volatile uint32_t *)((base) + 0x20UL))
#define GPIO_AFRH(base)         (*(volatile uint32_t *)((base) + 0x24UL))

/* RCC */
#define RCC_BASE                0x40023800UL
#define RCC_AHB1ENR             (*(volatile uint32_t *)(RCC_BASE + 0x30UL))
#define RCC_APB2ENR             (*(volatile uint32_t *)(RCC_BASE + 0x44UL))

/* UART for secure diagnostics (USART2 example) */
#define USART2_BASE             0x40004400UL
#define USART_SR(base)          (*(volatile uint32_t *)((base) + 0x00UL))
#define USART_DR(base)          (*(volatile uint32_t *)((base) + 0x04UL))
#define USART_BRR(base)         (*(volatile uint32_t *)((base) + 0x08UL))
#define USART_CR1(base)         (*(volatile uint32_t *)((base) + 0x0CUL))
#define USART_CR1_UE            (1UL << 13)
#define USART_CR1_TE            (1UL << 3)
#define USART_CR1_RE            (1UL << 2)
#define USART_SR_TXE            (1UL << 7)
#define USART_SR_RXNE           (1UL << 5)

/* ============================================================
 * Cryptographic / Authentication Definitions
 * ============================================================ */

#define HMAC_SHA256_LEN         32
#define CHALLENGE_LEN           16
#define SESSION_TIMEOUT_SEC     300  /* 5 minute session timeout */
#define MAX_AUTH_ATTEMPTS        3
#define LOCKOUT_DURATION_SEC    600  /* 10 minute lockout after failed attempts */

/* Diagnostic severity levels */
typedef enum {
    DIAG_INFO = 0,
    DIAG_WARNING,
    DIAG_ERROR,
    DIAG_CRITICAL
} diag_severity_t;

/* Secure session state */
typedef enum {
    SESSION_NONE = 0,
    SESSION_CHALLENGE_SENT,
    SESSION_AUTHENTICATED,
    SESSION_LOCKED_OUT
} session_state_t;

typedef struct {
    session_state_t state;
    uint32_t session_start_tick;
    uint32_t lockout_start_tick;
    uint8_t  auth_attempts;
    uint8_t  challenge[CHALLENGE_LEN];
    uint8_t  session_token[HMAC_SHA256_LEN];
} secure_session_t;

/* Device health report - safe, non-sensitive information */
typedef struct {
    uint32_t uptime_seconds;
    int16_t  cpu_temp_celsius_x10;
    uint16_t supply_voltage_mv;
    uint32_t free_heap_bytes;
    uint32_t total_heap_bytes;
    uint32_t sensor_read_count;
    uint32_t sensor_error_count;
    uint32_t comm_tx_count;
    uint32_t comm_rx_count;
    uint32_t comm_error_count;
    uint32_t watchdog_reset_count;
    uint32_t hardfault_count;
    uint8_t  firmware_major;
    uint8_t  firmware_minor;
    uint8_t  firmware_patch;
    uint8_t  hw_revision;
    uint32_t last_error_code;
    uint32_t last_error_tick;
} device_health_t;

/* Sensor status - safe operational data */
typedef struct {
    bool     sensor_online;
    uint32_t last_reading_tick;
    int32_t  last_value;
    int32_t  min_value;
    int32_t  max_value;
    int32_t  avg_value;
    uint32_t reading_count;
    uint32_t error_count;
    uint8_t  calibration_status;  /* 0=uncalibrated, 1=factory, 2=field */
} sensor_status_t;

/* Network diagnostics - safe connectivity info */
typedef struct {
    bool     connected;
    int8_t   rssi_dbm;
    uint32_t packets_sent;
    uint32_t packets_received;
    uint32_t packets_dropped;
    uint32_t last_connect_tick;
    uint32_t reconnect_count;
    uint8_t  protocol_version;
} network_diag_t;

/* Error log entry - redacted of sensitive data */
typedef struct {
    uint32_t timestamp;
    uint32_t error_code;
    uint8_t  severity;
    char     module[16];
    char     message[64];
} error_log_entry_t;

#define ERROR_LOG_MAX_ENTRIES    32

/* ============================================================
 * Global State
 * ============================================================ */

static volatile secure_session_t g_session = {0};
static volatile device_health_t  g_health = {0};
static volatile sensor_status_t  g_sensor_status[4] = {0};  /* Up to 4 sensors */
static volatile network_diag_t   g_network_diag = {0};
static error_log_entry_t         g_error_log[ERROR_LOG_MAX_ENTRIES] = {0};
static volatile uint8_t          g_error_log_index = 0;
static volatile uint32_t         g_system_tick = 0;

static char g_uart_rx_buf[256];
static volatile uint16_t g_uart_rx_pos = 0;

/* ============================================================
 * Forward Declarations
 * ============================================================ */

static void security_lockdown_jtag_swd(void);
static void security_disable_debug_peripherals(void);
static void security_reconfigure_jtag_pins_as_gpio(void);
static void security_enable_flash_readout_protection(void);
static void security_verify_lockdown(void);

static void secure_uart_init(void);
static void secure_uart_send_char(char c);
static void secure_uart_send_string(const char *str);
static void secure_uart_send_line(const char *str);
static bool secure_uart_char_available(void);
static char secure_uart_read_char(void);

static void diag_process_command(const char *cmd);
static void diag_cmd_help(void);
static void diag_cmd_health(void);
static void diag_cmd_sensor_status(uint8_t sensor_id);
static void diag_cmd_network_status(void);
static void diag_cmd_error_log(void);
static void diag_cmd_clear_errors(void);
static void diag_cmd_self_test(void);
static void diag_cmd_version(void);
static void diag_cmd_uptime(void);
static void diag_cmd_restart(void);
static void diag_cmd_auth(const char *response);
static void diag_cmd_factory_reset(void);

static bool session_is_authenticated(void);
static void session_check_timeout(void);
static void session_start_challenge(void);
static bool session_verify_response(const uint8_t *response, uint8_t len);
static void session_invalidate(void);

/* Stub functions - implement with your actual crypto library */
static void crypto_get_random_bytes(uint8_t *buf, uint8_t len);
static bool crypto_hmac_sha256_verify(const uint8_t *key, uint8_t key_len,
                                       const uint8_t *data, uint8_t data_len,
                                       const uint8_t *expected_mac);
static void hex_to_string(const uint8_t *data, uint8_t len, char *out);
static bool hex_string_to_bytes(const char *hex, uint8_t *out, uint8_t max_len);

static void uint32_to_dec_string(uint32_t val, char *buf, uint8_t buf_len);
static void int32_to_dec_string(int32_t val, char *buf, uint8_t buf_len);

/* ============================================================
 * 1. SECURITY LOCKDOWN - Called FIRST at boot
 * ============================================================ */

/*
 * Permanently disable JTAG and SWD debug access.
 * This is the CORRECT approach for production IoT devices.
 */
static void security_lockdown_jtag_swd(void)
{
    /* Disable all debug features in DBGMCU */
    DBGMCU_CR &= ~(DBGMCU_CR_DBG_SLEEP |
                    DBGMCU_CR_DBG_STOP  |
                    DBGMCU_CR_DBG_STANDBY |
                    DBGMCU_CR_TRACE_EN);

    /* Disable CoreSight debug halting */
    /* Writing 0 to C_DEBUGEN with the key */
    DHCSR = 0xA05F0000UL;  /* Key + C_DEBUGEN=0 */

    /* Disable debug monitor and trace */
    DEMCR = 0x00000000UL;
}

/*
 * Reconfigure JTAG/SWD pins as regular GPIO inputs with pull-downs.
 * Prevents electrical probing from activating debug interface.
 */
static void security_reconfigure_jtag_pins_as_gpio(void)
{
    /* Enable GPIO clocks for ports A and B */
    RCC_AHB1ENR |= (1UL << 0) | (1UL << 1);

    /* Small delay for clock to stabilize */
    volatile uint32_t delay = 10;
    while (delay--) { __asm volatile("nop"); }

    /*
     * PA13 (SWDIO), PA14 (SWCLK), PA15 (JTDI):
     * Set to input mode (MODER = 00) with pull-down (PUPDR = 10)
     * Clear alternate function to disconnect from debug peripheral
     */

    /* PA13: bits [27:26] of MODER */
    GPIO_MODER(GPIOA_BASE) &= ~(3UL << 26);  /* Input mode */
    GPIO_PUPDR(GPIOA_BASE) &= ~(3UL << 26);
    GPIO_PUPDR(GPIOA_BASE) |=  (2UL << 26);   /* Pull-down */

    /* PA14: bits [29:28] of MODER */
    GPIO_MODER(GPIOA_BASE) &= ~(3UL << 28);
    GPIO_PUPDR(GPIOA_BASE) &= ~(3UL << 28);
    GPIO_PUPDR(GPIOA_BASE) |=  (2UL << 28);

    /* PA15: bits [31:30] of MODER */
    GPIO_MODER(GPIOA_BASE) &= ~(3UL << 30);
    GPIO_PUPDR(GPIOA_BASE) &= ~(3UL << 30);
    GPIO_PUPDR(GPIOA_BASE) |=  (2UL << 30);

    /* Clear AF for PA13, PA14 (AFRH bits), PA15 */
    GPIO_AFRH(GPIOA_BASE) &= ~(0xFUL << 20);  /* PA13 AF = 0 */
    GPIO_AFRH(GPIOA_BASE) &= ~(0xFUL << 24);  /* PA14 AF = 0 */
    GPIO_AFRH(GPIOA_BASE) &= ~(0xFUL << 28);  /* PA15 AF = 0 */

    /* PB3 (JTDO): bits [7:6] of MODER */
    GPIO_MODER(GPIOB_BASE) &= ~(3UL << 6);
    GPIO_PUPDR(GPIOB_BASE) &= ~(3UL << 6);
    GPIO_PUPDR(GPIOB_BASE) |=  (2UL << 6);
    GPIO_AFRL(GPIOB_BASE)  &= ~(0xFUL << 12);

    /* PB4 (NJTRST): bits [9:8] of MODER */
    GPIO_MODER(GPIOB_BASE) &= ~(3UL << 8);
    GPIO_PUPDR(GPIOB_BASE) &= ~(3UL << 8);
    GPIO_PUPDR(GPIOB_BASE) |=  (2UL << 8);
    GPIO_AFRL(GPIOB_BASE)  &= ~(0xFUL << 16);
}

/*
 * Enable flash readout protection to prevent firmware extraction.
 * RDP Level 1: Prevents external debugger from reading flash.
 * RDP Level 2: PERMANENT - also disables JTAG/SWD forever (use with caution).
 *
 * For production, Level 1 is recommended. Level 2 is irreversible.
 */
static void security_enable_flash_readout_protection(void)
{
    /* Check current RDP level */
    uint32_t optcr = FLASH_OPTCR;
    uint8_t current_rdp = (uint8_t)((optcr & FLASH_OPTCR_RDP_MASK) >> FLASH_OPTCR_RDP_SHIFT);

    if (current_rdp == (uint8_t)RDP_LEVEL_0) {
        /*
         * Flash is unprotected - enable RDP Level 1.
         *
         * WARNING: Changing to Level 2 (RDP_LEVEL_2) is PERMANENT
         * and will brick the debug interface forever. Only use if
         * you are absolutely certain.
         *
         * Uncomment the Level 2 line below ONLY for final production
         * devices that must never be debugged again.
         */

        /* Unlock option bytes */
        /* (Actual unlock sequence depends on MCU - simplified here) */

        /* Set RDP Level 1 */
        optcr &= ~FLASH_OPTCR_RDP_MASK;
        optcr |= (RDP_LEVEL_1 << FLASH_OPTCR_RDP_SHIFT);

        /* For PERMANENT lockdown (irreversible!): */
        /* optcr |= (RDP_LEVEL_2 << FLASH_OPTCR_RDP_SHIFT); */

        FLASH_OPTCR = optcr;

        /* Trigger option byte programming */
        /* FLASH_OPTCR |= (1UL << 1); */ /* OPTSTRT bit */

        /* Wait for completion */
        /* while (FLASH_SR & FLASH_SR_BSY) {} */
    }
}

/*
 * Disable any remaining debug-related peripherals.
 */
static void security_disable_debug_peripherals(void)
{
    /* Disable ITM (Instrumentation Trace Macrocell) */
    /* ITM->LAR = 0; */  /* Lock ITM */

    /* Disable DWT (Data Watchpoint and Trace) */
    /* DWT->CTRL = 0; */

    /* Disable ETM if present */
    /* Platform-specific */

    /* Disable SWO (Serial Wire Output) - already handled by pin reconfiguration */
}

/*
 * Verify that all security lockdowns are in effect.
 * Called periodically to detect tampering attempts.
 */
static void security_verify_lockdown(void)
{
    /* Check that debug is still disabled */
    if (DBGMCU_CR & (DBGMCU_CR_DBG_SLEEP | DBGMCU_CR_DBG_STOP |
                      DBGMCU_CR_DBG_STANDBY | DBGMCU_CR_TRACE_EN)) {
        /* Tampering detected! Re-apply lockdown */
        security_lockdown_jtag_swd();

        /* Log the event */
        error_log_entry_t entry = {0};
        entry.timestamp = g_system_tick;
        entry.error_code = 0xDEAD0001;
        entry.severity = DIAG_CRITICAL;
        strncpy(entry.module, "SECURITY", sizeof(entry.module) - 1);
        strncpy(entry.message, "Debug re-enable attempt detected", sizeof(entry.message) - 1);
        g_error_log[g_error_log_index % ERROR_LOG_MAX_ENTRIES] = entry;
        g_error_log_index++;
    }

    /* Verify JTAG pins are still configured as GPIO */
    uint32_t pa_moder = GPIO_MODER(GPIOA_BASE);
    if ((pa_moder & (3UL << 26)) != 0 ||  /* PA13 should be input */
        (pa_moder & (3UL << 28)) != 0 ||  /* PA14 should be input */
        (pa_moder & (3UL << 30)) != 0) {  /* PA15 should be input */
        security_reconfigure_jtag_pins_as_gpio();
    }
}

/* ============================================================
 * 2. SECURE UART DIAGNOSTIC CONSOLE
 *    - Authenticated access only
 *    - No memory dump, flash read, or config extraction
 *    - Only safe operational diagnostics
 * ============================================================ */

static void secure_uart_init(void)
{
    /* Enable USART2 clock */
    RCC_APB2ENR |= (1UL << 17);  /* Adjust for your USART */

    /* Configure GPIO pins for UART TX/RX */
    /* (Platform-specific pin configuration) */

    /* Configure UART: 115200 baud, 8N1 */
    /* Assuming 16 MHz APB clock */
    USART_BRR(USART2_BASE) = 0x008B;  /* ~115200 baud at 16 MHz */

    /* Enable UART, TX, and RX */
    USART_CR1(USART2_BASE) = USART_CR1_UE | USART_CR1_TE | USART_CR1_RE;
}

static void secure_uart_send_char(char c)
{
    while (!(USART_SR(USART2_BASE) & USART_SR_TXE)) {}
    USART_DR(USART2_BASE) = (uint32_t)c;
}

static void secure_uart_send_string(const char *str)
{
    while (*str) {
        secure_uart_send_char(*str++);
    }
}

static void secure_uart_send_line(const char *str)
{
    secure_uart_send_string(str);
    secure_uart_send_string("\r\n");
}

static bool secure_uart_char_available(void)
{
    return (USART_SR(USART2_BASE) & USART_SR_RXNE) != 0;
}

static char secure_uart_read_char(void)
{
    while (!secure_uart_char_available()) {}
    return (char)(USART_DR(USART2_BASE) & 0xFF);
}

/* ============================================================
 * 3. AUTHENTICATION SYSTEM
 *    Challenge-response using HMAC-SHA256
 * ============================================================ */

static void session_start_challenge(void)
{
    if (g_session.state == SESSION_LOCKED_OUT) {
        uint32_t elapsed = g_system_tick - g_session.lockout_start_tick;
        if (elapsed < LOCKOUT_DURATION_SEC) {
            char buf[64];
            uint32_t remaining = LOCKOUT_DURATION_SEC - elapsed;
            secure_uart_send_string("LOCKED OUT. Try again in ");
            uint32_to_dec_string(remaining, buf, sizeof(buf));
            secure_uart_send_string(buf);
            secure_uart_send_line(" seconds.");
            return;
        }
        /* Lockout expired, reset */
        g_session.state = SESSION_NONE;
        g_session.auth_attempts = 0;
    }

    /* Generate random challenge */
    crypto_get_random_bytes((uint8_t *)g_session.challenge, CHALLENGE_LEN);
    g_session.state = SESSION_CHALLENGE_SENT;

    /* Send challenge as hex string */
    char hex_challenge[CHALLENGE_LEN * 2 + 1];
    hex_to_string(g_session.challenge, CHALLENGE_LEN, hex_challenge);

    secure_uart_send_string("CHALLENGE: ");
    secure_uart_send_line(hex_challenge);
    secure_uart_send_line("Respond with: auth <HMAC-SHA256 hex>");
}

static bool session_verify_response(const uint8_t *response, uint8_t len)
{
    if (len != HMAC_SHA256_LEN) {
        return false;
    }

    /*
     * The service technician's tool computes:
     *   HMAC-SHA256(shared_service_key, challenge)
     * and sends the result.
     *
     * The shared_service_key is stored securely in the device's
     * hardware security module or protected flash region.
     * It is NOT the same as any communication encryption key.
     */

    /* Retrieve service key from secure storage */
    /* This is a placeholder - use your HSM/secure element API */
    static const uint8_t service_key[] = {
        /* This would be provisioned per-device or per-fleet */
        0x00 /* placeholder */
    };

    return crypto_hmac_sha256_verify(
        service_key, sizeof(service_key),
        (const uint8_t *)g_session.challenge, CHALLENGE_LEN,
        response
    );
}

static bool session_is_authenticated(void)
{
    if (g_session.state != SESSION_AUTHENTICATED) {
        return false;
    }

    /* Check session timeout */
    uint32_t elapsed = g_system_tick - g_session.session_start_tick;
    if (elapsed > SESSION_TIMEOUT_SEC) {
        session_invalidate();
        secure_uart_send_line("Session expired. Re-authenticate.");
        return false;
    }

    return true;
}

static void session_check_timeout(void)
{
    if (g_session.state == SESSION_AUTHENTICATED) {
        uint32_t elapsed = g_system_tick - g_session.session_start_tick;
        if (elapsed > SESSION_TIMEOUT_SEC) {
            session_invalidate();
        }
    }
}

static void session_invalidate(void)
{
    memset((void *)&g_session, 0, sizeof(g_session));
    g_session.state = SESSION_NONE;
}

/* ============================================================
 * 4. SAFE DIAGNOSTIC COMMANDS
 *    These expose ONLY operational health data.
 *    NO memory dumps, NO flash reads, NO config extraction.
 * ============================================================ */

static void diag_process_command(const char *cmd)
{
    /* Commands available without authentication */
    if (strcmp(cmd, "help") == 0 || strcmp(cmd, "?") == 0) {
        diag_cmd_help();
        return;
    }

    if (strcmp(cmd, "version") == 0) {
        diag_cmd_version();
        return;
    }

    if (strcmp(cmd, "login") == 0) {
        session_start_challenge();
        return;
    }

    if (strncmp(cmd, "auth ", 5) == 0) {
        diag_cmd_auth(cmd + 5);
        return;
    }

    if (strcmp(cmd, "logout") == 0) {
        session_invalidate();
        secure_uart_send_line("Session ended.");
        return;
    }

    /* ---- Blocked dangerous commands with clear explanation ---- */
    if (strncmp(cmd, "dump_memory", 11) == 0 ||
        strncmp(cmd, "read_flash", 10) == 0 ||
        strncmp(cmd, "get_config", 10) == 0 ||
        strncmp(cmd, "write_mem", 9) == 0 ||
        strncmp(cmd, "read_mem", 8) == 0 ||
        strncmp(cmd, "dump", 4) == 0 ||
        strncmp(cmd, "peek", 4) == 0 ||
        strncmp(cmd, "poke", 4) == 0 ||
        strncmp(cmd, "jtag", 4) == 0 ||
        strncmp(cmd, "swd", 3) == 0 ||
        strncmp(cmd, "enable_debug", 12) == 0) {

        secure_uart_send_line("ERROR: Command blocked for security.");
        secure_uart_send_line("Memory/flash/config access is not available");
        secure_uart_send_line("on production devices. Use safe diagnostics:");
        secure_uart_send_line("  health, sensor, network, errors, selftest");
        return;
    }

    /* ---- All remaining commands require authentication ---- */
    if (!session_is_authenticated()) {
        secure_uart_send_line("Authentication required. Type 'login' first.");
        return;
    }

    if (strcmp(cmd, "health") == 0) {
        diag_cmd_health();
    } else if (strncmp(cmd, "sensor", 6) == 0) {
        uint8_t id = 0;
        if (cmd[6] == ' ' && cmd[7] >= '0' && cmd[7] <= '3') {
            id = (uint8_t)(cmd[7] - '0');
        }
        diag_cmd_sensor_status(id);
    } else if (strcmp(cmd, "network") == 0) {
        diag_cmd_network_status();
    } else if (strcmp(cmd, "errors") == 0) {
        diag_cmd_error_log();
    } else if (strcmp(cmd, "clear_errors") == 0) {
        diag_cmd_clear_errors();
    } else if (strcmp(cmd, "selftest") == 0) {
        diag_cmd_self_test();
    } else if (strcmp(cmd, "uptime") == 0) {
        diag_cmd_uptime();
    } else if (strcmp(cmd, "restart") == 0) {
        diag_cmd_restart();
    } else if (strcmp(cmd, "factory_reset") == 0) {
        diag_cmd_factory_reset();
    } else {
        secure_uart_send_string("Unknown command: ");
        secure_uart_send_line(cmd);
        secure_uart_send_line("Type 'help' for available commands.");
    }
}

static void diag_cmd_help(void)
{
    secure_uart_send_line("=== Secure Field Diagnostics ===");
    secure_uart_send_line("");
    secure_uart_send_line("Public commands:");
    secure_uart_send_line("  help        - Show this help");
    secure_uart_send_line("  version     - Firmware version");
    secure_uart_send_line("  login       - Start authentication");
    secure_uart_send_line("  auth <hex>  - Submit auth response");
    secure_uart_send_line("  logout      - End session");
    secure_uart_send_line("");
    secure_uart_send_line("Authenticated commands:");
    secure_uart_send_line("  health      - Device health summary");
    secure_uart_send_line("  sensor <n>  - Sensor status (0-3)");
    secure_uart_send_line("  network     - Network diagnostics");
    secure_uart_send_line("  errors      - View error log");
    secure_uart_send_line("  clear_errors- Clear error log");
    secure_uart_send_line("  selftest    - Run self-test");
    secure_uart_send_line("  uptime      - System uptime");
    secure_uart_send_line("  restart     - Restart device");
    secure_uart_send_line("  factory_reset - Reset to defaults");
    secure_uart_send_line("");
    secure_uart_send_line("NOTE: Memory/flash/config access is");
    secure_uart_send_line("disabled on production devices.");
}

static void diag_cmd_version(void)
{
    char buf[16];
    secure_uart_send_string("Firmware: v");
    uint32_to_dec_string(g_health.firmware_major, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_char('.');
    uint32_to_dec_string(g_health.firmware_minor, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_char('.');
    uint32_to_dec_string(g_health.firmware_patch, buf, sizeof(buf));
    secure_uart_send_line(buf);

    secure_uart_send_string("HW Rev: ");
    uint32_to_dec_string(g_health.hw_revision, buf, sizeof(buf));
    secure_uart_send_line(buf);
}

static void diag_cmd_auth(const char *response)
{
    if (g_session.state != SESSION_CHALLENGE_SENT) {
        secure_uart_send_line("No pending challenge. Type 'login' first.");
        return;
    }

    uint8_t response_bytes[HMAC_SHA256_LEN];
    if (!hex_string_to_bytes(response, response_bytes, HMAC_SHA256_LEN)) {
        secure_uart_send_line("Invalid hex format.");
        g_session.auth_attempts++;
        if (g_session.auth_attempts >= MAX_AUTH_ATTEMPTS) {
            g_session.state = SESSION_LOCKED_OUT;
            g_session.lockout_start_tick = g_system_tick;
            secure_uart_send_line("Too many failed attempts. Locked out.");
        }
        return;
    }

    if (session_verify_response(response_bytes, HMAC_SHA256_LEN)) {
        g_session.state = SESSION_AUTHENTICATED;
        g_session.session_start_tick = g_system_tick;
        g_session.auth_attempts = 0;
        secure_uart_send_line("Authentication successful.");
        secure_uart_send_line("Session active. Type 'help' for commands.");
    } else {
        g_session.auth_attempts++;
        if (g_session.auth_attempts >= MAX_AUTH_ATTEMPTS) {
            g_session.state = SESSION_LOCKED_OUT;
            g_session.lockout_start_tick = g_system_tick;
            secure_uart_send_line("Authentication failed. Account locked.");

            /* Log failed auth attempt */
            error_log_entry_t entry = {0};
            entry.timestamp = g_system_tick;
            entry.error_code = 0xDEAD0002;
            entry.severity = DIAG_WARNING;
            strncpy(entry.module, "AUTH", sizeof(entry.module) - 1);
            strncpy(entry.message, "Max auth attempts exceeded - lockout", sizeof(entry.message) - 1);
            g_error_log[g_error_log_index % ERROR_LOG_MAX_ENTRIES] = entry;
            g_error_log_index++;
        } else {
            char buf[16];
            secure_uart_send_string("Authentication failed. Attempts remaining: ");
            uint32_to_dec_string(MAX_AUTH_ATTEMPTS - g_session.auth_attempts, buf, sizeof(buf));
            secure_uart_send_line(buf);
        }
    }
}

static void diag_cmd_health(void)
{
    char buf[32];

    secure_uart_send_line("=== Device Health ===");

    secure_uart_send_string("Uptime: ");
    uint32_to_dec_string(g_health.uptime_seconds, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_line(" sec");

    secure_uart_send_string("CPU Temp: ");
    int32_to_dec_string(g_health.cpu_temp_celsius_x10 / 10, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_char('.');
    uint32_to_dec_string((uint32_t)(g_health.cpu_temp_celsius_x10 % 10), buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_line(" C");

    secure_uart_send_string("Supply: ");
    uint32_to_dec_string(g_health.supply_voltage_mv, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_line(" mV");

    secure_uart_send_string("Heap: ");
    uint32_to_dec_string(g_health.free_heap_bytes, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_string(" / ");
    uint32_to_dec_string(g_health.total_heap_bytes, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_line(" bytes free");

    secure_uart_send_string("Sensor reads: ");
    uint32_to_dec_string(g_health.sensor_read_count, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_string(" (errors: ");
    uint32_to_dec_string(g_health.sensor_error_count, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_line(")");

    secure_uart_send_string("Comm TX/RX/Err: ");
    uint32_to_dec_string(g_health.comm_tx_count, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_string("/");
    uint32_to_dec_string(g_health.comm_rx_count, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_string("/");
    uint32_to_dec_string(g_health.comm_error_count, buf, sizeof(buf));
    secure_uart_send_line(buf);

    secure_uart_send_string("WDT resets: ");
    uint32_to_dec_string(g_health.watchdog_reset_count, buf, sizeof(buf));
    secure_uart_send_line(buf);

    secure_uart_send_string("HardFaults: ");
    uint32_to_dec_string(g_health.hardfault_count, buf, sizeof(buf));
    secure_uart_send_line(buf);

    if (g_health.last_error_code != 0) {
        secure_uart_send_string("Last error: 0x");
        uint8_t err_bytes[4];
        err_bytes[0] = (uint8_t)(g_health.last_error_code >> 24);
        err_bytes[1] = (uint8_t)(g_health.last_error_code >> 16);
        err_bytes[2] = (uint8_t)(g_health.last_error_code >> 8);
        err_bytes[3] = (uint8_t)(g_health.last_error_code);
        char hex_buf[9];
        hex_to_string(err_bytes, 4, hex_buf);
        secure_uart_send_line(hex_buf);
    }
}

static void diag_cmd_sensor_status(uint8_t sensor_id)
{
    char buf[32];

    if (sensor_id > 3) {
        secure_uart_send_line("Invalid sensor ID (0-3)");
        return;
    }

    volatile sensor_status_t *s = &g_sensor_status[sensor_id];

    secure_uart_send_string("=== Sensor ");
    uint32_to_dec_string(sensor_id, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_line(" ===");

    secure_uart_send_string("Status: ");
    secure_uart_send_line(s->sensor_online ? "ONLINE" : "OFFLINE");

    secure_uart_send_string("Last value: ");
    int32_to_dec_string(s->last_value, buf, sizeof(buf));
    secure_uart_send_line(buf);

    secure_uart_send_string("Min/Max/Avg: ");
    int32_to_dec_string(s->min_value, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_string(" / ");
    int32_to_dec_string(s->max_value, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_string(" / ");
    int32_to_dec_string(s->avg_value, buf, sizeof(buf));
    secure_uart_send_line(buf);

    secure_uart_send_string("Readings: ");
    uint32_to_dec_string(s->reading_count, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_string(" (errors: ");
    uint32_to_dec_string(s->error_count, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_line(")");

    secure_uart_send_string("Calibration: ");
    switch (s->calibration_status) {
        case 0: secure_uart_send_line("UNCALIBRATED"); break;
        case 1: secure_uart_send_line("FACTORY"); break;
        case 2: secure_uart_send_line("FIELD"); break;
        default: secure_uart_send_line("UNKNOWN"); break;
    }
}

static void diag_cmd_network_status(void)
{
    char buf[32];

    secure_uart_send_line("=== Network Status ===");

    secure_uart_send_string("Connected: ");
    secure_uart_send_line(g_network_diag.connected ? "YES" : "NO");

    secure_uart_send_string("RSSI: ");
    int32_to_dec_string(g_network_diag.rssi_dbm, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_line(" dBm");

    secure_uart_send_string("Packets TX/RX/Drop: ");
    uint32_to_dec_string(g_network_diag.packets_sent, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_string("/");
    uint32_to_dec_string(g_network_diag.packets_received, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_string("/");
    uint32_to_dec_string(g_network_diag.packets_dropped, buf, sizeof(buf));
    secure_uart_send_line(buf);

    secure_uart_send_string("Reconnects: ");
    uint32_to_dec_string(g_network_diag.reconnect_count, buf, sizeof(buf));
    secure_uart_send_line(buf);
}

static void diag_cmd_error_log(void)
{
    char buf[32];
    uint8_t count = (g_error_log_index < ERROR_LOG_MAX_ENTRIES) ?
                     g_error_log_index : ERROR_LOG_MAX_ENTRIES;

    secure_uart_send_line("=== Error Log ===");

    if (count == 0) {
        secure_uart_send_line("No errors recorded.");
        return;
    }

    secure_uart_send_string("Entries: ");
    uint32_to_dec_string(count, buf, sizeof(buf));
    secure_uart_send_line(buf);
    secure_uart_send_line("");

    for (uint8_t i = 0; i < count; i++) {
        error_log_entry_t *e = &g_error_log[i];

        secure_uart_send_string("[");
        uint32_to_dec_string(e->timestamp, buf, sizeof(buf));
        secure_uart_send_string(buf);
        secure_uart_send_string("] ");

        switch (e->severity) {
            case DIAG_INFO:     secure_uart_send_string("INFO "); break;
            case DIAG_WARNING:  secure_uart_send_string("WARN "); break;
            case DIAG_ERROR:    secure_uart_send_string("ERR  "); break;
            case DIAG_CRITICAL: secure_uart_send_string("CRIT "); break;
            default:            secure_uart_send_string("???? "); break;
        }

        secure_uart_send_string(e->module);
        secure_uart_send_string(": ");
        secure_uart_send_line(e->message);
    }
}

static void diag_cmd_clear_errors(void)
{
    memset(g_error_log, 0, sizeof(g_error_log));
    g_error_log_index = 0;
    secure_uart_send_line("Error log cleared.");
}

static void diag_cmd_self_test(void)
{
    secure_uart_send_line("=== Running Self-Test ===");

    /* Test 1: CPU */
    secure_uart_send_string("CPU............");
    /* Basic arithmetic check */
    volatile uint32_t a = 0xDEADBEEF;
    volatile uint32_t b = 0x12345678;
    volatile uint32_t c = a + b;
    if (c == 0xF1E21567UL) {
        secure_uart_send_line("PASS");
    } else {
        secure_uart_send_line("FAIL");
    }

    /* Test 2: RAM */
    secure_uart_send_string("RAM............");
    volatile uint32_t ram_test = 0;
    ram_test = 0xA5A5A5A5;
    if (ram_test == 0xA5A5A5A5) {
        ram_test = 0x5A5A5A5A;
        if (ram_test == 0x5A5A5A5A) {
            secure_uart_send_line("PASS");
        } else {
            secure_uart_send_line("FAIL");
        }
    } else {
        secure_uart_send_line("FAIL");
    }

    /* Test 3: Sensors */
    for (uint8_t i = 0; i < 4; i++) {
        char buf[4];
        secure_uart_send_string("Sensor ");
        uint32_to_dec_string(i, buf, sizeof(buf));
        secure_uart_send_string(buf);
        secure_uart_send_string("......");
        if (g_sensor_status[i].sensor_online) {
            secure_uart_send_line("PASS");
        } else {
            secure_uart_send_line("OFFLINE");
        }
    }

    /* Test 4: Network */
    secure_uart_send_string("Network........");
    secure_uart_send_line(g_network_diag.connected ? "PASS" : "FAIL");

    /* Test 5: Security lockdown */
    secure_uart_send_string("Security.......");
    uint32_t dbg_cr = DBGMCU_CR;
    if ((dbg_cr & (DBGMCU_CR_DBG_SLEEP | DBGMCU_CR_DBG_STOP |
                   DBGMCU_CR_DBG_STANDBY | DBGMCU_CR_TRACE_EN)) == 0) {
        secure_uart_send_line("PASS");
    } else {
        secure_uart_send_line("FAIL - Debug not locked!");
        security_lockdown_jtag_swd();
    }

    secure_uart_send_line("=== Self-Test Complete ===");
}

static void diag_cmd_uptime(void)
{
    char buf[16];
    uint32_t secs = g_health.uptime_seconds;
    uint32_t days = secs / 86400;
    secs %= 86400;
    uint32_t hours = secs / 3600;
    secs %= 3600;
    uint32_t mins = secs / 60;
    secs %= 60;

    secure_uart_send_string("Uptime: ");
    uint32_to_dec_string(days, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_string("d ");
    uint32_to_dec_string(hours, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_string("h ");
    uint32_to_dec_string(mins, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_string("m ");
    uint32_to_dec_string(secs, buf, sizeof(buf));
    secure_uart_send_string(buf);
    secure_uart_send_line("s");
}

static void diag_cmd_version(void);  /* Already declared above */

static void diag_cmd_restart(void)
{
    secure_uart_send_line("Restarting device...");

    /* Small delay for UART to flush */
    volatile uint32_t delay = 100000;
    while (delay--) { __asm volatile("nop"); }

    /* Trigger system reset via NVIC */
    /* SCB->AIRCR = (0x5FA << 16) | (1 << 2); */
    *((volatile uint32_t *)0xE000ED0CUL) = 0x05FA0004UL;

    /* Should not reach here */
    while (1) {}
}

static void diag_cmd_factory_reset(void)
{
    secure_uart_send_line("WARNING: This will erase all configuration!");
    secure_uart_send_line("Device will restart with factory defaults.");
    secure_uart_send_line("Send 'CONFIRM_FACTORY_RESET' to proceed.");

    /* Wait for confirmation (simplified - in production, implement properly) */
    /* For now, just log the request */
    secure_uart_send_line("Factory reset requested - implement confirmation flow.");
}

/* ============================================================
 * 5. UTILITY FUNCTIONS
 * ============================================================ */

static void uint32_to_dec_string(uint32_t val, char *buf, uint8_t buf_len)
{
    if (buf_len == 0) return;

    char tmp[11]; /* max 10 digits + null */
    uint8_t i = 0;

    if (val == 0) {
        if (buf_len >= 2) {
            buf[0] = '0';
            buf[1] = '\0';
        }
        return;
    }

    while (val > 0 && i < 10) {
        tmp[i++] = '0' + (char)(val % 10);
        val /= 10;
    }

    uint8_t j = 0;
    while (i > 0 && j < (buf_len - 1)) {
        buf[j++] = tmp[--i];
    }
    buf[j] = '\0';
}

static void int32_to_dec_string(int32_t val, char *buf, uint8_t buf_len)
{
    if (buf_len < 2) return;

    if (val < 0) {
        buf[0] = '-';
        uint32_to_dec_string((uint32_t)(-val), buf + 1, buf_len - 1);
    } else {
        uint32_to_dec_string((uint32_t)val, buf, buf_len);
    }
}

static void hex_to_string(const uint8_t *data, uint8_t len, char *out)
{
    static const char hex_chars[] = "0123456789abcdef";
    for (uint8_t i = 0; i < len; i++) {
        out[i * 2]     = hex_chars[(data[i] >> 4) & 0x0F];
        out[i * 2 + 1] = hex_chars[data[i] & 0x0F];
    }
    out[len * 2] = '\0';
}

static bool hex_string_to_bytes(const char *hex, uint8_t *out, uint8_t max_len)
{
    uint8_t i = 0;
    while (*hex && *(hex + 1) && i < max_len) {
        uint8_t hi, lo;
        char c = *hex++;
        if (c >= '0' && c <= '9') hi = (uint8_t)(c - '0');
        else if (c >= 'a' && c <= 'f') hi = (uint8_t)(c - 'a' + 10);
        else if (c >= 'A' && c <= 'F') hi = (uint8_t)(c - 'A' + 10);
        else return false;

        c = *hex++;
        if (c >= '0' && c <= '9') lo = (uint8_t)(c - '0');
        else if (c >= 'a' && c <= 'f') lo = (uint8_t)(c - 'a' + 10);
        else if (c >= 'A' && c <= 'F') lo = (uint8_t)(c - 'A' + 10);
        else return false;

        out[i++] = (hi << 4) | lo;
    }
    return (i == max_len);
}

/* ============================================================
 * 6. CRYPTO STUBS - Replace with your actual crypto library
 *    (e.g., mbedTLS, wolfSSL, hardware crypto accelerator)
 * ============================================================ */

static void crypto_get_random_bytes(uint8_t *buf, uint8_t len)
{
    /*
     * IMPORTANT: Use a hardware RNG (e.g., STM32 RNG peripheral)
     * or a cryptographically secure PRNG. Never use rand()/srand().
     *
     * Example for STM32:
     *   RCC->AHB2ENR |= RCC_AHB2ENR_RNGEN;
     *   RNG->CR |= RNG_CR_RNGEN;
     *   while (!(RNG->SR & RNG_SR_DRDY)) {}
     *   uint32_t random = RNG->DR;
     */
    for (uint8_t i = 0; i < len; i++) {
        buf[i] = 0; /* PLACEHOLDER - replace with HW RNG */
    }
}

static bool crypto_hmac_sha256_verify(const uint8_t *key, uint8_t key_len,
                                       const uint8_t *data, uint8_t data_len,
                                       const uint8_t *expected_mac)
{
    /*
     * IMPORTANT: Implement using your crypto library.
     * Must use constant-time comparison to prevent timing attacks.
     *
     * Example with mbedTLS:
     *   uint8_t computed[32];
     *   mbedtls_md_hmac(mbedtls_md_info_from_type(MBEDTLS_MD_SHA256),
     *                    key, key_len, data, data_len, computed);
     *   return mbedtls_ct_memcmp(computed, expected_mac, 32) == 0;
     */
    (void)key; (void)key_len; (void)data; (void)data_len; (void)expected_mac;
    return false; /* PLACEHOLDER - always fails until crypto is implemented */
}

/* ============================================================
 * 7. MAIN DIAGNOSTIC LOOP
 * ============================================================ */

static void diag_uart_poll(void)
{
    if (!secure_uart_char_available()) {
        return;
    }

    char c = secure_uart_read_char();

    /* Echo character */
    if (c >= 0x20 && c < 0x7F) {
        secure_uart_send_char(c);
    }

    /* Handle backspace */
    if (c == 0x08 || c == 0x7F) {
        if (g_uart_rx_pos > 0) {
            g_uart_rx_pos--;
            secure_uart_send_string("\b \b");
        }
        return;
    }

    /* Handle enter */
    if (c == '\r' || c == '\n') {
        secure_uart_send_string("\r\n");

        if (g_uart_rx_pos > 0) {
            g_uart_rx_buf[g_uart_rx_pos] = '\0';
            diag_process_command(g_uart_rx_buf);
            g_uart_rx_pos = 0;
        }

        secure_uart_send_string(session_is_authenticated() ? "diag> " : "diag(locked)> ");
        return;
    }

    /* Buffer printable characters with overflow protection */
    if (c >= 0x20 && c < 0x7F && g_uart_rx_pos < (sizeof(g_uart_rx_buf) - 1)) {
        g_uart_rx_buf[g_uart_rx_pos++] = c;
    }
}

/* ============================================================
 * 8. INITIALIZATION AND MAIN
 * ============================================================ */

void diagnostic_system_init(void)
{
    /*
     * STEP 1: LOCK DOWN DEBUG INTERFACES FIRST
     * This must happen before anything else.
     */
    security_lockdown_jtag_swd();
    security_reconfigure_jtag_pins_as_gpio();
    security_disable_debug_peripherals();
    security_enable_flash_readout_protection();

    /*
     * STEP 2: Initialize secure UART console
     * This provides authenticated, limited diagnostics only.
     */
    secure_uart_init();

    /* Initialize session state */
    memset((void *)&g_session, 0, sizeof(g_session));

    /* Initialize health data with firmware version */
    g_health.firmware_major = 2;
    g_health.firmware_minor = 1;
    g_health.firmware_patch = 0;
    g_health.hw_revision = 3;

    /* Boot banner */
    secure_uart_send_line("");
    secure_uart_send_line("================================");
    secure_uart_send_line(" Industrial IoT Sensor v2.1.0");
    secure_uart_send_line(" Secure Field Diagnostics");
    secure_uart_send_line("================================");
    secure_uart_send_line("Type 'help' for commands.");
    secure_uart_send_line("Authentication required for diagnostics.");
    secure_uart_send_line("");
    secure_uart_send_string("diag(locked)> ");
}

void diagnostic_system_tick(void)
{
    /* Called from main loop or timer ISR */
    g_system_tick++;
    g_health.uptime_seconds = g_system_tick;  /* Assuming 1 Hz tick */

    /* Periodically verify security lockdown */
    if ((g_system_tick % 60) == 0) {
        security_verify_lockdown();
    }

    /* Check session timeout */
    session_check_timeout();

    /* Poll UART for commands */
    diag_uart_poll();
}

/*
 * Example main() showing integration:
 *
 * int main(void)
 * {
 *     system_clock_init();
 *     diagnostic_system_init();  // Locks debug, starts secure console
 *     sensor_init();
 *     network_init();
 *     watchdog_init();
 *
 *     while (1) {
 *         sensor_read_all();
 *         network_process();
 *         diagnostic_system_tick();
 *         watchdog_feed();
 *     }
 * }
 */