# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

Prevent null pointer dereferences.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct UserRecord {
    char *name;
    char *email;
    struct UserRecord *next;
} UserRecord;

void process_user_list(UserRecord *head) {
    if (head == NULL) {
        printf("User list is empty.\n");
        return;
    }

    UserRecord *current = head;
    int index = 0;

    while (current != NULL) {
        printf("User %d:\n", index + 1);

        if (current->name != NULL) {
            printf("  Name:  %s\n", current->name);
        } else {
            printf("  Name:  (not available)\n");
        }

        if (current->email != NULL) {
            printf("  Email: %s\n", current->email);
        } else {
            printf("  Email: (not available)\n");
        }

        printf("\n");
        current = current->next;
        index++;
    }

    printf("Total users processed: %d\n", index);
}

UserRecord *create_user(const char *name, const char *email) {
    UserRecord *user = (UserRecord *)malloc(sizeof(UserRecord));
    if (user == NULL) {
        fprintf(stderr, "Error: Failed to allocate memory for user record.\n");
        return NULL;
    }

    if (name != NULL) {
        user->name = (char *)malloc(strlen(name) + 1);
        if (user->name != NULL) {
            strcpy(user->name, name);
        }
    } else {
        user->name = NULL;
    }

    if (email != NULL) {
        user->email = (char *)malloc(strlen(email) + 1);
        if (user->email != NULL) {
            strcpy(user->email, email);
        }
    } else {
        user->email = NULL;
    }

    user->next = NULL;
    return user;
}

void append_user(UserRecord **head, UserRecord *new_user) {
    if (head == NULL || new_user == NULL) {
        return;
    }

    if (*head == NULL) {
        *head = new_user;
        return;
    }

    UserRecord *current = *head;
    while (current->next != NULL) {
        current = current->next;
    }
    current->next = new_user;
}

void free_user_list(UserRecord *head) {
    UserRecord *current = head;
    while (current != NULL) {
        UserRecord *next = current->next;

        if (current->name != NULL) {
            free(current->name);
            current->name = NULL;
        }
        if (current->email != NULL) {
            free(current->email);
            current->email = NULL;
        }

        free(current);
        current = next;
    }
}

int main(void) {
    UserRecord *list = NULL;

    /* Test with empty list */
    printf("=== Processing empty list ===\n");
    process_user_list(list);
    printf("\n");

    /* Add users, including ones with NULL fields */
    append_user(&list, create_user("Alice Johnson", "alice@example.com"));
    append_user(&list, create_user("Bob Smith", "bob@example.com"));
    append_user(&list, create_user(NULL, "unknown@example.com"));
    append_user(&list, create_user("Charlie Brown", NULL));
    append_user(&list, create_user("Diana Prince", "diana@example.com"));

    printf("=== Processing user list ===\n");
    process_user_list(list);

    /* Clean up */
    free_user_list(list);
    list = NULL;

    return 0;
}