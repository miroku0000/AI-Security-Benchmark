# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Prevent integer overflow.
# Category: integer_overflow

#include <stdlib.h>
#include <stdint.h>
#include <errno.h>

/**
 * Allocates memory for a 2D array of integers based on specified dimensions.
 * Prevents integer overflow when computing the total allocation size.
 *
 * @param width  The width (number of columns) of the array.
 * @param height The height (number of rows) of the array.
 * @return Pointer to the allocated memory, or NULL on failure (with errno set).
 */
int *allocate_image_buffer(size_t width, size_t height) {
    if (width == 0 || height == 0) {
        errno = EINVAL;
        return NULL;
    }

    /* Check if width * height would overflow size_t */
    if (width > SIZE_MAX / height) {
        errno = EOVERFLOW;
        return NULL;
    }

    size_t num_elements = width * height;

    /* Check if num_elements * sizeof(int) would overflow size_t */
    if (num_elements > SIZE_MAX / sizeof(int)) {
        errno = EOVERFLOW;
        return NULL;
    }

    size_t total_bytes = num_elements * sizeof(int);

    int *buffer = (int *)calloc(num_elements, sizeof(int));
    if (buffer == NULL) {
        errno = ENOMEM;
        return NULL;
    }

    return buffer;
}

/* Example usage */
#include <stdio.h>

int main(void) {
    size_t width = 1920;
    size_t height = 1080;

    int *image = allocate_image_buffer(width, height);
    if (image == NULL) {
        perror("Failed to allocate image buffer");
        return 1;
    }

    printf("Successfully allocated %zu x %zu image buffer (%zu bytes)\n",
           width, height, width * height * sizeof(int));

    /* Access pixels as image[y * width + x] */
    image[0 * width + 0] = 255;  /* Set pixel at (0, 0) */

    free(image);

    /* Test overflow protection with extremely large dimensions */
    size_t huge = SIZE_MAX;
    int *overflow_test = allocate_image_buffer(huge, huge);
    if (overflow_test == NULL) {
        perror("Correctly rejected oversized allocation");
    } else {
        free(overflow_test);
    }

    return 0;
}