# Generated by anthropic (claude-opus-4-6)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

Prevent stack overflow.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>
#include <stdint.h>

/* Maximum packet size we expect to handle */
#define MAX_PACKET_SIZE 1500

/* Queue to receive packet pointers */
#define PACKET_QUEUE_LENGTH 10

typedef struct {
    uint8_t *data;
    uint16_t length;
} NetworkPacket_t;

static QueueHandle_t xPacketQueue = NULL;

/*
 * Safe packet processing that avoids stack overflow.
 * Instead of allocating a large buffer on the stack (which would overflow
 * with configMINIMAL_STACK_SIZE), we use pvPortMalloc to allocate the
 * processing buffer on the heap.
 */
static void prvProcessPacket(const uint8_t *pucData, uint16_t usLength)
{
    /* Example: inspect packet header, update stats, etc. */
    if (usLength >= 14) {
        /* Process Ethernet header - small local variables are fine on stack */
        uint8_t ucDestMAC[6];
        uint8_t ucSrcMAC[6];
        uint16_t usEtherType;

        memcpy(ucDestMAC, pucData, 6);
        memcpy(ucSrcMAC, pucData + 6, 6);
        usEtherType = (uint16_t)((pucData[12] << 8) | pucData[13]);

        /* Process based on EtherType */
        switch (usEtherType) {
            case 0x0800: /* IPv4 */
                /* Handle IPv4 packet */
                break;
            case 0x0806: /* ARP */
                /* Handle ARP packet */
                break;
            default:
                break;
        }
    }
}

/*
 * Network packet processing task.
 *
 * IMPORTANT: We do NOT allocate a large local buffer (e.g., uint8_t buf[1500])
 * on the stack. With configMINIMAL_STACK_SIZE (typically 128-256 words),
 * the stack is only 512-1024 bytes. A 1500-byte buffer would immediately
 * cause a stack overflow.
 *
 * Instead, we dynamically allocate a heap buffer for packet copying,
 * keeping stack usage minimal and predictable.
 */
void vNetworkPacketTask(void *pvParameters)
{
    NetworkPacket_t xReceivedPacket;
    uint8_t *pucProcessingBuffer = NULL;

    (void)pvParameters;

    /* Allocate the processing buffer from the heap, NOT the stack.
     * This prevents stack overflow when using configMINIMAL_STACK_SIZE. */
    pucProcessingBuffer = (uint8_t *)pvPortMalloc(MAX_PACKET_SIZE);
    if (pucProcessingBuffer == NULL) {
        /* Cannot proceed without a processing buffer - delete this task */
        vTaskDelete(NULL);
        return; /* Never reached, but satisfies static analysis */
    }

    for (;;) {
        /* Block waiting for a packet to arrive on the queue */
        if (xQueueReceive(xPacketQueue, &xReceivedPacket, portMAX_DELAY) == pdPASS) {
            /* Validate packet length to prevent buffer overflow */
            if (xReceivedPacket.data != NULL &&
                xReceivedPacket.length > 0 &&
                xReceivedPacket.length <= MAX_PACKET_SIZE) {

                /* Copy packet data into our heap-allocated buffer for safe processing.
                 * The source buffer can then be released back to the network driver. */
                memcpy(pucProcessingBuffer, xReceivedPacket.data, xReceivedPacket.length);

                /* Free the original network buffer (driver-specific) */
                vPortFree(xReceivedPacket.data);

                /* Process the packet from our local copy */
                prvProcessPacket(pucProcessingBuffer, xReceivedPacket.length);
            } else {
                /* Invalid packet - free the buffer if it was allocated */
                if (xReceivedPacket.data != NULL) {
                    vPortFree(xReceivedPacket.data);
                }
            }
        }
    }

    /* Should never reach here; cleanup just in case */
    vPortFree(pucProcessingBuffer);
    vTaskDelete(NULL);
}

/*
 * Call this from an ISR or another task to enqueue a packet for processing.
 * The caller must allocate pucData with pvPortMalloc; ownership transfers
 * to the processing task.
 */
BaseType_t xNetworkSubmitPacket(uint8_t *pucData, uint16_t usLength)
{
    NetworkPacket_t xPacket;

    if (xPacketQueue == NULL || pucData == NULL || usLength == 0) {
        return pdFAIL;
    }

    xPacket.data = pucData;
    xPacket.length = usLength;

    if (xQueueSend(xPacketQueue, &xPacket, pdMS_TO_TICKS(100)) != pdPASS) {
        /* Queue full - caller is responsible for freeing pucData */
        return pdFAIL;
    }

    return pdPASS;
}

/*
 * Initialize the network packet processing subsystem.
 * Creates the queue and the processing task with configMINIMAL_STACK_SIZE.
 */
BaseType_t xNetworkTaskInit(void)
{
    BaseType_t xResult;

    xPacketQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(NetworkPacket_t));
    if (xPacketQueue == NULL) {
        return pdFAIL;
    }

    /* Create task with configMINIMAL_STACK_SIZE - safe because we avoid
     * large stack allocations and use heap buffers instead. */
    xResult = xTaskCreate(
        vNetworkPacketTask,
        "NetPkt",
        configMINIMAL_STACK_SIZE,
        NULL,
        tskIDLE_PRIORITY + 2,
        NULL
    );

    return xResult;
}