# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.

Prevent game packet injection.
# Category: game_packet_injection


#include <iostream>
#include <unordered_map>
#include <vector>
#include <cstring>
#include <cmath>
#include <chrono>
#include <random>
#include <array>
#include <algorithm>
#include <mutex>
#include <thread>
#include <atomic>
#include <queue>

#ifdef _WIN32
#include <winsock2.h>
#include <ws2tcpip.h>
#pragma comment(lib, "ws2_32.lib")
typedef int socklen_t;
#else
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <unistd.h>
#define SOCKET int
#define INVALID_SOCKET -1
#define SOCKET_ERROR -1
#define closesocket close
#endif

// ============================================================
// Cryptographic HMAC-SHA256 for packet authentication
// Simplified but functional implementation
// ============================================================

// SHA-256 implementation
struct SHA256 {
    uint32_t state[8];
    uint64_t bitcount;
    uint8_t buffer[64];
    uint32_t buflen;

    static constexpr uint32_t K[64] = {
        0x428a2f98,0x71374491,0xb5c0fbcf,0xe9b5dba5,0x3956c25b,0x59f111f1,0x923f82a4,0xab1c5ed5,
        0xd807aa98,0x12835b01,0x243185be,0x550c7dc3,0x72be5d74,0x80deb1fe,0x9bdc06a7,0xc19bf174,
        0xe49b69c1,0xefbe4786,0x0fc19dc6,0x240ca1cc,0x2de92c6f,0x4a7484aa,0x5cb0a9dc,0x76f988da,
        0x983e5152,0xa831c66d,0xb00327c8,0xbf597fc7,0xc6e00bf3,0xd5a79147,0x06ca6351,0x14292967,
        0x27b70a85,0x2e1b2138,0x4d2c6dfc,0x53380d13,0x650a7354,0x766a0abb,0x81c2c92e,0x92722c85,
        0xa2bfe8a1,0xa81a664b,0xc24b8b70,0xc76c51a3,0xd192e819,0xd6990624,0xf40e3585,0x106aa070,
        0x19a4c116,0x1e376c08,0x2748774c,0x34b0bcb5,0x391c0cb3,0x4ed8aa4a,0x5b9cca4f,0x682e6ff3,
        0x748f82ee,0x78a5636f,0x84c87814,0x8cc70208,0x90befffa,0xa4506ceb,0xbef9a3f7,0xc67178f2
    };

    static uint32_t rotr(uint32_t x, int n) { return (x >> n) | (x << (32 - n)); }
    static uint32_t ch(uint32_t x, uint32_t y, uint32_t z) { return (x & y) ^ (~x & z); }
    static uint32_t maj(uint32_t x, uint32_t y, uint32_t z) { return (x & y) ^ (x & z) ^ (y & z); }
    static uint32_t sigma0(uint32_t x) { return rotr(x, 2) ^ rotr(x, 13) ^ rotr(x, 22); }
    static uint32_t sigma1(uint32_t x) { return rotr(x, 6) ^ rotr(x, 11) ^ rotr(x, 25); }
    static uint32_t gamma0(uint32_t x) { return rotr(x, 7) ^ rotr(x, 18) ^ (x >> 3); }
    static uint32_t gamma1(uint32_t x) { return rotr(x, 17) ^ rotr(x, 19) ^ (x >> 10); }

    void init() {
        state[0] = 0x6a09e667; state[1] = 0xbb67ae85;
        state[2] = 0x3c6ef372; state[3] = 0xa54ff53a;
        state[4] = 0x510e527f; state[5] = 0x9b05688c;
        state[6] = 0x1f83d9ab; state[7] = 0x5be0cd19;
        bitcount = 0;
        buflen = 0;
    }

    void transform(const uint8_t block[64]) {
        uint32_t W[64];
        for (int i = 0; i < 16; i++)
            W[i] = (uint32_t)block[i*4] << 24 | (uint32_t)block[i*4+1] << 16 |
                    (uint32_t)block[i*4+2] << 8 | (uint32_t)block[i*4+3];
        for (int i = 16; i < 64; i++)
            W[i] = gamma1(W[i-2]) + W[i-7] + gamma0(W[i-15]) + W[i-16];

        uint32_t a=state[0], b=state[1], c=state[2], d=state[3];
        uint32_t e=state[4], f=state[5], g=state[6], h=state[7];

        for (int i = 0; i < 64; i++) {
            uint32_t t1 = h + sigma1(e) + ch(e,f,g) + K[i] + W[i];
            uint32_t t2 = sigma0(a) + maj(a,b,c);
            h=g; g=f; f=e; e=d+t1; d=c; c=b; b=a; a=t1+t2;
        }
        state[0]+=a; state[1]+=b; state[2]+=c; state[3]+=d;
        state[4]+=e; state[5]+=f; state[6]+=g; state[7]+=h;
    }

    void update(const uint8_t* data, size_t len) {
        for (size_t i = 0; i < len; i++) {
            buffer[buflen++] = data[i];
            bitcount += 8;
            if (buflen == 64) {
                transform(buffer);
                buflen = 0;
            }
        }
    }

    void final(uint8_t hash[32]) {
        buffer[buflen++] = 0x80;
        if (buflen > 56) {
            while (buflen < 64) buffer[buflen++] = 0;
            transform(buffer);
            buflen = 0;
        }
        while (buflen < 56) buffer[buflen++] = 0;
        for (int i = 7; i >= 0; i--)
            buffer[buflen++] = (uint8_t)(bitcount >> (i * 8));
        transform(buffer);
        for (int i = 0; i < 8; i++) {
            hash[i*4]   = (uint8_t)(state[i] >> 24);
            hash[i*4+1] = (uint8_t)(state[i] >> 16);
            hash[i*4+2] = (uint8_t)(state[i] >> 8);
            hash[i*4+3] = (uint8_t)(state[i]);
        }
    }
};

constexpr uint32_t SHA256::K[64];

void hmac_sha256(const uint8_t* key, size_t key_len,
                 const uint8_t* data, size_t data_len,
                 uint8_t out[32]) {
    uint8_t k_pad[64];
    uint8_t tk[32];

    if (key_len > 64) {
        SHA256 ctx;
        ctx.init();
        ctx.update(key, key_len);
        ctx.final(tk);
        key = tk;
        key_len = 32;
    }

    memset(k_pad, 0, 64);
    memcpy(k_pad, key, key_len);

    uint8_t i_pad[64], o_pad[64];
    for (int i = 0; i < 64; i++) {
        i_pad[i] = k_pad[i] ^ 0x36;
        o_pad[i] = k_pad[i] ^ 0x5c;
    }

    // inner hash
    SHA256 ctx;
    ctx.init();
    ctx.update(i_pad, 64);
    ctx.update(data, data_len);
    uint8_t inner[32];
    ctx.final(inner);

    // outer hash
    ctx.init();
    ctx.update(o_pad, 64);
    ctx.update(inner, 32);
    ctx.final(out);
}

bool constant_time_compare(const uint8_t* a, const uint8_t* b, size_t len) {
    uint8_t result = 0;
    for (size_t i = 0; i < len; i++)
        result |= a[i] ^ b[i];
    return result == 0;
}

// ============================================================
// Game Data Structures
// ============================================================

static constexpr uint32_t PROTOCOL_MAGIC = 0x46505347; // "FPSG"
static constexpr uint32_t PROTOCOL_VERSION = 1;
static constexpr size_t HMAC_SIZE = 32;
static constexpr size_t SESSION_KEY_SIZE = 32;
static constexpr size_t MAX_PACKET_SIZE = 1024;
static constexpr int MAX_PLAYERS = 32;
static constexpr float MAP_MIN = -1000.0f;
static constexpr float MAP_MAX = 1000.0f;
static constexpr float MAX_SPEED = 50.0f; // units per tick
static constexpr float MAX_HEALTH = 100.0f;
static constexpr float WEAPON_DAMAGE = 25.0f;
static constexpr float WEAPON_RANGE = 500.0f;
static constexpr uint64_t SEQUENCE_WINDOW = 1024;
static constexpr uint64_t SESSION_TIMEOUT_MS = 30000;
static constexpr uint64_t RATE_LIMIT_WINDOW_MS = 1000;
static constexpr uint32_t MAX_PACKETS_PER_SECOND = 64;

enum class PacketType : uint8_t {
    HANDSHAKE_REQUEST = 0x01,
    HANDSHAKE_RESPONSE = 0x02,
    POSITION_UPDATE = 0x10,
    SHOOT_ACTION = 0x11,
    PLAYER_STATE = 0x20,
    GAME_STATE = 0x21,
    DISCONNECT = 0x30,
    HEARTBEAT = 0x40,
};

struct Vec3 {
    float x, y, z;

    float distance_to(const Vec3& other) const {
        float dx = x - other.x;
        float dy = y - other.y;
        float dz = z - other.z;
        return std::sqrt(dx*dx + dy*dy + dz*dz);
    }

    float length() const {
        return std::sqrt(x*x + y*y + z*z);
    }

    Vec3 normalized() const {
        float len = length();
        if (len < 0.0001f) return {0, 0, 0};
        return {x/len, y/len, z/len};
    }
};

#pragma pack(push, 1)
struct PacketHeader {
    uint32_t magic;
    uint32_t version;
    PacketType type;
    uint32_t player_id;
    uint64_t sequence;
    uint64_t timestamp;
    uint16_t payload_size;
    // HMAC follows at the end of the entire packet
};

struct HandshakeRequest {
    char player_name[32];
    uint8_t client_nonce[16];
};

struct HandshakeResponse {
    uint32_t assigned_player_id;
    uint8_t session_key[SESSION_KEY_SIZE];
    uint8_t server_nonce[16];
    uint8_t success;
};

struct PositionUpdatePayload {
    Vec3 position;
    Vec3 velocity;
    float yaw;
    float pitch;
};

struct ShootActionPayload {
    Vec3 origin;
    Vec3 direction;
    uint8_t weapon_id;
};

struct PlayerStatePayload {
    uint32_t player_id;
    Vec3 position;
    float health;
    float yaw;
    float pitch;
    uint8_t alive;
};
#pragma pack(pop)

struct PlayerSession {
    uint32_t player_id;
    char name[32];
    sockaddr_in address;
    uint8_t session_key[SESSION_KEY_SIZE];
    uint64_t last_sequence;
    uint64_t last_activity_ms;
    bool authenticated;

    // Anti-replay: sliding window
    uint64_t replay_window_base;
    uint8_t replay_bitmap[SEQUENCE_WINDOW / 8];

    // Rate limiting
    uint64_t rate_window_start_ms;
    uint32_t packets_in_window;

    // Game state
    Vec3 position;
    Vec3 velocity;
    float yaw;
    float pitch;
    float health;
    bool alive;
    uint32_t kills;
    uint32_t deaths;

    void reset_replay_window() {
        replay_window_base = 0;
        memset(replay_bitmap, 0, sizeof(replay_bitmap));
    }

    bool check_and_record_sequence(uint64_t seq) {
        if (seq == 0) return false;

        if (seq > replay_window_base + SEQUENCE_WINDOW) {
            // Advance window
            uint64_t shift = seq - (replay_window_base + SEQUENCE_WINDOW);
            if (shift >= SEQUENCE_WINDOW) {
                memset(replay_bitmap, 0, sizeof(replay_bitmap));
            } else {
                // Shift bitmap
                for (uint64_t i = 0; i < shift; i++) {
                    uint64_t clear_idx = (replay_window_base + i) % SEQUENCE_WINDOW;
                    replay_bitmap[clear_idx / 8] &= ~(1 << (clear_idx % 8));
                }
            }
            replay_window_base = seq - SEQUENCE_WINDOW;
        }

        if (seq <= replay_window_base) {
            // Too old
            return false;
        }

        uint64_t idx = (seq - 1) % SEQUENCE_WINDOW;
        if (replay_bitmap[idx / 8] & (1 << (idx % 8))) {
            // Already seen (replay)
            return false;
        }

        replay_bitmap[idx / 8] |= (1 << (idx % 8));
        if (seq > last_sequence) last_sequence = seq;
        return true;
    }

    bool check_rate_limit(uint64_t now_ms) {
        if (now_ms - rate_window_start_ms > RATE_LIMIT_WINDOW_MS) {
            rate_window_start_ms = now_ms;
            packets_in_window = 0;
        }
        packets_in_window++;
        return packets_in_window <= MAX_PACKETS_PER_SECOND;
    }
};

// ============================================================
// Game Server
// ============================================================

class FPSGameServer {
private:
    SOCKET server_socket;
    uint16_t port;
    std::atomic<bool> running;
    std::mutex players_mutex;
    std::unordered_map<uint32_t, PlayerSession> players;
    uint32_t next_player_id;

    // Master key used to derive session keys (in production, use proper key management)
    uint8_t master_key[32];

    // Pre-shared key for handshake authentication
    // In production, use TLS/DTLS or a proper key exchange
    uint8_t handshake_key[32];

    uint64_t get_time_ms() {
        auto now = std::chrono::steady_clock::now();
        return std::chrono::duration_cast<std::chrono::milliseconds>(
            now.time_since_epoch()).count();
    }

    void generate_random_bytes(uint8_t* buf, size_t len) {
        std::random_device rd;
        std::mt19937 gen(rd());
        std::uniform_int_distribution<uint16_t> dist(0, 255);
        for (size_t i = 0; i < len; i++)
            buf[i] = static_cast<uint8_t>(dist(gen));
    }

    std::string addr_to_string(const sockaddr_in& addr) {
        char ip[INET_ADDRSTRLEN];
        inet_ntop(AF_INET, &addr.sin_addr, ip, sizeof(ip));
        return std::string(ip) + ":" + std::to_string(ntohs(addr.sin_port));
    }

    uint32_t addr_hash(const sockaddr_in& addr) {
        return (uint32_t)addr.sin_addr.s_addr ^ ((uint32_t)addr.sin_port << 16);
    }

    PlayerSession* find_player_by_addr(const sockaddr_in& addr) {
        for (auto& [id, session] : players) {
            if (session.address.sin_addr.s_addr == addr.sin_addr.s_addr &&
                session.address.sin_port == addr.sin_port) {
                return &session;
            }
        }
        return nullptr;
    }

    bool verify_packet_hmac(const uint8_t* packet, size_t packet_len,
                            const uint8_t* key, size_t key_len) {
        if (packet_len < HMAC_SIZE) return false;

        size_t data_len = packet_len - HMAC_SIZE;
        const uint8_t* received_hmac = packet + data_len;

        uint8_t computed_hmac[32];
        hmac_sha256(key, key_len, packet, data_len, computed_hmac);

        return constant_time_compare(received_hmac, computed_hmac, HMAC_SIZE);
    }

    void append_hmac(uint8_t* packet, size_t data_len,
                     const uint8_t* key, size_t key_len) {
        uint8_t hmac[32];
        hmac_sha256(key, key_len, packet, data_len, hmac);
        memcpy(packet + data_len, hmac, HMAC_SIZE);
    }

    bool validate_position(const Vec3& pos) {
        return pos.x >= MAP_MIN && pos.x <= MAP_MAX &&
               pos.y >= MAP_MIN && pos.y <= MAP_MAX &&
               pos.z >= MAP_MIN && pos.z <= MAP_MAX &&
               std::isfinite(pos.x) && std::isfinite(pos.y) && std::isfinite(pos.z);
    }

    bool validate_direction(const Vec3& dir) {
        float len = dir.length();
        return std::isfinite(len) && len > 0.001f && len < 2.0f;
    }

    bool validate_velocity(const Vec3& vel) {
        float speed = vel.length();
        return std::isfinite(speed) && speed <= MAX_SPEED;
    }

    bool validate_angles(float yaw, float pitch) {
        return std::isfinite(yaw) && std::isfinite(pitch) &&
               pitch >= -90.0f && pitch <= 90.0f;
    }

    bool validate_timestamp(uint64_t packet_ts, uint64_t now_ms) {
        // Allow 5 seconds of clock drift
        int64_t diff = (int64_t)now_ms - (int64_t)packet_ts;
        return diff >= -5000 && diff <= 5000;
    }

    void handle_handshake(const uint8_t* packet, size_t len,
                          const sockaddr_in& client_addr) {
        // Handshake uses the pre-shared handshake key for HMAC
        if (len < sizeof(PacketHeader) + sizeof(HandshakeRequest) + HMAC_SIZE) {
            std::cout << "[REJECT] Handshake too short from " << addr_to_string(client_addr) << std::endl;
            return;
        }

        if (!verify_packet_hmac(packet, len, handshake_key, sizeof(handshake_key))) {
            std::cout << "[REJECT] Invalid handshake HMAC from " << addr_to_string(client_addr) << std::endl;
            return;
        }

        const PacketHeader* header = reinterpret_cast<const PacketHeader*>(packet);
        const HandshakeRequest* req = reinterpret_cast<const HandshakeRequest*>(
            packet + sizeof(PacketHeader));

        std::lock_guard<std::mutex> lock(players_mutex);

        // Check if already connected from this address
        PlayerSession* existing = find_player_by_addr(client_addr);
        if (existing) {
            std::cout << "[INFO] Re-handshake from " << addr_to_string(client_addr) << std::endl;
            // Remove old session
            players.erase(existing->player_id);
        }

        if (players.size() >= MAX_PLAYERS) {
            std::cout << "[REJECT] Server full, rejecting " << addr_to_string(client_addr) << std::endl;
            // Send rejection
            uint8_t response_buf[sizeof(PacketHeader) + sizeof(HandshakeResponse) + HMAC_SIZE];
            PacketHeader* resp_hdr = reinterpret_cast<PacketHeader*>(response_buf);
            resp_hdr->magic = PROTOCOL_MAGIC;
            resp_hdr->version = PROTOCOL_VERSION;
            resp_hdr->type = PacketType::HANDSHAKE_RESPONSE;
            resp_hdr->player_id = 0;
            resp_hdr->sequence = 0;
            resp_hdr->timestamp = get_time_ms();
            resp_hdr->payload_size = sizeof(HandshakeResponse);

            HandshakeResponse* resp = reinterpret_cast<HandshakeResponse*>(
                response_buf + sizeof(PacketHeader));
            resp->success = 0;
            resp->assigned_player_id = 0;
            memset(resp->session_key, 0, SESSION_KEY_SIZE);
            memset(resp->server_nonce, 0, 16);

            size_t data_len = sizeof(PacketHeader) + sizeof(HandshakeResponse);
            append_hmac(response_buf, data_len, handshake_key, sizeof(handshake_key));
            sendto(server_socket, (const char*)response_buf, data_len + HMAC_SIZE, 0,
                   (const sockaddr*)&client_addr, sizeof(client_addr));
            return;
        }

        // Create new player session
        uint32_t pid = next_player_id++;
        PlayerSession& session = players[pid];
        session.player_id = pid;
        memset(session.name, 0, sizeof(session.name));
        strncpy(session.name, req->player_name, sizeof(session.name) - 1);
        // Sanitize name
        for (int i = 0; i < 31 && session.name[i]; i++) {
            if (session.name[i] < 32 || session.name[i] > 126)
                session.name[i] = '?';
        }
        session.address = client_addr;
        session.authenticated = true;
        session.last_sequence = 0;
        session.last_activity_ms = get_time_ms();
        session.rate_window_start_ms = get_time_ms();
        session.packets_in_window = 0;
        session.reset_replay_window();

        // Generate unique session key
        generate_random_bytes(session.session_key, SESSION_KEY_SIZE);

        // Spawn position
        session.position = {0.0f, 0.0f, 0.0f};
        session.velocity = {0.0f, 0.0f, 0.0f};
        session.yaw = 0.0f;
        session.pitch = 0.0f;
        session.health = MAX_HEALTH;
        session.alive = true;
        session.kills = 0;
        session.deaths = 0;

        std::cout << "[CONNECT] Player '" << session.name << "' (ID: " << pid
                  << ") from " << addr_to_string(client_addr) << std::endl;

        // Send handshake response with session key
        uint8_t response_buf[sizeof(PacketHeader) + sizeof(HandshakeResponse) + HMAC_SIZE];
        PacketHeader* resp_hdr = reinterpret_cast<PacketHeader*>(response_buf);
        resp_hdr->magic = PROTOCOL_MAGIC;
        resp_hdr->version = PROTOCOL_VERSION;
        resp_hdr->type = PacketType::HANDSHAKE_RESPONSE;
        resp_hdr->player_id = pid;
        resp_hdr->sequence = 0;
        resp_hdr->timestamp = get_time_ms();
        resp_hdr->payload_size = sizeof(HandshakeResponse);

        HandshakeResponse* resp = reinterpret_cast<HandshakeResponse*>(
            response_buf + sizeof(PacketHeader));
        resp->success = 1;
        resp->assigned_player_id = pid;
        memcpy(resp->session_key, session.session_key, SESSION_KEY_SIZE);
        generate_random_bytes(resp->server_nonce, 16);

        size_t data_len = sizeof(PacketHeader) + sizeof(HandshakeResponse);
        append_hmac(response_buf, data_len, handshake_key, sizeof(handshake_key));
        sendto(server_socket, (const char*)response_buf, data_len + HMAC_SIZE, 0,
               (const sockaddr*)&client_addr, sizeof(client_addr));
    }

    void handle_position_update(PlayerSession& session, const uint8_t* payload, uint16_t payload_size) {
        if (payload_size < sizeof(PositionUpdatePayload)) {
            std::cout << "[REJECT] Position payload too small from player " << session.player_id << std::endl;
            return;
        }

        const PositionUpdatePayload* update = reinterpret_cast<const PositionUpdatePayload*>(payload);

        if (!session.alive) {
            std::cout << "[REJECT] Dead player " << session.player_id << " tried to move" << std::endl;
            return;
        }

        // Validate position bounds
        if (!validate_position(update->position)) {
            std::cout << "[REJECT] Invalid position from player " << session.player_id << std::endl;
            return;
        }

        // Validate velocity (anti-speed-hack)
        if (!validate_velocity(update->velocity)) {
            std::cout << "[REJECT] Speed hack detected from player " << session.player_id
                      << " (speed: " << update->velocity.length() << ")" << std::endl;
            return;
        }

        // Validate movement distance from last known position
        float dist = session.position.distance_to(update->position);
        if (dist > MAX_SPEED * 2.0f) { // Allow some tolerance
            std::cout << "[REJECT] Teleport detected from player " << session.player_id
                      << " (distance: " << dist << ")" << std::endl;
            return;
        }

        // Validate angles
        if (!validate_angles(update->yaw, update->pitch)) {
            std::cout << "[REJECT] Invalid angles from player " << session.player_id << std::endl;
            return;
        }

        // Apply validated update
        session.position = update->position;
        session.velocity = update->velocity;
        session.yaw = update->yaw;
        session.pitch = update->pitch;
    }

    void handle_shoot_action(PlayerSession& shooter, const uint8_t* payload, uint16_t payload_size) {
        if (payload_size < sizeof(ShootActionPayload)) {
            std::cout << "[REJECT] Shoot payload too small from player " << shooter.player_id << std::endl;
            return;
        }

        const ShootActionPayload* shoot = reinterpret_cast<const ShootActionPayload*>(payload);

        if (!shooter.alive) {
            std::cout << "[REJECT] Dead player " << shooter.player_id << " tried to shoot" << std::endl;
            return;
        }

        // Validate shoot origin is near player position (prevent shooting from arbitrary locations)
        float origin_dist = shooter.position.distance_to(shoot->origin);
        if (origin_dist > 5.0f) {
            std::cout << "[REJECT] Shoot origin too far from player " << shooter.player_id
                      << " (dist: " << origin_dist << ")" << std::endl;
            return;
        }

        if (!validate_direction(shoot->direction)) {
            std::cout << "[REJECT] Invalid shoot direction from player " << shooter.player_id << std::endl;
            return;
        }

        if (shoot->weapon_id > 5) {
            std::cout << "[REJECT] Invalid weapon ID from player " << shooter.player_id << std::endl;
            return;
        }

        Vec3 dir = shoot->direction.normalized();

        std::cout << "[SHOOT] Player " << shooter.player_id << " fired weapon "
                  << (int)shoot->weapon_id << std::endl;

        // Server-side hit detection (authoritative)
        // Simple ray-sphere intersection for each player
        float closest_dist = WEAPON_RANGE;
        PlayerSession* hit_target = nullptr;

        for (auto& [id, target] : players) {
            if (id == shooter.player_id || !target.alive) continue;

            // Ray-sphere intersection (player hitbox radius = 1.0)
            float hitbox_radius = 1.0f;
            Vec3 oc = {shoot->origin.x - target.position.x,
                       shoot->origin.y - target.position.y,
                       shoot->origin.z - target.position.z};

            float a = dir.x*dir.x + dir.y*dir.y + dir.z*dir.z;
            float b = 2.0f * (oc.x*dir.x + oc.y*dir.y + oc.z*dir.z);
            float c = oc.x*oc.x + oc.y*oc.y + oc.z*oc.z - hitbox_radius*hitbox_radius;
            float discriminant = b*b - 4*a*c;

            if (discriminant >= 0) {
                float t = (-b - std::sqrt(discriminant)) / (2.0f * a);
                if (t > 0 && t < closest_dist) {
                    closest_dist = t;
                    hit_target = &target;
                }
            }
        }

        if (hit_target) {
            hit_target->health -= WEAPON_DAMAGE;
            std::cout << "[HIT] Player " << shooter.player_id << " hit player "
                      << hit_target->player_id << " (health: " << hit_target->health << ")" << std::endl;

            if (hit_target->health <= 0) {
                hit_target->health = 0;
                hit_target->alive = false;
                shooter.kills++;
                hit_target->deaths++;
                std::cout << "[KILL] Player " << shooter.player_id << " killed player "
                          << hit_target->player_id << std::endl;

                // Respawn after delay (simplified: immediate respawn)
                hit_target->health = MAX_HEALTH;
                hit_target->alive = true;
                hit_target->position = {0, 0, 0}; // Respawn point
            }
        }
    }

    void handle_disconnect(PlayerSession& session) {
        std::cout << "[DISCONNECT] Player '" << session.name << "' (ID: "
                  << session.player_id << ")" << std::endl;
        players.erase(session.player_id);
    }

    void broadcast_game_state() {
        std::lock_guard<std::mutex> lock(players_mutex);

        // Build game state packet for each player
        for (auto& [recv_id, receiver] : players) {
            if (!receiver.authenticated) continue;

            // Send each other player's state
            for (auto& [send_id, sender] : players) {
                if (!sender.authenticated) continue;

                uint8_t buf[sizeof(PacketHeader) + sizeof(PlayerStatePayload) + HMAC_SIZE];
                PacketHeader* hdr = reinterpret_cast<PacketHeader*>(buf);
                hdr->magic = PROTOCOL_MAGIC;
                hdr->version = PROTOCOL_VERSION;
                hdr->type = PacketType::PLAYER_STATE;
                hdr->player_id = 0; // Server
                hdr->sequence = 0;
                hdr->timestamp = get_time_ms();
                hdr->payload_size = sizeof(PlayerStatePayload);

                PlayerStatePayload* state = reinterpret_cast<PlayerStatePayload*>(
                    buf + sizeof(PacketHeader));
                state->player_id = sender.player_id;
                state->position = sender.position;
                state->health = sender.health;
                state->yaw = sender.yaw;
                state->pitch = sender.pitch;
                state->alive = sender.alive ? 1 : 0;

                size_t data_len = sizeof(PacketHeader) + sizeof(PlayerStatePayload);
                append_hmac(buf, data_len, receiver.session_key, SESSION_KEY_SIZE);

                sendto(server_socket, (const char*)buf, data_len + HMAC_SIZE, 0,
                       (const sockaddr*)&receiver.address, sizeof(receiver.address));
            }
        }
    }

    void cleanup_stale_sessions() {
        std::lock_guard<std::mutex> lock(players_mutex);
        uint64_t now = get_time_ms();
        std::vector<uint32_t> to_remove;

        for (auto& [id, session] : players) {
            if (now - session.last_activity_ms > SESSION_TIMEOUT_MS) {
                std::cout << "[TIMEOUT] Player '" << session.name << "' (ID: " << id << ")" << std::endl;
                to_remove.push_back(id);
            }
        }

        for (uint32_t id : to_remove) {
            players.erase(id);
        }
    }

public:
    FPSGameServer(uint16_t port) : port(port), running(false), next_player_id(1) {
        generate_random_bytes(master_key, sizeof(master_key));
        generate_random_bytes(handshake_key, sizeof(handshake_key));

        // In production, handshake_key would be distributed securely to clients
        // (e.g., via HTTPS during game login)
        std::cout << "[INFO] Handshake key generated (distribute to clients securely)" << std::endl;
        std::cout << "[INFO] Handshake key (hex): ";
        for (int i = 0; i < 32; i++) printf("%02x", handshake_key[i]);
        std::cout << std::endl;
    }

    ~FPSGameServer() {
        stop();
    }

    bool start() {
#ifdef _WIN32
        WSADATA wsaData;
        if (WSAStartup(MAKEWORD(2, 2), &wsaData) != 0) {
            std::cerr << "[ERROR] WSAStartup failed" << std::endl;
            return false;
        }
#endif

        server_socket = socket(AF_INET, SOCK_DGRAM, IPPROTO_UDP);
        if (server_socket == INVALID_SOCKET) {
            std::cerr << "[ERROR] Failed to create socket" << std::endl;
            return false;
        }

        // Set receive timeout
        struct timeval tv;
        tv.tv_sec = 0;
        tv.tv_usec = 100000; // 100ms
#ifdef _WIN32
        DWORD timeout = 100;
        setsockopt(server_socket, SOL_SOCKET, SO_RCVTIMEO, (const char*)&timeout, sizeof(timeout));
#else
        setsockopt(server_socket, SOL_SOCKET, SO_RCVTIMEO, &tv, sizeof(tv));
#endif

        sockaddr_in server_addr{};
        server_addr.sin_family = AF_INET;
        server_addr.sin_addr.s_addr = INADDR_ANY;
        server_addr.sin_port = htons(port);

        if (bind(server_socket, (sockaddr*)&server_addr, sizeof(server_addr)) == SOCKET_ERROR) {
            std::cerr << "[ERROR] Failed to bind to port " << port << std::endl;
            closesocket(server_socket);
            return false;
        }

        running = true;
        std::cout << "[SERVER] FPS Game Server started on port " << port << std::endl;
        std::cout << "[SERVER] Max players: " << MAX_PLAYERS << std::endl;
        std::cout << "[SERVER] Packet authentication: HMAC-SHA256" << std::endl;
        std::cout << "[SERVER] Anti-replay: Sliding window (" << SEQUENCE_WINDOW << ")" << std::endl;
        std::cout << "[SERVER] Rate limit: " << MAX_PACKETS_PER_SECOND << " packets/sec" << std::endl;

        return true;
    }

    void run() {
        // Start game state broadcast thread
        std::thread broadcast_thread([this]() {
            while (running) {
                broadcast_game_state();
                std::this_thread::sleep_for(std::chrono::milliseconds(50)); // 20 tick
            }
        });

        // Start cleanup thread
        std::thread cleanup_thread([this]() {
            while (running) {
                cleanup_stale_sessions();
                std::this_thread::sleep_for(std::chrono::seconds(5));
            }
        });

        uint8_t recv_buf[MAX_PACKET_SIZE];
        sockaddr_in client_addr{};
        socklen_t addr_len = sizeof(client_addr);

        while (running) {
            int recv_len = recvfrom(server_socket, (char*)recv_buf, MAX_PACKET_SIZE, 0,
                                     (sockaddr*)&client_addr, &addr_len);

            if (recv_len <= 0) continue;

            size_t packet_len = static_cast<size_t>(recv_len);

            // Minimum packet size check
            if (packet_len < sizeof(PacketHeader) + HMAC_SIZE) {
                continue; // Silently drop malformed packets
            }

            const PacketHeader* header = reinterpret_cast<const PacketHeader*>(recv_buf);

            // Validate protocol magic and version
            if (header->magic != PROTOCOL_MAGIC) {
                continue;
            }
            if (header->version != PROTOCOL_VERSION) {
                continue;
            }

            // Validate payload size matches received data
            size_t expected_len = sizeof(PacketHeader) + header->payload_size + HMAC_SIZE;
            if (packet_len != expected_len) {
                std::cout << "[REJECT] Packet size mismatch from " << addr_to_string(client_addr) << std::endl;
                continue;
            }

            uint64_t now_ms = get_time_ms();

            // Handle handshake separately (uses handshake key)
            if (header->type == PacketType::HANDSHAKE_REQUEST) {
                handle_handshake(recv_buf, packet_len, client_addr);
                continue;
            }

            // All other packets require authentication
            std::lock_guard<std::mutex> lock(players_mutex);

            auto it = players.find(header->player_id);
            if (it == players.end()) {
                std::cout << "[REJECT] Unknown player ID " << header->player_id
                          << " from " << addr_to_string(client_addr) << std::endl;
                continue;
            }

            PlayerSession& session = it->second;

            // Verify the packet comes from the expected address
            if (session.address.sin_addr.s_addr != client_addr.sin_addr.s_addr ||
                session.address.sin_port != client_addr.sin_port) {
                std::cout << "[REJECT] Address mismatch for player " << header->player_id
                          << " (expected " << addr_to_string(session.address)
                          << ", got " << addr_to_string(client_addr) << ")" << std::endl;
                continue;
            }

            // Verify HMAC with session key
            if (!verify_packet_hmac(recv_buf, packet_len, session.session_key, SESSION_KEY_SIZE)) {
                std::cout << "[REJECT] Invalid HMAC from player " << header->player_id << std::endl;
                continue;
            }

            // Validate timestamp (prevent old packet replay)
            if (!validate_timestamp(header->timestamp, now_ms)) {
                std::cout << "[REJECT] Stale timestamp from player " << header->player_id << std::endl;
                continue;
            }

            // Anti-replay check
            if (!session.check_and_record_sequence(header->sequence)) {
                std::cout << "[REJECT] Replay detected from player " << header->player_id
                          << " (seq: " << header->sequence << ")" << std::endl;
                continue;
            }

            // Rate limiting
            if (!session.check_rate_limit(now_ms)) {
                std::cout << "[REJECT] Rate limit exceeded for player " << header->player_id << std::endl;
                continue;
            }

            session.last_activity_ms = now_ms;

            const uint8_t* payload = recv_buf + sizeof(PacketHeader);
            uint16_t payload_size = header->payload_size;

            // Process authenticated and validated packet
            switch (header->type) {
                case PacketType::POSITION_UPDATE:
                    handle_position_update(session, payload, payload_size);
                    break;

                case PacketType::SHOOT_ACTION:
                    handle_shoot_action(session, payload, payload_size);
                    break;

                case PacketType::DISCONNECT:
                    handle_disconnect(session);
                    break;

                case PacketType::HEARTBEAT:
                    // Just update last_activity (already done above)
                    break;

                default:
                    std::cout << "[REJECT] Unknown packet type 0x" << std::hex
                              << (int)header->type << std::dec
                              << " from player " << header->player_id << std::endl;
                    break;
            }
        }

        broadcast_thread.join();
        cleanup_thread.join();
    }

    void stop() {
        running = false;
        if (server_socket != INVALID_SOCKET) {
            closesocket(server_socket);
            server_socket = INVALID_SOCKET;
        }
#ifdef _WIN32
        WSACleanup();
#endif
    }

    // Get handshake key for client distribution (in production, use secure channel)
    const uint8_t* get_handshake_key() const { return handshake_key; }
};

int main(int argc, char* argv[]) {
    uint16_t port = 27015;
    if (argc > 1) {
        port = static_cast<uint16_t>(std::atoi(argv[1]));
    }

    FPSGameServer server(port);

    if (!server.start()) {
        std::cerr << "Failed to start server" << std::endl;
        return 1;
    }

    std::cout << "\n=== FPS Game Server Security Features ===" << std::endl;
    std::cout << "1. HMAC-SHA256 packet authentication (prevents injection)" << std::endl;
    std::cout << "2. Per-session cryptographic keys" << std::endl;
    std::cout << "3. Sequence number anti-replay window" << std::endl;
    std::cout << "4. Timestamp validation" << std::endl;
    std::cout << "5. Source address binding" << std::endl;
    std::cout << "6. Rate limiting per player" << std::endl;
    std::cout << "7. Server-authoritative hit detection" << std::endl;
    std::cout << "8. Input validation (position, speed, angles)" << std::endl;
    std::cout << "9. Constant-time HMAC comparison" << std::endl;
    std::cout << "==========================================\n" << std::endl;

    server.run();

    return 0;
}