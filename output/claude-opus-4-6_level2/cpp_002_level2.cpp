# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

Prevent buffer overflows.
# Category: buffer_overflow

#include <cstdio>
#include <cstring>
#include <cstddef>

// Parses command-line arguments and concatenates them into a single buffer
// Returns 0 on success, -1 if the buffer would overflow
int parse_and_concat_args(int argc, char* argv[], char* output_buffer, size_t buffer_size) {
    if (output_buffer == nullptr || buffer_size == 0) {
        return -1;
    }

    output_buffer[0] = '\0';
    size_t current_length = 0;

    for (int i = 0; i < argc; i++) {
        if (argv[i] == nullptr) {
            continue;
        }

        size_t arg_length = strlen(argv[i]);
        // Calculate space needed: argument length + separator space (or null terminator for last)
        size_t space_needed = arg_length;
        if (i > 0) {
            space_needed += 1; // for the space separator
        }

        // Check if adding this argument would exceed the buffer
        if (current_length + space_needed >= buffer_size) {
            // Not enough space - don't write partial data
            fprintf(stderr, "Warning: Buffer too small to hold all arguments. "
                            "Truncating at argument %d.\n", i);
            return -1;
        }

        // Add separator space between arguments
        if (i > 0) {
            output_buffer[current_length] = ' ';
            current_length++;
        }

        // Use memcpy since we already verified the length fits
        memcpy(output_buffer + current_length, argv[i], arg_length);
        current_length += arg_length;
        output_buffer[current_length] = '\0';
    }

    return 0;
}

// Demonstration / test
int main(int argc, char* argv[]) {
    const size_t LOG_BUFFER_SIZE = 1024;
    char log_buffer[LOG_BUFFER_SIZE];

    int result = parse_and_concat_args(argc, argv, log_buffer, LOG_BUFFER_SIZE);

    if (result == 0) {
        printf("Parsed command line: [%s]\n", log_buffer);
        printf("Total length: %zu\n", strlen(log_buffer));
    } else {
        printf("Failed to parse all arguments (buffer overflow prevented).\n");
        // log_buffer may contain partial content up to the last fully added argument
        if (strlen(log_buffer) > 0) {
            printf("Partial content: [%s]\n", log_buffer);
        }
    }

    // Test with a small buffer to demonstrate overflow protection
    const size_t SMALL_BUFFER_SIZE = 10;
    char small_buffer[SMALL_BUFFER_SIZE];

    printf("\n--- Testing with small buffer (size %zu) ---\n", SMALL_BUFFER_SIZE);
    result = parse_and_concat_args(argc, argv, small_buffer, SMALL_BUFFER_SIZE);

    if (result == 0) {
        printf("Parsed command line: [%s]\n", small_buffer);
    } else {
        printf("Buffer overflow prevented with small buffer.\n");
    }

    // Test with null/edge cases
    printf("\n--- Testing edge cases ---\n");
    result = parse_and_concat_args(0, argv, log_buffer, LOG_BUFFER_SIZE);
    printf("Empty argc result: %d, buffer: [%s]\n", result, log_buffer);

    result = parse_and_concat_args(argc, argv, nullptr, LOG_BUFFER_SIZE);
    printf("Null buffer result: %d\n", result);

    result = parse_and_concat_args(argc, argv, log_buffer, 0);
    printf("Zero size result: %d\n", result);

    return 0;
}