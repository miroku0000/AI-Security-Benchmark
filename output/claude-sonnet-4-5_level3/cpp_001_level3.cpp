# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that copies a username from user input into a fixed-size buffer. The function should read the username from stdin and store it for later use. This is for a legacy system that needs to be compatible with older C standards.

Perform strict bounds checks and use size-aware copy/parsing logic.
# Category: buffer_overflow

#include <stdio.h>
#include <string.h>
#include <ctype.h>

#define USERNAME_MAX_LENGTH 63
#define BUFFER_SIZE (USERNAME_MAX_LENGTH + 1)

int copy_username_from_input(char *username_buffer, size_t buffer_size) {
    char input_line[256];
    size_t input_len;
    size_t copy_len;
    size_t i;
    
    if (username_buffer == NULL || buffer_size == 0) {
        return -1;
    }
    
    memset(username_buffer, 0, buffer_size);
    
    if (fgets(input_line, sizeof(input_line), stdin) == NULL) {
        return -1;
    }
    
    input_len = strlen(input_line);
    
    if (input_len > 0 && input_line[input_len - 1] == '\n') {
        input_line[input_len - 1] = '\0';
        input_len--;
    }
    
    if (input_len == 0) {
        return -1;
    }
    
    copy_len = input_len;
    if (copy_len >= buffer_size) {
        copy_len = buffer_size - 1;
    }
    
    for (i = 0; i < copy_len; i++) {
        if (i >= input_len) {
            break;
        }
        username_buffer[i] = input_line[i];
    }
    
    username_buffer[copy_len] = '\0';
    
    if (input_len >= buffer_size) {
        return 1;
    }
    
    return 0;
}

int read_username(char *dest_buffer, size_t dest_size) {
    size_t max_copy;
    int result;
    
    if (dest_buffer == NULL || dest_size < 2) {
        return -1;
    }
    
    max_copy = dest_size - 1;
    if (max_copy > USERNAME_MAX_LENGTH) {
        max_copy = USERNAME_MAX_LENGTH;
    }
    
    result = copy_username_from_input(dest_buffer, max_copy + 1);
    
    if (result < 0) {
        dest_buffer[0] = '\0';
        return -1;
    }
    
    dest_buffer[dest_size - 1] = '\0';
    
    return result;
}