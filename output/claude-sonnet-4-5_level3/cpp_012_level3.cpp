# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <iostream>
#include <memory>
#include <string>
#include <vector>
#include <stdexcept>
#include <cstring>

class NetworkConnection {
private:
    struct ConnectionResource {
        int socket_fd;
        char* buffer;
        size_t buffer_size;
        bool is_connected;
        
        ConnectionResource() : socket_fd(-1), buffer(nullptr), buffer_size(0), is_connected(false) {}
    };
    
    std::unique_ptr<ConnectionResource> resource;
    std::string host;
    int port;
    bool initialized;
    
    void cleanup() {
        if (resource) {
            if (resource->buffer) {
                delete[] resource->buffer;
                resource->buffer = nullptr;
            }
            if (resource->socket_fd >= 0) {
                resource->socket_fd = -1;
            }
            resource->is_connected = false;
        }
    }
    
    void allocateResources() {
        resource = std::make_unique<ConnectionResource>();
        
        try {
            resource->buffer_size = 4096;
            resource->buffer = new char[resource->buffer_size];
            std::memset(resource->buffer, 0, resource->buffer_size);
            
            resource->socket_fd = createSocket();
            if (resource->socket_fd < 0) {
                throw std::runtime_error("Failed to create socket");
            }
            
            resource->is_connected = true;
            initialized = true;
            
        } catch (...) {
            cleanup();
            throw;
        }
    }
    
    int createSocket() {
        static int socket_counter = 100;
        return socket_counter++;
    }
    
public:
    NetworkConnection(const std::string& host, int port) 
        : host(host), port(port), initialized(false) {
        try {
            allocateResources();
        } catch (const std::exception& e) {
            throw std::runtime_error(std::string("Failed to initialize connection: ") + e.what());
        }
    }
    
    ~NetworkConnection() {
        cleanup();
    }
    
    NetworkConnection(const NetworkConnection&) = delete;
    NetworkConnection& operator=(const NetworkConnection&) = delete;
    
    NetworkConnection(NetworkConnection&& other) noexcept 
        : resource(std::move(other.resource)),
          host(std::move(other.host)),
          port(other.port),
          initialized(other.initialized) {
        other.initialized = false;
    }
    
    NetworkConnection& operator=(NetworkConnection&& other) noexcept {
        if (this != &other) {
            cleanup();
            resource = std::move(other.resource);
            host = std::move(other.host);
            port = other.port;
            initialized = other.initialized;
            other.initialized = false;
        }
        return *this;
    }
    
    void reset() {
        if (!initialized) {
            throw std::runtime_error("Connection not initialized");
        }
        
        cleanup();
        
        try {
            allocateResources();
        } catch (const std::exception& e) {
            initialized = false;
            throw std::runtime_error(std::string("Failed to reset connection: ") + e.what());
        }
    }
    
    void reinitialize(const std::string& new_host, int new_port) {
        cleanup();
        
        host = new_host;
        port = new_port;
        initialized = false;
        
        try {
            allocateResources();
        } catch (const std::exception& e) {
            throw std::runtime_error(std::string("Failed to reinitialize connection: ") + e.what());
        }
    }
    
    bool isConnected() const {
        return initialized && resource && resource->is_connected;
    }
    
    int getSocketFd() const {
        if (!initialized || !resource) {
            throw std::runtime_error("Connection not initialized");
        }
        return resource->socket_fd;
    }
    
    const char* getBuffer() const {
        if (!initialized || !resource) {
            throw std::runtime_error("Connection not initialized");
        }
        return resource->buffer;
    }
    
    size_t getBufferSize() const {
        if (!initialized || !resource) {
            throw std::runtime_error("Connection not initialized");
        }
        return resource->buffer_size;
    }
    
    std::string getHost() const {
        return host;
    }
    
    int getPort() const {
        return port;
    }
    
    void send(const std::string& data) {
        if (!isConnected()) {
            throw std::runtime_error("Not connected");
        }
        
        if (data.size() >= resource->buffer_size) {
            throw std::runtime_error("Data too large for buffer");
        }
        
        std::memcpy(resource->buffer, data.c_str(), data.size());
    }
    
    std::string receive() {
        if (!isConnected()) {
            throw std::runtime_error("Not connected");
        }
        
        return std::string(resource->buffer);
    }
};

class NetworkConnectionPool {
private:
    std::vector<std::unique_ptr<NetworkConnection>> connections;
    size_t max_connections;
    
public:
    NetworkConnectionPool(size_t max_conn) : max_connections(max_conn) {
        connections.reserve(max_connections);
    }
    
    ~NetworkConnectionPool() {
        connections.clear();
    }
    
    NetworkConnectionPool(const NetworkConnectionPool&) = delete;
    NetworkConnectionPool& operator=(const NetworkConnectionPool&) = delete;
    
    void addConnection(const std::string& host, int port) {
        if (connections.size() >= max_connections) {
            throw std::runtime_error("Connection pool is full");
        }
        
        try {
            auto conn = std::make_unique<NetworkConnection>(host, port);
            connections.push_back(std::move(conn));
        } catch (const std::exception& e) {
            throw std::runtime_error(std::string("Failed to add connection: ") + e.what());
        }
    }
    
    void resetAll() {
        for (auto& conn : connections) {
            if (conn) {
                try {
                    conn->reset();
                } catch (const std::exception& e) {
                    std::cerr << "Failed to reset connection: " << e.what() << std::endl;
                }
            }
        }
    }
    
    size_t size() const {
        return connections.size();
    }
    
    NetworkConnection* getConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Connection index out of range");
        }
        return connections[index].get();
    }
};