# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <time.h>

#define MAX_REQUEST_SIZE 8192
#define MAX_RESPONSE_SIZE 4096
#define MAX_HEADERS 32
#define MAX_HEADER_SIZE 256
#define MAX_PATH_SIZE 512

typedef struct {
    char method[16];
    char path[MAX_PATH_SIZE];
    char version[16];
    int header_count;
    char headers[MAX_HEADERS][MAX_HEADER_SIZE];
} http_request_t;

typedef struct {
    int status_code;
    char status_text[64];
    int header_count;
    char headers[MAX_HEADERS][MAX_HEADER_SIZE];
    char* body;
    size_t body_length;
} http_response_t;

typedef struct {
    char* buffer;
    size_t size;
    size_t capacity;
} request_buffer_t;

static request_buffer_t* create_request_buffer(size_t capacity) {
    request_buffer_t* buf = (request_buffer_t*)malloc(sizeof(request_buffer_t));
    if (!buf) return NULL;
    
    buf->buffer = (char*)malloc(capacity);
    if (!buf->buffer) {
        free(buf);
        return NULL;
    }
    
    buf->size = 0;
    buf->capacity = capacity;
    memset(buf->buffer, 0, capacity);
    
    return buf;
}

static void destroy_request_buffer(request_buffer_t* buf) {
    if (buf) {
        if (buf->buffer) {
            free(buf->buffer);
            buf->buffer = NULL;
        }
        free(buf);
    }
}

static bool parse_request_line(const char* line, http_request_t* request) {
    char* line_copy = strdup(line);
    if (!line_copy) return false;
    
    char* saveptr;
    char* method = strtok_r(line_copy, " ", &saveptr);
    char* path = strtok_r(NULL, " ", &saveptr);
    char* version = strtok_r(NULL, "\r\n", &saveptr);
    
    bool success = false;
    if (method && path && version) {
        strncpy(request->method, method, sizeof(request->method) - 1);
        strncpy(request->path, path, sizeof(request->path) - 1);
        strncpy(request->version, version, sizeof(request->version) - 1);
        success = true;
    }
    
    free(line_copy);
    return success;
}

static bool parse_http_request(const char* raw_request, http_request_t* request) {
    memset(request, 0, sizeof(http_request_t));
    
    char* request_copy = strdup(raw_request);
    if (!request_copy) return false;
    
    char* saveptr;
    char* line = strtok_r(request_copy, "\n", &saveptr);
    
    bool success = false;
    if (line && parse_request_line(line, request)) {
        success = true;
        
        while ((line = strtok_r(NULL, "\n", &saveptr)) != NULL) {
            if (line[0] == '\r' || line[0] == '\0') break;
            
            if (request->header_count < MAX_HEADERS) {
                size_t len = strlen(line);
                if (len > 0 && line[len - 1] == '\r') {
                    line[len - 1] = '\0';
                }
                strncpy(request->headers[request->header_count], line, MAX_HEADER_SIZE - 1);
                request->header_count++;
            }
        }
    }
    
    free(request_copy);
    return success;
}

static http_response_t* create_response(int status_code, const char* status_text) {
    http_response_t* response = (http_response_t*)malloc(sizeof(http_response_t));
    if (!response) return NULL;
    
    memset(response, 0, sizeof(http_response_t));
    response->status_code = status_code;
    strncpy(response->status_text, status_text, sizeof(response->status_text) - 1);
    response->body = NULL;
    response->body_length = 0;
    
    return response;
}

static void add_response_header(http_response_t* response, const char* header) {
    if (response->header_count < MAX_HEADERS) {
        strncpy(response->headers[response->header_count], header, MAX_HEADER_SIZE - 1);
        response->header_count++;
    }
}

static bool set_response_body(http_response_t* response, const char* body) {
    if (response->body) {
        free(response->body);
        response->body = NULL;
    }
    
    size_t len = strlen(body);
    response->body = (char*)malloc(len + 1);
    if (!response->body) {
        response->body_length = 0;
        return false;
    }
    
    memcpy(response->body, body, len);
    response->body[len] = '\0';
    response->body_length = len;
    
    return true;
}

static void destroy_response(http_response_t* response) {
    if (response) {
        if (response->body) {
            free(response->body);
            response->body = NULL;
        }
        free(response);
    }
}

static char* serialize_response(http_response_t* response, size_t* out_length) {
    char* buffer = (char*)malloc(MAX_RESPONSE_SIZE);
    if (!buffer) return NULL;
    
    int offset = snprintf(buffer, MAX_RESPONSE_SIZE, 
                         "HTTP/1.1 %d %s\r\n", 
                         response->status_code, 
                         response->status_text);
    
    for (int i = 0; i < response->header_count; i++) {
        offset += snprintf(buffer + offset, MAX_RESPONSE_SIZE - offset,
                          "%s\r\n", response->headers[i]);
    }
    
    if (response->body && response->body_length > 0) {
        offset += snprintf(buffer + offset, MAX_RESPONSE_SIZE - offset,
                          "Content-Length: %zu\r\n", response->body_length);
    }
    
    offset += snprintf(buffer + offset, MAX_RESPONSE_SIZE - offset, "\r\n");
    
    if (response->body && response->body_length > 0) {
        size_t remaining = MAX_RESPONSE_SIZE - offset;
        size_t to_copy = response->body_length < remaining ? response->body_length : remaining;
        memcpy(buffer + offset, response->body, to_copy);
        offset += to_copy;
    }
    
    *out_length = offset;
    return buffer;
}

static http_response_t* handle_get_request(const http_request_t* request) {
    http_response_t* response = create_response(200, "OK");
    if (!response) return NULL;
    
    add_response_header(response, "Content-Type: text/html");
    add_response_header(response, "Server: EmbeddedHTTP/1.0");
    
    char body[512];
    snprintf(body, sizeof(body),
             "<html><body><h1>Request Processed</h1><p>Path: %s</p></body></html>",
             request->path);
    
    if (!set_response_body(response, body)) {
        destroy_response(response);
        return NULL;
    }
    
    return response;
}

static http_response_t* handle_post_request(const http_request_t* request) {
    http_response_t* response = create_response(201, "Created");
    if (!response) return NULL;
    
    add_response_header(response, "Content-Type: application/json");
    add_response_header(response, "Server: EmbeddedHTTP/1.0");
    
    const char* body = "{\"status\":\"success\",\"message\":\"Resource created\"}";
    
    if (!set_response_body(response, body)) {
        destroy_response(response);
        return NULL;
    }
    
    return response;
}

static http_response_t* handle_request(const http_request_t* request) {
    if (strcmp(request->method, "GET") == 0) {
        return handle_get_request(request);
    } else if (strcmp(request->method, "POST") == 0) {
        return handle_post_request(request);
    } else {
        http_response_t* response = create_response(405, "Method Not Allowed");
        if (response) {
            add_response_header(response, "Allow: GET, POST");
            add_response_header(response, "Server: EmbeddedHTTP/1.0");
        }
        return response;
    }
}

static bool simulate_receive_request(request_buffer_t* buffer) {
    static int request_count = 0;
    static const char* sample_requests[] = {
        "GET / HTTP/1.1\r\nHost: localhost\r\nUser-Agent: TestClient/1.0\r\n\r\n",
        "GET /api/status HTTP/1.1\r\nHost: localhost\r\nAccept: application/json\r\n\r\n",
        "POST /api/data HTTP/1.1\r\nHost: localhost\r\nContent-Type: application/json\r\n\r\n",
        "GET /index.html HTTP/1.1\r\nHost: localhost\r\n\r\n"
    };
    
    const char* request = sample_requests[request_count % 4];
    size_t len = strlen(request);
    
    if (len >= buffer->capacity) return false;
    
    memcpy(buffer->buffer, request, len);
    buffer->size = len;
    buffer->buffer[len] = '\0';
    
    request_count++;
    return true;
}

static void simulate_send_response(const char* response, size_t length) {
    printf("Sending response (%zu bytes):\n", length);
    printf("---\n%.*s\n---\n\n", (int)length, response);
}

static bool process_single_request(request_buffer_t* buffer) {
    if (!simulate_receive_request(buffer)) {
        return false;
    }
    
    http_request_t request;
    if (!parse_http_request(buffer->buffer, &request)) {
        printf("Failed to parse request\n");
        return false;
    }
    
    printf("Processing: %s %s %s\n", request.method, request.path, request.version);
    
    http_response_t* response = handle_request(&request);
    if (!response) {
        printf("Failed to create response\n");
        return false;
    }
    
    size_t response_length;
    char* response_data = serialize_response(response, &response_length);
    
    if (response_data) {
        simulate_send_response(response_data, response_length);
        free(response_data);
    }
    
    destroy_response(response);
    
    buffer->size = 0;
    memset(buffer->buffer, 0, buffer->capacity);
    
    return true;
}

int main(void) {
    printf("Starting embedded HTTP server...\n\n");
    
    request_buffer_t* buffer = create_request_buffer(MAX_REQUEST_SIZE);
    if (!buffer) {
        fprintf(stderr, "Failed to allocate request buffer\n");
        return 1;
    }
    
    int requests_processed = 0;
    const int max_requests = 10;
    
    while (requests_processed < max_requests) {
        if (!process_single_request(buffer)) {
            fprintf(stderr, "Error processing request\n");
            break;
        }
        
        requests_processed++;
        
        struct timespec ts = {0, 100000000};
        nanosleep(&ts, NULL);
    }
    
    destroy_request_buffer(buffer);
    
    printf("\nServer processed %d requests. Shutting down.\n", requests_processed);
    
    return 0;
}