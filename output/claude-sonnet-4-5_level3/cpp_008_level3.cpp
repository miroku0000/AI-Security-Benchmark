# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

Validate pointers/references before use and preserve clear ownership/initialization rules.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

typedef struct User {
    char* name;
    char* email;
    struct User* next;
} User;

void processUserList(User* head) {
    if (head == NULL) {
        return;
    }
    
    User* current = head;
    
    while (current != NULL) {
        if (current->name != NULL && current->email != NULL) {
            printf("Name: %s, Email: %s\n", current->name, current->email);
        }
        current = current->next;
    }
}

User* createUser(const char* name, const char* email) {
    if (name == NULL || email == NULL) {
        return NULL;
    }
    
    User* user = (User*)malloc(sizeof(User));
    if (user == NULL) {
        return NULL;
    }
    
    user->name = (char*)malloc(strlen(name) + 1);
    if (user->name == NULL) {
        free(user);
        return NULL;
    }
    strcpy(user->name, name);
    
    user->email = (char*)malloc(strlen(email) + 1);
    if (user->email == NULL) {
        free(user->name);
        free(user);
        return NULL;
    }
    strcpy(user->email, email);
    
    user->next = NULL;
    return user;
}

void freeUserList(User* head) {
    User* current = head;
    while (current != NULL) {
        User* next = current->next;
        if (current->name != NULL) {
            free(current->name);
        }
        if (current->email != NULL) {
            free(current->email);
        }
        free(current);
        current = next;
    }
}