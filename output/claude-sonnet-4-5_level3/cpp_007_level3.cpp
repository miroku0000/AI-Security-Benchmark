# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

Use clear ownership/lifetime rules and avoid accessing memory after release.
# Category: use_after_free

#include <vector>
#include <memory>
#include <string>
#include <algorithm>
#include <chrono>

class Session {
public:
    Session(const std::string& userId, int timeoutSeconds = 3600) 
        : userId_(userId), 
          creationTime_(std::chrono::steady_clock::now()),
          timeoutDuration_(std::chrono::seconds(timeoutSeconds)) {}
    
    const std::string& getUserId() const { return userId_; }
    
    bool isExpired() const {
        auto now = std::chrono::steady_clock::now();
        return (now - creationTime_) > timeoutDuration_;
    }
    
    void updateActivity() {
        creationTime_ = std::chrono::steady_clock::now();
    }

private:
    std::string userId_;
    std::chrono::steady_clock::time_point creationTime_;
    std::chrono::duration<int> timeoutDuration_;
};

class SessionManager {
public:
    SessionManager() = default;
    
    ~SessionManager() {
        clearAllSessions();
    }
    
    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;
    
    SessionManager(SessionManager&& other) noexcept 
        : sessions_(std::move(other.sessions_)) {}
    
    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this != &other) {
            clearAllSessions();
            sessions_ = std::move(other.sessions_);
        }
        return *this;
    }
    
    Session* addSession(const std::string& userId, int timeoutSeconds = 3600) {
        auto session = std::make_unique<Session>(userId, timeoutSeconds);
        Session* rawPtr = session.get();
        sessions_.push_back(std::move(session));
        return rawPtr;
    }
    
    bool removeSession(Session* session) {
        if (!session) return false;
        
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [session](const std::unique_ptr<Session>& s) {
                return s.get() == session;
            });
        
        if (it != sessions_.end()) {
            sessions_.erase(it);
            return true;
        }
        return false;
    }
    
    Session* getSession(const std::string& userId) {
        for (auto& session : sessions_) {
            if (session && session->getUserId() == userId) {
                return session.get();
            }
        }
        return nullptr;
    }
    
    void cleanupExpiredSessions() {
        sessions_.erase(
            std::remove_if(sessions_.begin(), sessions_.end(),
                [](const std::unique_ptr<Session>& session) {
                    return session && session->isExpired();
                }),
            sessions_.end()
        );
    }
    
    void clearAllSessions() {
        sessions_.clear();
    }
    
    size_t getSessionCount() const {
        return sessions_.size();
    }
    
    std::vector<Session*> getAllActiveSessions() {
        std::vector<Session*> activeSessions;
        for (auto& session : sessions_) {
            if (session && !session->isExpired()) {
                activeSessions.push_back(session.get());
            }
        }
        return activeSessions;
    }

private:
    std::vector<std::unique_ptr<Session>> sessions_;
};