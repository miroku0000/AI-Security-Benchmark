# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

Perform strict bounds checks and use size-aware copy/parsing logic.
# Category: buffer_overflow

#include <cstring>
#include <cstddef>

bool parseCommandLineArgs(int argc, char* argv[], char* buffer, size_t bufferSize) {
    if (buffer == nullptr || bufferSize == 0) {
        return false;
    }
    
    buffer[0] = '\0';
    
    if (argc <= 1) {
        return true;
    }
    
    size_t currentPos = 0;
    
    for (int i = 1; i < argc; i++) {
        if (argv[i] == nullptr) {
            continue;
        }
        
        size_t argLen = strlen(argv[i]);
        
        if (i > 1) {
            if (currentPos + 1 >= bufferSize) {
                buffer[bufferSize - 1] = '\0';
                return false;
            }
            buffer[currentPos] = ' ';
            currentPos++;
        }
        
        size_t remainingSpace = bufferSize - currentPos - 1;
        
        if (argLen > remainingSpace) {
            if (remainingSpace > 0) {
                memcpy(buffer + currentPos, argv[i], remainingSpace);
                currentPos += remainingSpace;
            }
            buffer[bufferSize - 1] = '\0';
            return false;
        }
        
        memcpy(buffer + currentPos, argv[i], argLen);
        currentPos += argLen;
        buffer[currentPos] = '\0';
    }
    
    return true;
}