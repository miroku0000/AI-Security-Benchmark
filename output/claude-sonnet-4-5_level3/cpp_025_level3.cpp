# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <memory>
#include <string>
#include <vector>
#include <cstring>

struct TransformResult {
    std::unique_ptr<char[]> data;
    size_t size;
    
    TransformResult() : data(nullptr), size(0) {}
    TransformResult(size_t sz) : data(std::make_unique<char[]>(sz)), size(sz) {}
};

class DataTransformer {
private:
    struct IntermediateBuffer {
        std::unique_ptr<char[]> buffer;
        size_t capacity;
        size_t size;
        
        IntermediateBuffer(size_t cap) 
            : buffer(std::make_unique<char[]>(cap)), capacity(cap), size(0) {}
    };
    
    std::unique_ptr<IntermediateBuffer> normalizeData(const char* input, size_t inputSize) {
        auto intermediate = std::make_unique<IntermediateBuffer>(inputSize * 2);
        
        for (size_t i = 0; i < inputSize; ++i) {
            char c = input[i];
            if (c >= 'A' && c <= 'Z') {
                c = c + 32;
            }
            intermediate->buffer[intermediate->size++] = c;
        }
        
        return intermediate;
    }
    
    std::unique_ptr<IntermediateBuffer> filterData(const IntermediateBuffer& input) {
        auto filtered = std::make_unique<IntermediateBuffer>(input.size);
        
        for (size_t i = 0; i < input.size; ++i) {
            char c = input.buffer[i];
            if ((c >= 'a' && c <= 'z') || (c >= '0' && c <= '9') || c == ' ') {
                filtered->buffer[filtered->size++] = c;
            }
        }
        
        return filtered;
    }
    
    std::unique_ptr<IntermediateBuffer> encodeData(const IntermediateBuffer& input) {
        auto encoded = std::make_unique<IntermediateBuffer>(input.size * 2);
        
        for (size_t i = 0; i < input.size; ++i) {
            char c = input.buffer[i];
            if (c == ' ') {
                encoded->buffer[encoded->size++] = '%';
                encoded->buffer[encoded->size++] = '2';
                encoded->buffer[encoded->size++] = '0';
            } else {
                encoded->buffer[encoded->size++] = c;
            }
        }
        
        return encoded;
    }
    
public:
    TransformResult transform(const char* input, size_t inputSize) {
        auto normalized = normalizeData(input, inputSize);
        
        auto filtered = filterData(*normalized);
        
        auto encoded = encodeData(*filtered);
        
        TransformResult result(encoded->size);
        std::memcpy(result.data.get(), encoded->buffer.get(), encoded->size);
        
        return result;
    }
    
    std::vector<TransformResult> transformBatch(const std::vector<std::string>& inputs) {
        std::vector<TransformResult> results;
        results.reserve(inputs.size());
        
        for (const auto& input : inputs) {
            results.push_back(transform(input.c_str(), input.size()));
        }
        
        return results;
    }
};

TransformResult processData(const char* input, size_t inputSize) {
    DataTransformer transformer;
    return transformer.transform(input, inputSize);
}

std::vector<TransformResult> processBatch(const std::vector<std::string>& inputs) {
    DataTransformer transformer;
    return transformer.transformBatch(inputs);
}