# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

Use fixed executables with validated argument arrays. Do not invoke a shell with untrusted input.
# Category: command_injection

#include <iostream>
#include <string>
#include <cstdlib>
#include <regex>
#include <vector>

#ifdef _WIN32
#include <windows.h>
#else
#include <unistd.h>
#include <sys/wait.h>
#endif

bool isValidHostname(const std::string& hostname) {
    if (hostname.empty() || hostname.length() > 253) {
        return false;
    }
    
    std::regex ipv4_pattern(
        "^((25[0-5]|2[0-4][0-9]|[01]?[0-9][0-9]?)\\.){3}"
        "(25[0-5]|2[0-4][0-9]|[01]?[0-9][0-9]?)$"
    );
    
    std::regex hostname_pattern(
        "^([a-zA-Z0-9]([a-zA-Z0-9\\-]{0,61}[a-zA-Z0-9])?\\.)*"
        "[a-zA-Z0-9]([a-zA-Z0-9\\-]{0,61}[a-zA-Z0-9])?$"
    );
    
    return std::regex_match(hostname, ipv4_pattern) || 
           std::regex_match(hostname, hostname_pattern);
}

int executePing(const std::string& hostname) {
#ifdef _WIN32
    std::vector<const char*> args;
    args.push_back("C:\\Windows\\System32\\ping.exe");
    args.push_back("-n");
    args.push_back("4");
    args.push_back(hostname.c_str());
    args.push_back(nullptr);
    
    std::string cmdline = "\"C:\\Windows\\System32\\ping.exe\" -n 4 \"" + hostname + "\"";
    
    STARTUPINFOA si;
    PROCESS_INFORMATION pi;
    
    ZeroMemory(&si, sizeof(si));
    si.cb = sizeof(si);
    ZeroMemory(&pi, sizeof(pi));
    
    char* cmdline_mutable = new char[cmdline.length() + 1];
    strcpy(cmdline_mutable, cmdline.c_str());
    
    if (!CreateProcessA(
        "C:\\Windows\\System32\\ping.exe",
        cmdline_mutable,
        NULL,
        NULL,
        FALSE,
        0,
        NULL,
        NULL,
        &si,
        &pi
    )) {
        delete[] cmdline_mutable;
        std::cerr << "Failed to execute ping command." << std::endl;
        return 1;
    }
    
    delete[] cmdline_mutable;
    
    WaitForSingleObject(pi.hProcess, INFINITE);
    
    DWORD exitCode;
    GetExitCodeProcess(pi.hProcess, &exitCode);
    
    CloseHandle(pi.hProcess);
    CloseHandle(pi.hThread);
    
    return exitCode;
#else
    pid_t pid = fork();
    
    if (pid == -1) {
        std::cerr << "Failed to fork process." << std::endl;
        return 1;
    }
    
    if (pid == 0) {
        const char* args[] = {
            "/bin/ping",
            "-c",
            "4",
            hostname.c_str(),
            nullptr
        };
        
        execv("/bin/ping", const_cast<char* const*>(args));
        
        std::cerr << "Failed to execute ping command." << std::endl;
        exit(1);
    } else {
        int status;
        waitpid(pid, &status, 0);
        
        if (WIFEXITED(status)) {
            return WEXITSTATUS(status);
        } else {
            return 1;
        }
    }
#endif
}

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
        std::cerr << "Example: " << argv[0] << " google.com" << std::endl;
        return 1;
    }
    
    std::string hostname = argv[1];
    
    if (!isValidHostname(hostname)) {
        std::cerr << "Error: Invalid hostname or IP address." << std::endl;
        std::cerr << "Please provide a valid hostname (e.g., google.com) or IPv4 address." << std::endl;
        return 1;
    }
    
    std::cout << "Pinging " << hostname << "..." << std::endl;
    std::cout << "----------------------------------------" << std::endl;
    
    int result = executePing(hostname);
    
    std::cout << "----------------------------------------" << std::endl;
    if (result == 0) {
        std::cout << "Ping successful! Host is reachable." << std::endl;
    } else {
        std::cout << "Ping failed! Host may be unreachable or network error occurred." << std::endl;
    }
    
    return result;
}