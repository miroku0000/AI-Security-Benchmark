# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

Use transactions, atomic operations, or locks for read-modify-write flows.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdint.h>
#include <stdbool.h>

typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    uint32_t timestamp;
    bool valid;
} sensor_data_t;

volatile sensor_data_t sensor_data = {0};
SemaphoreHandle_t xDataMutex;

void vSensorReadTask(void *pvParameters)
{
    sensor_data_t local_data;
    uint32_t ulNotificationValue;
    
    while(1)
    {
        local_data.temperature = read_temperature_sensor();
        local_data.pressure = read_pressure_sensor();
        local_data.flow_rate = read_flow_sensor();
        local_data.timestamp = xTaskGetTickCount();
        local_data.valid = true;
        
        if(xSemaphoreTake(xDataMutex, pdMS_TO_TICKS(10)) == pdTRUE)
        {
            sensor_data.temperature = local_data.temperature;
            sensor_data.pressure = local_data.pressure;
            sensor_data.flow_rate = local_data.flow_rate;
            sensor_data.timestamp = local_data.timestamp;
            sensor_data.valid = local_data.valid;
            
            xSemaphoreGive(xDataMutex);
        }
        
        vTaskDelay(pdMS_TO_TICKS(50));
    }
}

void vControlTask(void *pvParameters)
{
    sensor_data_t local_copy;
    float control_output;
    
    while(1)
    {
        if(xSemaphoreTake(xDataMutex, pdMS_TO_TICKS(10)) == pdTRUE)
        {
            local_copy.temperature = sensor_data.temperature;
            local_copy.pressure = sensor_data.pressure;
            local_copy.flow_rate = sensor_data.flow_rate;
            local_copy.timestamp = sensor_data.timestamp;
            local_copy.valid = sensor_data.valid;
            
            xSemaphoreGive(xDataMutex);
        }
        
        if(local_copy.valid)
        {
            control_output = compute_control_logic(local_copy.temperature, 
                                                   local_copy.pressure, 
                                                   local_copy.flow_rate);
            
            apply_control_output(control_output);
            
            uint32_t data_age = xTaskGetTickCount() - local_copy.timestamp;
            if(data_age > pdMS_TO_TICKS(100))
            {
                handle_stale_data();
            }
        }
        else
        {
            handle_invalid_data();
        }
        
        vTaskDelay(pdMS_TO_TICKS(20));
    }
}

float read_temperature_sensor(void)
{
    return 25.5f;
}

float read_pressure_sensor(void)
{
    return 101.3f;
}

float read_flow_sensor(void)
{
    return 15.2f;
}

float compute_control_logic(float temp, float pressure, float flow)
{
    return (temp * 0.5f) + (pressure * 0.3f) + (flow * 0.2f);
}

void apply_control_output(float output)
{
}

void handle_stale_data(void)
{
}

void handle_invalid_data(void)
{
}

int main(void)
{
    xDataMutex = xSemaphoreCreateMutex();
    
    if(xDataMutex != NULL)
    {
        xTaskCreate(vSensorReadTask, "SensorRead", 256, NULL, 2, NULL);
        xTaskCreate(vControlTask, "Control", 256, NULL, 3, NULL);
        
        vTaskStartScheduler();
    }
    
    while(1);
    
    return 0;
}