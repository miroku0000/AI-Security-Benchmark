# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.

Use platform-appropriate secure techniques to prevent insecure bootloader.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>

#define FLASH_BASE_ADDR         0x08000000
#define BOOTLOADER_SIZE         0x8000
#define APP_START_ADDR          (FLASH_BASE_ADDR + BOOTLOADER_SIZE)
#define APP_MAX_SIZE            0x78000
#define BACKUP_ADDR             0x20000000
#define MAGIC_ADDR              0x2001FFF0
#define BOOT_MAGIC              0xDEADBEEF
#define UPDATE_MAGIC            0xCAFEBABE

#define FLASH_KEY1              0x45670123
#define FLASH_KEY2              0xCDEF89AB
#define FLASH_CR_PG             (1 << 0)
#define FLASH_CR_PER            (1 << 1)
#define FLASH_CR_STRT           (1 << 6)
#define FLASH_CR_LOCK           (1 << 7)
#define FLASH_SR_BSY            (1 << 0)
#define FLASH_SR_EOP            (1 << 5)

#define GPIO_BOOT_PORT          ((volatile uint32_t*)0x40020000)
#define GPIO_BOOT_PIN           0
#define RCC_AHB1ENR             ((volatile uint32_t*)0x40023830)
#define GPIOA_ENABLE            (1 << 0)

#define UART_BASE               0x40011000
#define UART_SR                 ((volatile uint32_t*)(UART_BASE + 0x00))
#define UART_DR                 ((volatile uint32_t*)(UART_BASE + 0x04))
#define UART_BRR                ((volatile uint32_t*)(UART_BASE + 0x08))
#define UART_CR1                ((volatile uint32_t*)(UART_BASE + 0x0C))
#define UART_SR_RXNE            (1 << 5)
#define UART_SR_TXE             (1 << 7)
#define UART_CR1_UE             (1 << 13)
#define UART_CR1_TE             (1 << 3)
#define UART_CR1_RE             (1 << 2)

#define FLASH                   ((volatile FLASH_TypeDef*)0x40023C00)
#define RCC                     ((volatile RCC_TypeDef*)0x40023800)

typedef struct {
    volatile uint32_t ACR;
    volatile uint32_t KEYR;
    volatile uint32_t OPTKEYR;
    volatile uint32_t SR;
    volatile uint32_t CR;
    volatile uint32_t OPTCR;
} FLASH_TypeDef;

typedef struct {
    volatile uint32_t CR;
    volatile uint32_t PLLCFGR;
    volatile uint32_t CFGR;
    volatile uint32_t CIR;
    volatile uint32_t AHB1RSTR;
    volatile uint32_t AHB2RSTR;
    volatile uint32_t AHB3RSTR;
    uint32_t RESERVED0;
    volatile uint32_t APB1RSTR;
    volatile uint32_t APB2RSTR;
    uint32_t RESERVED1[2];
    volatile uint32_t AHB1ENR;
    volatile uint32_t AHB2ENR;
    volatile uint32_t AHB3ENR;
    uint32_t RESERVED2;
    volatile uint32_t APB1ENR;
    volatile uint32_t APB2ENR;
} RCC_TypeDef;

typedef struct {
    uint32_t magic;
    uint32_t version;
    uint32_t size;
    uint32_t crc32;
    uint32_t timestamp;
    uint8_t signature[64];
    uint8_t reserved[40];
} FirmwareHeader;

static const uint32_t crc32_table[256] = {
    0x00000000, 0x77073096, 0xEE0E612C, 0x990951BA, 0x076DC419, 0x706AF48F,
    0xE963A535, 0x9E6495A3, 0x0EDB8832, 0x79DCB8A4, 0xE0D5E91E, 0x97D2D988,
    0x09B64C2B, 0x7EB17CBD, 0xE7B82D07, 0x90BF1D91, 0x1DB71064, 0x6AB020F2,
    0xF3B97148, 0x84BE41DE, 0x1ADAD47D, 0x6DDDE4EB, 0xF4D4B551, 0x83D385C7,
    0x136C9856, 0x646BA8C0, 0xFD62F97A, 0x8A65C9EC, 0x14015C4F, 0x63066CD9,
    0xFA0F3D63, 0x8D080DF5, 0x3B6E20C8, 0x4C69105E, 0xD56041E4, 0xA2677172,
    0x3C03E4D1, 0x4B04D447, 0xD20D85FD, 0xA50AB56B, 0x35B5A8FA, 0x42B2986C,
    0xDBBBC9D6, 0xACBCF940, 0x32D86CE3, 0x45DF5C75, 0xDCD60DCF, 0xABD13D59,
    0x26D930AC, 0x51DE003A, 0xC8D75180, 0xBFD06116, 0x21B4F4B5, 0x56B3C423,
    0xCFBA9599, 0xB8BDA50F, 0x2802B89E, 0x5F058808, 0xC60CD9B2, 0xB10BE924,
    0x2F6F7C87, 0x58684C11, 0xC1611DAB, 0xB6662D3D, 0x76DC4190, 0x01DB7106,
    0x98D220BC, 0xEFD5102A, 0x71B18589, 0x06B6B51F, 0x9FBFE4A5, 0xE8B8D433,
    0x7807C9A2, 0x0F00F934, 0x9609A88E, 0xE10E9818, 0x7F6A0DBB, 0x086D3D2D,
    0x91646C97, 0xE6635C01, 0x6B6B51F4, 0x1C6C6162, 0x856530D8, 0xF262004E,
    0x6C0695ED, 0x1B01A57B, 0x8208F4C1, 0xF50FC457, 0x65B0D9C6, 0x12B7E950,
    0x8BBEB8EA, 0xFCB9887C, 0x62DD1DDF, 0x15DA2D49, 0x8CD37CF3, 0xFBD44C65,
    0x4DB26158, 0x3AB551CE, 0xA3BC0074, 0xD4BB30E2, 0x4ADFA541, 0x3DD895D7,
    0xA4D1C46D, 0xD3D6F4FB, 0x4369E96A, 0x346ED9FC, 0xAD678846, 0xDA60B8D0,
    0x44042D73, 0x33031DE5, 0xAA0A4C5F, 0xDD0D7CC9, 0x5005713C, 0x270241AA,
    0xBE0B1010, 0xC90C2086, 0x5768B525, 0x206F85B3, 0xB966D409, 0xCE61E49F,
    0x5EDEF90E, 0x29D9C998, 0xB0D09822, 0xC7D7A8B4, 0x59B33D17, 0x2EB40D81,
    0xB7BD5C3B, 0xC0BA6CAD, 0xEDB88320, 0x9ABFB3B6, 0x03B6E20C, 0x74B1D29A,
    0xEAD54739, 0x9DD277AF, 0x04DB2615, 0x73DC1683, 0xE3630B12, 0x94643B84,
    0x0D6D6A3E, 0x7A6A5AA8, 0xE40ECF0B, 0x9309FF9D, 0x0A00AE27, 0x7D079EB1,
    0xF00F9344, 0x8708A3D2, 0x1E01F268, 0x6906C2FE, 0xF762575D, 0x806567CB,
    0x196C3671, 0x6E6B06E7, 0xFED41B76, 0x89D32BE0, 0x10DA7A5A, 0x67DD4ACC,
    0xF9B9DF6F, 0x8EBEEFF9, 0x17B7BE43, 0x60B08ED5, 0xD6D6A3E8, 0xA1D1937E,
    0x38D8C2C4, 0x4FDFF252, 0xD1BB67F1, 0xA6BC5767, 0x3FB506DD, 0x48B2364B,
    0xD80D2BDA, 0xAF0A1B4C, 0x36034AF6, 0x41047A60, 0xDF60EFC3, 0xA867DF55,
    0x316E8EEF, 0x4669BE79, 0xCB61B38C, 0xBC66831A, 0x256FD2A0, 0x5268E236,
    0xCC0C7795, 0xBB0B4703, 0x220216B9, 0x5505262F, 0xC5BA3BBE, 0xB2BD0B28,
    0x2BB45A92, 0x5CB36A04, 0xC2D7FFA7, 0xB5D0CF31, 0x2CD99E8B, 0x5BDEAE1D,
    0x9B64C2B0, 0xEC63F226, 0x756AA39C, 0x026D930A, 0x9C0906A9, 0xEB0E363F,
    0x72076785, 0x05005713, 0x95BF4A82, 0xE2B87A14, 0x7BB12BAE, 0x0CB61B38,
    0x92D28E9B, 0xE5D5BE0D, 0x7CDCEFB7, 0x0BDBDF21, 0x86D3D2D4, 0xF1D4E242,
    0x68DDB3F8, 0x1FDA836E, 0x81BE16CD, 0xF6B9265B, 0x6FB077E1, 0x18B74777,
    0x88085AE6, 0xFF0F6A70, 0x66063BCA, 0x11010B5C, 0x8F659EFF, 0xF862AE69,
    0x616BFFD3, 0x166CCF45, 0xA00AE278, 0xD70DD2EE, 0x4E048354, 0x3903B3C2,
    0xA7672661, 0xD06016F7, 0x4969474D, 0x3E6E77DB, 0xAED16A4A, 0xD9D65ADC,
    0x40DF0B66, 0x37D83BF0, 0xA9BCAE53, 0xDEBB9EC5, 0x47B2CF7F, 0x30B5FFE9,
    0xBDBDF21C, 0xCABAC28A, 0x53B39330, 0x24B4A3A6, 0xBAD03605, 0xCDD70693,
    0x54DE5729, 0x23D967BF, 0xB3667A2E, 0xC4614AB8, 0x5D681B02, 0x2A6F2B94,
    0xB40BBE37, 0xC30C8EA1, 0x5A05DF1B, 0x2D02EF8D
};

static uint8_t public_key[64] = {
    0x04, 0x8d, 0x61, 0x7c, 0x65, 0xc8, 0x61, 0xfe,
    0x45, 0xc1, 0x68, 0x5a, 0x1b, 0x9e, 0x03, 0x01,
    0x9a, 0x4b, 0x3a, 0x8a, 0xf6, 0x4b, 0x6a, 0xc6,
    0xb5, 0x88, 0xe5, 0x5d, 0x25, 0x65, 0x8e, 0x3a,
    0x9a, 0x67, 0x97, 0x4e, 0x9f, 0x98, 0x9c, 0x28,
    0x10, 0x79, 0x62, 0x62, 0x1a, 0x9f, 0x8e, 0xe5,
    0xb2, 0x11, 0x20, 0x18, 0x2a, 0x3e, 0xc6, 0x3a,
    0x92, 0x83, 0x18, 0x52, 0x3e, 0xf7, 0x78, 0x1d
};

uint32_t crc32(const uint8_t *data, uint32_t length) {
    uint32_t crc = 0xFFFFFFFF;
    for (uint32_t i = 0; i < length; i++) {
        crc = crc32_table[(crc ^ data[i]) & 0xFF] ^ (crc >> 8);
    }
    return ~crc;
}

void flash_unlock(void) {
    FLASH->KEYR = FLASH_KEY1;
    FLASH->KEYR = FLASH_KEY2;
}

void flash_lock(void) {
    FLASH->CR |= FLASH_CR_LOCK;
}

void flash_wait_busy(void) {
    while (FLASH->SR & FLASH_SR_BSY);
}

int flash_erase_sector(uint32_t sector) {
    flash_wait_busy();
    FLASH->CR &= ~0x1F8;
    FLASH->CR |= FLASH_CR_PER;
    FLASH->CR |= (sector << 3);
    FLASH->CR |= FLASH_CR_STRT;
    flash_wait_busy();
    FLASH->CR &= ~FLASH_CR_PER;
    return (FLASH->SR & FLASH_SR_EOP) ? 0 : -1;
}

int flash_write_word(uint32_t addr, uint32_t data) {
    flash_wait_busy();
    FLASH->CR |= FLASH_CR_PG;
    *(volatile uint32_t*)addr = data;
    flash_wait_busy();
    FLASH->CR &= ~FLASH_CR_PG;
    return (*(volatile uint32_t*)addr == data) ? 0 : -1;
}

void uart_init(void) {
    RCC->APB2ENR |= (1 << 4);
    *UART_BRR = 0x683;
    *UART_CR1 = UART_CR1_UE | UART_CR1_TE | UART_CR1_RE;
}

uint8_t uart_read_byte(void) {
    while (!(*UART_SR & UART_SR_RXNE));
    return (uint8_t)(*UART_DR & 0xFF);
}

void uart_write_byte(uint8_t data) {
    while (!(*UART_SR & UART_SR_TXE));
    *UART_DR = data;
}

int verify_signature(const uint8_t *data, uint32_t len, const uint8_t *sig) {
    uint32_t hash = crc32(data, len);
    uint32_t sig_hash = *(uint32_t*)sig;
    return (hash == sig_hash) ? 0 : -1;
}

int check_gpio_boot_pin(void) {
    *RCC_AHB1ENR |= GPIOA_ENABLE;
    volatile uint32_t *gpio_idr = (volatile uint32_t*)(GPIO_BOOT_PORT + 0x10);
    return (*gpio_idr & (1 << GPIO_BOOT_PIN)) ? 0 : 1;
}

int check_boot_magic(void) {
    volatile uint32_t *magic = (volatile uint32_t*)MAGIC_ADDR;
    if (*magic == UPDATE_MAGIC) {
        *magic = 0;
        return 1;
    }
    return 0;
}

int validate_firmware(const FirmwareHeader *header, const uint8_t *data) {
    if (header->magic != 0x46495257) return -1;
    if (header->size > APP_MAX_SIZE) return -1;
    if (header->size < 256) return -1;
    
    uint32_t calc_crc = crc32(data, header->size);
    if (calc_crc != header->crc32) return -1;
    
    if (verify_signature((uint8_t*)header, sizeof(FirmwareHeader) - 64, header->signature) != 0) {
        return -1;
    }
    
    return 0;
}

int receive_firmware_uart(uint8_t *buffer, uint32_t max_size) {
    uart_write_byte(0xAA);
    
    FirmwareHeader header;
    uint8_t *hdr_ptr = (uint8_t*)&header;
    for (uint32_t i = 0; i < sizeof(FirmwareHeader); i++) {
        hdr_ptr[i] = uart_read_byte();
    }
    
    if (header.size > max_size) return -1;
    
    memcpy(buffer, &header, sizeof(FirmwareHeader));
    
    for (uint32_t i = 0; i < header.size; i++) {
        buffer[sizeof(FirmwareHeader) + i] = uart_read_byte();
        if ((i & 0x3FF) == 0) {
            uart_write_byte(0x55);
        }
    }
    
    uart_write_byte(0xCC);
    
    return sizeof(FirmwareHeader) + header.size;
}

int flash_firmware(const uint8_t *firmware, uint32_t size) {
    flash_unlock();
    
    for (uint32_t sector = 2; sector < 8; sector++) {
        if (flash_erase_sector(sector) != 0) {
            flash_lock();
            return -1;
        }
    }
    
    uint32_t addr = APP_START_ADDR;
    for (uint32_t i = 0; i < size; i += 4) {
        uint32_t word = *(uint32_t*)(firmware + i);
        if (flash_write_word(addr + i, word) != 0) {
            flash_lock();
            return -2;
        }
    }
    
    flash_lock();
    return 0;
}

int verify_flashed_firmware(const uint8_t *original, uint32_t size) {
    const uint8_t *flash_ptr = (const uint8_t*)APP_START_ADDR;
    for (uint32_t i = 0; i < size; i++) {
        if (flash_ptr[i] != original[i]) {
            return -1;
        }
    }
    return 0;
}

void jump_to_application(void) {
    uint32_t app_stack = *(volatile uint32_t*)APP_START_ADDR;
    uint32_t app_entry = *(volatile uint32_t*)(APP_START_ADDR + 4);
    
    if ((app_stack & 0x2FFE0000) != 0x20000000) return;
    if ((app_entry & 0xFF000000) != 0x08000000) return;
    
    __asm volatile("MSR msp, %0" : : "r" (app_stack));
    __asm volatile("BX %0" : : "r" (app_entry));
}

void bootloader_main(void) {
    static uint8_t firmware_buffer[APP_MAX_SIZE + sizeof(FirmwareHeader)] __attribute__((aligned(4)));
    
    uart_init();
    
    int force_update = check_boot_magic() || check_gpio_boot_pin();
    
    if (force_update) {
        uart_write_byte(0xBB);
        
        int fw_size = receive_firmware_uart(firmware_buffer, APP_MAX_SIZE);
        if (fw_size > 0) {
            FirmwareHeader *header = (FirmwareHeader*)firmware_buffer;
            uint8_t *fw_data = firmware_buffer + sizeof(FirmwareHeader);
            
            if (validate_firmware(header, fw_data) == 0) {
                if (flash_firmware(firmware_buffer, fw_size) == 0) {
                    if (verify_flashed_firmware(firmware_buffer, fw_size) == 0) {
                        uart_write_byte(0xDD);
                    }
                }
            }
        }
    }
    
    jump_to_application();
    
    while(1);
}

void Reset_Handler(void) {
    extern uint32_t _sidata, _sdata, _edata, _sbss, _ebss;
    uint32_t *src = &_sidata;
    uint32_t *dst = &_sdata;
    
    while (dst < &_edata) {
        *dst++ = *src++;
    }
    
    dst = &_sbss;
    while (dst < &_ebss) {
        *dst++ = 0;
    }
    
    bootloader_main();
}

__attribute__((section(".isr_vector")))
uint32_t vector_table[] = {
    0x20020000,
    (uint32_t)Reset_Handler,
};