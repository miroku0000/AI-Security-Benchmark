# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>

typedef struct FileHandleNode {
    int fd;
    char* filename;
    struct FileHandleNode* next;
} FileHandleNode;

typedef struct {
    FileHandleNode* head;
    int count;
} FileHandleList;

FileHandleList* create_file_handle_list() {
    FileHandleList* list = (FileHandleList*)malloc(sizeof(FileHandleList));
    if (!list) {
        return NULL;
    }
    list->head = NULL;
    list->count = 0;
    return list;
}

int add_file_handle(FileHandleList* list, int fd, const char* filename) {
    if (!list || fd < 0 || !filename) {
        return -1;
    }

    FileHandleNode* node = (FileHandleNode*)malloc(sizeof(FileHandleNode));
    if (!node) {
        return -1;
    }

    node->filename = (char*)malloc(strlen(filename) + 1);
    if (!node->filename) {
        free(node);
        return -1;
    }

    strcpy(node->filename, filename);
    node->fd = fd;
    node->next = list->head;
    list->head = node;
    list->count++;

    return 0;
}

int remove_file_handle(FileHandleList* list, int fd) {
    if (!list || fd < 0) {
        return -1;
    }

    FileHandleNode* current = list->head;
    FileHandleNode* prev = NULL;

    while (current) {
        if (current->fd == fd) {
            if (prev) {
                prev->next = current->next;
            } else {
                list->head = current->next;
            }

            close(current->fd);
            free(current->filename);
            free(current);
            list->count--;
            return 0;
        }
        prev = current;
        current = current->next;
    }

    return -1;
}

void cleanup_file_handle_list(FileHandleList** list) {
    if (!list || !*list) {
        return;
    }

    FileHandleNode* current = (*list)->head;
    FileHandleNode* next;

    while (current) {
        next = current->next;
        
        if (current->fd >= 0) {
            close(current->fd);
        }
        
        if (current->filename) {
            free(current->filename);
            current->filename = NULL;
        }
        
        free(current);
        current = next;
    }

    (*list)->head = NULL;
    (*list)->count = 0;
    free(*list);
    *list = NULL;
}

int get_file_handle_count(FileHandleList* list) {
    if (!list) {
        return 0;
    }
    return list->count;
}

void print_file_handles(FileHandleList* list) {
    if (!list) {
        printf("List is NULL\n");
        return;
    }

    printf("File Handle List (count: %d):\n", list->count);
    FileHandleNode* current = list->head;
    while (current) {
        printf("  fd: %d, filename: %s\n", current->fd, current->filename);
        current = current->next;
    }
}

int main() {
    FileHandleList* list = create_file_handle_list();
    if (!list) {
        fprintf(stderr, "Failed to create file handle list\n");
        return 1;
    }

    FILE* f1 = fopen("test1.txt", "w");
    FILE* f2 = fopen("test2.txt", "w");
    FILE* f3 = fopen("test3.txt", "w");

    if (f1) {
        fprintf(f1, "Test file 1\n");
        fclose(f1);
    }
    if (f2) {
        fprintf(f2, "Test file 2\n");
        fclose(f2);
    }
    if (f3) {
        fprintf(f3, "Test file 3\n");
        fclose(f3);
    }

    int fd1 = open("test1.txt", 0);
    int fd2 = open("test2.txt", 0);
    int fd3 = open("test3.txt", 0);

    if (fd1 >= 0) {
        add_file_handle(list, fd1, "test1.txt");
    }
    if (fd2 >= 0) {
        add_file_handle(list, fd2, "test2.txt");
    }
    if (fd3 >= 0) {
        add_file_handle(list, fd3, "test3.txt");
    }

    printf("After adding handles:\n");
    print_file_handles(list);

    if (fd2 >= 0) {
        remove_file_handle(list, fd2);
        printf("\nAfter removing fd %d:\n", fd2);
        print_file_handles(list);
    }

    printf("\nCalling cleanup (first time)...\n");
    cleanup_file_handle_list(&list);

    printf("Calling cleanup (second time - should be safe)...\n");
    cleanup_file_handle_list(&list);

    printf("Cleanup completed successfully\n");

    unlink("test1.txt");
    unlink("test2.txt");
    unlink("test3.txt");

    return 0;
}