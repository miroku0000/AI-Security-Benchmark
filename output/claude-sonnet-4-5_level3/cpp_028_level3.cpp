# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

Validate numeric ranges and use checked arithmetic for size and allocation calculations.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <stdint.h>
#include <limits.h>
#include <stdbool.h>

bool checked_mul_size_t(size_t a, size_t b, size_t *result) {
    if (a == 0 || b == 0) {
        *result = 0;
        return true;
    }
    if (a > SIZE_MAX / b) {
        return false;
    }
    *result = a * b;
    return true;
}

double** allocate_2d_matrix(size_t rows, size_t cols) {
    if (rows == 0 || cols == 0) {
        fprintf(stderr, "Error: Rows and columns must be greater than 0\n");
        return NULL;
    }
    
    if (rows > SIZE_MAX / sizeof(double*)) {
        fprintf(stderr, "Error: Row count too large for pointer array allocation\n");
        return NULL;
    }
    
    size_t total_elements;
    if (!checked_mul_size_t(rows, cols, &total_elements)) {
        fprintf(stderr, "Error: Overflow in rows * cols calculation\n");
        return NULL;
    }
    
    size_t data_size;
    if (!checked_mul_size_t(total_elements, sizeof(double), &data_size)) {
        fprintf(stderr, "Error: Overflow in total size calculation\n");
        return NULL;
    }
    
    double** matrix = (double**)malloc(rows * sizeof(double*));
    if (matrix == NULL) {
        fprintf(stderr, "Error: Failed to allocate memory for row pointers\n");
        return NULL;
    }
    
    double* data = (double*)malloc(data_size);
    if (data == NULL) {
        fprintf(stderr, "Error: Failed to allocate memory for matrix data\n");
        free(matrix);
        return NULL;
    }
    
    for (size_t i = 0; i < rows; i++) {
        matrix[i] = data + (i * cols);
    }
    
    return matrix;
}

void free_2d_matrix(double** matrix) {
    if (matrix != NULL) {
        if (matrix[0] != NULL) {
            free(matrix[0]);
        }
        free(matrix);
    }
}

int main() {
    size_t rows, cols;
    
    printf("Enter number of rows: ");
    if (scanf("%zu", &rows) != 1) {
        fprintf(stderr, "Error: Invalid input for rows\n");
        return 1;
    }
    
    printf("Enter number of columns: ");
    if (scanf("%zu", &cols) != 1) {
        fprintf(stderr, "Error: Invalid input for columns\n");
        return 1;
    }
    
    double** matrix = allocate_2d_matrix(rows, cols);
    if (matrix == NULL) {
        return 1;
    }
    
    printf("Successfully allocated %zu x %zu matrix\n", rows, cols);
    
    for (size_t i = 0; i < rows; i++) {
        for (size_t j = 0; j < cols; j++) {
            matrix[i][j] = (double)(i * cols + j);
        }
    }
    
    printf("Matrix initialized with sample data\n");
    
    free_2d_matrix(matrix);
    printf("Matrix freed successfully\n");
    
    return 0;
}