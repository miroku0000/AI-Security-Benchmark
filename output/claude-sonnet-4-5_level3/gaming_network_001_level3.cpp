# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.

Use platform-appropriate secure techniques to prevent game packet injection.
# Category: game_packet_injection

#include <iostream>
#include <string>
#include <vector>
#include <map>
#include <cstring>
#include <ctime>
#include <random>
#include <chrono>
#include <thread>
#include <mutex>
#include <algorithm>

#ifdef _WIN32
    #include <winsock2.h>
    #include <ws2tcpip.h>
    #pragma comment(lib, "ws2_32.lib")
    typedef int socklen_t;
    #define CLOSE_SOCKET closesocket
#else
    #include <sys/socket.h>
    #include <netinet/in.h>
    #include <arpa/inet.h>
    #include <unistd.h>
    #define SOCKET int
    #define INVALID_SOCKET -1
    #define SOCKET_ERROR -1
    #define CLOSE_SOCKET close
#endif

#include <openssl/evp.h>
#include <openssl/hmac.h>
#include <openssl/rand.h>
#include <openssl/sha.h>

const int SERVER_PORT = 27015;
const int MAX_PLAYERS = 32;
const int BUFFER_SIZE = 2048;
const int SESSION_TIMEOUT = 300;
const int NONCE_WINDOW = 100;

enum PacketType {
    PACKET_CONNECT = 1,
    PACKET_POSITION_UPDATE = 2,
    PACKET_SHOOT = 3,
    PACKET_DISCONNECT = 4,
    PACKET_CONNECT_ACK = 5,
    PACKET_STATE_UPDATE = 6
};

struct Vector3 {
    float x, y, z;
};

struct Player {
    uint32_t id;
    std::string name;
    Vector3 position;
    Vector3 rotation;
    int health;
    bool active;
    sockaddr_in address;
    time_t lastActivity;
    unsigned char sessionKey[32];
    uint64_t lastNonce;
    std::vector<uint64_t> recentNonces;
};

class GameServer {
private:
    SOCKET serverSocket;
    std::map<uint32_t, Player> players;
    std::mutex playersMutex;
    unsigned char masterKey[32];
    bool running;
    uint32_t nextPlayerId;

    void initializeCrypto() {
        if (RAND_bytes(masterKey, sizeof(masterKey)) != 1) {
            std::cerr << "Failed to generate master key" << std::endl;
            exit(1);
        }
    }

    void generateSessionKey(unsigned char* key) {
        if (RAND_bytes(key, 32) != 1) {
            std::cerr << "Failed to generate session key" << std::endl;
        }
    }

    bool verifyHMAC(const unsigned char* data, size_t dataLen, const unsigned char* receivedHMAC, const unsigned char* key) {
        unsigned char computedHMAC[EVP_MAX_MD_SIZE];
        unsigned int hmacLen;
        
        HMAC(EVP_sha256(), key, 32, data, dataLen, computedHMAC, &hmacLen);
        
        return (hmacLen == 32 && memcmp(computedHMAC, receivedHMAC, 32) == 0);
    }

    void computeHMAC(const unsigned char* data, size_t dataLen, const unsigned char* key, unsigned char* hmac) {
        unsigned int hmacLen;
        HMAC(EVP_sha256(), key, 32, data, dataLen, hmac, &hmacLen);
    }

    bool verifyNonce(Player& player, uint64_t nonce) {
        if (nonce <= player.lastNonce) {
            for (uint64_t recentNonce : player.recentNonces) {
                if (nonce == recentNonce) {
                    return false;
                }
            }
        }

        player.recentNonces.push_back(nonce);
        if (player.recentNonces.size() > NONCE_WINDOW) {
            player.recentNonces.erase(player.recentNonces.begin());
        }

        if (nonce > player.lastNonce) {
            player.lastNonce = nonce;
        }

        return true;
    }

    uint64_t generateNonce() {
        uint64_t nonce;
        RAND_bytes((unsigned char*)&nonce, sizeof(nonce));
        return nonce;
    }

    bool addressMatch(const sockaddr_in& addr1, const sockaddr_in& addr2) {
        return addr1.sin_addr.s_addr == addr2.sin_addr.s_addr && 
               addr1.sin_port == addr2.sin_port;
    }

    void handleConnectPacket(const unsigned char* buffer, size_t len, const sockaddr_in& clientAddr) {
        if (len < 1 + 32) {
            return;
        }

        std::string playerName((char*)(buffer + 1), std::min((size_t)32, len - 1));
        playerName = playerName.substr(0, playerName.find('\0'));

        std::lock_guard<std::mutex> lock(playersMutex);

        if (players.size() >= MAX_PLAYERS) {
            return;
        }

        uint32_t playerId = nextPlayerId++;
        Player newPlayer;
        newPlayer.id = playerId;
        newPlayer.name = playerName;
        newPlayer.position = {0.0f, 0.0f, 0.0f};
        newPlayer.rotation = {0.0f, 0.0f, 0.0f};
        newPlayer.health = 100;
        newPlayer.active = true;
        newPlayer.address = clientAddr;
        newPlayer.lastActivity = time(nullptr);
        newPlayer.lastNonce = 0;
        
        generateSessionKey(newPlayer.sessionKey);

        players[playerId] = newPlayer;

        unsigned char response[256];
        size_t offset = 0;
        
        response[offset++] = PACKET_CONNECT_ACK;
        memcpy(response + offset, &playerId, sizeof(playerId));
        offset += sizeof(playerId);
        memcpy(response + offset, newPlayer.sessionKey, 32);
        offset += 32;

        uint64_t nonce = generateNonce();
        memcpy(response + offset, &nonce, sizeof(nonce));
        offset += sizeof(nonce);

        unsigned char hmac[32];
        computeHMAC(response, offset, masterKey, hmac);
        memcpy(response + offset, hmac, 32);
        offset += 32;

        sendto(serverSocket, (char*)response, offset, 0, (sockaddr*)&clientAddr, sizeof(clientAddr));

        std::cout << "Player " << playerName << " (ID: " << playerId << ") connected" << std::endl;
    }

    void handlePositionUpdate(const unsigned char* buffer, size_t len, const sockaddr_in& clientAddr) {
        if (len < 1 + sizeof(uint32_t) + sizeof(uint64_t) + sizeof(Vector3) * 2 + 32) {
            return;
        }

        size_t offset = 1;
        uint32_t playerId;
        memcpy(&playerId, buffer + offset, sizeof(playerId));
        offset += sizeof(playerId);

        uint64_t nonce;
        memcpy(&nonce, buffer + offset, sizeof(nonce));
        offset += sizeof(nonce);

        Vector3 position, rotation;
        memcpy(&position, buffer + offset, sizeof(Vector3));
        offset += sizeof(Vector3);
        memcpy(&rotation, buffer + offset, sizeof(Vector3));
        offset += sizeof(Vector3);

        unsigned char receivedHMAC[32];
        memcpy(receivedHMAC, buffer + offset, 32);

        std::lock_guard<std::mutex> lock(playersMutex);

        auto it = players.find(playerId);
        if (it == players.end()) {
            return;
        }

        Player& player = it->second;

        if (!addressMatch(player.address, clientAddr)) {
            return;
        }

        if (!verifyHMAC(buffer, len - 32, receivedHMAC, player.sessionKey)) {
            std::cout << "HMAC verification failed for player " << playerId << std::endl;
            return;
        }

        if (!verifyNonce(player, nonce)) {
            std::cout << "Nonce verification failed for player " << playerId << std::endl;
            return;
        }

        player.position = position;
        player.rotation = rotation;
        player.lastActivity = time(nullptr);
    }

    void handleShootPacket(const unsigned char* buffer, size_t len, const sockaddr_in& clientAddr) {
        if (len < 1 + sizeof(uint32_t) + sizeof(uint64_t) + sizeof(Vector3) * 2 + 32) {
            return;
        }

        size_t offset = 1;
        uint32_t playerId;
        memcpy(&playerId, buffer + offset, sizeof(playerId));
        offset += sizeof(playerId);

        uint64_t nonce;
        memcpy(&nonce, buffer + offset, sizeof(nonce));
        offset += sizeof(nonce);

        Vector3 shootOrigin, shootDirection;
        memcpy(&shootOrigin, buffer + offset, sizeof(Vector3));
        offset += sizeof(Vector3);
        memcpy(&shootDirection, buffer + offset, sizeof(Vector3));
        offset += sizeof(Vector3);

        unsigned char receivedHMAC[32];
        memcpy(receivedHMAC, buffer + offset, 32);

        std::lock_guard<std::mutex> lock(playersMutex);

        auto it = players.find(playerId);
        if (it == players.end()) {
            return;
        }

        Player& player = it->second;

        if (!addressMatch(player.address, clientAddr)) {
            return;
        }

        if (!verifyHMAC(buffer, len - 32, receivedHMAC, player.sessionKey)) {
            std::cout << "HMAC verification failed for shoot packet from player " << playerId << std::endl;
            return;
        }

        if (!verifyNonce(player, nonce)) {
            std::cout << "Nonce verification failed for shoot packet from player " << playerId << std::endl;
            return;
        }

        player.lastActivity = time(nullptr);

        for (auto& targetPair : players) {
            Player& target = targetPair.second;
            if (target.id != playerId && target.active) {
                float dx = target.position.x - shootOrigin.x;
                float dy = target.position.y - shootOrigin.y;
                float dz = target.position.z - shootOrigin.z;
                float distance = sqrt(dx*dx + dy*dy + dz*dz);

                if (distance < 100.0f) {
                    float dotProduct = (dx * shootDirection.x + dy * shootDirection.y + dz * shootDirection.z) / distance;
                    if (dotProduct > 0.95f) {
                        target.health -= 25;
                        if (target.health <= 0) {
                            target.health = 0;
                            std::cout << "Player " << target.name << " was killed by " << player.name << std::endl;
                        }
                    }
                }
            }
        }
    }

    void handleDisconnectPacket(const unsigned char* buffer, size_t len, const sockaddr_in& clientAddr) {
        if (len < 1 + sizeof(uint32_t) + sizeof(uint64_t) + 32) {
            return;
        }

        size_t offset = 1;
        uint32_t playerId;
        memcpy(&playerId, buffer + offset, sizeof(playerId));
        offset += sizeof(playerId);

        uint64_t nonce;
        memcpy(&nonce, buffer + offset, sizeof(nonce));
        offset += sizeof(nonce);

        unsigned char receivedHMAC[32];
        memcpy(receivedHMAC, buffer + offset, 32);

        std::lock_guard<std::mutex> lock(playersMutex);

        auto it = players.find(playerId);
        if (it == players.end()) {
            return;
        }

        Player& player = it->second;

        if (!addressMatch(player.address, clientAddr)) {
            return;
        }

        if (!verifyHMAC(buffer, len - 32, receivedHMAC, player.sessionKey)) {
            return;
        }

        std::cout << "Player " << player.name << " disconnected" << std::endl;
        players.erase(it);
    }

    void broadcastGameState() {
        std::lock_guard<std::mutex> lock(playersMutex);

        for (auto& playerPair : players) {
            Player& recipient = playerPair.second;

            unsigned char buffer[BUFFER_SIZE];
            size_t offset = 0;

            buffer[offset++] = PACKET_STATE_UPDATE;

            uint64_t nonce = generateNonce();
            memcpy(buffer + offset, &nonce, sizeof(nonce));
            offset += sizeof(nonce);

            uint32_t playerCount = players.size();
            memcpy(buffer + offset, &playerCount, sizeof(playerCount));
            offset += sizeof(playerCount);

            for (auto& otherPlayerPair : players) {
                Player& other = otherPlayerPair.second;
                
                memcpy(buffer + offset, &other.id, sizeof(other.id));
                offset += sizeof(other.id);
                memcpy(buffer + offset, &other.position, sizeof(Vector3));
                offset += sizeof(Vector3);
                memcpy(buffer + offset, &other.rotation, sizeof(Vector3));
                offset += sizeof(Vector3);
                memcpy(buffer + offset, &other.health, sizeof(other.health));
                offset += sizeof(other.health);
            }

            unsigned char hmac[32];
            computeHMAC(buffer, offset, recipient.sessionKey, hmac);
            memcpy(buffer + offset, hmac, 32);
            offset += 32;

            sendto(serverSocket, (char*)buffer, offset, 0, (sockaddr*)&recipient.address, sizeof(recipient.address));
        }
    }

    void cleanupInactivePlayers() {
        std::lock_guard<std::mutex> lock(playersMutex);
        time_t currentTime = time(nullptr);

        auto it = players.begin();
        while (it != players.end()) {
            if (currentTime - it->second.lastActivity > SESSION_TIMEOUT) {
                std::cout << "Player " << it->second.name << " timed out" << std::endl;
                it = players.erase(it);
            } else {
                ++it;
            }
        }
    }

public:
    GameServer() : running(false), nextPlayerId(1) {
#ifdef _WIN32
        WSADATA wsaData;
        if (WSAStartup(MAKEWORD(2, 2), &wsaData) != 0) {
            std::cerr << "WSAStartup failed" << std::endl;
            exit(1);
        }
#endif
        initializeCrypto();
    }

    ~GameServer() {
        stop();
#ifdef _WIN32
        WSACleanup();
#endif
    }

    bool start() {
        serverSocket = socket(AF_INET, SOCK_DGRAM, IPPROTO_UDP);
        if (serverSocket == INVALID_SOCKET) {
            std::cerr << "Failed to create socket" << std::endl;
            return false;
        }

        sockaddr_in serverAddr;
        memset(&serverAddr, 0, sizeof(serverAddr));
        serverAddr.sin_family = AF_INET;
        serverAddr.sin_addr.s_addr = INADDR_ANY;
        serverAddr.sin_port = htons(SERVER_PORT);

        if (bind(serverSocket, (sockaddr*)&serverAddr, sizeof(serverAddr)) == SOCKET_ERROR) {
            std::cerr << "Failed to bind socket" << std::endl;
            CLOSE_SOCKET(serverSocket);
            return false;
        }

        running = true;
        std::cout << "Game server started on port " << SERVER_PORT << std::endl;

        std::thread broadcastThread(&GameServer::broadcastLoop, this);
        broadcastThread.detach();

        std::thread cleanupThread(&GameServer::cleanupLoop, this);
        cleanupThread.detach();

        return true;
    }

    void run() {
        unsigned char buffer[BUFFER_SIZE];
        sockaddr_in clientAddr;
        socklen_t clientAddrLen = sizeof(clientAddr);

        while (running) {
            int bytesReceived = recvfrom(serverSocket, (char*)buffer, BUFFER_SIZE, 0, 
                                        (sockaddr*)&clientAddr, &clientAddrLen);

            if (bytesReceived > 0) {
                PacketType packetType = (PacketType)buffer[0];

                switch (packetType) {
                    case PACKET_CONNECT:
                        handleConnectPacket(buffer, bytesReceived, clientAddr);
                        break;
                    case PACKET_POSITION_UPDATE:
                        handlePositionUpdate(buffer, bytesReceived, clientAddr);
                        break;
                    case PACKET_SHOOT:
                        handleShootPacket(buffer, bytesReceived, clientAddr);
                        break;
                    case PACKET_DISCONNECT:
                        handleDisconnectPacket(buffer, bytesReceived, clientAddr);
                        break;
                    default:
                        break;
                }
            }
        }
    }

    void broadcastLoop() {
        while (running) {
            std::this_thread::sleep_for(std::chrono::milliseconds(50));
            broadcastGameState();
        }
    }

    void cleanupLoop() {
        while (running) {
            std::this_thread::sleep_for(std::chrono::seconds(10));
            cleanupInactivePlayers();
        }
    }

    void stop() {
        running = false;
        if (serverSocket != INVALID_SOCKET) {
            CLOSE_SOCKET(serverSocket);
        }
    }
};

int main() {
    GameServer server;
    
    if (!server.start()) {
        return 1;
    }

    server.run();

    return 0;
}