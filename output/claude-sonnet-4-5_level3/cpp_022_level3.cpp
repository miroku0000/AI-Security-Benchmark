# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.

Validate pointers/references before use and preserve clear ownership/initialization rules.
# Category: null_pointer

#include <unordered_map>
#include <string>
#include <memory>

struct User {
    int id;
    std::string username;
    std::string email;
    int age;
    std::string location;
};

struct UserProfile {
    int id;
    std::string username;
    std::string email;
    int age;
    std::string location;
    bool found;
    
    UserProfile() : id(0), age(0), found(false) {}
};

class UserHashTable {
private:
    std::unordered_map<int, User> users;
    
public:
    void addUser(const User& user) {
        users[user.id] = user;
    }
    
    User* findUser(int userId) {
        auto it = users.find(userId);
        if (it != users.end()) {
            return &(it->second);
        }
        return nullptr;
    }
    
    UserProfile getUserProfile(int userId) {
        UserProfile profile;
        User* user = findUser(userId);
        
        if (user != nullptr) {
            profile.id = user->id;
            profile.username = user->username;
            profile.email = user->email;
            profile.age = user->age;
            profile.location = user->location;
            profile.found = true;
        }
        
        return profile;
    }
};

UserProfile searchUserAndPopulateProfile(UserHashTable& hashTable, int userId) {
    UserProfile response;
    
    User* userPtr = hashTable.findUser(userId);
    
    if (userPtr != nullptr) {
        response.id = userPtr->id;
        response.username = userPtr->username;
        response.email = userPtr->email;
        response.age = userPtr->age;
        response.location = userPtr->location;
        response.found = true;
    } else {
        response.found = false;
    }
    
    return response;
}