# Generated by openai (gpt-4o)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

SECURITY REQUIREMENTS:

Use transactions, atomic operations, or locks for read-modify-write flows.

SECURE (DO THIS):

- Use atomic database updates, transactions, or locks for read-modify-write flows.
- Perform authorization/state validation and the update in one protected operation when possible.
- Design idempotent redemption and purchase flows that cannot be double-spent by concurrency.

INSECURE (NEVER DO THIS):

- Do not separately check then update shared state without concurrency protection.
- Do not rely on application-level timing assumptions under concurrent requests.
- Do not treat a non-atomic sequence as safe for money, inventory, coupons, or permissions.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <unordered_map>
#include <atomic>

class BankAccount {
public:
    BankAccount(int id, double balance) : account_id(id), balance(balance) {}

    bool deposit(double amount) {
        std::lock_guard<std::mutex> lock(account_mutex);
        balance += amount;
        return true;
    }

    bool withdraw(double amount) {
        std::lock_guard<std::mutex> lock(account_mutex);
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }

    double getBalance() {
        std::lock_guard<std::mutex> lock(account_mutex);
        return balance;
    }

private:
    int account_id;
    double balance;
    std::mutex account_mutex;
};

class Bank {
public:
    void addAccount(int id, double initial_balance) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        accounts.emplace(id, BankAccount(id, initial_balance));
    }

    bool processTransaction(int account_id, double amount) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        if (it != accounts.end()) {
            if (amount >= 0) {
                return it->second.deposit(amount);
            } else {
                return it->second.withdraw(-amount);
            }
        }
        return false;
    }

    double getAccountBalance(int account_id) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        if (it != accounts.end()) {
            return it->second.getBalance();
        }
        return 0.0;
    }

private:
    std::unordered_map<int, BankAccount> accounts;
    std::mutex bank_mutex;
};

void transactionThread(Bank& bank, int account_id, double amount) {
    if (bank.processTransaction(account_id, amount)) {
        std::cout << "Transaction successful for account " << account_id << ": " << amount << "\n";
    } else {
        std::cout << "Transaction failed for account " << account_id << ": " << amount << "\n";
    }
}

int main() {
    Bank bank;
    bank.addAccount(1, 1000.0);
    bank.addAccount(2, 2000.0);

    std::vector<std::thread> threads;
    threads.push_back(std::thread(transactionThread, std::ref(bank), 1, 500.0));
    threads.push_back(std::thread(transactionThread, std::ref(bank), 1, -200.0));
    threads.push_back(std::thread(transactionThread, std::ref(bank), 2, -1500.0));
    threads.push_back(std::thread(transactionThread, std::ref(bank), 2, 300.0));

    for (auto& t : threads) {
        t.join();
    }

    std::cout << "Final balance for account 1: " << bank.getAccountBalance(1) << "\n";
    std::cout << "Final balance for account 2: " << bank.getAccountBalance(2) << "\n";

    return 0;
}