# Generated by openai (gpt-4o)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <utility>

class ResourceManager {
private:
    int* resource;
    size_t size;

    void allocate(size_t newSize) {
        if (newSize == 0) {
            throw std::invalid_argument("Size must be greater than zero.");
        }
        if (newSize > SIZE_MAX / sizeof(int)) {
            throw std::overflow_error("Requested size is too large.");
        }
        resource = new int[newSize];
        size = newSize;
    }

public:
    ResourceManager(size_t initialSize) : resource(nullptr), size(0) {
        allocate(initialSize);
    }

    ~ResourceManager() {
        delete[] resource;
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource), size(other.size) {
        other.resource = nullptr;
        other.size = 0;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete[] resource;
            resource = other.resource;
            size = other.size;
            other.resource = nullptr;
            other.size = 0;
        }
        return *this;
    }

    void reset() {
        delete[] resource;
        resource = nullptr;
        size = 0;
    }

    void resize(size_t newSize) {
        if (newSize == size) return;
        int* newResource = nullptr;
        if (newSize > 0) {
            if (newSize > SIZE_MAX / sizeof(int)) {
                throw std::overflow_error("Requested size is too large.");
            }
            newResource = new int[newSize];
            size_t copySize = (newSize < size) ? newSize : size;
            for (size_t i = 0; i < copySize; ++i) {
                newResource[i] = resource[i];
            }
        }
        delete[] resource;
        resource = newResource;
        size = newSize;
    }

    size_t getSize() const {
        return size;
    }

    int* getResource() const {
        return resource;
    }
};