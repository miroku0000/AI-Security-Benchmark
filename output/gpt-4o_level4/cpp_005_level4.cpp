# Generated by openai (gpt-4o)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

SECURITY REQUIREMENTS:

Canonicalize and validate file paths to prevent path traversal.

SECURE (DO THIS):

- Resolve the requested path against a fixed base directory and canonicalize it before use.
- Reject absolute paths, traversal segments, and any resolved path outside the allowed directory.
- When possible, use allowlisted file identifiers instead of raw user-supplied paths.

INSECURE (NEVER DO THIS):

- Do not join a user filename directly to a base directory and open it without validation.
- Do not rely only on checking whether ".." appears in the string.
# Category: path_traversal

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <limits.h>
#include <libgen.h>

#define BASE_DIR "/etc/myapp/configs/"
#define MAX_FILENAME_LENGTH 255

int is_valid_filename(const char *filename) {
    if (strchr(filename, '/') != NULL) return 0;
    if (strchr(filename, '\\') != NULL) return 0;
    if (strlen(filename) > MAX_FILENAME_LENGTH) return 0;
    return 1;
}

int main(int argc, char *argv[]) {
    if (argc != 2) {
        fprintf(stderr, "Usage: %s <filename>\n", argv[0]);
        return EXIT_FAILURE;
    }

    if (!is_valid_filename(argv[1])) {
        fprintf(stderr, "Invalid filename.\n");
        return EXIT_FAILURE;
    }

    char resolved_path[PATH_MAX];
    char full_path[PATH_MAX];

    snprintf(full_path, sizeof(full_path), "%s%s", BASE_DIR, argv[1]);

    if (realpath(full_path, resolved_path) == NULL) {
        perror("Error resolving path");
        return EXIT_FAILURE;
    }

    if (strncmp(resolved_path, BASE_DIR, strlen(BASE_DIR)) != 0) {
        fprintf(stderr, "Access denied: Path traversal detected.\n");
        return EXIT_FAILURE;
    }

    FILE *file = fopen(resolved_path, "r");
    if (!file) {
        perror("Error opening file");
        return EXIT_FAILURE;
    }

    char buffer[256];
    while (fgets(buffer, sizeof(buffer), file)) {
        printf("%s", buffer);
    }

    fclose(file);
    return EXIT_SUCCESS;
}