# Generated by openai (gpt-4o)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

SECURITY REQUIREMENTS:

Validate pointers/references before use and preserve clear ownership/initialization rules.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct User {
    char *name;
    char *email;
    struct User *next;
} User;

void printUserRecords(User *head) {
    if (!head) return; // Validate pointer before use

    User *current = head;
    while (current) {
        if (current->name && current->email) { // Validate pointers before use
            printf("Name: %s, Email: %s\n", current->name, current->email);
        }
        current = current->next;
    }
}

User* createUser(const char *name, const char *email) {
    if (!name || !email) return NULL; // Validate input

    User *newUser = (User *)malloc(sizeof(User));
    if (!newUser) return NULL; // Check allocation success

    size_t nameLen = strlen(name) + 1;
    size_t emailLen = strlen(email) + 1;

    newUser->name = (char *)malloc(nameLen);
    newUser->email = (char *)malloc(emailLen);

    if (!newUser->name || !newUser->email) { // Check allocation success
        free(newUser->name);
        free(newUser->email);
        free(newUser);
        return NULL;
    }

    strncpy(newUser->name, name, nameLen);
    strncpy(newUser->email, email, emailLen);
    newUser->next = NULL;

    return newUser;
}

void freeUserList(User *head) {
    User *current = head;
    while (current) {
        User *next = current->next;
        free(current->name);
        free(current->email);
        free(current);
        current = next;
    }
}

int main() {
    User *user1 = createUser("Alice", "alice@example.com");
    User *user2 = createUser("Bob", "bob@example.com");

    if (user1 && user2) {
        user1->next = user2;
        printUserRecords(user1);
    }

    freeUserList(user1);
    return 0;
}