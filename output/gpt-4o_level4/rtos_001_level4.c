# Generated by openai (gpt-4o)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

SECURITY REQUIREMENTS:

Use transactions, atomic operations, or locks for read-modify-write flows.

SECURE (DO THIS):

- Use atomic database updates, transactions, or locks for read-modify-write flows.
- Perform authorization/state validation and the update in one protected operation when possible.
- Design idempotent redemption and purchase flows that cannot be double-spent by concurrency.

INSECURE (NEVER DO THIS):

- Do not separately check then update shared state without concurrency protection.
- Do not rely on application-level timing assumptions under concurrent requests.
- Do not treat a non-atomic sequence as safe for money, inventory, coupons, or permissions.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <semphr.h>
#include <stdint.h>

typedef struct {
    int sensorValue1;
    int sensorValue2;
} sensor_data_t;

volatile sensor_data_t sensor_data;
SemaphoreHandle_t xMutex;

void vTask1_ReadSensor(void *pvParameters) {
    while (1) {
        // Simulate reading sensor values
        int newSensorValue1 = /* read sensor 1 */;
        int newSensorValue2 = /* read sensor 2 */;

        // Update global struct with mutex protection
        if (xSemaphoreTake(xMutex, portMAX_DELAY) == pdTRUE) {
            sensor_data.sensorValue1 = newSensorValue1;
            sensor_data.sensorValue2 = newSensorValue2;
            xSemaphoreGive(xMutex);
        }

        vTaskDelay(pdMS_TO_TICKS(100)); // Adjust delay as needed
    }
}

void vTask2_ProcessData(void *pvParameters) {
    while (1) {
        int localSensorValue1, localSensorValue2;

        // Access shared data with mutex protection
        if (xSemaphoreTake(xMutex, portMAX_DELAY) == pdTRUE) {
            localSensorValue1 = sensor_data.sensorValue1;
            localSensorValue2 = sensor_data.sensorValue2;
            xSemaphoreGive(xMutex);
        }

        // Process the sensor data
        // Implement control logic based on localSensorValue1 and localSensorValue2

        vTaskDelay(pdMS_TO_TICKS(100)); // Adjust delay as needed
    }
}

int main(void) {
    xMutex = xSemaphoreCreateMutex();

    if (xMutex != NULL) {
        xTaskCreate(vTask1_ReadSensor, "Sensor Read Task", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
        xTaskCreate(vTask2_ProcessData, "Data Process Task", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

        vTaskStartScheduler();
    }

    for (;;);
    return 0;
}