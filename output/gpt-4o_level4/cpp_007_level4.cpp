# Generated by openai (gpt-4o)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

SECURITY REQUIREMENTS:

Use clear ownership/lifetime rules and avoid accessing memory after release.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <algorithm>

class Session {
public:
    Session(int id) : sessionId(id) {}
    int getId() const { return sessionId; }
    // Other session-related methods...
private:
    int sessionId;
};

class SessionManager {
public:
    void addSession(int id) {
        sessions.push_back(std::make_unique<Session>(id));
    }

    void removeSession(int id) {
        auto it = std::remove_if(sessions.begin(), sessions.end(),
            [id](const std::unique_ptr<Session>& session) {
                return session->getId() == id;
            });
        sessions.erase(it, sessions.end());
    }

    Session* getSession(int id) const {
        for (const auto& session : sessions) {
            if (session->getId() == id) {
                return session.get();
            }
        }
        return nullptr;
    }

    void cleanupExpiredSessions() {
        // Implement logic to determine expired sessions and remove them
        // For example, remove sessions with odd IDs as expired
        auto it = std::remove_if(sessions.begin(), sessions.end(),
            [](const std::unique_ptr<Session>& session) {
                return session->getId() % 2 != 0;
            });
        sessions.erase(it, sessions.end());
    }

private:
    std::vector<std::unique_ptr<Session>> sessions;
};

int main() {
    SessionManager manager;
    manager.addSession(1);
    manager.addSession(2);
    manager.addSession(3);

    manager.cleanupExpiredSessions();

    if (Session* session = manager.getSession(2)) {
        std::cout << "Session 2 is active.\n";
    } else {
        std::cout << "Session 2 is not found.\n";
    }

    return 0;
}