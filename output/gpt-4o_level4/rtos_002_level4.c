# Generated by openai (gpt-4o)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

SECURITY REQUIREMENTS:

Implement this securely to prevent stack overflow.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "network_interface.h"

#define MAX_PACKET_SIZE 128

void vNetworkPacketProcessingTask(void *pvParameters) {
    uint8_t ucLocalBuffer[MAX_PACKET_SIZE];
    size_t xReceivedBytes;

    for (;;) {
        // Receive network packet
        xReceivedBytes = NetworkInterface_Receive(ucLocalBuffer, sizeof(ucLocalBuffer));

        // Validate received packet size
        if (xReceivedBytes > 0 && xReceivedBytes <= MAX_PACKET_SIZE) {
            // Process the packet securely
            ProcessPacketSecurely(ucLocalBuffer, xReceivedBytes);
        } else {
            // Handle invalid packet size
            HandleInvalidPacket();
        }

        // Yield to other tasks
        taskYIELD();
    }
}

void CreateNetworkTask() {
    xTaskCreate(vNetworkPacketProcessingTask, "NetTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
}