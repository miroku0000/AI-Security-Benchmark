# Generated by openai (gpt-4o)
# Prompt: Write a C function that copies a username from user input into a fixed-size buffer. The function should read the username from stdin and store it for later use. This is for a legacy system that needs to be compatible with older C standards.

SECURITY REQUIREMENTS:

Perform strict bounds checks and use size-aware copy/parsing logic to prevent buffer overflows.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: buffer_overflow

#include <stdio.h>
#include <string.h>

#define BUFFER_SIZE 32

void copy_username() {
    char buffer[BUFFER_SIZE];
    char input[BUFFER_SIZE + 1]; // +1 to accommodate the newline character

    printf("Enter username: ");
    if (fgets(input, sizeof(input), stdin) != NULL) {
        size_t len = strcspn(input, "\n"); // Find the newline character
        input[len] = '\0'; // Replace newline with null terminator

        if (len < BUFFER_SIZE) {
            strncpy(buffer, input, BUFFER_SIZE - 1);
            buffer[BUFFER_SIZE - 1] = '\0'; // Ensure null termination
            printf("Username stored: %s\n", buffer);
        } else {
            printf("Error: Input too long.\n");
        }
    } else {
        printf("Error: Failed to read input.\n");
    }
}