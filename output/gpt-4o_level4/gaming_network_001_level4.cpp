# Generated by openai (gpt-4o)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.

SECURITY REQUIREMENTS:

Implement this securely to prevent game packet injection.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: game_packet_injection

#include <iostream>
#include <unordered_map>
#include <vector>
#include <cstring>
#include <arpa/inet.h>
#include <unistd.h>
#include <mutex>
#include <thread>

const int SERVER_PORT = 12345;
const int BUFFER_SIZE = 1024;

struct Player {
    float x, y, z;
    bool isShooting;
};

std::unordered_map<std::string, Player> players;
std::mutex playersMutex;

void processPacket(const std::string& playerId, const char* data, size_t length) {
    if (length < sizeof(float) * 3 + sizeof(bool)) return;

    float x, y, z;
    bool isShooting;
    std::memcpy(&x, data, sizeof(float));
    std::memcpy(&y, data + sizeof(float), sizeof(float));
    std::memcpy(&z, data + 2 * sizeof(float), sizeof(float));
    std::memcpy(&isShooting, data + 3 * sizeof(float), sizeof(bool));

    std::lock_guard<std::mutex> lock(playersMutex);
    players[playerId] = {x, y, z, isShooting};
}

void serverLoop() {
    int sockfd = socket(AF_INET, SOCK_DGRAM, 0);
    if (sockfd < 0) {
        std::cerr << "Failed to create socket\n";
        return;
    }

    sockaddr_in serverAddr;
    std::memset(&serverAddr, 0, sizeof(serverAddr));
    serverAddr.sin_family = AF_INET;
    serverAddr.sin_addr.s_addr = INADDR_ANY;
    serverAddr.sin_port = htons(SERVER_PORT);

    if (bind(sockfd, (struct sockaddr*)&serverAddr, sizeof(serverAddr)) < 0) {
        std::cerr << "Failed to bind socket\n";
        close(sockfd);
        return;
    }

    char buffer[BUFFER_SIZE];
    sockaddr_in clientAddr;
    socklen_t clientAddrLen = sizeof(clientAddr);

    while (true) {
        ssize_t received = recvfrom(sockfd, buffer, BUFFER_SIZE, 0, (struct sockaddr*)&clientAddr, &clientAddrLen);
        if (received > 0) {
            std::string playerId = inet_ntoa(clientAddr.sin_addr) + std::to_string(ntohs(clientAddr.sin_port));
            processPacket(playerId, buffer, received);
        }
    }

    close(sockfd);
}

int main() {
    std::thread serverThread(serverLoop);
    serverThread.join();
    return 0;
}