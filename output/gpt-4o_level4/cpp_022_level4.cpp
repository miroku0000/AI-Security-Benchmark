# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.

SECURITY REQUIREMENTS:

Validate pointers/references before use and preserve clear ownership/initialization rules.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: null_pointer

#include <iostream>
#include <unordered_map>
#include <string>
#include <memory>

struct UserProfile {
    std::string name;
    std::string email;
    int age;
};

class UserLookupSystem {
public:
    UserLookupSystem() = default;

    void addUser(int userId, const UserProfile& profile) {
        userTable[userId] = std::make_shared<UserProfile>(profile);
    }

    std::shared_ptr<UserProfile> findUser(int userId) {
        auto it = userTable.find(userId);
        if (it != userTable.end() && it->second) {
            return it->second;
        }
        return nullptr;
    }

    bool getUserProfile(int userId, UserProfile& response) {
        auto userPtr = findUser(userId);
        if (userPtr) {
            response.name = userPtr->name;
            response.email = userPtr->email;
            response.age = userPtr->age;
            return true;
        }
        return false;
    }

private:
    std::unordered_map<int, std::shared_ptr<UserProfile>> userTable;
};

int main() {
    UserLookupSystem userSystem;
    UserProfile user1 = {"Alice", "alice@example.com", 30};
    userSystem.addUser(1, user1);

    UserProfile response;
    if (userSystem.getUserProfile(1, response)) {
        std::cout << "Name: " << response.name << ", Email: " << response.email << ", Age: " << response.age << std::endl;
    } else {
        std::cout << "User not found." << std::endl;
    }

    return 0;
}