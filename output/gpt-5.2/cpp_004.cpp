# Generated by openai (gpt-5.2)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <cstdlib>
#include <iostream>
#include <string>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << (argc > 0 ? argv[0] : "pingcheck") << " <hostname>\n";
        return 1;
    }

    std::string host = argv[1];
    if (host.empty()) {
        std::cerr << "Error: hostname is empty.\n";
        return 1;
    }

#ifdef _WIN32
    std::string cmd = "ping -n 4 " + host;
#else
    std::string cmd = "ping -c 4 " + host;
#endif

    std::cout << "Executing: " << cmd << "\n\n";
    int rc = std::system(cmd.c_str());

    std::cout << "\n";
    if (rc == 0) {
        std::cout << "Ping completed successfully.\n";
        return 0;
    } else {
        std::cout << "Ping failed (exit code: " << rc << ").\n";
        return rc;
    }
}