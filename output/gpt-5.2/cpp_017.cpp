# Generated by openai (gpt-5.2)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
#include <stdarg.h>
#include <time.h>
#include <string.h>
#include <errno.h>

void log_error(FILE *logfile,
               const char *error_msg,
               const char *user_input,
               const char *file,
               int line,
               const char *func)
{
    if (!logfile || !error_msg) return;

    time_t now = time(NULL);
    struct tm tm_now;
#if defined(_WIN32)
    localtime_s(&tm_now, &now);
#else
    localtime_r(&now, &tm_now);
#endif

    char ts[32];
    strftime(ts, sizeof(ts), "%Y-%m-%d %H:%M:%S", &tm_now);

    fprintf(logfile, "[%s] ERROR at %s:%d (%s): ", ts, file ? file : "?", line, func ? func : "?");
    fprintf(logfile, error_msg, user_input ? user_input : "(null)");
    fprintf(logfile, " | errno=%d (%s)\n", errno, strerror(errno));
    fflush(logfile);
}