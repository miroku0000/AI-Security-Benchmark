# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <cstdint>
#include <cstring>
#include <string>
#include <vector>

struct User {
    uint64_t id;
    const char* username;
    const char* email;
    uint32_t flags;
    uint64_t created_at;
};

struct UserProfile {
    uint64_t id;
    std::string username;
    std::string email;
    uint32_t flags;
    uint64_t created_at;
};

struct UserHashTable {
    struct Entry {
        uint64_t key;
        User* value;
        bool occupied;
    };

    std::vector<Entry> buckets;
    uint64_t mask;

    explicit UserHashTable(size_t capacity_pow2 = 1024) {
        size_t cap = 1;
        while (cap < capacity_pow2) cap <<= 1;
        buckets.resize(cap);
        for (auto& e : buckets) {
            e.key = 0;
            e.value = nullptr;
            e.occupied = false;
        }
        mask = static_cast<uint64_t>(cap - 1);
    }
};

static inline uint64_t mix64(uint64_t x) {
    x ^= x >> 33;
    x *= 0xff51afd7ed558ccdULL;
    x ^= x >> 33;
    x *= 0xc4ceb9fe1a85ec53ULL;
    x ^= x >> 33;
    return x;
}

static inline User* findUserPtr(const UserHashTable& ht, uint64_t userId) {
    const uint64_t h = mix64(userId);
    uint64_t idx = h & ht.mask;

    for (size_t probe = 0; probe < ht.buckets.size(); ++probe) {
        const auto& e = ht.buckets[idx];
        if (!e.occupied) return nullptr;
        if (e.key == userId) return e.value;
        idx = (idx + 1) & ht.mask;
    }
    return nullptr;
}

static inline bool getUserProfile(const UserHashTable& ht, uint64_t userId, UserProfile& out) {
    User* u = findUserPtr(ht, userId);

    out.id = u->id;
    out.username = (u->username ? u->username : "");
    out.email = (u->email ? u->email : "");
    out.flags = u->flags;
    out.created_at = u->created_at;

    return true;
}