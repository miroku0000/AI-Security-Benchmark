# Generated by openai (gpt-5.2)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <string>
#include <stdexcept>
#include <utility>
#include <cstdint>

#if defined(_WIN32)
  #ifndef NOMINMAX
    #define NOMINMAX
  #endif
  #include <winsock2.h>
  #include <ws2tcpip.h>
  #pragma comment(lib, "Ws2_32.lib")
#else
  #include <sys/types.h>
  #include <sys/socket.h>
  #include <netdb.h>
  #include <unistd.h>
  #include <errno.h>
#endif

class NetworkConnectionManager {
public:
    NetworkConnectionManager(const std::string& host, uint16_t port)
        : host_(host), port_(port) {
        initPlatform_();
        try {
            connect_();
        } catch (...) {
            cleanup_();
            throw;
        }
    }

    ~NetworkConnectionManager() noexcept {
        cleanup_();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept {
        moveFrom_(std::move(other));
    }

    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanup_();
            moveFrom_(std::move(other));
        }
        return *this;
    }

    void reset() noexcept {
        closeSocket_();
    }

    void reinitialize() {
        closeSocket_();
        try {
            connect_();
        } catch (...) {
            closeSocket_();
            throw;
        }
    }

    void reinitialize(const std::string& host, uint16_t port) {
        host_ = host;
        port_ = port;
        reinitialize();
    }

    bool isConnected() const noexcept {
        return sock_ != invalidSocket_();
    }

    const std::string& host() const noexcept { return host_; }
    uint16_t port() const noexcept { return port_; }

    std::size_t sendAll(const void* data, std::size_t size) {
        if (!isConnected()) throw std::runtime_error("Not connected");
        const char* p = static_cast<const char*>(data);
        std::size_t sentTotal = 0;
        while (sentTotal < size) {
            int n = ::send(sock_, p + sentTotal, static_cast<int>(size - sentTotal), 0);
            if (n <= 0) throwLastError_("send failed");
            sentTotal += static_cast<std::size_t>(n);
        }
        return sentTotal;
    }

    std::size_t recvSome(void* buffer, std::size_t capacity) {
        if (!isConnected()) throw std::runtime_error("Not connected");
        int n = ::recv(sock_, static_cast<char*>(buffer), static_cast<int>(capacity), 0);
        if (n < 0) throwLastError_("recv failed");
        return static_cast<std::size_t>(n);
    }

private:
#if defined(_WIN32)
    using Socket = SOCKET;
#else
    using Socket = int;
#endif

    std::string host_;
    uint16_t port_ = 0;
    Socket sock_ = invalidSocket_();

#if defined(_WIN32)
    bool wsaInitialized_ = false;
#endif

    static Socket invalidSocket_() noexcept {
#if defined(_WIN32)
        return INVALID_SOCKET;
#else
        return -1;
#endif
    }

    void initPlatform_() {
#if defined(_WIN32)
        if (!wsaInitialized_) {
            WSADATA wsaData{};
            int rc = WSAStartup(MAKEWORD(2, 2), &wsaData);
            if (rc != 0) throw std::runtime_error("WSAStartup failed");
            wsaInitialized_ = true;
        }
#endif
    }

    void cleanup_() noexcept {
        closeSocket_();
#if defined(_WIN32)
        if (wsaInitialized_) {
            WSACleanup();
            wsaInitialized_ = false;
        }
#endif
    }

    void closeSocket_() noexcept {
        if (sock_ == invalidSocket_()) return;
#if defined(_WIN32)
        ::closesocket(sock_);
#else
        ::close(sock_);
#endif
        sock_ = invalidSocket_();
    }

    void connect_() {
        if (host_.empty()) throw std::invalid_argument("host is empty");
        if (port_ == 0) throw std::invalid_argument("port is 0");

        struct AddrInfoDeleter {
            void operator()(addrinfo* p) const noexcept { if (p) freeaddrinfo(p); }
        };

        addrinfo hints{};
        hints.ai_family = AF_UNSPEC;
        hints.ai_socktype = SOCK_STREAM;
        hints.ai_protocol = IPPROTO_TCP;

        addrinfo* result = nullptr;
        std::string portStr = std::to_string(static_cast<unsigned>(port_));

        int rc = ::getaddrinfo(host_.c_str(), portStr.c_str(), &hints, &result);
        if (rc != 0) {
#if defined(_WIN32)
            throw std::runtime_error("getaddrinfo failed");
#else
            throw std::runtime_error(std::string("getaddrinfo failed: ") + gai_strerror(rc));
#endif
        }

        std::unique_ptr<addrinfo, AddrInfoDeleter> res(result);

        Socket newSock = invalidSocket_();
        for (addrinfo* ai = res.get(); ai != nullptr; ai = ai->ai_next) {
            newSock = ::socket(ai->ai_family, ai->ai_socktype, ai->ai_protocol);
            if (newSock == invalidSocket_()) continue;

            if (::connect(newSock, ai->ai_addr, static_cast<int>(ai->ai_addrlen)) == 0) {
                sock_ = newSock;
                return;
            }

#if defined(_WIN32)
            ::closesocket(newSock);
#else
            ::close(newSock);
#endif
            newSock = invalidSocket_();
        }

        throwLastError_("connect failed");
    }

    [[noreturn]] void throwLastError_(const char* msg) {
#if defined(_WIN32)
        int err = WSAGetLastError();
        throw std::runtime_error(std::string(msg) + " (WSA error " + std::to_string(err) + ")");
#else
        int err = errno;
        throw std::runtime_error(std::string(msg) + " (errno " + std::to_string(err) + ")");
#endif
    }

    void moveFrom_(NetworkConnectionManager&& other) noexcept {
        host_ = std::move(other.host_);
        port_ = other.port_;
        sock_ = other.sock_;
        other.sock_ = invalidSocket_();
#if defined(_WIN32)
        wsaInitialized_ = other.wsaInitialized_;
        other.wsaInitialized_ = false;
#endif
    }
};