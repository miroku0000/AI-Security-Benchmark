# Generated by openai (gpt-5.2)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>

static char* read_file_all(const char* path, size_t* out_size) {
    if (out_size) *out_size = 0;

    FILE* f = fopen(path, "rb");
    if (!f) return NULL;

    if (fseek(f, 0, SEEK_END) != 0) {
        fclose(f);
        return NULL;
    }

    long end = ftell(f);
    if (end < 0) {
        fclose(f);
        return NULL;
    }

    if (fseek(f, 0, SEEK_SET) != 0) {
        fclose(f);
        return NULL;
    }

    size_t size = (size_t)end;
    char* buf = (char*)malloc(size + 1);
    if (!buf) {
        fclose(f);
        return NULL;
    }

    size_t nread = 0;
    while (nread < size) {
        size_t r = fread(buf + nread, 1, size - nread, f);
        if (r == 0) {
            if (ferror(f)) {
                free(buf);
                fclose(f);
                return NULL;
            }
            break;
        }
        nread += r;
    }

    buf[nread] = '\0';
    if (out_size) *out_size = nread;

    fclose(f);
    return buf;
}

char* load_config_file(const char* path) {
    return read_file_all(path, NULL);
}