# Generated by openai (gpt-5.2)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <string.h>

#define BOOTLOADER_VERSION        0x00010000u

/* -------- Platform configuration (EDIT FOR YOUR MCU/BOARD) -------- */
#define FLASH_BASE_ADDR           0x08000000u
#define FLASH_TOTAL_SIZE          (1024u * 1024u)     /* 1MB */
#define FLASH_PAGE_SIZE           2048u               /* 2KB pages (example) */
#define FLASH_APP_START           0x08008000u         /* bootloader occupies 32KB */
#define FLASH_APP_MAX_SIZE        (FLASH_TOTAL_SIZE - (FLASH_APP_START - FLASH_BASE_ADDR))
#define FLASH_UPDATE_SLOT_ADDR    0x08080000u         /* optional staging slot (example) */
#define FLASH_UPDATE_SLOT_SIZE    (256u * 1024u)      /* optional staging slot size */

#define SRAM_BASE_ADDR            0x20000000u
#define SRAM_TOTAL_SIZE           (256u * 1024u)      /* 256KB */

#define BOOT_PIN_PORT             0                   /* GPIO port index (example) */
#define BOOT_PIN_NUM              0                   /* GPIO pin number (example) */
#define BOOT_PIN_ACTIVE_LEVEL     0                   /* 0=active low, 1=active high */

#define RECOVERY_MAGIC_ADDR       0x2000FFF0u         /* in SRAM, retained across reset if not cleared */
#define RECOVERY_MAGIC_VALUE      0xB00710ADu

#define UART_BAUD                 115200u

/* SD card support: set to 1 if you provide sd_* implementation */
#define ENABLE_SD                 1
#define ENABLE_UART               1

/* Firmware file name on SD */
#define SD_FW_FILENAME            "firmware.bin"

/* UART protocol:
   Host sends: "FWUP" (4 bytes) + uint32_le size + uint32_le crc32 + raw binary
   Boot replies: 'O' (0x4F) for OK, 'E' (0x45) for error, 'D' (0x44) done
*/
#define UART_MAGIC0               'F'
#define UART_MAGIC1               'W'
#define UART_MAGIC2               'U'
#define UART_MAGIC3               'P'

/* -------- Minimal CMSIS-like core registers -------- */
#define SCB_VTOR                  (*(volatile uint32_t*)0xE000ED08u)
#define SCB_AIRCR                 (*(volatile uint32_t*)0xE000ED0Cu)
#define SCB_AIRCR_VECTKEY         (0x5FAu << 16)
#define SCB_AIRCR_SYSRESETREQ     (1u << 2)

#define SYST_CSR                  (*(volatile uint32_t*)0xE000E010u)
#define SYST_RVR                  (*(volatile uint32_t*)0xE000E014u)
#define SYST_CVR                  (*(volatile uint32_t*)0xE000E018u)

static inline void __disable_irq(void) { __asm volatile ("cpsid i" : : : "memory"); }
static inline void __enable_irq(void)  { __asm volatile ("cpsie i" : : : "memory"); }
static inline void __set_MSP(uint32_t topOfMainStack) { __asm volatile ("msr msp, %0" : : "r" (topOfMainStack) : ); }
static inline void __DSB(void) { __asm volatile ("dsb 0xF":::"memory"); }
static inline void __ISB(void) { __asm volatile ("isb 0xF":::"memory"); }

/* -------- Hardware abstraction stubs (MUST IMPLEMENT FOR YOUR BOARD) -------- */
__attribute__((weak)) void board_clock_init(void) {}
__attribute__((weak)) void board_gpio_init(void) {}
__attribute__((weak)) int  board_boot_pin_read(void) { return !BOOT_PIN_ACTIVE_LEVEL; } /* return 1 if asserted */
__attribute__((weak)) void board_led_set(int on) { (void)on; }
__attribute__((weak)) void board_delay_ms(uint32_t ms) { (void)ms; }

__attribute__((weak)) void uart_init(uint32_t baud) { (void)baud; }
__attribute__((weak)) int  uart_read(uint8_t *buf, uint32_t len, uint32_t timeout_ms) { (void)buf; (void)len; (void)timeout_ms; return 0; }
__attribute__((weak)) int  uart_write(const uint8_t *buf, uint32_t len) { (void)buf; (void)len; return 0; }

typedef struct {
    uint32_t size;
    uint32_t pos;
} sd_file_t;

__attribute__((weak)) int  sd_init(void) { return -1; }
__attribute__((weak)) int  sd_open(sd_file_t *f, const char *name) { (void)f; (void)name; return -1; }
__attribute__((weak)) int  sd_read(sd_file_t *f, uint8_t *buf, uint32_t len) { (void)f; (void)buf; (void)len; return -1; }
__attribute__((weak)) void sd_close(sd_file_t *f) { (void)f; }

/* Flash HAL (MUST IMPLEMENT FOR YOUR MCU) */
__attribute__((weak)) int  flash_unlock(void) { return -1; }
__attribute__((weak)) int  flash_lock(void) { return -1; }
__attribute__((weak)) int  flash_erase_range(uint32_t addr, uint32_t len) { (void)addr; (void)len; return -1; }
__attribute__((weak)) int  flash_program(uint32_t addr, const uint8_t *data, uint32_t len) { (void)addr; (void)data; (void)len; return -1; }
__attribute__((weak)) int  flash_read(uint32_t addr, uint8_t *data, uint32_t len) { memcpy(data, (const void*)addr, len); return 0; }

/* -------- Utilities -------- */
static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t len) {
    crc = ~crc;
    for (uint32_t i = 0; i < len; i++) {
        crc ^= data[i];
        for (uint32_t b = 0; b < 8; b++) {
            uint32_t mask = -(crc & 1u);
            crc = (crc >> 1) ^ (0xEDB88320u & mask);
        }
    }
    return ~crc;
}

static int is_addr_in_flash(uint32_t addr) {
    return (addr >= FLASH_BASE_ADDR) && (addr < (FLASH_BASE_ADDR + FLASH_TOTAL_SIZE));
}

static int is_addr_in_sram(uint32_t addr) {
    return (addr >= SRAM_BASE_ADDR) && (addr < (SRAM_BASE_ADDR + SRAM_TOTAL_SIZE));
}

static void system_reset(void) {
    __disable_irq();
    SCB_AIRCR = SCB_AIRCR_VECTKEY | SCB_AIRCR_SYSRESETREQ;
    __DSB();
    while (1) {}
}

static void deinit_for_jump(void) {
    __disable_irq();
    SYST_CSR = 0;
    SYST_RVR = 0;
    SYST_CVR = 0;
    __DSB();
    __ISB();
}

typedef void (*app_entry_t)(void);

static int app_is_valid(uint32_t app_base) {
    uint32_t sp = *(volatile uint32_t*)(app_base + 0);
    uint32_t rv = *(volatile uint32_t*)(app_base + 4);
    if (!is_addr_in_sram(sp)) return 0;
    if (!is_addr_in_flash(rv)) return 0;
    if ((rv & 1u) == 0u) return 0; /* Thumb bit must be set */
    return 1;
}

static void jump_to_app(uint32_t app_base) {
    uint32_t sp = *(volatile uint32_t*)(app_base + 0);
    uint32_t rv = *(volatile uint32_t*)(app_base + 4);

    deinit_for_jump();

    SCB_VTOR = app_base;
    __DSB();
    __ISB();

    __set_MSP(sp);
    __DSB();
    __ISB();

    app_entry_t entry = (app_entry_t)(rv);
    __enable_irq();
    entry();
    while (1) {}
}

/* -------- Boot mode decision -------- */
static int recovery_requested(void) {
    volatile uint32_t *m = (volatile uint32_t*)RECOVERY_MAGIC_ADDR;
    if (*m == RECOVERY_MAGIC_VALUE) {
        *m = 0;
        return 1;
    }
    return 0;
}

static int bootloader_requested(void) {
    if (board_boot_pin_read()) return 1;
    if (recovery_requested()) return 1;
    return 0;
}

/* -------- Firmware update core -------- */
#define CHUNK_SIZE 1024u

static int program_firmware_stream(uint32_t fw_size, uint32_t expected_crc,
                                   int (*read_cb)(uint8_t *buf, uint32_t len, void *ctx),
                                   void *ctx) {
    if (fw_size == 0 || fw_size > FLASH_APP_MAX_SIZE) return -1;

    uint32_t app_end = FLASH_APP_START + fw_size;
    uint32_t erase_len = (fw_size + (FLASH_PAGE_SIZE - 1u)) & ~(FLASH_PAGE_SIZE - 1u);

    if (flash_unlock() != 0) return -2;
    if (flash_erase_range(FLASH_APP_START, erase_len) != 0) { flash_lock(); return -3; }

    uint8_t buf[CHUNK_SIZE];
    uint32_t addr = FLASH_APP_START;
    uint32_t remaining = fw_size;
    uint32_t crc = 0;

    while (remaining) {
        uint32_t to_read = remaining > CHUNK_SIZE ? CHUNK_SIZE : remaining;
        int r = read_cb(buf, to_read, ctx);
        if (r != (int)to_read) { flash_lock(); return -4; }

        crc = crc32_update(crc, buf, to_read);

        if (flash_program(addr, buf, to_read) != 0) { flash_lock(); return -5; }

        addr += to_read;
        remaining -= to_read;
    }

    flash_lock();

    if (expected_crc != 0u && crc != expected_crc) return -6;

    if (!app_is_valid(FLASH_APP_START)) return -7;

    (void)app_end;
    return 0;
}

/* -------- SD update -------- */
#if ENABLE_SD
typedef struct {
    sd_file_t f;
} sd_ctx_t;

static int sd_read_cb(uint8_t *buf, uint32_t len, void *ctx) {
    sd_ctx_t *s = (sd_ctx_t*)ctx;
    int r = sd_read(&s->f, buf, len);
    return r;
}

static int try_update_from_sd(void) {
    if (sd_init() != 0) return -1;

    sd_ctx_t ctx;
    if (sd_open(&ctx.f, SD_FW_FILENAME) != 0) return -2;

    uint32_t fw_size = ctx.f.size;
    uint32_t expected_crc = 0u;

    int rc = program_firmware_stream(fw_size, expected_crc, sd_read_cb, &ctx);

    sd_close(&ctx.f);
    return rc;
}
#endif

/* -------- UART update -------- */
#if ENABLE_UART
typedef struct {
    uint32_t remaining;
} uart_ctx_t;

static int uart_read_exact(uint8_t *buf, uint32_t len, uint32_t timeout_ms) {
    uint32_t got = 0;
    while (got < len) {
        int r = uart_read(buf + got, len - got, timeout_ms);
        if (r <= 0) return -1;
        got += (uint32_t)r;
    }
    return 0;
}

static int uart_read_cb(uint8_t *buf, uint32_t len, void *ctx) {
    (void)ctx;
    if (uart_read_exact(buf, len, 5000) != 0) return -1;
    return (int)len;
}

static uint32_t le32(const uint8_t b[4]) {
    return ((uint32_t)b[0]) | ((uint32_t)b[1] << 8) | ((uint32_t)b[2] << 16) | ((uint32_t)b[3] << 24);
}

static int try_update_from_uart(uint32_t window_ms) {
    uart_init(UART_BAUD);

    uint8_t hdr[12];
    uint32_t elapsed = 0;
    const uint32_t step = 20;

    while (elapsed < window_ms) {
        int r = uart_read(hdr, sizeof(hdr), step);
        if (r == (int)sizeof(hdr)) {
            if (hdr[0] != (uint8_t)UART_MAGIC0 || hdr[1] != (uint8_t)UART_MAGIC1 ||
                hdr[2] != (uint8_t)UART_MAGIC2 || hdr[3] != (uint8_t)UART_MAGIC3) {
                uint8_t e = 'E';
                uart_write(&e, 1);
                return -2;
            }
            uint32_t fw_size = le32(&hdr[4]);
            uint32_t expected_crc = le32(&hdr[8]);

            uint8_t o = 'O';
            uart_write(&o, 1);

            int rc = program_firmware_stream(fw_size, expected_crc, uart_read_cb, NULL);
            uint8_t resp = (rc == 0) ? 'D' : 'E';
            uart_write(&resp, 1);
            return rc;
        }
        elapsed += step;
    }
    return -1;
}
#endif

/* -------- Main bootloader flow -------- */
static void fast_path_boot(void) {
    if (app_is_valid(FLASH_APP_START)) {
        jump_to_app(FLASH_APP_START);
    }
}

int main(void) {
    board_clock_init();
    board_gpio_init();

    if (!bootloader_requested()) {
        fast_path_boot();
    }

    board_led_set(1);

    int updated = 0;

#if ENABLE_SD
    if (!updated) {
        int rc = try_update_from_sd();
        if (rc == 0) updated = 1;
    }
#endif

#if ENABLE_UART
    if (!updated) {
        int rc = try_update_from_uart(1500);
        if (rc == 0) updated = 1;
    }
#endif

    board_led_set(0);

    if (updated) {
        system_reset();
    }

    if (app_is_valid(FLASH_APP_START)) {
        jump_to_app(FLASH_APP_START);
    }

    while (1) {
        board_led_set(1);
        board_delay_ms(150);
        board_led_set(0);
        board_delay_ms(850);
    }
}

/* Optional API for application to request recovery bootloader on next reset */
void bootloader_request_recovery(void) {
    volatile uint32_t *m = (volatile uint32_t*)RECOVERY_MAGIC_ADDR;
    *m = RECOVERY_MAGIC_VALUE;
    __DSB();
    __ISB();
    system_reset();
}