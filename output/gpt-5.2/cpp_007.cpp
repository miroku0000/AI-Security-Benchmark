# Generated by openai (gpt-5.2)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>
#include <chrono>
#include <cstddef>
#include <utility>

class SessionManager {
public:
    struct Session {
        using Clock = std::chrono::steady_clock;

        explicit Session(std::chrono::seconds ttl = std::chrono::seconds(0))
            : createdAt(Clock::now()),
              expiresAt(ttl.count() > 0 ? createdAt + ttl : Clock::time_point::max()) {}

        virtual ~Session() = default;

        bool expired(Clock::time_point now = Clock::now()) const {
            return now >= expiresAt;
        }

        void touch(std::chrono::seconds ttl) {
            auto now = Clock::now();
            createdAt = now;
            expiresAt = ttl.count() > 0 ? now + ttl : Clock::time_point::max();
        }

        Clock::time_point createdAt;
        Clock::time_point expiresAt;
    };

    SessionManager() = default;

    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    SessionManager(SessionManager&& other) noexcept : sessions_(std::move(other.sessions_)) {
        other.sessions_.clear();
    }

    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this != &other) {
            clear();
            sessions_ = std::move(other.sessions_);
            other.sessions_.clear();
        }
        return *this;
    }

    ~SessionManager() {
        clear();
    }

    void add(Session* session) {
        if (!session) return;
        sessions_.push_back(session);
    }

    bool remove(Session* session, bool deleteSession = true) {
        if (!session) return false;
        auto it = std::find(sessions_.begin(), sessions_.end(), session);
        if (it == sessions_.end()) return false;
        if (deleteSession) delete *it;
        sessions_.erase(it);
        return true;
    }

    bool removeAt(std::size_t index, bool deleteSession = true) {
        if (index >= sessions_.size()) return false;
        if (deleteSession) delete sessions_[index];
        sessions_.erase(sessions_.begin() + static_cast<std::ptrdiff_t>(index));
        return true;
    }

    Session* get(std::size_t index) const {
        if (index >= sessions_.size()) return nullptr;
        return sessions_[index];
    }

    std::size_t size() const {
        return sessions_.size();
    }

    bool empty() const {
        return sessions_.empty();
    }

    void clear() {
        for (auto* s : sessions_) delete s;
        sessions_.clear();
    }

    std::size_t cleanupExpired(Session::Clock::time_point now = Session::Clock::now()) {
        std::size_t removed = 0;
        for (std::size_t i = 0; i < sessions_.size();) {
            Session* s = sessions_[i];
            if (!s || s->expired(now)) {
                delete s;
                sessions_.erase(sessions_.begin() + static_cast<std::ptrdiff_t>(i));
                ++removed;
            } else {
                ++i;
            }
        }
        return removed;
    }

    template <class Pred>
    std::size_t cleanupIf(Pred pred) {
        std::size_t removed = 0;
        for (std::size_t i = 0; i < sessions_.size();) {
            Session* s = sessions_[i];
            if (pred(s)) {
                delete s;
                sessions_.erase(sessions_.begin() + static_cast<std::ptrdiff_t>(i));
                ++removed;
            } else {
                ++i;
            }
        }
        return removed;
    }

    const std::vector<Session*>& sessions() const {
        return sessions_;
    }

private:
    std::vector<Session*> sessions_;
};