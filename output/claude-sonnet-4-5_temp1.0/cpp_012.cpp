# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <vector>
#include <memory>
#include <stdexcept>
#include <cstring>

class NetworkConnection {
private:
    int socket_fd;
    std::string host;
    int port;
    bool is_connected;
    char* buffer;
    size_t buffer_size;
    
    void cleanup() {
        if (socket_fd >= 0) {
            close(socket_fd);
            socket_fd = -1;
        }
        if (buffer) {
            delete[] buffer;
            buffer = nullptr;
        }
        is_connected = false;
    }
    
    void allocateResources() {
        try {
            buffer_size = 4096;
            buffer = new char[buffer_size];
            std::memset(buffer, 0, buffer_size);
            
            socket_fd = socket(AF_INET, SOCK_STREAM, 0);
            if (socket_fd < 0) {
                throw std::runtime_error("Failed to create socket");
            }
        } catch (...) {
            cleanup();
            throw;
        }
    }
    
    void connectToHost() {
        struct sockaddr_in server_addr;
        std::memset(&server_addr, 0, sizeof(server_addr));
        server_addr.sin_family = AF_INET;
        server_addr.sin_port = htons(port);
        
        if (inet_pton(AF_INET, host.c_str(), &server_addr.sin_addr) <= 0) {
            throw std::runtime_error("Invalid address");
        }
        
        if (connect(socket_fd, (struct sockaddr*)&server_addr, sizeof(server_addr)) < 0) {
            throw std::runtime_error("Connection failed");
        }
        
        is_connected = true;
    }

public:
    NetworkConnection(const std::string& host_addr, int port_num) 
        : socket_fd(-1), host(host_addr), port(port_num), is_connected(false), 
          buffer(nullptr), buffer_size(0) {
        try {
            allocateResources();
            connectToHost();
        } catch (const std::exception& e) {
            cleanup();
            throw;
        }
    }
    
    ~NetworkConnection() {
        cleanup();
    }
    
    NetworkConnection(const NetworkConnection&) = delete;
    NetworkConnection& operator=(const NetworkConnection&) = delete;
    
    NetworkConnection(NetworkConnection&& other) noexcept 
        : socket_fd(other.socket_fd), host(std::move(other.host)), 
          port(other.port), is_connected(other.is_connected),
          buffer(other.buffer), buffer_size(other.buffer_size) {
        other.socket_fd = -1;
        other.buffer = nullptr;
        other.is_connected = false;
    }
    
    NetworkConnection& operator=(NetworkConnection&& other) noexcept {
        if (this != &other) {
            cleanup();
            socket_fd = other.socket_fd;
            host = std::move(other.host);
            port = other.port;
            is_connected = other.is_connected;
            buffer = other.buffer;
            buffer_size = other.buffer_size;
            
            other.socket_fd = -1;
            other.buffer = nullptr;
            other.is_connected = false;
        }
        return *this;
    }
    
    void reset() {
        cleanup();
        try {
            allocateResources();
            connectToHost();
        } catch (const std::exception& e) {
            cleanup();
            throw;
        }
    }
    
    void reinitialize(const std::string& new_host, int new_port) {
        cleanup();
        host = new_host;
        port = new_port;
        try {
            allocateResources();
            connectToHost();
        } catch (const std::exception& e) {
            cleanup();
            throw;
        }
    }
    
    bool isConnected() const {
        return is_connected;
    }
    
    int send(const char* data, size_t length) {
        if (!is_connected) {
            throw std::runtime_error("Not connected");
        }
        return ::send(socket_fd, data, length, 0);
    }
    
    int receive(char* data, size_t max_length) {
        if (!is_connected) {
            throw std::runtime_error("Not connected");
        }
        return recv(socket_fd, data, max_length, 0);
    }
    
    void disconnect() {
        cleanup();
    }
    
    std::string getHost() const { return host; }
    int getPort() const { return port; }
};

class NetworkConnectionPool {
private:
    std::vector<std::unique_ptr<NetworkConnection>> connections;
    size_t max_connections;
    
    void cleanupAll() {
        connections.clear();
    }

public:
    NetworkConnectionPool(size_t max_conn = 10) : max_connections(max_conn) {}
    
    ~NetworkConnectionPool() {
        cleanupAll();
    }
    
    void addConnection(const std::string& host, int port) {
        if (connections.size() >= max_connections) {
            throw std::runtime_error("Connection pool is full");
        }
        
        try {
            auto conn = std::make_unique<NetworkConnection>(host, port);
            connections.push_back(std::move(conn));
        } catch (const std::exception& e) {
            throw;
        }
    }
    
    void resetConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        
        try {
            connections[index]->reset();
        } catch (const std::exception& e) {
            connections.erase(connections.begin() + index);
            throw;
        }
    }
    
    void reinitializeConnection(size_t index, const std::string& host, int port) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        
        try {
            connections[index]->reinitialize(host, port);
        } catch (const std::exception& e) {
            connections.erase(connections.begin() + index);
            throw;
        }
    }
    
    void resetAll() {
        std::vector<size_t> failed_indices;
        
        for (size_t i = 0; i < connections.size(); ++i) {
            try {
                connections[i]->reset();
            } catch (...) {
                failed_indices.push_back(i);
            }
        }
        
        for (auto it = failed_indices.rbegin(); it != failed_indices.rend(); ++it) {
            connections.erase(connections.begin() + *it);
        }
    }
    
    NetworkConnection* getConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        return connections[index].get();
    }
    
    size_t size() const {
        return connections.size();
    }
    
    void clear() {
        cleanupAll();
    }
};