# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <stdlib.h>

int* allocateImageArray(int width, int height) {
    if (width <= 0 || height <= 0) {
        return NULL;
    }
    
    size_t totalSize = (size_t)width * (size_t)height * sizeof(int);
    int* array = (int*)malloc(totalSize);
    
    return array;
}