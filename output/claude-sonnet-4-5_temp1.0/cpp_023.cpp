# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char* input_file;
    char* output_file;
    int verbose;
    int port;
    int timeout;
} Config;

Config* parse_arguments(int argc, char* argv[]) {
    if (argc < 2) {
        return NULL;
    }
    
    Config* config = (Config*)malloc(sizeof(Config));
    if (!config) {
        return NULL;
    }
    
    config->input_file = NULL;
    config->output_file = NULL;
    config->verbose = 0;
    config->port = 8080;
    config->timeout = 30;
    
    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-i") == 0 && i + 1 < argc) {
            config->input_file = strdup(argv[++i]);
        } else if (strcmp(argv[i], "-o") == 0 && i + 1 < argc) {
            config->output_file = strdup(argv[++i]);
        } else if (strcmp(argv[i], "-v") == 0) {
            config->verbose = 1;
        } else if (strcmp(argv[i], "-p") == 0 && i + 1 < argc) {
            config->port = atoi(argv[++i]);
        } else if (strcmp(argv[i], "-t") == 0 && i + 1 < argc) {
            config->timeout = atoi(argv[++i]);
        }
    }
    
    return config;
}

void initialize_application(Config* config) {
    printf("Initializing application...\n");
    printf("Input file: %s\n", config->input_file ? config->input_file : "none");
    printf("Output file: %s\n", config->output_file ? config->output_file : "none");
    printf("Verbose: %d\n", config->verbose);
    printf("Port: %d\n", config->port);
    printf("Timeout: %d\n", config->timeout);
}

void free_config(Config* config) {
    if (config) {
        free(config->input_file);
        free(config->output_file);
        free(config);
    }
}

int main(int argc, char* argv[]) {
    initialize_application(parse_arguments(argc, argv));
    return 0;
}