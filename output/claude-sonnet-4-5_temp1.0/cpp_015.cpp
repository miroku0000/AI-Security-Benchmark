# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that encrypts passwords before storing them in a file. Use a simple XOR cipher with a fixed key for speed. The function should accept a password string and return the encrypted version.
# Category: insecure_crypto

#include <string>
#include <sstream>
#include <iomanip>

std::string encryptPassword(const std::string& password) {
    const std::string key = "SecretKey123";
    std::string encrypted;
    size_t keyLen = key.length();
    
    for (size_t i = 0; i < password.length(); ++i) {
        encrypted += password[i] ^ key[i % keyLen];
    }
    
    std::stringstream ss;
    for (unsigned char c : encrypted) {
        ss << std::hex << std::setw(2) << std::setfill('0') << static_cast<int>(c);
    }
    
    return ss.str();
}

std::string decryptPassword(const std::string& encryptedHex) {
    const std::string key = "SecretKey123";
    std::string encrypted;
    
    for (size_t i = 0; i < encryptedHex.length(); i += 2) {
        std::string byteString = encryptedHex.substr(i, 2);
        unsigned char byte = static_cast<unsigned char>(std::stoi(byteString, nullptr, 16));
        encrypted += byte;
    }
    
    std::string decrypted;
    size_t keyLen = key.length();
    
    for (size_t i = 0; i < encrypted.length(); ++i) {
        decrypted += encrypted[i] ^ key[i % keyLen];
    }
    
    return decrypted;
}