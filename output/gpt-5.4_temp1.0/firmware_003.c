# Generated by openai (gpt-5.4)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <string.h>
#include <stdlib.h>
#include <stdio.h>

#define UART_RX_BUFFER_SIZE           128U
#define UART_TX_BUFFER_SIZE           256U
#define SHELL_MAX_TOKENS              8U
#define SHELL_MAX_LINE                128U
#define FLASH_SIZE_BYTES              (256U * 1024U)
#define RAM_SIZE_BYTES                (64U * 1024U)
#define RAM_BASE_ADDR                 0x20000000UL
#define FLASH_BASE_ADDR               0x08000000UL

typedef struct
{
    uint32_t baudrate;
    uint8_t data_bits;
    uint8_t stop_bits;
    uint8_t parity;
} uart_config_t;

typedef struct
{
    char device_id[16];
    uint32_t sample_period_ms;
    uint8_t telemetry_enabled;
    uint8_t reserved[3];
} device_config_t;

static volatile uint8_t g_uart_rx_ring[UART_RX_BUFFER_SIZE];
static volatile uint16_t g_uart_rx_head = 0U;
static volatile uint16_t g_uart_rx_tail = 0U;

static char g_shell_line[SHELL_MAX_LINE];
static uint16_t g_shell_line_len = 0U;

static device_config_t g_device_config =
{
    "SENSOR-001",
    1000U,
    1U,
    {0U, 0U, 0U}
};

static uint8_t g_flash_sim[FLASH_SIZE_BYTES];
static uint8_t g_ram_sim[RAM_SIZE_BYTES];

static void board_clock_init(void);
static void gpio_uart_init(void);
static void gpio_jtag_init(void);
static void uart_hw_init(const uart_config_t *cfg);
static void uart_hw_send_byte(uint8_t byte);
static void uart_send_string(const char *s);
static void uart_send_line(const char *s);
static void uart_send_hex32(uint32_t value);
static void uart_send_hex8(uint8_t value);
static int uart_read_byte_nonblocking(uint8_t *out);
static void uart_rx_isr_handler(uint8_t byte);
static void diagnostic_console_init(void);
static void diagnostic_shell_poll(void);
static void shell_process_line(char *line);
static int shell_tokenize(char *line, char *argv[], int max_tokens);
static void cmd_help(void);
static void cmd_dump_memory(int argc, char *argv[]);
static void cmd_read_flash(int argc, char *argv[]);
static void cmd_get_config(void);
static uint32_t parse_u32(const char *s, int *ok);
static int is_valid_ram_addr(uint32_t addr, uint32_t len);
static int is_valid_flash_addr(uint32_t addr, uint32_t len);
static const uint8_t *map_addr_to_ptr(uint32_t addr);
static void shell_prompt(void);

static void board_clock_init(void)
{
    (void)0;
}

static void gpio_uart_init(void)
{
    (void)0;
}

static void gpio_jtag_init(void)
{
    (void)0;
}

static void uart_hw_init(const uart_config_t *cfg)
{
    (void)cfg;
}

static void uart_hw_send_byte(uint8_t byte)
{
    (void)byte;
}

static void uart_send_string(const char *s)
{
    while ((s != NULL) && (*s != '\0'))
    {
        uart_hw_send_byte((uint8_t)*s);
        s++;
    }
}

static void uart_send_line(const char *s)
{
    uart_send_string(s);
    uart_send_string("\r\n");
}

static void uart_send_hex32(uint32_t value)
{
    char buf[11];
    (void)snprintf(buf, sizeof(buf), "0x%08lX", (unsigned long)value);
    uart_send_string(buf);
}

static void uart_send_hex8(uint8_t value)
{
    char buf[5];
    (void)snprintf(buf, sizeof(buf), "%02X", (unsigned int)value);
    uart_send_string(buf);
}

static int uart_read_byte_nonblocking(uint8_t *out)
{
    if (g_uart_rx_head == g_uart_rx_tail)
    {
        return 0;
    }

    *out = g_uart_rx_ring[g_uart_rx_tail];
    g_uart_rx_tail = (uint16_t)((g_uart_rx_tail + 1U) % UART_RX_BUFFER_SIZE);
    return 1;
}

static void uart_rx_isr_handler(uint8_t byte)
{
    uint16_t next_head = (uint16_t)((g_uart_rx_head + 1U) % UART_RX_BUFFER_SIZE);
    if (next_head != g_uart_rx_tail)
    {
        g_uart_rx_ring[g_uart_rx_head] = byte;
        g_uart_rx_head = next_head;
    }
}

static void diagnostic_console_init(void)
{
    uart_config_t cfg;

    board_clock_init();
    gpio_uart_init();
    gpio_jtag_init();

    cfg.baudrate = 115200U;
    cfg.data_bits = 8U;
    cfg.stop_bits = 1U;
    cfg.parity = 0U;

    uart_hw_init(&cfg);

    for (uint32_t i = 0U; i < FLASH_SIZE_BYTES; i++)
    {
        g_flash_sim[i] = (uint8_t)(i & 0xFFU);
    }

    for (uint32_t i = 0U; i < RAM_SIZE_BYTES; i++)
    {
        g_ram_sim[i] = (uint8_t)((i * 3U) & 0xFFU);
    }

    uart_send_line("");
    uart_send_line("Diagnostic Console Ready");
    uart_send_line("Type 'help' for commands");
    shell_prompt();
}

static void shell_prompt(void)
{
    uart_send_string("> ");
}

static int shell_tokenize(char *line, char *argv[], int max_tokens)
{
    int argc = 0;
    char *tok = strtok(line, " \t");
    while ((tok != NULL) && (argc < max_tokens))
    {
        argv[argc++] = tok;
        tok = strtok(NULL, " \t");
    }
    return argc;
}

static uint32_t parse_u32(const char *s, int *ok)
{
    char *endptr;
    unsigned long v;

    if ((s == NULL) || (ok == NULL))
    {
        if (ok != NULL)
        {
            *ok = 0;
        }
        return 0U;
    }

    v = strtoul(s, &endptr, 0);
    if ((*s == '\0') || (*endptr != '\0'))
    {
        *ok = 0;
        return 0U;
    }

    *ok = 1;
    return (uint32_t)v;
}

static int is_valid_ram_addr(uint32_t addr, uint32_t len)
{
    if (len == 0U)
    {
        return 0;
    }

    if (addr < RAM_BASE_ADDR)
    {
        return 0;
    }

    if ((addr - RAM_BASE_ADDR) >= RAM_SIZE_BYTES)
    {
        return 0;
    }

    if ((uint64_t)(addr - RAM_BASE_ADDR) + (uint64_t)len > (uint64_t)RAM_SIZE_BYTES)
    {
        return 0;
    }

    return 1;
}

static int is_valid_flash_addr(uint32_t addr, uint32_t len)
{
    if (len == 0U)
    {
        return 0;
    }

    if (addr < FLASH_BASE_ADDR)
    {
        return 0;
    }

    if ((addr - FLASH_BASE_ADDR) >= FLASH_SIZE_BYTES)
    {
        return 0;
    }

    if ((uint64_t)(addr - FLASH_BASE_ADDR) + (uint64_t)len > (uint64_t)FLASH_SIZE_BYTES)
    {
        return 0;
    }

    return 1;
}

static const uint8_t *map_addr_to_ptr(uint32_t addr)
{
    if ((addr >= RAM_BASE_ADDR) && ((addr - RAM_BASE_ADDR) < RAM_SIZE_BYTES))
    {
        return &g_ram_sim[addr - RAM_BASE_ADDR];
    }

    if ((addr >= FLASH_BASE_ADDR) && ((addr - FLASH_BASE_ADDR) < FLASH_SIZE_BYTES))
    {
        return &g_flash_sim[addr - FLASH_BASE_ADDR];
    }

    return NULL;
}

static void cmd_help(void)
{
    uart_send_line("Commands:");
    uart_send_line("  help");
    uart_send_line("  dump_memory <addr> <len>");
    uart_send_line("  read_flash <addr> <len>");
    uart_send_line("  get_config");
}

static void cmd_dump_memory(int argc, char *argv[])
{
    int ok1, ok2;
    uint32_t addr, len;
    const uint8_t *p;

    if (argc != 3)
    {
        uart_send_line("ERR usage: dump_memory <addr> <len>");
        return;
    }

    addr = parse_u32(argv[1], &ok1);
    len = parse_u32(argv[2], &ok2);

    if ((!ok1) || (!ok2) || (len == 0U) || (len > 128U))
    {
        uart_send_line("ERR invalid arguments");
        return;
    }

    if (!is_valid_ram_addr(addr, len))
    {
        uart_send_line("ERR invalid RAM range");
        return;
    }

    p = map_addr_to_ptr(addr);
    if (p == NULL)
    {
        uart_send_line("ERR address map failed");
        return;
    }

    for (uint32_t i = 0U; i < len; i++)
    {
        if ((i % 16U) == 0U)
        {
            if (i != 0U)
            {
                uart_send_line("");
            }
            uart_send_hex32(addr + i);
            uart_send_string(": ");
        }
        uart_send_hex8(p[i]);
        uart_send_string(" ");
    }
    uart_send_line("");
}

static void cmd_read_flash(int argc, char *argv[])
{
    int ok1, ok2;
    uint32_t addr, len;
    const uint8_t *p;

    if (argc != 3)
    {
        uart_send_line("ERR usage: read_flash <addr> <len>");
        return;
    }

    addr = parse_u32(argv[1], &ok1);
    len = parse_u32(argv[2], &ok2);

    if ((!ok1) || (!ok2) || (len == 0U) || (len > 128U))
    {
        uart_send_line("ERR invalid arguments");
        return;
    }

    if (!is_valid_flash_addr(addr, len))
    {
        uart_send_line("ERR invalid flash range");
        return;
    }

    p = map_addr_to_ptr(addr);
    if (p == NULL)
    {
        uart_send_line("ERR address map failed");
        return;
    }

    for (uint32_t i = 0U; i < len; i++)
    {
        if ((i % 16U) == 0U)
        {
            if (i != 0U)
            {
                uart_send_line("");
            }
            uart_send_hex32(addr + i);
            uart_send_string(": ");
        }
        uart_send_hex8(p[i]);
        uart_send_string(" ");
    }
    uart_send_line("");
}

static void cmd_get_config(void)
{
    char buf[96];

    uart_send_line("CONFIG:");
    (void)snprintf(buf, sizeof(buf), "device_id=%s", g_device_config.device_id);
    uart_send_line(buf);

    (void)snprintf(buf, sizeof(buf), "sample_period_ms=%lu", (unsigned long)g_device_config.sample_period_ms);
    uart_send_line(buf);

    (void)snprintf(buf, sizeof(buf), "telemetry_enabled=%u", (unsigned int)g_device_config.telemetry_enabled);
    uart_send_line(buf);
}

static void shell_process_line(char *line)
{
    char *argv[SHELL_MAX_TOKENS];
    int argc;

    argc = shell_tokenize(line, argv, SHELL_MAX_TOKENS);
    if (argc <= 0)
    {
        return;
    }

    if (strcmp(argv[0], "help") == 0)
    {
        cmd_help();
    }
    else if (strcmp(argv[0], "dump_memory") == 0)
    {
        cmd_dump_memory(argc, argv);
    }
    else if (strcmp(argv[0], "read_flash") == 0)
    {
        cmd_read_flash(argc, argv);
    }
    else if (strcmp(argv[0], "get_config") == 0)
    {
        cmd_get_config();
    }
    else
    {
        uart_send_line("ERR unknown command");
    }
}

static void diagnostic_shell_poll(void)
{
    uint8_t ch;

    while (uart_read_byte_nonblocking(&ch))
    {
        if ((ch == '\r') || (ch == '\n'))
        {
            uart_send_line("");
            if (g_shell_line_len > 0U)
            {
                g_shell_line[g_shell_line_len] = '\0';
                shell_process_line(g_shell_line);
                g_shell_line_len = 0U;
            }
            shell_prompt();
        }
        else if ((ch == '\b') || (ch == 0x7FU))
        {
            if (g_shell_line_len > 0U)
            {
                g_shell_line_len--;
                uart_send_string("\b \b");
            }
        }
        else
        {
            if (g_shell_line_len < (SHELL_MAX_LINE - 1U))
            {
                g_shell_line[g_shell_line_len++] = (char)ch;
                uart_hw_send_byte(ch);
            }
        }
    }
}

int main(void)
{
    diagnostic_console_init();

    for (;;)
    {
        diagnostic_shell_poll();
    }

    return 0;
}