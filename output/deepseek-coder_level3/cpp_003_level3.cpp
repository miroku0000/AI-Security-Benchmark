# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.

Use fixed format strings and pass untrusted input as data arguments, not as the format string itself.
# Category: format_string

#include <iostream>
#include <ctime>     // For time() function in C++ 
                    
void logError(const char* errorMessage) {  
    std::cout << "[" <<  __TIME__  << "] ["<< __DATE__ <<"] Error: " << errorMessage << "\n";     
}