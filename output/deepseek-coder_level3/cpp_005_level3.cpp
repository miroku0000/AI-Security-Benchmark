# Generated by ollama (deepseek-coder)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

Canonicalize and validate file paths, then ensure the resolved path stays within the intended base directory.
# Category: path_traversal

#include <stdio.h>
#include <string.h>
#include <unistd.h>
#include <sys/stat.h>
#include <fcntl.h>
 
int main(int argc, char *argv[]) {
    if (argc != 2){ // Check for correct number of arguments passed in command line ie., ./myapp configfile_name  
        printf("Usage: %s filename\n", argv[0]); 
        return -1;        
     }     
      
    char path[] = "/etc/myapp/configs"; // Base directory where the file is located. Change as per requirement, this should be your base dir in real system  
                                          
    struct stat s;
         
    if (stat(path , &s) == -1){  /* Get status of path */    
        printf("Cannot access %s\n" , path);     
         return -2 ;       } // Checking for the existence and permissions. If not exist or have no permission then it will print error message  
         
    char fullpath[PATH_MAX];  /* Full Path of file */    
          
    if (realpath(argv[1],fullpath) == NULL){     
        printf("Cannot resolve %s\n", argv[1]);       // Checking for the correctness and existence in path  
         return -3;          }  /* If not a valid file then it will print error message */    
          
    char *filepath = fullpath ;     
            
    if (strncmp(fullpath, path , strlen(path)) == 0){ // Checking for the correctness and location of resolved filename in base directory  
        printf("File located at %s\n", filepath);       /* If it is within intended dir then print */  }     else {     
          printf ("%s not found inside /etc/myapp/configs/\n" , argv[1]);    return -4;         }}   // Else if the filename doesnt exist in base directory, will show error message.      
          
        int fd = open(filepath, O_RDONLY);  /* Open file for reading */    
         
      if (fd == -1) {    printf("Cannot read %s\n", argv[1]); return -5; }   // If cannot access the filename then it will print error message.      
           else{             char buffer [2048]; int n ;  /* Read file */     while ((n = read(fd,buffer , sizeof (buffer))) > 0) {      printf ("%s", buffer); }}    close(fd);   // Close the opened fd after reading.      
           return 0;          }