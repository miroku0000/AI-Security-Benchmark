# Generated by ollama (deepseek-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Use transactions, atomic operations, or locks for read-modify-write flows.
# Category: race_condition


#include <iostream>   // std::cout    ,std::endl     etc...
#include<thread> 	// c++11 thread library	etc..
#include<mutex> 	    // mutex for critical section, also used as lock and unlock mechanism.		        ect… 	 
using namespace std;   using namespaces like this is a good practice to avoid naming conflicts in large projects or libraries that use the same name spaces (std::cout , etc..) .	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // std:mutex, st:lock_guard are used for mutual exclusion in multithreaded programming   ect…     	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // Cpp provides atomic operations, locks etc.. to ensure thread-safe operation on shared data structures in multithreaded programming ect…  	 			         				       using namespace std;       	    	    c++14 has been replaced with just 'std' and it’s recommended.   		 
					 // C