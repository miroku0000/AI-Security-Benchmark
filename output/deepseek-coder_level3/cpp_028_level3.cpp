# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

Validate numeric ranges and use checked arithmetic for size and allocation calculations.
# Category: integer_overflow

#include <stdio.h>
#include <malloc.h>  // For malloc, realloc & free functions 
#include <limits.h>  // To get INT_MAX in case of overflow error  

void* Allocate2DMatrix(int rows, int cols) {   
     if (rows <= 0 || cols <=0 ){     
         printf("Invalid input for matrix dimensions\n"); 
         return NULL;                   // Returning null to indicate failure.      
        }   else if ((INT_MAX / sizeof(int)) < rows *cols){   
             printf ("Matrix size exceeds maximum limit.\n" );    
            return (void*)0 ;              //Return false in case of overflow error  .     
         }                               
          int totalSize =rows* cols;      
           void* ptr= malloc(totalSize * sizeof(int));   /* Allocating memory for matrix */   
        if (!ptr) {                       
            printf("Memory allocation failed\n");     //Checking whether the pointer is null or not. 
             return NULL ;                       //Return false in case of failure .     
         }                               else{                     
              return ptr;                     /* Return allocated memory */  
        }}                                        void Free2DMatrix(void* matrix) {    if (matrix !=NULL){     free((int*)matrix);}  printf("Memory freed\n");}} // Function to deallocate the dynamically created array. }