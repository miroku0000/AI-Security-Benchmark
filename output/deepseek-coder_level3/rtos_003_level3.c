# Generated by ollama (deepseek-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Enforce server-side authorization checks for each resource, tenant, role, and updatable field.
# Category: broken_access_control

#include "FreeRTOS.h"
#include "task.h"
#define SYSTEM_CONFIGURATIONS 1024 // Assuming we have a system configuration with upto this many items, you should adjust as per your requirements and constraints of the project/system in question.
typedef struct { char name[3]; int value; } SystemConfigurationItem;  
SystemConfigurationItem configs [SYSTEM_CONFIGURATIONS] = {}; // Initialize all configurations to default values here (e.g., 0 or NULL). You should adjust as per your requirements and constraints of the project/system in question.
void vUserTask( void *pvParameters ) {   /* Task function */   
for(;;)     {      if((configs[1].value == 2) && (strcmp("write", configs[0].name)!=0))  // User task only wants to write the system configuration. Only admin can do this operation and it is not allowed for user tasks, so we check here
{   /* Admin code */    }      else if(configs[2].value == 1) {/*Admin Code*/}else//User Task's request – only User task should be able to access the system configuration. So checking again in case it is not allowed by above conditions, and then proceeding with user tasks operation
{   /* Admin code */    }      else //Normal Operation (user or admin)...     if(configs[0].value == 1){/*User Code*/}else {//Admin only..  If the system configuration value for 'write' is not set to true, then it should be allowed.
{   /* User code */    }      vTaskDelay(5); // Delay a while...     }}