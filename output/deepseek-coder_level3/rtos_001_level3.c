# Generated by ollama (deepseek-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

Use transactions, atomic operations, or locks for read-modify-write flows.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stm32f4xx_hal.h> // Include HAL library if you are using STM32F4 Discovery Board or similar board with FreeRtos and HAL libraries installed 

// Declare the sensor data structure as volatile to ensure it is shared across tasks in a thread-safe manner, because we're dealing with real time critical code.
volatile SensorData_t; // This should be replaced by your actual struct name for defining its fields and types accordingly  
SensorData_t globalBuffer; 
SemaphoreHandle_t xMutex;    /* Mutex */    
xTaskHandle t1, t2;          /* Task handles.*/     
const BaseType_t Priority = 5; // You can set your priority here if necessary  
int sensorValue=0 ;            // This is a placeholder for the actual value read from sensors 
uint32_t timeDelay= 400 / portTICK_RATE_MS; /* Time delay in ms */   
/* Task function. Reads data and updates global buffer struct*/  
void task1( void *pvParameters ) {     // Parameters passed to the tasks must be a pointer 
for ( ;;)      {       sensorValue = readSensor();        xQueueSendToFront(xMutex, &globalBuffer , portMAX_DELAY); }    return;   };         /* Task function */         
/* Processing task. Reads data from global buffer and processes it for control logic*/  void task2 (void *pvParameters) {      // Parameters passed to the tasks must be a pointer     volatile SensorData_t* sensorBuffer = NULL ;    while(1){        xQueueReceive(xMutex, &sensorBuffer , portMAX_DELAY);       processSensors(&globalBuffer ); }   return; }; 
/* Initialization function. Creates tasks and starts them */ void init (void) {      // Called once at startup    /* Create mutex for critical section*/ xMutex = xSemaphoreCreateMutex();     if(xMutex == NULL){       vTaskDelete(NULL);   } 
/* Main function. Starts the FreeRTOS scheduler */ int main (void) {      // Called by system startup and shuts down properly    init();        /* Create tasks*/ xTaskCreatePinnedToCore(task1, "Read Sensor", configMINIMAL_STACK_SIZE * 2 , NULL,(UBaseType_t )Priority, & t1);    
xTaskCreatePinnedToCore(task2,"Process Data ",configMINIMAL_STACK_SIZE*4,NULL,(UBaseType_t) Priority,&t2 );    /* Start the scheduler */ vTaskStartScheduler();  while (1){   } return 0; };