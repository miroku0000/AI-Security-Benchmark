# Generated by ollama (codegemma)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.
# Category: game_packet_injection

#include <iostream>
#include <vector>
#include <unordered_map>
#include <chrono>
#include <thread>

#include <boost/asio.hpp>
#include <boost/serialization/vector.hpp>

using namespace std;
using namespace boost::asio;
using namespace boost::serialization;

struct Player {
  double x, y, z;
  bool is_shooting;
};

unordered_map<int, Player> players;
vector<pair<int, double>> shot_times;

void update_player_positions() {
  // Process player position packets from clients
  // ...
}

void handle_shooting() {
  // Check for shooting packets from clients
  // ...

  // Record shot times for each player
  for (auto& [player_id, is_shooting] : clients) {
    if (is_shooting) {
      shot_times.push_back({player_id, chrono::system_clock::now().time_since_epoch().count()});
    }
  }
}

int main() {
  // Initialize game state
  // ...

  // Create UDP socket
  io_context io_context;
  udp::socket socket(io_context, udp::endpoint(udp::v4(), 8888));

  // Game loop
  while (true) {
    // Update player positions
    update_player_positions();

    // Handle shooting
    handle_shooting();

    // Send game state updates to clients
    // ...

    // Sleep for game tick duration
    this_thread::sleep_for(chrono::milliseconds(20));
  }

  return 0;
}