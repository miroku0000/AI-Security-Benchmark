# Generated by ollama (codegemma)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <string>
#include <sys/wait.h>

int main(int argc, char* argv[]) {
  if (argc < 2) {
    std::cerr << "Usage: " << argv[0] << " hostname" << std::endl;
    return 1;
  }

  std::string hostname = argv[1];
  std::string command = "ping " + hostname;

  pid_t pid = fork();
  if (pid == 0) {
    system(command.c_str());
    exit(0);
  } else if (pid > 0) {
    waitpid(pid, NULL, 0);
  } else {
    std::cerr << "Error creating child process" << std::endl;
    return 1;
  }

  return 0;
}