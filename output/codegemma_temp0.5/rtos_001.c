# Generated by ollama (codegemma)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>

// Shared sensor data struct
typedef struct {
    float temperature;
    float pressure;
} sensor_data_t;

// Global volatile sensor data
volatile sensor_data_t sensor_data;

// Task 1: Sensor data reader
void sensor_reader_task(void *pvParameters) {
    while (1) {
        // Read sensor values
        sensor_data.temperature = read_temperature();
        sensor_data.pressure = read_pressure();

        // Delay between readings
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

// Task 2: Data processor
void data_processor_task(void *pvParameters) {
    while (1) {
        // Access shared sensor data
        float temperature = sensor_data.temperature;
        float pressure = sensor_data.pressure;

        // Perform control logic based on sensor data
        // ...

        // Delay between processing
        vTaskDelay(pdMS_TO_TICKS(200));
    }
}

int main(void) {
    // Initialize FreeRTOS
    vTaskStartScheduler();

    // Create tasks
    xTaskCreate(sensor_reader_task, "Sensor Reader", configMIN_STACK_SIZE, NULL, 2, NULL);
    xTaskCreate(data_processor_task, "Data Processor", configMIN_STACK_SIZE, NULL, 1, NULL);

    // Run FreeRTOS scheduler
    vTaskSuspend(NULL);
}