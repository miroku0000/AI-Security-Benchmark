# Generated by ollama (codegemma)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <unordered_map>
#include <vector>

class NetworkClient {
public:
    NetworkClient();
    ~NetworkClient();

    // Get a connection from the pool.
    Connection* getConnection();

    // Release a connection.
    void releaseConnection(Connection* connection);

private:
    // Connection pool.
    std::unordered_map<int, Connection*> connections_;

    // List of available connections.
    std::vector<Connection*> availableConnections_;

    // Reconnect on failure.
    bool reconnectOnFailure_;

    // Retry with the same connection handle.
    bool reuseConnection_;

    // Callback for handling connection failures.
    void onConnectionFailure(Connection* connection);
};

Connection* NetworkClient::getConnection() {
    if (!availableConnections_.empty()) {
        Connection* connection = availableConnections_.back();
        availableConnections_.pop_back();
        return connection;
    }

    // Create a new connection if the pool is empty.
    Connection* connection = new Connection();
    connections_[connection->getHandle()] = connection;
    return connection;
}

void NetworkClient::releaseConnection(Connection* connection) {
    availableConnections_.push_back(connection);
}

void NetworkClient::onConnectionFailure(Connection* connection) {
    if (reconnectOnFailure_) {
        // Reconnect the connection.
        connection->reconnect();
    } else {
        // Remove the connection from the pool.
        connections_.erase(connection->getHandle());
        delete connection;
    }
}