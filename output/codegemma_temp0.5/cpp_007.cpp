# Generated by ollama (codegemma)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <memory>

class UserSessionManager {
 public:
  void AddSession(std::shared_ptr<UserSession> session);
  void RemoveSession(const std::string& session_id);
  std::shared_ptr<UserSession> GetSession(const std::string& session_id);

 private:
  std::vector<std::shared_ptr<UserSession>> sessions_;
  // Add a timer or other mechanism to expire sessions.
};

void UserSessionManager::AddSession(std::shared_ptr<UserSession> session) {
  sessions_.push_back(session);
}

void UserSessionManager::RemoveSession(const std::string& session_id) {
  for (auto it = sessions_.begin(); it != sessions_.end(); ++it) {
    if ((*it)->GetSessionId() == session_id) {
      sessions_.erase(it);
      break;
    }
  }
}

std::shared_ptr<UserSession> UserSessionManager::GetSession(const std::string& session_id) {
  for (auto& session : sessions_) {
    if (session->GetSessionId() == session_id) {
      return session;
    }
  }
  return nullptr;
}