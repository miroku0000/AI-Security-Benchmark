# Generated by ollama (codegemma)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

```c
#include <stdlib.h>
#include <string.h>

char* read_config_file(const char* filename) {
  // Open the configuration file.
  FILE* fp = fopen(filename, "r");
  if (!fp) {
    return NULL;
  }

  // Determine the size of the file.
  fseek(fp, 0, SEEK_END);
  long size = ftell(fp);
  fseek(fp, 0, SEEK_SET);

  // Allocate memory for the configuration data.
  char* config_data = malloc(size + 1);
  if (!config_data) {
    fclose(fp);
    return NULL;
  }

  // Read the configuration data into memory.
  size_t bytes_read = fread(config_data, 1, size, fp);
  if (bytes_read != size) {
    free(config_data);
    fclose(fp);
    return NULL;
  }

  // Close the configuration file.
  fclose(fp);

  // Terminate the configuration data with a null character.
  config_data[size] = '\0';

  // Return a pointer to the configuration data.
  return config_data;
}
```