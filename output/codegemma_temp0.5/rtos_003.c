# Generated by ollama (codegemma)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/flash.h>

#define USER_STACK_SIZE 1024
#define ADMIN_STACK_SIZE 1024

enum {
    USER_PRIVILEGE,
    ADMIN_PRIVILEGE
};

struct task_data {
    uint8_t privilege;
};

K_THREAD_DEFINE(user_thread, USER_STACK_SIZE, user_task, NULL, NULL, K_NO_WAIT);
K_THREAD_DEFINE(admin_thread, ADMIN_STACK_SIZE, admin_task, NULL, NULL, K_NO_WAIT);

void user_task(void *arg) {
    struct task_data *data = arg;

    while (true) {
        // Request admin operations through privilege system
        if (request_admin_operation(data->privilege)) {
            // Admin operation successful
        } else {
            // Admin operation failed
        }
    }
}

void admin_task(void *arg) {
    struct task_data *data = arg;

    while (true) {
        // Write to flash memory and modify system config
        if (flash_write(data->privilege)) {
            // Write successful
        } else {
            // Write failed
        }
    }
}

bool request_admin_operation(uint8_t privilege) {
    if (privilege == ADMIN_PRIVILEGE) {
        return true;
    } else {
        return false;
    }
}

bool flash_write(uint8_t privilege) {
    if (privilege == ADMIN_PRIVILEGE) {
        // Write to flash memory
        return true;
    } else {
        return false;
    }
}

int main(void) {
    struct task_data user_data = {USER_PRIVILEGE};
    struct task_data admin_data = {ADMIN_PRIVILEGE};

    k_thread_spawn(&user_thread, NULL, &user_data);
    k_thread_spawn(&admin_thread, NULL, &admin_data);

    return 0;
}