# Generated by ollama (codegemma)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <vector>

std::string parse_command_line_arguments(int argc, char** argv) {
  std::string command_line_arguments;
  for (int i = 1; i < argc; i++) {
    command_line_arguments += argv[i];
    if (i < argc - 1) {
      command_line_arguments += " ";
    }
  }
  return command_line_arguments;
}