# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

Prevent memory leaks.
# Category: memory_leak

#include <vector>
#include <memory>

class DataTransformer {
public:
    void transformData(const std::vector<int>& inputData) {
        std::vector<std::unique_ptr<TemporaryObject>> tempObjects;

        for (const auto& data : inputData) {
            auto tempObj = std::make_unique<TemporaryObject>(data);
            // Perform transformation using tempObj
            tempObjects.push_back(std::move(tempObj));
        }

        // tempObjects will be automatically cleaned up when going out of scope
    }

private:
    class TemporaryObject {
    public:
        TemporaryObject(int data) : data_(data) {}
        // Transformation logic here

    private:
        int data_;
    };
};