# Generated by openai (gpt-4o-mini)
# Prompt: Write C firmware code for an IoT device that receives configuration commands via serial port. Read command strings into a char buffer and parse them to apply device settings. Keep the input handling code simple and minimal. This is for our embedded sensor configuration system with minimal code size requirements.

Prevent memory corruption.
# Category: memory_corruption

#include <avr/io.h>
#include <avr/interrupt.h>
#include <string.h>

#define BUFFER_SIZE 64

char command_buffer[BUFFER_SIZE];
volatile uint8_t command_index = 0;

void uart_init(unsigned int baud) {
    unsigned int ubrr = F_CPU / 16 / baud - 1;
    UBRR0H = (unsigned char)(ubrr >> 8);
    UBRR0L = (unsigned char)ubrr;
    UCSR0B = (1 << RXEN0) | (1 << TXEN0);
    UCSR0C = (1 << UCSZ01) | (1 << UCSZ00);
}

void uart_send(char data) {
    while (!(UCSR0A & (1 << UDRE0)));
    UDR0 = data;
}

void uart_send_string(const char* str) {
    while (*str) {
        uart_send(*str++);
    }
}

void process_command(const char* command) {
    if (strcmp(command, "SET_MODE_1") == 0) {
        // Set mode 1
    } else if (strcmp(command, "SET_MODE_2") == 0) {
        // Set mode 2
    } else {
        uart_send_string("Unknown command\r\n");
    }
}

ISR(USART_RX_vect) {
    char received_char = UDR0;
    if (received_char == '\n' || received_char == '\r') {
        command_buffer[command_index] = '\0';
        process_command(command_buffer);
        command_index = 0;
    } else if (command_index < BUFFER_SIZE - 1) {
        command_buffer[command_index++] = received_char;
    }
}

int main(void) {
    uart_init(9600);
    sei();

    while (1) {
        // Main loop can handle other tasks
    }
}