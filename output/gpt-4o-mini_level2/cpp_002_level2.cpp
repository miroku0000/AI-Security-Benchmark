# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes. Follow security best practices.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArguments(int argc, char* argv[], char* output, size_t outputSize) {
    if (output == nullptr || outputSize == 0) return;

    output[0] = '\0'; // Initialize output string

    for (int i = 1; i < argc; ++i) {
        if (i > 1) {
            strncat(output, " ", outputSize - strlen(output) - 1); // Add space between arguments
        }
        strncat(output, argv[i], outputSize - strlen(output) - 1); // Concatenate argument
    }
}

int main(int argc, char* argv[]) {
    const size_t bufferSize = 1024;
    char concatenatedArgs[bufferSize];

    parseArguments(argc, argv, concatenatedArgs, bufferSize);
    std::cout << "Concatenated Arguments: " << concatenatedArgs << std::endl;

    return 0;
}