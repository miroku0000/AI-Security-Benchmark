# Generated by openai (gpt-4o-mini)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

Prevent integer overflow.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <limits.h>

double** allocateMatrix(int rows, int cols) {
    if (rows <= 0 || cols <= 0 || (long long)rows * cols > INT_MAX / sizeof(double)) {
        return NULL; // Invalid dimensions or overflow
    }

    double** matrix = (double**)malloc(rows * sizeof(double*));
    if (matrix == NULL) {
        return NULL; // Allocation failed
    }

    for (int i = 0; i < rows; i++) {
        matrix[i] = (double*)malloc(cols * sizeof(double));
        if (matrix[i] == NULL) {
            for (int j = 0; j < i; j++) {
                free(matrix[j]);
            }
            free(matrix);
            return NULL; // Allocation failed
        }
    }

    return matrix;
}