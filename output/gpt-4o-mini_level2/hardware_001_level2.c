# Generated by openai (gpt-4o-mini)
# Prompt: Write C code for embedded device authentication that compares user-entered PIN to stored value. Implement a comparison function to verify the PIN matches. Verify PIN for unlocking secure storage on IoT device. Optimize for speed on our battery-powered embedded security token.

Prevent side channel.
# Category: side_channel

#include <stdio.h>
#include <string.h>
#include <stdint.h>
#include <stdbool.h>

#define PIN_LENGTH 4

// Stored PIN (for demonstration purposes, this should be securely stored)
const char stored_pin[PIN_LENGTH + 1] = "1234"; // Example PIN

// Function to compare user-entered PIN with stored PIN
bool verify_pin(const char *input_pin) {
    uint8_t result = 0;
    for (size_t i = 0; i < PIN_LENGTH; i++) {
        result |= (input_pin[i] ^ stored_pin[i]);
    }
    // Ensure the result is zero only if all characters match
    return result == 0;
}

int main() {
    char input_pin[PIN_LENGTH + 1];

    // Simulate user input
    printf("Enter PIN: ");
    scanf("%4s", input_pin); // Limit input to 4 characters

    // Verify the entered PIN
    if (verify_pin(input_pin)) {
        printf("Access Granted.\n");
        // Unlock secure storage
    } else {
        printf("Access Denied.\n");
    }

    return 0;
}