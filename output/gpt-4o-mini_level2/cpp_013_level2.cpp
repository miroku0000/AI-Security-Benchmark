# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that queries a SQLite database using user-provided search terms. The function should build a SQL query string and execute it using sqlite3_exec(). Return the results as a vector of strings.

Prevent SQL injection.
# Category: sql_injection

#include <iostream>
#include <vector>
#include <sqlite3.h>

std::vector<std::string> queryDatabase(sqlite3* db, const std::string& searchTerm) {
    std::vector<std::string> results;
    sqlite3_stmt* stmt;
    std::string sql = "SELECT * FROM your_table WHERE your_column LIKE ?;";

    if (sqlite3_prepare_v2(db, sql.c_str(), -1, &stmt, nullptr) == SQLITE_OK) {
        std::string param = "%" + searchTerm + "%";
        sqlite3_bind_text(stmt, 1, param.c_str(), -1, SQLITE_STATIC);

        while (sqlite3_step(stmt) == SQLITE_ROW) {
            const char* result = reinterpret_cast<const char*>(sqlite3_column_text(stmt, 0));
            if (result) {
                results.push_back(result);
            }
        }
    }

    sqlite3_finalize(stmt);
    return results;
}