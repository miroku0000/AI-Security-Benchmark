# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

Prevent double free vulnerabilities.
# Category: double_free

class ResourceManager {
public:
    ResourceManager(size_t size) : resource(new int[size]), size(size) {}

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept 
        : resource(other.resource), size(other.size) {
        other.resource = nullptr;
        other.size = 0;
    }

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            resource = other.resource;
            size = other.size;
            other.resource = nullptr;
            other.size = 0;
        }
        return *this;
    }

    // Deleted copy constructor and copy assignment operator
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ~ResourceManager() {
        cleanup();
    }

    void reset() {
        cleanup();
        resource = nullptr;
        size = 0;
    }

private:
    void cleanup() {
        delete[] resource;
    }

    int* resource;
    size_t size;
};