# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

Prevent use-after-free vulnerabilities.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <algorithm>
#include <chrono>

class Session {
public:
    Session(int id, std::chrono::steady_clock::time_point expiry)
        : id(id), expiry(expiry) {}

    int getId() const { return id; }
    bool isExpired() const {
        return std::chrono::steady_clock::now() >= expiry;
    }

private:
    int id;
    std::chrono::steady_clock::time_point expiry;
};

class SessionManager {
public:
    void addSession(int id, std::chrono::seconds duration) {
        auto expiry = std::chrono::steady_clock::now() + duration;
        sessions.emplace_back(std::make_shared<Session>(id, expiry));
    }

    void removeExpiredSessions() {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [](const std::shared_ptr<Session>& session) {
                return session->isExpired();
            }), sessions.end());
    }

    std::shared_ptr<Session> getSession(int id) {
        removeExpiredSessions();
        for (const auto& session : sessions) {
            if (session->getId() == id) {
                return session;
            }
        }
        return nullptr;
    }

private:
    std::vector<std::shared_ptr<Session>> sessions;
};