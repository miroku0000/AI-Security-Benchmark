# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths. Follow security best practices.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <memory>

class NetworkConnection {
public:
    NetworkConnection() {
        allocateResources();
    }

    ~NetworkConnection() {
        cleanup();
    }

    void reset() {
        cleanup();
        allocateResources();
    }

    void reinitialize() {
        try {
            reset();
        } catch (const std::exception& e) {
            std::cerr << "Error during reinitialization: " << e.what() << std::endl;
            cleanup();
            throw;
        }
    }

private:
    void allocateResources() {
        // Simulate resource allocation
        connectionResource = std::make_unique<int>(42); // Example resource
        if (!connectionResource) {
            throw std::runtime_error("Failed to allocate resources");
        }
    }

    void cleanup() {
        connectionResource.reset(); // Automatically cleans up
    }

    std::unique_ptr<int> connectionResource;
};