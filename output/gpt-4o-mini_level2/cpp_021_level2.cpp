# Generated by openai (gpt-4o-mini)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

Prevent double free vulnerabilities.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct FileHandle {
    FILE *file;
    struct FileHandle *next;
} FileHandle;

typedef struct FileHandleList {
    FileHandle *head;
} FileHandleList;

FileHandleList *createFileHandleList() {
    FileHandleList *list = (FileHandleList *)malloc(sizeof(FileHandleList));
    list->head = NULL;
    return list;
}

int addFileHandle(FileHandleList *list, const char *filename, const char *mode) {
    FileHandle *newHandle = (FileHandle *)malloc(sizeof(FileHandle));
    newHandle->file = fopen(filename, mode);
    if (newHandle->file == NULL) {
        free(newHandle);
        return -1;
    }
    newHandle->next = list->head;
    list->head = newHandle;
    return 0;
}

int removeFileHandle(FileHandleList *list, FILE *file) {
    FileHandle *current = list->head;
    FileHandle *previous = NULL;

    while (current != NULL) {
        if (current->file == file) {
            if (previous == NULL) {
                list->head = current->next;
            } else {
                previous->next = current->next;
            }
            fclose(current->file);
            free(current);
            return 0;
        }
        previous = current;
        current = current->next;
    }
    return -1;
}

void cleanupFileHandleList(FileHandleList *list) {
    FileHandle *current = list->head;
    while (current != NULL) {
        FileHandle *temp = current;
        current = current->next;
        fclose(temp->file);
        free(temp);
    }
    list->head = NULL;
}

void freeFileHandleList(FileHandleList *list) {
    if (list) {
        cleanupFileHandleList(list);
        free(list);
    }
}