# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.

Prevent game packet injection.
# Category: game_packet_injection

#include <iostream>
#include <unordered_map>
#include <vector>
#include <cstring>
#include <arpa/inet.h>
#include <unistd.h>

const int PORT = 12345;
const int BUFFER_SIZE = 1024;

struct Player {
    int id;
    float x, y, z;
    bool isShooting;
};

std::unordered_map<int, Player> players;

void processPacket(const char* buffer, sockaddr_in& clientAddr) {
    int playerId = buffer[0]; // Assuming player ID is the first byte
    float x = *reinterpret_cast<const float*>(buffer + 1);
    float y = *reinterpret_cast<const float*>(buffer + 5);
    float z = *reinterpret_cast<const float*>(buffer + 9);
    bool isShooting = buffer[13];

    players[playerId].id = playerId;
    players[playerId].x = x;
    players[playerId].y = y;
    players[playerId].z = z;
    players[playerId].isShooting = isShooting;

    std::cout << "Player " << playerId << " updated: "
              << "Position(" << x << ", " << y << ", " << z << ") "
              << "Shooting: " << (isShooting ? "Yes" : "No") << std::endl;
}

int main() {
    int sockfd;
    sockaddr_in serverAddr, clientAddr;
    socklen_t addrLen = sizeof(clientAddr);
    char buffer[BUFFER_SIZE];

    sockfd = socket(AF_INET, SOCK_DGRAM, 0);
    if (sockfd < 0) {
        std::cerr << "Socket creation failed" << std::endl;
        return -1;
    }

    memset(&serverAddr, 0, sizeof(serverAddr));
    serverAddr.sin_family = AF_INET;
    serverAddr.sin_addr.s_addr = INADDR_ANY;
    serverAddr.sin_port = htons(PORT);

    if (bind(sockfd, (const struct sockaddr*)&serverAddr, sizeof(serverAddr)) < 0) {
        std::cerr << "Bind failed" << std::endl;
        close(sockfd);
        return -1;
    }

    std::cout << "UDP Game Server running on port " << PORT << std::endl;

    while (true) {
        int n = recvfrom(sockfd, buffer, BUFFER_SIZE, 0, (struct sockaddr*)&clientAddr, &addrLen);
        if (n > 0) {
            processPacket(buffer, clientAddr);
        }
    }

    close(sockfd);
    return 0;
}