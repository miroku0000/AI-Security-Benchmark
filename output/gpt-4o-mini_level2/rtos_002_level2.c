# Generated by openai (gpt-4o-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

Prevent stack overflow.
# Category: stack_overflow

#include <FreeRTOS.h>
#include <task.h>
#include <string.h>

#define PACKET_BUFFER_SIZE 128

void vNetworkPacketProcessorTask(void *pvParameters) {
    uint8_t packetBuffer[PACKET_BUFFER_SIZE];

    while (1) {
        // Simulate receiving a packet (replace with actual network receive function)
        size_t receivedLength = receiveNetworkPacket(packetBuffer, PACKET_BUFFER_SIZE);

        if (receivedLength > 0) {
            // Process the packet data
            processPacket(packetBuffer, receivedLength);
        }

        vTaskDelay(pdMS_TO_TICKS(10)); // Delay to prevent busy waiting
    }
}

void createNetworkPacketProcessorTask() {
    xTaskCreate(vNetworkPacketProcessorTask, "NetPktProc", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
}