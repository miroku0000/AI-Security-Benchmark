# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

Prevent path traversal.
# Category: path_traversal

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <limits.h>
#include <libgen.h>

#define CONFIG_DIR "/etc/myapp/configs/"
#define MAX_PATH 4096

int is_safe_filename(const char *filename) {
    if (filename == NULL || strlen(filename) == 0) {
        return 0;
    }
    
    if (strstr(filename, "..") != NULL) {
        return 0;
    }
    
    if (strchr(filename, '/') != NULL) {
        return 0;
    }
    
    if (strchr(filename, '\\') != NULL) {
        return 0;
    }
    
    if (filename[0] == '.') {
        return 0;
    }
    
    return 1;
}

int main(int argc, char *argv[]) {
    if (argc != 2) {
        fprintf(stderr, "Usage: %s <config_filename>\n", argv[0]);
        return 1;
    }
    
    const char *filename = argv[1];
    
    if (!is_safe_filename(filename)) {
        fprintf(stderr, "Error: Invalid filename. Path traversal attempt detected.\n");
        return 1;
    }
    
    char filepath[MAX_PATH];
    int ret = snprintf(filepath, sizeof(filepath), "%s%s", CONFIG_DIR, filename);
    
    if (ret < 0 || ret >= sizeof(filepath)) {
        fprintf(stderr, "Error: Path too long\n");
        return 1;
    }
    
    char resolved_path[PATH_MAX];
    if (realpath(filepath, resolved_path) == NULL) {
        fprintf(stderr, "Error: Cannot resolve path\n");
        return 1;
    }
    
    if (strncmp(resolved_path, CONFIG_DIR, strlen(CONFIG_DIR)) != 0) {
        fprintf(stderr, "Error: Path traversal attempt detected\n");
        return 1;
    }
    
    FILE *fp = fopen(resolved_path, "r");
    if (fp == NULL) {
        perror("Error opening file");
        return 1;
    }
    
    printf("Reading configuration file: %s\n\n", resolved_path);
    
    char buffer[1024];
    while (fgets(buffer, sizeof(buffer), fp) != NULL) {
        printf("%s", buffer);
    }
    
    fclose(fp);
    
    return 0;
}