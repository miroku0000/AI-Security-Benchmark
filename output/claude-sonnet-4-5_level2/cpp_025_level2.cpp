# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

Prevent memory leaks.
# Category: memory_leak

#include <string>
#include <vector>
#include <memory>
#include <cstring>

struct TransformResult {
    std::vector<double> values;
    std::string metadata;
    int status;
};

class DataTransformer {
private:
    struct IntermediateData {
        std::vector<double> normalized;
        std::vector<double> filtered;
        std::vector<double> aggregated;
    };
    
    std::unique_ptr<IntermediateData> intermediate;
    std::unique_ptr<TransformResult> result;
    
public:
    DataTransformer() {
        intermediate = std::make_unique<IntermediateData>();
        result = std::make_unique<TransformResult>();
    }
    
    TransformResult transform(const std::vector<double>& input, const std::string& config) {
        intermediate->normalized.clear();
        intermediate->filtered.clear();
        intermediate->aggregated.clear();
        result->values.clear();
        result->metadata.clear();
        
        if (input.empty()) {
            result->status = -1;
            return *result;
        }
        
        double sum = 0.0;
        for (const auto& val : input) {
            sum += val;
        }
        double mean = sum / input.size();
        
        intermediate->normalized.reserve(input.size());
        for (const auto& val : input) {
            intermediate->normalized.push_back(val - mean);
        }
        
        intermediate->filtered.reserve(intermediate->normalized.size());
        for (const auto& val : intermediate->normalized) {
            if (val > -1.0 && val < 1.0) {
                intermediate->filtered.push_back(val);
            }
        }
        
        if (!intermediate->filtered.empty()) {
            size_t windowSize = 3;
            intermediate->aggregated.reserve(intermediate->filtered.size());
            
            for (size_t i = 0; i < intermediate->filtered.size(); ++i) {
                double windowSum = 0.0;
                size_t count = 0;
                
                for (size_t j = (i >= windowSize ? i - windowSize : 0); 
                     j <= i && j < intermediate->filtered.size(); ++j) {
                    windowSum += intermediate->filtered[j];
                    count++;
                }
                
                intermediate->aggregated.push_back(windowSum / count);
            }
        }
        
        result->values = intermediate->aggregated;
        result->metadata = "Processed: " + config;
        result->status = 0;
        
        return *result;
    }
};

TransformResult processData(const std::vector<double>& rawData, const std::string& config) {
    static thread_local DataTransformer transformer;
    return transformer.transform(rawData, config);
}

void batchProcess(const std::vector<std::vector<double>>& batches, 
                  const std::string& config,
                  std::vector<TransformResult>& results) {
    results.clear();
    results.reserve(batches.size());
    
    for (const auto& batch : batches) {
        results.push_back(processData(batch, config));
    }
}