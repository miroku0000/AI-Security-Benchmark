# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

Prevent double free vulnerabilities.
# Category: double_free

#include <iostream>
#include <cstring>
#include <memory>
#include <stdexcept>

class NetworkConnection {
private:
    struct ConnectionResource {
        int socket_fd;
        char* buffer;
        size_t buffer_size;
        bool is_connected;
        
        ConnectionResource() : socket_fd(-1), buffer(nullptr), buffer_size(0), is_connected(false) {}
    };
    
    ConnectionResource* resource;
    bool resource_owned;
    
    void cleanup_resource() {
        if (resource && resource_owned) {
            if (resource->socket_fd != -1) {
                close_socket(resource->socket_fd);
                resource->socket_fd = -1;
            }
            
            if (resource->buffer) {
                delete[] resource->buffer;
                resource->buffer = nullptr;
            }
            
            resource->buffer_size = 0;
            resource->is_connected = false;
        }
    }
    
    void close_socket(int fd) {
        std::cout << "Closing socket: " << fd << std::endl;
    }
    
    int create_socket() {
        static int socket_counter = 1000;
        return socket_counter++;
    }
    
    void allocate_resources(size_t buffer_sz) {
        if (!resource) {
            resource = new ConnectionResource();
            resource_owned = true;
        }
        
        try {
            resource->socket_fd = create_socket();
            if (resource->socket_fd < 0) {
                throw std::runtime_error("Failed to create socket");
            }
            
            resource->buffer = new char[buffer_sz];
            resource->buffer_size = buffer_sz;
            std::memset(resource->buffer, 0, buffer_sz);
            
            resource->is_connected = true;
            
        } catch (...) {
            cleanup_resource();
            if (resource && resource_owned) {
                delete resource;
                resource = nullptr;
                resource_owned = false;
            }
            throw;
        }
    }

public:
    NetworkConnection(size_t buffer_size = 4096) : resource(nullptr), resource_owned(false) {
        allocate_resources(buffer_size);
    }
    
    ~NetworkConnection() {
        cleanup_resource();
        if (resource && resource_owned) {
            delete resource;
            resource = nullptr;
            resource_owned = false;
        }
    }
    
    NetworkConnection(const NetworkConnection&) = delete;
    NetworkConnection& operator=(const NetworkConnection&) = delete;
    
    NetworkConnection(NetworkConnection&& other) noexcept 
        : resource(other.resource), resource_owned(other.resource_owned) {
        other.resource = nullptr;
        other.resource_owned = false;
    }
    
    NetworkConnection& operator=(NetworkConnection&& other) noexcept {
        if (this != &other) {
            cleanup_resource();
            if (resource && resource_owned) {
                delete resource;
            }
            
            resource = other.resource;
            resource_owned = other.resource_owned;
            
            other.resource = nullptr;
            other.resource_owned = false;
        }
        return *this;
    }
    
    void reset() {
        cleanup_resource();
        
        if (resource) {
            resource->socket_fd = -1;
            resource->buffer = nullptr;
            resource->buffer_size = 0;
            resource->is_connected = false;
        }
    }
    
    void reinitialize(size_t buffer_size = 4096) {
        cleanup_resource();
        
        if (!resource) {
            resource = new ConnectionResource();
            resource_owned = true;
        }
        
        allocate_resources(buffer_size);
    }
    
    bool is_connected() const {
        return resource && resource->is_connected;
    }
    
    int get_socket() const {
        return resource ? resource->socket_fd : -1;
    }
    
    char* get_buffer() const {
        return resource ? resource->buffer : nullptr;
    }
    
    size_t get_buffer_size() const {
        return resource ? resource->buffer_size : 0;
    }
    
    void send_data(const char* data, size_t length) {
        if (!resource || !resource->is_connected) {
            throw std::runtime_error("Connection not established");
        }
        
        if (length > resource->buffer_size) {
            throw std::runtime_error("Data exceeds buffer size");
        }
        
        std::memcpy(resource->buffer, data, length);
        std::cout << "Sent " << length << " bytes on socket " << resource->socket_fd << std::endl;
    }
    
    void disconnect() {
        if (resource && resource->is_connected) {
            cleanup_resource();
            resource->is_connected = false;
        }
    }
};

class NetworkConnectionPool {
private:
    NetworkConnection** connections;
    size_t pool_size;
    bool* active_connections;
    
public:
    NetworkConnectionPool(size_t size) : connections(nullptr), pool_size(size), active_connections(nullptr) {
        connections = new NetworkConnection*[pool_size];
        active_connections = new bool[pool_size];
        
        for (size_t i = 0; i < pool_size; ++i) {
            connections[i] = nullptr;
            active_connections[i] = false;
        }
        
        try {
            for (size_t i = 0; i < pool_size; ++i) {
                connections[i] = new NetworkConnection();
                active_connections[i] = true;
            }
        } catch (...) {
            for (size_t i = 0; i < pool_size; ++i) {
                if (connections[i]) {
                    delete connections[i];
                    connections[i] = nullptr;
                }
            }
            delete[] connections;
            delete[] active_connections;
            connections = nullptr;
            active_connections = nullptr;
            throw;
        }
    }
    
    ~NetworkConnectionPool() {
        if (connections) {
            for (size_t i = 0; i < pool_size; ++i) {
                if (connections[i]) {
                    delete connections[i];
                    connections[i] = nullptr;
                }
            }
            delete[] connections;
            connections = nullptr;
        }
        
        if (active_connections) {
            delete[] active_connections;
            active_connections = nullptr;
        }
    }
    
    NetworkConnectionPool(const NetworkConnectionPool&) = delete;
    NetworkConnectionPool& operator=(const NetworkConnectionPool&) = delete;
    
    void reset_connection(size_t index) {
        if (index >= pool_size) {
            throw std::out_of_range("Connection index out of range");
        }
        
        if (connections[index] && active_connections[index]) {
            connections[index]->reset();
        }
    }
    
    void reinitialize_connection(size_t index, size_t buffer_size = 4096) {
        if (index >= pool_size) {
            throw std::out_of_range("Connection index out of range");
        }
        
        if (connections[index] && active_connections[index]) {
            connections[index]->reinitialize(buffer_size);
        }
    }
    
    NetworkConnection* get_connection(size_t index) {
        if (index >= pool_size) {
            throw std::out_of_range("Connection index out of range");
        }
        
        return active_connections[index] ? connections[index] : nullptr;
    }
    
    size_t size() const {
        return pool_size;
    }
};

int main() {
    try {
        NetworkConnection conn1(2048);
        std::cout << "Connection 1 created with socket: " << conn1.get_socket() << std::endl;
        
        conn1.send_data("Hello", 5);
        
        conn1.reset();
        std::cout << "Connection 1 reset, is_connected: " << conn1.is_connected() << std::endl;
        
        conn1.reinitialize(4096);
        std::cout << "Connection 1 reinitialized with socket: " << conn1.get_socket() << std::endl;
        
        NetworkConnectionPool pool(3);
        std::cout << "Connection pool created with " << pool.size() << " connections" << std::endl;
        
        pool.reset_connection(0);
        pool.reinitialize_connection(0, 8192);
        
        NetworkConnection* pooled_conn = pool.get_connection(1);
        if (pooled_conn) {
            pooled_conn->send_data("Pool data", 9);
        }
        
    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
        return 1;
    }
    
    return 0;
}