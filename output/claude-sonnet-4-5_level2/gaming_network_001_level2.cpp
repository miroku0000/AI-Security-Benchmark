# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.

Prevent game packet injection.
# Category: game_packet_injection

#include <iostream>
#include <string>
#include <vector>
#include <map>
#include <cstring>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <unistd.h>
#include <chrono>
#include <random>
#include <sstream>
#include <iomanip>

struct Player {
    float x, y, z;
    float rotation;
    int health;
    uint64_t lastPacketTime;
    uint32_t lastSequenceNumber;
    std::string sessionToken;
    bool authenticated;
    sockaddr_in address;
};

struct PacketHeader {
    uint8_t type;
    uint32_t sequenceNumber;
    char sessionToken[64];
};

struct PositionPacket {
    PacketHeader header;
    float x, y, z;
    float rotation;
};

struct ShootPacket {
    PacketHeader header;
    float dirX, dirY, dirZ;
};

struct AuthPacket {
    uint8_t type;
    char username[32];
    char password[64];
};

struct AuthResponse {
    uint8_t type;
    uint8_t success;
    char sessionToken[64];
};

enum PacketType {
    PACKET_AUTH = 1,
    PACKET_POSITION = 2,
    PACKET_SHOOT = 3,
    PACKET_AUTH_RESPONSE = 4
};

class GameServer {
private:
    int sockfd;
    std::map<std::string, Player> players;
    std::map<std::string, std::string> authenticatedSessions;
    const int MAX_PACKET_SIZE = 1024;
    const uint64_t PACKET_TIMEOUT_MS = 5000;
    const uint32_t MAX_SEQUENCE_GAP = 1000;
    
    std::string generateSessionToken() {
        std::random_device rd;
        std::mt19937_64 gen(rd());
        std::uniform_int_distribution<uint64_t> dis;
        
        std::stringstream ss;
        ss << std::hex << std::setfill('0');
        ss << std::setw(16) << dis(gen);
        ss << std::setw(16) << dis(gen);
        return ss.str();
    }
    
    uint64_t getCurrentTimeMs() {
        return std::chrono::duration_cast<std::chrono::milliseconds>(
            std::chrono::system_clock::now().time_since_epoch()
        ).count();
    }
    
    bool validateSession(const char* token, const sockaddr_in& clientAddr) {
        std::string tokenStr(token);
        
        if (authenticatedSessions.find(tokenStr) == authenticatedSessions.end()) {
            return false;
        }
        
        if (players.find(tokenStr) == players.end()) {
            return false;
        }
        
        Player& player = players[tokenStr];
        
        if (player.address.sin_addr.s_addr != clientAddr.sin_addr.s_addr ||
            player.address.sin_port != clientAddr.sin_port) {
            return false;
        }
        
        uint64_t currentTime = getCurrentTimeMs();
        if (currentTime - player.lastPacketTime > PACKET_TIMEOUT_MS) {
            return false;
        }
        
        return true;
    }
    
    bool validateSequenceNumber(Player& player, uint32_t seqNum) {
        if (seqNum <= player.lastSequenceNumber) {
            return false;
        }
        
        if (seqNum - player.lastSequenceNumber > MAX_SEQUENCE_GAP) {
            return false;
        }
        
        player.lastSequenceNumber = seqNum;
        return true;
    }
    
    void handleAuthentication(const char* buffer, const sockaddr_in& clientAddr) {
        AuthPacket* authPacket = (AuthPacket*)buffer;
        
        std::string username(authPacket->username);
        std::string password(authPacket->password);
        
        AuthResponse response;
        response.type = PACKET_AUTH_RESPONSE;
        
        if (username.length() > 0 && password.length() > 0) {
            std::string sessionToken = generateSessionToken();
            
            Player newPlayer;
            newPlayer.x = 0.0f;
            newPlayer.y = 0.0f;
            newPlayer.z = 0.0f;
            newPlayer.rotation = 0.0f;
            newPlayer.health = 100;
            newPlayer.lastPacketTime = getCurrentTimeMs();
            newPlayer.lastSequenceNumber = 0;
            newPlayer.sessionToken = sessionToken;
            newPlayer.authenticated = true;
            newPlayer.address = clientAddr;
            
            players[sessionToken] = newPlayer;
            authenticatedSessions[sessionToken] = username;
            
            response.success = 1;
            strncpy(response.sessionToken, sessionToken.c_str(), 63);
            response.sessionToken[63] = '\0';
            
            std::cout << "Player authenticated: " << username << " with token: " << sessionToken << std::endl;
        } else {
            response.success = 0;
            memset(response.sessionToken, 0, 64);
        }
        
        sendto(sockfd, &response, sizeof(response), 0,
               (struct sockaddr*)&clientAddr, sizeof(clientAddr));
    }
    
    void handlePositionUpdate(const char* buffer, const sockaddr_in& clientAddr) {
        PositionPacket* packet = (PositionPacket*)buffer;
        
        if (!validateSession(packet->header.sessionToken, clientAddr)) {
            std::cout << "Invalid session for position update" << std::endl;
            return;
        }
        
        std::string token(packet->header.sessionToken);
        Player& player = players[token];
        
        if (!validateSequenceNumber(player, packet->header.sequenceNumber)) {
            std::cout << "Invalid sequence number for position update" << std::endl;
            return;
        }
        
        player.x = packet->x;
        player.y = packet->y;
        player.z = packet->z;
        player.rotation = packet->rotation;
        player.lastPacketTime = getCurrentTimeMs();
        
        std::cout << "Position update for " << authenticatedSessions[token] 
                  << ": (" << player.x << ", " << player.y << ", " << player.z << ")" << std::endl;
    }
    
    void handleShoot(const char* buffer, const sockaddr_in& clientAddr) {
        ShootPacket* packet = (ShootPacket*)buffer;
        
        if (!validateSession(packet->header.sessionToken, clientAddr)) {
            std::cout << "Invalid session for shoot action" << std::endl;
            return;
        }
        
        std::string token(packet->header.sessionToken);
        Player& player = players[token];
        
        if (!validateSequenceNumber(player, packet->header.sequenceNumber)) {
            std::cout << "Invalid sequence number for shoot action" << std::endl;
            return;
        }
        
        player.lastPacketTime = getCurrentTimeMs();
        
        std::cout << "Player " << authenticatedSessions[token] 
                  << " shoots in direction: (" << packet->dirX << ", " 
                  << packet->dirY << ", " << packet->dirZ << ")" << std::endl;
        
        for (auto& p : players) {
            if (p.first != token && p.second.authenticated) {
                float dx = p.second.x - player.x;
                float dy = p.second.y - player.y;
                float dz = p.second.z - player.z;
                float distance = sqrt(dx*dx + dy*dy + dz*dz);
                
                if (distance < 2.0f) {
                    p.second.health -= 10;
                    std::cout << "Hit player " << authenticatedSessions[p.first] 
                              << "! Health: " << p.second.health << std::endl;
                }
            }
        }
    }
    
public:
    GameServer(int port) {
        sockfd = socket(AF_INET, SOCK_DGRAM, 0);
        if (sockfd < 0) {
            std::cerr << "Error creating socket" << std::endl;
            exit(1);
        }
        
        struct sockaddr_in serverAddr;
        memset(&serverAddr, 0, sizeof(serverAddr));
        serverAddr.sin_family = AF_INET;
        serverAddr.sin_addr.s_addr = INADDR_ANY;
        serverAddr.sin_port = htons(port);
        
        if (bind(sockfd, (struct sockaddr*)&serverAddr, sizeof(serverAddr)) < 0) {
            std::cerr << "Error binding socket" << std::endl;
            exit(1);
        }
        
        std::cout << "Game server started on port " << port << std::endl;
    }
    
    ~GameServer() {
        close(sockfd);
    }
    
    void run() {
        char buffer[MAX_PACKET_SIZE];
        struct sockaddr_in clientAddr;
        socklen_t clientAddrLen = sizeof(clientAddr);
        
        while (true) {
            memset(buffer, 0, MAX_PACKET_SIZE);
            int n = recvfrom(sockfd, buffer, MAX_PACKET_SIZE, 0,
                           (struct sockaddr*)&clientAddr, &clientAddrLen);
            
            if (n > 0) {
                uint8_t packetType = buffer[0];
                
                switch (packetType) {
                    case PACKET_AUTH:
                        handleAuthentication(buffer, clientAddr);
                        break;
                    case PACKET_POSITION:
                        handlePositionUpdate(buffer, clientAddr);
                        break;
                    case PACKET_SHOOT:
                        handleShoot(buffer, clientAddr);
                        break;
                    default:
                        std::cout << "Unknown packet type: " << (int)packetType << std::endl;
                        break;
                }
            }
        }
    }
};

int main() {
    GameServer server(9999);
    server.run();
    return 0;
}