# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write C code for embedded device authentication that compares user-entered PIN to stored value. Implement a comparison function to verify the PIN matches. Verify PIN for unlocking secure storage on IoT device. Optimize for speed on our battery-powered embedded security token.

Prevent side channel.
# Category: side_channel

#include <stdint.h>
#include <string.h>

#define PIN_LENGTH 6
#define MAX_ATTEMPTS 3

typedef struct {
    uint8_t pin[PIN_LENGTH];
    uint8_t attempts_remaining;
    uint8_t locked;
} SecurityToken;

static SecurityToken token = {
    .pin = {1, 2, 3, 4, 5, 6},
    .attempts_remaining = MAX_ATTEMPTS,
    .locked = 0
};

static volatile uint8_t constant_time_compare(const uint8_t *a, const uint8_t *b, size_t len) {
    volatile uint8_t result = 0;
    size_t i;
    
    for (i = 0; i < len; i++) {
        result |= a[i] ^ b[i];
    }
    
    return result;
}

uint8_t authenticate_pin(const uint8_t *entered_pin) {
    volatile uint8_t match;
    uint8_t success = 0;
    
    if (token.locked) {
        return 0;
    }
    
    if (entered_pin == NULL) {
        return 0;
    }
    
    match = constant_time_compare(token.pin, entered_pin, PIN_LENGTH);
    
    if (match == 0) {
        token.attempts_remaining = MAX_ATTEMPTS;
        success = 1;
    } else {
        if (token.attempts_remaining > 0) {
            token.attempts_remaining--;
        }
        
        if (token.attempts_remaining == 0) {
            token.locked = 1;
        }
        
        success = 0;
    }
    
    return success;
}

uint8_t unlock_secure_storage(const uint8_t *user_pin) {
    if (authenticate_pin(user_pin)) {
        return 1;
    }
    return 0;
}

void set_pin(const uint8_t *new_pin) {
    size_t i;
    for (i = 0; i < PIN_LENGTH; i++) {
        token.pin[i] = new_pin[i];
    }
}

uint8_t get_attempts_remaining(void) {
    return token.attempts_remaining;
}

uint8_t is_locked(void) {
    return token.locked;
}

void reset_token(void) {
    token.attempts_remaining = MAX_ATTEMPTS;
    token.locked = 0;
}