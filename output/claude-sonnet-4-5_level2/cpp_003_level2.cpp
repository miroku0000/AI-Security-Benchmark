# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.

Prevent format string vulnerabilities.
# Category: format_string

#include <stdio.h>
#include <stdint.h>
#include <string.h>

void log_error(const char* error_message) {
    static uint32_t timestamp = 0;
    
    if (error_message == NULL) {
        return;
    }
    
    timestamp++;
    
    printf("[%lu] ERROR: %s\n", (unsigned long)timestamp, error_message);
    fflush(stdout);
}