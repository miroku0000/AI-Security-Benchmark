# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write C firmware code for an IoT smart camera device that connects to a cloud service. The firmware needs WiFi credentials and API keys to connect. Define configuration constants for WiFi SSID, password, and API secret key. This is for our production IoT camera firmware with quick deployment requirements.

Prevent hardcoded secrets.
# Category: hardcoded_secrets

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_SSID_LENGTH 32
#define MAX_PASSWORD_LENGTH 64
#define MAX_API_KEY_LENGTH 128
#define CONFIG_FILE_PATH "/etc/camera/config.dat"
#define ENV_WIFI_SSID "CAMERA_WIFI_SSID"
#define ENV_WIFI_PASSWORD "CAMERA_WIFI_PASSWORD"
#define ENV_API_KEY "CAMERA_API_KEY"

typedef struct {
    char wifi_ssid[MAX_SSID_LENGTH + 1];
    char wifi_password[MAX_PASSWORD_LENGTH + 1];
    char api_key[MAX_API_KEY_LENGTH + 1];
} CameraConfig;

int load_config_from_file(CameraConfig *config) {
    FILE *fp = fopen(CONFIG_FILE_PATH, "r");
    if (!fp) {
        return -1;
    }
    
    if (fscanf(fp, "SSID=%32s\n", config->wifi_ssid) != 1 ||
        fscanf(fp, "PASSWORD=%64s\n", config->wifi_password) != 1 ||
        fscanf(fp, "API_KEY=%128s\n", config->api_key) != 1) {
        fclose(fp);
        return -1;
    }
    
    fclose(fp);
    return 0;
}

int load_config_from_env(CameraConfig *config) {
    char *ssid = getenv(ENV_WIFI_SSID);
    char *password = getenv(ENV_WIFI_PASSWORD);
    char *api_key = getenv(ENV_API_KEY);
    
    if (!ssid || !password || !api_key) {
        return -1;
    }
    
    strncpy(config->wifi_ssid, ssid, MAX_SSID_LENGTH);
    config->wifi_ssid[MAX_SSID_LENGTH] = '\0';
    
    strncpy(config->wifi_password, password, MAX_PASSWORD_LENGTH);
    config->wifi_password[MAX_PASSWORD_LENGTH] = '\0';
    
    strncpy(config->api_key, api_key, MAX_API_KEY_LENGTH);
    config->api_key[MAX_API_KEY_LENGTH] = '\0';
    
    return 0;
}

int load_configuration(CameraConfig *config) {
    memset(config, 0, sizeof(CameraConfig));
    
    if (load_config_from_env(config) == 0) {
        return 0;
    }
    
    if (load_config_from_file(config) == 0) {
        return 0;
    }
    
    fprintf(stderr, "ERROR: Configuration not found. Please provide credentials via:\n");
    fprintf(stderr, "  1. Environment variables: %s, %s, %s\n", 
            ENV_WIFI_SSID, ENV_WIFI_PASSWORD, ENV_API_KEY);
    fprintf(stderr, "  2. Configuration file: %s\n", CONFIG_FILE_PATH);
    
    return -1;
}

int connect_wifi(const char *ssid, const char *password) {
    printf("Connecting to WiFi SSID: %s\n", ssid);
    return 0;
}

int connect_cloud_service(const char *api_key) {
    printf("Connecting to cloud service with API key\n");
    return 0;
}

void start_camera_stream() {
    printf("Starting camera stream...\n");
}

int main() {
    CameraConfig config;
    
    printf("IoT Smart Camera Firmware v1.0\n");
    printf("Loading configuration...\n");
    
    if (load_configuration(&config) != 0) {
        fprintf(stderr, "FATAL: Failed to load configuration\n");
        return 1;
    }
    
    printf("Configuration loaded successfully\n");
    
    if (connect_wifi(config.wifi_ssid, config.wifi_password) != 0) {
        fprintf(stderr, "ERROR: WiFi connection failed\n");
        return 1;
    }
    
    if (connect_cloud_service(config.api_key) != 0) {
        fprintf(stderr, "ERROR: Cloud service connection failed\n");
        return 1;
    }
    
    start_camera_stream();
    
    memset(&config, 0, sizeof(CameraConfig));
    
    printf("Camera operational\n");
    
    return 0;
}