# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

Prevent double free vulnerabilities.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

typedef struct FileHandleNode {
    FILE *file;
    char *filename;
    int fd;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct {
    FileHandleNode *head;
    bool is_cleaned;
} FileHandleList;

FileHandleList* create_file_handle_list() {
    FileHandleList *list = (FileHandleList*)malloc(sizeof(FileHandleList));
    if (list == NULL) {
        return NULL;
    }
    list->head = NULL;
    list->is_cleaned = false;
    return list;
}

int add_file_handle(FileHandleList *list, FILE *file, const char *filename, int fd) {
    if (list == NULL || list->is_cleaned) {
        return -1;
    }
    
    FileHandleNode *node = (FileHandleNode*)malloc(sizeof(FileHandleNode));
    if (node == NULL) {
        return -1;
    }
    
    node->file = file;
    node->fd = fd;
    
    if (filename != NULL) {
        node->filename = (char*)malloc(strlen(filename) + 1);
        if (node->filename == NULL) {
            free(node);
            return -1;
        }
        strcpy(node->filename, filename);
    } else {
        node->filename = NULL;
    }
    
    node->next = list->head;
    list->head = node;
    
    return 0;
}

int remove_file_handle(FileHandleList *list, FILE *file) {
    if (list == NULL || list->is_cleaned || file == NULL) {
        return -1;
    }
    
    FileHandleNode *current = list->head;
    FileHandleNode *prev = NULL;
    
    while (current != NULL) {
        if (current->file == file) {
            if (prev == NULL) {
                list->head = current->next;
            } else {
                prev->next = current->next;
            }
            
            if (current->file != NULL) {
                fclose(current->file);
                current->file = NULL;
            }
            
            if (current->filename != NULL) {
                free(current->filename);
                current->filename = NULL;
            }
            
            free(current);
            return 0;
        }
        prev = current;
        current = current->next;
    }
    
    return -1;
}

int remove_file_handle_by_fd(FileHandleList *list, int fd) {
    if (list == NULL || list->is_cleaned) {
        return -1;
    }
    
    FileHandleNode *current = list->head;
    FileHandleNode *prev = NULL;
    
    while (current != NULL) {
        if (current->fd == fd) {
            if (prev == NULL) {
                list->head = current->next;
            } else {
                prev->next = current->next;
            }
            
            if (current->file != NULL) {
                fclose(current->file);
                current->file = NULL;
            }
            
            if (current->filename != NULL) {
                free(current->filename);
                current->filename = NULL;
            }
            
            free(current);
            return 0;
        }
        prev = current;
        current = current->next;
    }
    
    return -1;
}

void cleanup_file_handle_list(FileHandleList *list) {
    if (list == NULL || list->is_cleaned) {
        return;
    }
    
    FileHandleNode *current = list->head;
    FileHandleNode *next;
    
    while (current != NULL) {
        next = current->next;
        
        if (current->file != NULL) {
            fclose(current->file);
            current->file = NULL;
        }
        
        if (current->filename != NULL) {
            free(current->filename);
            current->filename = NULL;
        }
        
        free(current);
        current = next;
    }
    
    list->head = NULL;
    list->is_cleaned = true;
}

void destroy_file_handle_list(FileHandleList *list) {
    if (list == NULL) {
        return;
    }
    
    cleanup_file_handle_list(list);
    free(list);
}

int get_file_handle_count(FileHandleList *list) {
    if (list == NULL || list->is_cleaned) {
        return 0;
    }
    
    int count = 0;
    FileHandleNode *current = list->head;
    
    while (current != NULL) {
        count++;
        current = current->next;
    }
    
    return count;
}

FILE* find_file_handle_by_fd(FileHandleList *list, int fd) {
    if (list == NULL || list->is_cleaned) {
        return NULL;
    }
    
    FileHandleNode *current = list->head;
    
    while (current != NULL) {
        if (current->fd == fd) {
            return current->file;
        }
        current = current->next;
    }
    
    return NULL;
}

FILE* find_file_handle_by_name(FileHandleList *list, const char *filename) {
    if (list == NULL || list->is_cleaned || filename == NULL) {
        return NULL;
    }
    
    FileHandleNode *current = list->head;
    
    while (current != NULL) {
        if (current->filename != NULL && strcmp(current->filename, filename) == 0) {
            return current->file;
        }
        current = current->next;
    }
    
    return NULL;
}

int main() {
    FileHandleList *list = create_file_handle_list();
    if (list == NULL) {
        fprintf(stderr, "Failed to create file handle list\n");
        return 1;
    }
    
    FILE *f1 = fopen("test1.txt", "w");
    if (f1 != NULL) {
        add_file_handle(list, f1, "test1.txt", fileno(f1));
        fprintf(f1, "Test file 1\n");
    }
    
    FILE *f2 = fopen("test2.txt", "w");
    if (f2 != NULL) {
        add_file_handle(list, f2, "test2.txt", fileno(f2));
        fprintf(f2, "Test file 2\n");
    }
    
    FILE *f3 = fopen("test3.txt", "w");
    if (f3 != NULL) {
        add_file_handle(list, f3, "test3.txt", fileno(f3));
        fprintf(f3, "Test file 3\n");
    }
    
    printf("File handle count: %d\n", get_file_handle_count(list));
    
    remove_file_handle(list, f2);
    printf("File handle count after removal: %d\n", get_file_handle_count(list));
    
    cleanup_file_handle_list(list);
    printf("File handle count after cleanup: %d\n", get_file_handle_count(list));
    
    cleanup_file_handle_list(list);
    printf("File handle count after second cleanup: %d\n", get_file_handle_count(list));
    
    destroy_file_handle_list(list);
    
    return 0;
}