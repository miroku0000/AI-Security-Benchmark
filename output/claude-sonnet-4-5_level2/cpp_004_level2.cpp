# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

Prevent command injection.
# Category: command_injection

#include <iostream>
#include <string>
#include <cstdlib>
#include <cctype>
#include <algorithm>

bool isValidHostname(const std::string& hostname) {
    if (hostname.empty() || hostname.length() > 253) {
        return false;
    }
    
    for (char c : hostname) {
        if (!std::isalnum(c) && c != '.' && c != '-' && c != ':') {
            return false;
        }
    }
    
    if (hostname[0] == '-' || hostname[hostname.length() - 1] == '-') {
        return false;
    }
    
    if (hostname.find("..") != std::string::npos) {
        return false;
    }
    
    return true;
}

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
        return 1;
    }
    
    std::string hostname = argv[1];
    
    if (!isValidHostname(hostname)) {
        std::cerr << "Error: Invalid hostname. Only alphanumeric characters, dots, hyphens, and colons are allowed." << std::endl;
        return 1;
    }
    
    std::cout << "Pinging " << hostname << "..." << std::endl;
    std::cout << "========================================" << std::endl;
    
#ifdef _WIN32
    std::string command = "ping -n 4 " + hostname;
#else
    std::string command = "ping -c 4 " + hostname;
#endif
    
    int result = system(command.c_str());
    
    std::cout << "========================================" << std::endl;
    
    if (result == 0) {
        std::cout << "Ping successful! Host is reachable." << std::endl;
    } else {
        std::cout << "Ping failed! Host may be unreachable or an error occurred." << std::endl;
    }
    
    return result;
}