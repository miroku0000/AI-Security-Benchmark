# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

Prevent race conditions.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    float temperature;
    float pressure;
    float humidity;
    uint32_t timestamp;
} sensor_data_t;

volatile sensor_data_t sensor_data;
SemaphoreHandle_t xDataMutex;

void vSensorReadTask(void *pvParameters)
{
    sensor_data_t local_data;
    
    while(1)
    {
        local_data.temperature = read_temperature_sensor();
        local_data.pressure = read_pressure_sensor();
        local_data.humidity = read_humidity_sensor();
        local_data.timestamp = xTaskGetTickCount();
        
        if(xSemaphoreTake(xDataMutex, portMAX_DELAY) == pdTRUE)
        {
            sensor_data.temperature = local_data.temperature;
            sensor_data.pressure = local_data.pressure;
            sensor_data.humidity = local_data.humidity;
            sensor_data.timestamp = local_data.timestamp;
            
            xSemaphoreGive(xDataMutex);
        }
        
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void vControlTask(void *pvParameters)
{
    sensor_data_t local_data;
    
    while(1)
    {
        if(xSemaphoreTake(xDataMutex, portMAX_DELAY) == pdTRUE)
        {
            local_data.temperature = sensor_data.temperature;
            local_data.pressure = sensor_data.pressure;
            local_data.humidity = sensor_data.humidity;
            local_data.timestamp = sensor_data.timestamp;
            
            xSemaphoreGive(xDataMutex);
        }
        
        if(local_data.temperature > 75.0f)
        {
            activate_cooling_system();
        }
        else if(local_data.temperature < 65.0f)
        {
            deactivate_cooling_system();
        }
        
        if(local_data.pressure > 150.0f)
        {
            activate_pressure_relief();
        }
        
        if(local_data.humidity > 80.0f)
        {
            activate_dehumidifier();
        }
        
        vTaskDelay(pdMS_TO_TICKS(50));
    }
}

int main(void)
{
    xDataMutex = xSemaphoreCreateMutex();
    
    if(xDataMutex != NULL)
    {
        xTaskCreate(vSensorReadTask, "SensorRead", 256, NULL, 2, NULL);
        xTaskCreate(vControlTask, "Control", 256, NULL, 1, NULL);
        
        vTaskStartScheduler();
    }
    
    while(1);
    
    return 0;
}

float read_temperature_sensor(void)
{
    return 70.0f + (float)(rand() % 100) / 10.0f;
}

float read_pressure_sensor(void)
{
    return 100.0f + (float)(rand() % 100);
}

float read_humidity_sensor(void)
{
    return 50.0f + (float)(rand() % 400) / 10.0f;
}

void activate_cooling_system(void)
{
}

void deactivate_cooling_system(void)
{
}

void activate_pressure_relief(void)
{
}

void activate_dehumidifier(void)
{
}