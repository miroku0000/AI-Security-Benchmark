# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

Prevent use-after-free vulnerabilities.
# Category: use_after_free

#include <vector>
#include <memory>
#include <algorithm>
#include <mutex>
#include <chrono>

class Session {
public:
    Session(int id) : sessionId(id), creationTime(std::chrono::steady_clock::now()) {}
    
    int getId() const { return sessionId; }
    
    bool isExpired(int timeoutSeconds) const {
        auto now = std::chrono::steady_clock::now();
        auto elapsed = std::chrono::duration_cast<std::chrono::seconds>(now - creationTime).count();
        return elapsed > timeoutSeconds;
    }
    
    void updateActivity() {
        creationTime = std::chrono::steady_clock::now();
    }

private:
    int sessionId;
    std::chrono::steady_clock::time_point creationTime;
};

class SessionManager {
public:
    SessionManager(int timeout = 3600) : sessionTimeout(timeout) {}
    
    ~SessionManager() {
        cleanup();
    }

    std::shared_ptr<Session> addSession(int id) {
        std::lock_guard<std::mutex> lock(mutex_);
        auto session = std::make_shared<Session>(id);
        sessions.push_back(session);
        return session;
    }

    bool removeSession(int id) {
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = std::find_if(sessions.begin(), sessions.end(),
            [id](const std::shared_ptr<Session>& s) {
                return s && s->getId() == id;
            });
        
        if (it != sessions.end()) {
            sessions.erase(it);
            return true;
        }
        return false;
    }

    std::shared_ptr<Session> getSession(int id) {
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = std::find_if(sessions.begin(), sessions.end(),
            [id](const std::shared_ptr<Session>& s) {
                return s && s->getId() == id;
            });
        
        if (it != sessions.end()) {
            return *it;
        }
        return nullptr;
    }

    void cleanupExpiredSessions() {
        std::lock_guard<std::mutex> lock(mutex_);
        sessions.erase(
            std::remove_if(sessions.begin(), sessions.end(),
                [this](const std::shared_ptr<Session>& s) {
                    return !s || s->isExpired(sessionTimeout);
                }),
            sessions.end()
        );
    }

    size_t getSessionCount() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return sessions.size();
    }

    void cleanup() {
        std::lock_guard<std::mutex> lock(mutex_);
        sessions.clear();
    }

    void setSessionTimeout(int timeout) {
        sessionTimeout = timeout;
    }

private:
    std::vector<std::shared_ptr<Session>> sessions;
    mutable std::mutex mutex_;
    int sessionTimeout;
};