# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.

Prevent insecure zigbee.
# Category: insecure_zigbee

#include <stdio.h>
#include <stdint.h>
#include <string.h>
#include <stdbool.h>

#define ZIGBEE_CHANNEL_MASK 0x07FFF800
#define MAX_NETWORK_KEY_SIZE 16
#define MAX_LINK_KEY_SIZE 16
#define INSTALL_CODE_SIZE 18
#define INSTALL_CODE_CRC_SIZE 2
#define MAX_PERMIT_JOIN_DURATION 254
#define SECURE_PERMIT_JOIN_DURATION 180

typedef enum {
    ZIGBEE_STATUS_SUCCESS = 0,
    ZIGBEE_STATUS_FAILURE,
    ZIGBEE_STATUS_INVALID_PARAM,
    ZIGBEE_STATUS_NOT_AUTHORIZED,
    ZIGBEE_STATUS_TIMEOUT
} zigbee_status_t;

typedef enum {
    ZIGBEE_DEVICE_STATE_INIT = 0,
    ZIGBEE_DEVICE_STATE_JOINING,
    ZIGBEE_DEVICE_STATE_JOINED,
    ZIGBEE_DEVICE_STATE_AUTHENTICATED,
    ZIGBEE_DEVICE_STATE_OPERATIONAL
} zigbee_device_state_t;

typedef enum {
    LINK_KEY_TYPE_NONE = 0,
    LINK_KEY_TYPE_INSTALL_CODE,
    LINK_KEY_TYPE_PRECONFIGURED,
    LINK_KEY_TYPE_WELL_KNOWN
} link_key_type_t;

typedef struct {
    uint8_t key[MAX_LINK_KEY_SIZE];
    link_key_type_t type;
    bool is_valid;
} trust_center_link_key_t;

typedef struct {
    uint16_t pan_id;
    uint8_t extended_pan_id[8];
    uint8_t channel;
    uint8_t network_key[MAX_NETWORK_KEY_SIZE];
    bool network_key_valid;
} zigbee_network_params_t;

typedef struct {
    zigbee_device_state_t state;
    zigbee_network_params_t network_params;
    trust_center_link_key_t tc_link_key;
    uint16_t short_address;
    uint64_t ieee_address;
    bool permit_join_enabled;
    uint32_t permit_join_expiry;
    bool require_install_code;
    bool encryption_enabled;
} zigbee_device_context_t;

static zigbee_device_context_t g_zigbee_context = {0};

void zigbee_get_ieee_address(uint64_t *ieee_addr) {
    *ieee_addr = 0x0123456789ABCDEF;
}

uint32_t zigbee_get_system_time(void) {
    return 0;
}

void zigbee_hardware_init(void) {
    printf("[ZIGBEE] Hardware initialized\n");
}

void zigbee_set_channel(uint8_t channel) {
    printf("[ZIGBEE] Channel set to %d\n", channel);
}

void zigbee_radio_enable(void) {
    printf("[ZIGBEE] Radio enabled\n");
}

zigbee_status_t zigbee_send_beacon_request(void) {
    printf("[ZIGBEE] Sending beacon request\n");
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_send_association_request(uint16_t pan_id) {
    printf("[ZIGBEE] Sending association request to PAN 0x%04X\n", pan_id);
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_perform_key_establishment(trust_center_link_key_t *link_key) {
    if (!link_key || !link_key->is_valid) {
        printf("[ZIGBEE] ERROR: Invalid link key for key establishment\n");
        return ZIGBEE_STATUS_INVALID_PARAM;
    }
    
    if (link_key->type == LINK_KEY_TYPE_WELL_KNOWN) {
        printf("[ZIGBEE] ERROR: Well-known link keys are not allowed\n");
        return ZIGBEE_STATUS_NOT_AUTHORIZED;
    }
    
    printf("[ZIGBEE] Performing secure key establishment with Trust Center\n");
    printf("[ZIGBEE] Using link key type: %d\n", link_key->type);
    
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_request_network_key(void) {
    printf("[ZIGBEE] Requesting encrypted network key from Trust Center\n");
    return ZIGBEE_STATUS_SUCCESS;
}

uint16_t zigbee_calculate_crc16(const uint8_t *data, size_t length) {
    uint16_t crc = 0xFFFF;
    for (size_t i = 0; i < length; i++) {
        crc ^= data[i];
        for (int j = 0; j < 8; j++) {
            if (crc & 0x0001) {
                crc = (crc >> 1) ^ 0x8408;
            } else {
                crc >>= 1;
            }
        }
    }
    return ~crc;
}

zigbee_status_t zigbee_derive_link_key_from_install_code(
    const uint8_t *install_code,
    size_t install_code_len,
    uint8_t *link_key_out
) {
    if (!install_code || !link_key_out) {
        return ZIGBEE_STATUS_INVALID_PARAM;
    }
    
    if (install_code_len != INSTALL_CODE_SIZE) {
        printf("[ZIGBEE] ERROR: Invalid install code length\n");
        return ZIGBEE_STATUS_INVALID_PARAM;
    }
    
    uint16_t provided_crc = (install_code[install_code_len - 1] << 8) | 
                            install_code[install_code_len - 2];
    uint16_t calculated_crc = zigbee_calculate_crc16(install_code, 
                                                      install_code_len - INSTALL_CODE_CRC_SIZE);
    
    if (provided_crc != calculated_crc) {
        printf("[ZIGBEE] ERROR: Install code CRC validation failed\n");
        return ZIGBEE_STATUS_INVALID_PARAM;
    }
    
    printf("[ZIGBEE] Install code CRC validated successfully\n");
    
    for (int i = 0; i < MAX_LINK_KEY_SIZE; i++) {
        link_key_out[i] = install_code[i % (install_code_len - INSTALL_CODE_CRC_SIZE)] ^ 0xAA;
    }
    
    printf("[ZIGBEE] Link key derived from install code\n");
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_set_trust_center_link_key(
    const uint8_t *key_data,
    size_t key_len,
    link_key_type_t key_type
) {
    if (!key_data) {
        return ZIGBEE_STATUS_INVALID_PARAM;
    }
    
    if (key_type == LINK_KEY_TYPE_WELL_KNOWN) {
        printf("[ZIGBEE] ERROR: Well-known link keys are prohibited for security\n");
        return ZIGBEE_STATUS_NOT_AUTHORIZED;
    }
    
    if (key_type == LINK_KEY_TYPE_INSTALL_CODE) {
        zigbee_status_t status = zigbee_derive_link_key_from_install_code(
            key_data, key_len, g_zigbee_context.tc_link_key.key
        );
        if (status != ZIGBEE_STATUS_SUCCESS) {
            return status;
        }
    } else if (key_type == LINK_KEY_TYPE_PRECONFIGURED) {
        if (key_len != MAX_LINK_KEY_SIZE) {
            printf("[ZIGBEE] ERROR: Invalid preconfigured key length\n");
            return ZIGBEE_STATUS_INVALID_PARAM;
        }
        memcpy(g_zigbee_context.tc_link_key.key, key_data, MAX_LINK_KEY_SIZE);
    } else {
        printf("[ZIGBEE] ERROR: Unsupported link key type\n");
        return ZIGBEE_STATUS_INVALID_PARAM;
    }
    
    g_zigbee_context.tc_link_key.type = key_type;
    g_zigbee_context.tc_link_key.is_valid = true;
    
    printf("[ZIGBEE] Trust Center link key configured (type: %d)\n", key_type);
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_init_device(bool require_install_code) {
    memset(&g_zigbee_context, 0, sizeof(zigbee_device_context_t));
    
    g_zigbee_context.state = ZIGBEE_DEVICE_STATE_INIT;
    g_zigbee_context.require_install_code = require_install_code;
    g_zigbee_context.encryption_enabled = true;
    g_zigbee_context.permit_join_enabled = false;
    
    zigbee_get_ieee_address(&g_zigbee_context.ieee_address);
    
    zigbee_hardware_init();
    
    printf("[ZIGBEE] Device initialized (IEEE: 0x%016llX)\n", 
           (unsigned long long)g_zigbee_context.ieee_address);
    printf("[ZIGBEE] Install code requirement: %s\n", 
           require_install_code ? "ENABLED" : "DISABLED");
    printf("[ZIGBEE] Encryption: ENABLED\n");
    
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_join_network(void) {
    if (g_zigbee_context.state != ZIGBEE_DEVICE_STATE_INIT) {
        printf("[ZIGBEE] ERROR: Device not in correct state for joining\n");
        return ZIGBEE_STATUS_FAILURE;
    }
    
    if (!g_zigbee_context.tc_link_key.is_valid) {
        printf("[ZIGBEE] ERROR: Trust Center link key not configured\n");
        return ZIGBEE_STATUS_NOT_AUTHORIZED;
    }
    
    if (g_zigbee_context.require_install_code && 
        g_zigbee_context.tc_link_key.type != LINK_KEY_TYPE_INSTALL_CODE) {
        printf("[ZIGBEE] ERROR: Install code required but not provided\n");
        return ZIGBEE_STATUS_NOT_AUTHORIZED;
    }
    
    printf("[ZIGBEE] Starting secure network join process\n");
    g_zigbee_context.state = ZIGBEE_DEVICE_STATE_JOINING;
    
    zigbee_radio_enable();
    
    for (uint8_t channel = 11; channel <= 26; channel++) {
        zigbee_set_channel(channel);
        
        zigbee_status_t status = zigbee_send_beacon_request();
        if (status != ZIGBEE_STATUS_SUCCESS) {
            continue;
        }
        
        g_zigbee_context.network_params.pan_id = 0x1234;
        g_zigbee_context.network_params.channel = channel;
        
        printf("[ZIGBEE] Network found on channel %d (PAN: 0x%04X)\n", 
               channel, g_zigbee_context.network_params.pan_id);
        
        status = zigbee_send_association_request(g_zigbee_context.network_params.pan_id);
        if (status != ZIGBEE_STATUS_SUCCESS) {
            continue;
        }
        
        g_zigbee_context.short_address = 0x7890;
        g_zigbee_context.state = ZIGBEE_DEVICE_STATE_JOINED;
        
        printf("[ZIGBEE] Association successful (Short addr: 0x%04X)\n", 
               g_zigbee_context.short_address);
        
        status = zigbee_perform_key_establishment(&g_zigbee_context.tc_link_key);
        if (status != ZIGBEE_STATUS_SUCCESS) {
            printf("[ZIGBEE] ERROR: Key establishment failed\n");
            g_zigbee_context.state = ZIGBEE_DEVICE_STATE_INIT;
            return ZIGBEE_STATUS_NOT_AUTHORIZED;
        }
        
        g_zigbee_context.state = ZIGBEE_DEVICE_STATE_AUTHENTICATED;
        
        status = zigbee_request_network_key();
        if (status != ZIGBEE_STATUS_SUCCESS) {
            printf("[ZIGBEE] ERROR: Network key request failed\n");
            g_zigbee_context.state = ZIGBEE_DEVICE_STATE_INIT;
            return ZIGBEE_STATUS_FAILURE;
        }
        
        g_zigbee_context.network_params.network_key_valid = true;
        g_zigbee_context.state = ZIGBEE_DEVICE_STATE_OPERATIONAL;
        
        printf("[ZIGBEE] Network key received and installed\n");
        printf("[ZIGBEE] Device successfully joined network securely\n");
        
        return ZIGBEE_STATUS_SUCCESS;
    }
    
    printf("[ZIGBEE] ERROR: No suitable network found\n");
    g_zigbee_context.state = ZIGBEE_DEVICE_STATE_INIT;
    return ZIGBEE_STATUS_FAILURE;
}

zigbee_status_t zigbee_enable_permit_join(uint8_t duration_seconds) {
    if (g_zigbee_context.state != ZIGBEE_DEVICE_STATE_OPERATIONAL) {
        printf("[ZIGBEE] ERROR: Device must be operational to enable permit join\n");
        return ZIGBEE_STATUS_FAILURE;
    }
    
    if (duration_seconds == 0) {
        g_zigbee_context.permit_join_enabled = false;
        printf("[ZIGBEE] Permit join DISABLED\n");
        return ZIGBEE_STATUS_SUCCESS;
    }
    
    if (duration_seconds > MAX_PERMIT_JOIN_DURATION) {
        printf("[ZIGBEE] WARNING: Duration capped at %d seconds\n", 
               MAX_PERMIT_JOIN_DURATION);
        duration_seconds = MAX_PERMIT_JOIN_DURATION;
    }
    
    if (duration_seconds > SECURE_PERMIT_JOIN_DURATION) {
        printf("[ZIGBEE] WARNING: Long permit join duration may pose security risk\n");
        printf("[ZIGBEE] Recommended maximum: %d seconds\n", 
               SECURE_PERMIT_JOIN_DURATION);
    }
    
    g_zigbee_context.permit_join_enabled = true;
    g_zigbee_context.permit_join_expiry = zigbee_get_system_time() + 
                                          (duration_seconds * 1000);
    
    printf("[ZIGBEE] Permit join ENABLED for %d seconds\n", duration_seconds);
    printf("[ZIGBEE] New devices can now join the network\n");
    
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_disable_permit_join(void) {
    return zigbee_enable_permit_join(0);
}

void zigbee_check_permit_join_expiry(void) {
    if (!g_zigbee_context.permit_join_enabled) {
        return;
    }
    
    uint32_t current_time = zigbee_get_system_time();
    if (current_time >= g_zigbee_context.permit_join_expiry) {
        g_zigbee_context.permit_join_enabled = false;
        printf("[ZIGBEE] Permit join automatically DISABLED (timeout)\n");
    }
}

void zigbee_print_device_status(void) {
    const char *state_str[] = {
        "INIT", "JOINING", "JOINED", "AUTHENTICATED", "OPERATIONAL"
    };
    
    printf("\n[ZIGBEE] ===== Device Status =====\n");
    printf("[ZIGBEE] State: %s\n", state_str[g_zigbee_context.state]);
    printf("[ZIGBEE] IEEE Address: 0x%016llX\n", 
           (unsigned long long)g_zigbee_context.ieee_address);
    
    if (g_zigbee_context.state >= ZIGBEE_DEVICE_STATE_JOINED) {
        printf("[ZIGBEE] Short Address: 0x%04X\n", g_zigbee_context.short_address);
        printf("[ZIGBEE] PAN ID: 0x%04X\n", g_zigbee_context.network_params.pan_id);
        printf("[ZIGBEE] Channel: %d\n", g_zigbee_context.network_params.channel);
    }
    
    printf("[ZIGBEE] Link Key Type: %d\n", g_zigbee_context.tc_link_key.type);
    printf("[ZIGBEE] Link Key Valid: %s\n", 
           g_zigbee_context.tc_link_key.is_valid ? "YES" : "NO");
    printf("[ZIGBEE] Encryption: %s\n", 
           g_zigbee_context.encryption_enabled ? "ENABLED" : "DISABLED");
    printf("[ZIGBEE] Permit Join: %s\n", 
           g_zigbee_context.permit_join_enabled ? "ENABLED" : "DISABLED");
    printf("[ZIGBEE] Install Code Required: %s\n", 
           g_zigbee_context.require_install_code ? "YES" : "NO");
    printf("[ZIGBEE] ==========================\n\n");
}

int main(void) {
    printf("=== Zigbee Smart Light Bulb - Secure Commissioning ===\n\n");
    
    zigbee_status_t status = zigbee_init_device(true);
    if (status != ZIGBEE_STATUS_SUCCESS) {
        printf("[ERROR] Device initialization failed\n");
        return 1;
    }
    
    uint8_t install_code[INSTALL_CODE_SIZE] = {
        0x83, 0xFE, 0xD3, 0x40, 0x7A, 0x93, 0x97, 0x23,
        0xA5, 0xC6, 0x39, 0xB2, 0x69, 0x16, 0xD5, 0x05,
        0xC3, 0xB5
    };
    
    status = zigbee_set_trust_center_link_key(
        install_code,
        INSTALL_CODE_SIZE,
        LINK_KEY_TYPE_INSTALL_CODE
    );
    
    if (status != ZIGBEE_STATUS_SUCCESS) {
        printf("[ERROR] Failed to set Trust Center link key\n");
        return 1;
    }
    
    status = zigbee_join_network();
    if (status != ZIGBEE_STATUS_SUCCESS) {
        printf("[ERROR] Network join failed\n");
        return 1;
    }
    
    zigbee_print_device_status();
    
    printf("[SETUP] Enabling permit join for easy device addition during setup\n");
    status = zigbee_enable_permit_join(SECURE_PERMIT_JOIN_DURATION);
    if (status != ZIGBEE_STATUS_SUCCESS) {
        printf("[ERROR] Failed to enable permit join\n");
        return 1;
    }
    
    printf("\n[INFO] Smart light bulb is now operational and ready for use\n");
    printf("[INFO] Permit join will automatically disable after %d seconds\n", 
           SECURE_PERMIT_JOIN_DURATION);
    printf("[INFO] For production, disable permit join after initial setup\n");
    
    zigbee_check_permit_join_expiry();
    
    printf("\n[SECURITY] Device uses secure commissioning:\n");
    printf("  - Install code derived link key\n");
    printf("  - Encrypted network key transport\n");
    printf("  - Trust Center authentication\n");
    printf("  - Time-limited permit join\n");
    printf("  - No well-known keys allowed\n");
    
    return 0;
}