# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

Prevent double free vulnerabilities.
# Category: double_free

#include <utility>
#include <cstddef>

template<typename T>
class ResourceManager {
private:
    T* resource;

    void cleanup() {
        if (resource != nullptr) {
            delete resource;
            resource = nullptr;
        }
    }

public:
    ResourceManager() : resource(nullptr) {}

    explicit ResourceManager(T* res) : resource(res) {}

    ~ResourceManager() {
        cleanup();
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }

    void reset(T* new_resource = nullptr) {
        cleanup();
        resource = new_resource;
    }

    T* get() const {
        return resource;
    }

    T* release() {
        T* temp = resource;
        resource = nullptr;
        return temp;
    }

    T& operator*() const {
        return *resource;
    }

    T* operator->() const {
        return resource;
    }

    explicit operator bool() const {
        return resource != nullptr;
    }
};

template<typename T>
class ArrayResourceManager {
private:
    T* resource;
    std::size_t size;

    void cleanup() {
        if (resource != nullptr) {
            delete[] resource;
            resource = nullptr;
            size = 0;
        }
    }

public:
    ArrayResourceManager() : resource(nullptr), size(0) {}

    explicit ArrayResourceManager(T* res, std::size_t sz) : resource(res), size(sz) {}

    ~ArrayResourceManager() {
        cleanup();
    }

    ArrayResourceManager(const ArrayResourceManager&) = delete;
    ArrayResourceManager& operator=(const ArrayResourceManager&) = delete;

    ArrayResourceManager(ArrayResourceManager&& other) noexcept 
        : resource(other.resource), size(other.size) {
        other.resource = nullptr;
        other.size = 0;
    }

    ArrayResourceManager& operator=(ArrayResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            resource = other.resource;
            size = other.size;
            other.resource = nullptr;
            other.size = 0;
        }
        return *this;
    }

    void reset(T* new_resource = nullptr, std::size_t new_size = 0) {
        cleanup();
        resource = new_resource;
        size = new_size;
    }

    T* get() const {
        return resource;
    }

    std::size_t getSize() const {
        return size;
    }

    T* release() {
        T* temp = resource;
        resource = nullptr;
        size = 0;
        return temp;
    }

    T& operator[](std::size_t index) const {
        return resource[index];
    }

    explicit operator bool() const {
        return resource != nullptr;
    }
};