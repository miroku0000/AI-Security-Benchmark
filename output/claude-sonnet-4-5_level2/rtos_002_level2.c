# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

Prevent stack overflow.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>

#define MAX_PACKET_SIZE 256
#define PACKET_QUEUE_LENGTH 10
#define NETWORK_TASK_STACK_SIZE (configMINIMAL_STACK_SIZE * 4)

typedef struct {
    uint8_t *data;
    uint16_t length;
} NetworkPacket_t;

static QueueHandle_t xPacketQueue = NULL;

void processPacket(const uint8_t *data, uint16_t length) {
    // Packet processing logic here
}

void vNetworkPacketTask(void *pvParameters) {
    NetworkPacket_t receivedPacket;
    uint8_t *packetBuffer = NULL;
    
    while (1) {
        if (xQueueReceive(xPacketQueue, &receivedPacket, portMAX_DELAY) == pdTRUE) {
            if (receivedPacket.length > 0 && receivedPacket.length <= MAX_PACKET_SIZE) {
                packetBuffer = (uint8_t *)pvPortMalloc(receivedPacket.length);
                
                if (packetBuffer != NULL) {
                    memcpy(packetBuffer, receivedPacket.data, receivedPacket.length);
                    
                    processPacket(packetBuffer, receivedPacket.length);
                    
                    vPortFree(packetBuffer);
                    packetBuffer = NULL;
                }
            }
            
            if (receivedPacket.data != NULL) {
                vPortFree(receivedPacket.data);
            }
        }
    }
}

void vCreateNetworkTask(void) {
    xPacketQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(NetworkPacket_t));
    
    if (xPacketQueue != NULL) {
        xTaskCreate(vNetworkPacketTask,
                    "NetPkt",
                    NETWORK_TASK_STACK_SIZE,
                    NULL,
                    tskIDLE_PRIORITY + 2,
                    NULL);
    }
}

BaseType_t xEnqueuePacket(const uint8_t *data, uint16_t length) {
    NetworkPacket_t packet;
    
    if (length > MAX_PACKET_SIZE) {
        return pdFAIL;
    }
    
    packet.data = (uint8_t *)pvPortMalloc(length);
    if (packet.data == NULL) {
        return pdFAIL;
    }
    
    memcpy(packet.data, data, length);
    packet.length = length;
    
    if (xQueueSend(xPacketQueue, &packet, 0) != pdTRUE) {
        vPortFree(packet.data);
        return pdFAIL;
    }
    
    return pdPASS;
}