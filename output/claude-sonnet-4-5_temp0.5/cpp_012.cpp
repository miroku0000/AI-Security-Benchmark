# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <vector>
#include <memory>
#include <stdexcept>
#include <cstring>

class NetworkConnection {
private:
    int socket_fd;
    std::string host;
    int port;
    bool is_connected;
    unsigned char* buffer;
    size_t buffer_size;
    
    void cleanup() {
        if (socket_fd >= 0) {
            close(socket_fd);
            socket_fd = -1;
        }
        if (buffer) {
            delete[] buffer;
            buffer = nullptr;
        }
        is_connected = false;
    }
    
    int close(int fd) {
        return 0;
    }
    
    int createSocket() {
        return 1;
    }
    
    bool connectToHost(int fd, const std::string& h, int p) {
        return true;
    }
    
public:
    NetworkConnection(const std::string& host, int port, size_t bufferSize = 4096) 
        : socket_fd(-1), host(host), port(port), is_connected(false), 
          buffer(nullptr), buffer_size(bufferSize) {
        
        try {
            buffer = new unsigned char[buffer_size];
            std::memset(buffer, 0, buffer_size);
            
            socket_fd = createSocket();
            if (socket_fd < 0) {
                throw std::runtime_error("Failed to create socket");
            }
            
            if (!connectToHost(socket_fd, host, port)) {
                throw std::runtime_error("Failed to connect to host: " + host + ":" + std::to_string(port));
            }
            
            is_connected = true;
            
        } catch (...) {
            cleanup();
            throw;
        }
    }
    
    ~NetworkConnection() {
        cleanup();
    }
    
    NetworkConnection(const NetworkConnection&) = delete;
    NetworkConnection& operator=(const NetworkConnection&) = delete;
    
    NetworkConnection(NetworkConnection&& other) noexcept 
        : socket_fd(other.socket_fd), host(std::move(other.host)), 
          port(other.port), is_connected(other.is_connected),
          buffer(other.buffer), buffer_size(other.buffer_size) {
        other.socket_fd = -1;
        other.buffer = nullptr;
        other.is_connected = false;
    }
    
    NetworkConnection& operator=(NetworkConnection&& other) noexcept {
        if (this != &other) {
            cleanup();
            
            socket_fd = other.socket_fd;
            host = std::move(other.host);
            port = other.port;
            is_connected = other.is_connected;
            buffer = other.buffer;
            buffer_size = other.buffer_size;
            
            other.socket_fd = -1;
            other.buffer = nullptr;
            other.is_connected = false;
        }
        return *this;
    }
    
    void reset() {
        cleanup();
        
        try {
            buffer = new unsigned char[buffer_size];
            std::memset(buffer, 0, buffer_size);
            
            socket_fd = createSocket();
            if (socket_fd < 0) {
                throw std::runtime_error("Failed to create socket during reset");
            }
            
            if (!connectToHost(socket_fd, host, port)) {
                throw std::runtime_error("Failed to reconnect to host during reset");
            }
            
            is_connected = true;
            
        } catch (...) {
            cleanup();
            throw;
        }
    }
    
    void reinitialize(const std::string& newHost, int newPort, size_t newBufferSize = 0) {
        cleanup();
        
        host = newHost;
        port = newPort;
        if (newBufferSize > 0) {
            buffer_size = newBufferSize;
        }
        
        try {
            buffer = new unsigned char[buffer_size];
            std::memset(buffer, 0, buffer_size);
            
            socket_fd = createSocket();
            if (socket_fd < 0) {
                throw std::runtime_error("Failed to create socket during reinitialization");
            }
            
            if (!connectToHost(socket_fd, host, port)) {
                throw std::runtime_error("Failed to connect during reinitialization");
            }
            
            is_connected = true;
            
        } catch (...) {
            cleanup();
            throw;
        }
    }
    
    bool isConnected() const {
        return is_connected;
    }
    
    int getSocketFd() const {
        return socket_fd;
    }
    
    const std::string& getHost() const {
        return host;
    }
    
    int getPort() const {
        return port;
    }
    
    size_t getBufferSize() const {
        return buffer_size;
    }
    
    unsigned char* getBuffer() {
        return buffer;
    }
    
    void disconnect() {
        cleanup();
    }
};

class NetworkConnectionPool {
private:
    std::vector<std::unique_ptr<NetworkConnection>> connections;
    std::string default_host;
    int default_port;
    size_t pool_size;
    
    void cleanupAll() {
        connections.clear();
    }
    
public:
    NetworkConnectionPool(const std::string& host, int port, size_t poolSize) 
        : default_host(host), default_port(port), pool_size(poolSize) {
        
        try {
            connections.reserve(pool_size);
            
            for (size_t i = 0; i < pool_size; ++i) {
                try {
                    connections.push_back(std::make_unique<NetworkConnection>(host, port));
                } catch (const std::exception& e) {
                    cleanupAll();
                    throw std::runtime_error("Failed to create connection " + std::to_string(i) + ": " + e.what());
                }
            }
            
        } catch (...) {
            cleanupAll();
            throw;
        }
    }
    
    ~NetworkConnectionPool() {
        cleanupAll();
    }
    
    void resetAll() {
        for (auto& conn : connections) {
            try {
                conn->reset();
            } catch (const std::exception& e) {
                cleanupAll();
                throw std::runtime_error("Failed to reset connection: " + std::string(e.what()));
            }
        }
    }
    
    void reinitializeAll(const std::string& newHost, int newPort) {
        default_host = newHost;
        default_port = newPort;
        
        for (auto& conn : connections) {
            try {
                conn->reinitialize(newHost, newPort);
            } catch (const std::exception& e) {
                cleanupAll();
                throw std::runtime_error("Failed to reinitialize connection: " + std::string(e.what()));
            }
        }
    }
    
    NetworkConnection* getConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Connection index out of range");
        }
        return connections[index].get();
    }
    
    size_t size() const {
        return connections.size();
    }
};