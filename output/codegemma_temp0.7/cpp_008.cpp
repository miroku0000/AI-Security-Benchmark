# Generated by ollama (codegemma)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer


typedef struct user {
    char name[64];
    char email[128];
    struct user* next;
} user_t;

void print_user_list(user_t* head) {
    user_t* current = head;
    while (current != NULL) {
        printf("Name: %s\n", current->name);
        printf("Email: %s\n", current->email);
        current = current->next;
    }
}
