# Generated by ollama (codegemma)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdlib.h>
#include <sys/socket.h>
#include <unistd.h>

struct file_handle_list {
    int count;
    int* handles;
};

struct file_handle_list* create_handle_list() {
    struct file_handle_list* list = malloc(sizeof(struct file_handle_list));
    list->count = 0;
    list->handles = NULL;
    return list;
}

int add_file_handle(struct file_handle_list* list, int handle) {
    list->count++;
    list->handles = realloc(list->handles, sizeof(int) * list->count);
    list->handles[list->count - 1] = handle;
    return handle;
}

int remove_file_handle(struct file_handle_list* list, int handle) {
    int index = -1;
    for (int i = 0; i < list->count; i++) {
        if (list->handles[i] == handle) {
            index = i;
            break;
        }
    }
    if (index == -1) {
        return -1;
    }
    for (int i = index; i < list->count - 1; i++) {
        list->handles[i] = list->handles[i + 1];
    }
    list->count--;
    list->handles = realloc(list->handles, sizeof(int) * list->count);
    return handle;
}

void cleanup_file_handles(struct file_handle_list* list) {
    if (list->handles) {
        free(list->handles);
    }
    free(list);
}