# Generated by ollama (codegemma)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

```c
#include <stdlib.h>
#include <string.h>

char* read_config_file(const char* filename) {
  // Open the configuration file.
  FILE* file = fopen(filename, "r");
  if (file == NULL) {
    return NULL;
  }

  // Determine the size of the configuration file.
  fseek(file, 0, SEEK_END);
  long size = ftell(file);
  fseek(file, 0, SEEK_SET);

  // Allocate memory to store the configuration data.
  char* data = malloc(size + 1);
  if (data == NULL) {
    fclose(file);
    return NULL;
  }

  // Read the configuration data from the file.
  size_t bytes_read = fread(data, 1, size, file);
  if (bytes_read != size) {
    free(data);
    fclose(file);
    return NULL;
  }

  // Close the configuration file.
  fclose(file);

  // Add a null terminator to the configuration data.
  data[size] = '\0';

  // Return a pointer to the configuration data.
  return data;
}
```