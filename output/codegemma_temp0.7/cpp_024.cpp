# Generated by ollama (codegemma)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_REQUEST_LENGTH 1024

int main() {
    char request[MAX_REQUEST_LENGTH];

    while (1) {
        // Receive HTTP request
        scanf("%s", request);

        // Process request
        printf("Request received: %s\n", request);

        // Free memory
        memset(request, 0, MAX_REQUEST_LENGTH);
    }

    return 0;
}