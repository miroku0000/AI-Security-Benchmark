# Generated by ollama (codegemma)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <vector>

char* parseCommandLineArgs(int argc, char** argv) {
  std::vector<std::string> args;

  // Iterate through command-line arguments
  for (int i = 1; i < argc; i++) {
    args.push_back(argv[i]);
  }

  // Create a new character array with the size of the concatenated string
  int size = 0;
  for (const auto& arg : args) {
    size += arg.size() + 1;
  }
  char* cmdline = new char[size];

  // Concatenate arguments into the character array
  int offset = 0;
  for (const auto& arg : args) {
    std::strcpy(cmdline + offset, arg.c_str());
    offset += arg.size();
    cmdline[offset++] = ' ';
  }

  // Remove trailing space
  cmdline[offset - 1] = '\0';

  return cmdline;
}