# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/logging/log.h>
#include <string.h>

LOG_MODULE_REGISTER(privilege_system, LOG_LEVEL_INF);

#define ADMIN_STACK_SIZE 2048
#define USER_STACK_SIZE 1024
#define ADMIN_PRIORITY 5
#define USER_PRIORITY 7

#define FLASH_AREA_ID FIXED_PARTITION_ID(storage_partition)
#define CONFIG_FLASH_OFFSET 0x0
#define CONFIG_FLASH_SIZE 256

#define MAX_PENDING_REQUESTS 10

typedef enum {
    PRIV_LEVEL_USER = 0,
    PRIV_LEVEL_ADMIN = 1
} privilege_level_t;

typedef enum {
    OP_WRITE_FLASH,
    OP_MODIFY_CONFIG,
    OP_READ_CONFIG
} operation_type_t;

typedef struct {
    operation_type_t op_type;
    void *data;
    size_t data_len;
    uint32_t offset;
    int result;
    struct k_sem completion_sem;
} admin_request_t;

typedef struct {
    uint32_t magic;
    uint32_t version;
    uint32_t flags;
    char device_name[32];
    uint32_t max_users;
    uint32_t timeout_ms;
    uint8_t reserved[200];
} system_config_t;

K_MSGQ_DEFINE(admin_request_queue, sizeof(admin_request_t *), MAX_PENDING_REQUESTS, 4);

static system_config_t current_config = {
    .magic = 0xDEADBEEF,
    .version = 1,
    .flags = 0,
    .device_name = "EmbeddedDevice",
    .max_users = 10,
    .timeout_ms = 5000
};

static struct k_mutex config_mutex;
static const struct device *flash_dev;

static bool check_privilege(privilege_level_t required_level, privilege_level_t current_level)
{
    return current_level >= required_level;
}

static int admin_write_flash(uint32_t offset, const void *data, size_t len)
{
    int ret;
    const struct flash_area *fa;

    ret = flash_area_open(FLASH_AREA_ID, &fa);
    if (ret) {
        LOG_ERR("Failed to open flash area: %d", ret);
        return ret;
    }

    ret = flash_area_erase(fa, offset, len);
    if (ret) {
        LOG_ERR("Failed to erase flash: %d", ret);
        flash_area_close(fa);
        return ret;
    }

    ret = flash_area_write(fa, offset, data, len);
    if (ret) {
        LOG_ERR("Failed to write flash: %d", ret);
        flash_area_close(fa);
        return ret;
    }

    flash_area_close(fa);
    LOG_INF("Flash write successful: offset=%u, len=%u", offset, len);
    return 0;
}

static int admin_read_flash(uint32_t offset, void *data, size_t len)
{
    int ret;
    const struct flash_area *fa;

    ret = flash_area_open(FLASH_AREA_ID, &fa);
    if (ret) {
        LOG_ERR("Failed to open flash area: %d", ret);
        return ret;
    }

    ret = flash_area_read(fa, offset, data, len);
    if (ret) {
        LOG_ERR("Failed to read flash: %d", ret);
        flash_area_close(fa);
        return ret;
    }

    flash_area_close(fa);
    return 0;
}

static int admin_modify_config(const system_config_t *new_config)
{
    int ret;

    k_mutex_lock(&config_mutex, K_FOREVER);

    memcpy(&current_config, new_config, sizeof(system_config_t));

    ret = admin_write_flash(CONFIG_FLASH_OFFSET, &current_config, sizeof(system_config_t));
    
    k_mutex_unlock(&config_mutex);

    if (ret == 0) {
        LOG_INF("System config modified successfully");
        LOG_INF("  Device Name: %s", current_config.device_name);
        LOG_INF("  Max Users: %u", current_config.max_users);
        LOG_INF("  Timeout: %u ms", current_config.timeout_ms);
    }

    return ret;
}

static int admin_read_config(system_config_t *config)
{
    k_mutex_lock(&config_mutex, K_FOREVER);
    memcpy(config, &current_config, sizeof(system_config_t));
    k_mutex_unlock(&config_mutex);
    
    LOG_INF("Config read - Device: %s, Users: %u", config->device_name, config->max_users);
    return 0;
}

static void process_admin_request(admin_request_t *req)
{
    int ret = -EINVAL;

    switch (req->op_type) {
    case OP_WRITE_FLASH:
        ret = admin_write_flash(req->offset, req->data, req->data_len);
        break;

    case OP_MODIFY_CONFIG:
        if (req->data_len == sizeof(system_config_t)) {
            ret = admin_modify_config((system_config_t *)req->data);
        }
        break;

    case OP_READ_CONFIG:
        if (req->data_len == sizeof(system_config_t)) {
            ret = admin_read_config((system_config_t *)req->data);
        }
        break;

    default:
        LOG_ERR("Unknown operation type: %d", req->op_type);
        ret = -ENOTSUP;
        break;
    }

    req->result = ret;
    k_sem_give(&req->completion_sem);
}

static void admin_task(void *p1, void *p2, void *p3)
{
    admin_request_t *req;
    privilege_level_t my_privilege = PRIV_LEVEL_ADMIN;

    LOG_INF("Admin task started with privilege level: %d", my_privilege);

    while (1) {
        if (k_msgq_get(&admin_request_queue, &req, K_FOREVER) == 0) {
            LOG_INF("Admin task processing request type: %d", req->op_type);
            process_admin_request(req);
        }
    }
}

static int request_admin_operation(privilege_level_t user_priv, operation_type_t op_type,
                                   void *data, size_t data_len, uint32_t offset)
{
    admin_request_t request;
    admin_request_t *req_ptr = &request;
    int ret;

    if (!check_privilege(PRIV_LEVEL_USER, user_priv)) {
        LOG_ERR("Insufficient privileges for operation");
        return -EACCES;
    }

    k_sem_init(&request.completion_sem, 0, 1);
    request.op_type = op_type;
    request.data = data;
    request.data_len = data_len;
    request.offset = offset;
    request.result = -EINPROGRESS;

    ret = k_msgq_put(&admin_request_queue, &req_ptr, K_SECONDS(1));
    if (ret) {
        LOG_ERR("Failed to queue admin request: %d", ret);
        return ret;
    }

    LOG_INF("User task waiting for admin operation completion...");
    k_sem_take(&request.completion_sem, K_FOREVER);

    return request.result;
}

static void user_task(void *p1, void *p2, void *p3)
{
    privilege_level_t my_privilege = PRIV_LEVEL_USER;
    system_config_t new_config;
    uint8_t flash_data[64];
    int ret;
    int iteration = 0;

    LOG_INF("User task started with privilege level: %d", my_privilege);

    k_sleep(K_SECONDS(1));

    while (1) {
        iteration++;
        LOG_INF("=== User task iteration %d ===", iteration);

        ret = request_admin_operation(my_privilege, OP_READ_CONFIG, 
                                      &new_config, sizeof(new_config), 0);
        if (ret == 0) {
            LOG_INF("User task: Config read successful");
        } else {
            LOG_ERR("User task: Config read failed: %d", ret);
        }

        k_sleep(K_SECONDS(2));

        memcpy(&new_config, &current_config, sizeof(system_config_t));
        new_config.max_users = 15 + iteration;
        new_config.timeout_ms = 3000 + (iteration * 100);
        snprintf(new_config.device_name, sizeof(new_config.device_name), 
                "Device_%d", iteration);

        ret = request_admin_operation(my_privilege, OP_MODIFY_CONFIG,
                                      &new_config, sizeof(new_config), 0);
        if (ret == 0) {
            LOG_INF("User task: Config modification successful");
        } else {
            LOG_ERR("User task: Config modification failed: %d", ret);
        }

        k_sleep(K_SECONDS(2));

        for (int i = 0; i < sizeof(flash_data); i++) {
            flash_data[i] = (uint8_t)(0xA0 + i + iteration);
        }

        ret = request_admin_operation(my_privilege, OP_WRITE_FLASH,
                                      flash_data, sizeof(flash_data), 
                                      CONFIG_FLASH_SIZE);
        if (ret == 0) {
            LOG_INF("User task: Flash write successful");
        } else {
            LOG_ERR("User task: Flash write failed: %d", ret);
        }

        k_sleep(K_SECONDS(5));
    }
}

K_THREAD_DEFINE(admin_tid, ADMIN_STACK_SIZE, admin_task, NULL, NULL, NULL,
                ADMIN_PRIORITY, 0, 0);

K_THREAD_DEFINE(user_tid, USER_STACK_SIZE, user_task, NULL, NULL, NULL,
                USER_PRIORITY, 0, 0);

int main(void)
{
    LOG_INF("Privilege System Application Started");
    LOG_INF("Admin Priority: %d, User Priority: %d", ADMIN_PRIORITY, USER_PRIORITY);

    k_mutex_init(&config_mutex);

    flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
    if (!device_is_ready(flash_dev)) {
        LOG_ERR("Flash device not ready");
        return -ENODEV;
    }

    LOG_INF("Flash device ready");
    LOG_INF("System initialized successfully");

    return 0;
}