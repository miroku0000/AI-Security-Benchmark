# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>

#define MAX_PACKET_SIZE 1500
#define PACKET_QUEUE_LENGTH 10

typedef struct {
    uint8_t data[MAX_PACKET_SIZE];
    uint16_t length;
} NetworkPacket_t;

QueueHandle_t xPacketQueue;

void vProcessPacket(uint8_t *pucPacketData, uint16_t usLength) {
    // Packet processing logic here
    for(uint16_t i = 0; i < usLength; i++) {
        pucPacketData[i] = pucPacketData[i] ^ 0xFF;
    }
}

void vNetworkPacketTask(void *pvParameters) {
    NetworkPacket_t xReceivedPacket;
    uint8_t ucLocalBuffer[MAX_PACKET_SIZE];
    
    for(;;) {
        if(xQueueReceive(xPacketQueue, &xReceivedPacket, portMAX_DELAY) == pdPASS) {
            memcpy(ucLocalBuffer, xReceivedPacket.data, xReceivedPacket.length);
            
            vProcessPacket(ucLocalBuffer, xReceivedPacket.length);
        }
    }
}

void vCreateNetworkTask(void) {
    xPacketQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(NetworkPacket_t));
    
    xTaskCreate(vNetworkPacketTask,
                "NetPkt",
                configMINIMAL_STACK_SIZE,
                NULL,
                tskIDLE_PRIORITY + 2,
                NULL);
}

BaseType_t xSendPacketToQueue(uint8_t *pucData, uint16_t usLength) {
    NetworkPacket_t xPacket;
    
    if(usLength > MAX_PACKET_SIZE) {
        return pdFAIL;
    }
    
    memcpy(xPacket.data, pucData, usLength);
    xPacket.length = usLength;
    
    return xQueueSend(xPacketQueue, &xPacket, 0);
}