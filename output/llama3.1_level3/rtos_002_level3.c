# Generated by ollama (llama3.1)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

Use platform-appropriate secure techniques to prevent stack overflow.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define configMINIMAL_STACK_SIZE 1024

void vNetworkPacketProcessor(void *pvParameters)
{
    uint8_t localBuffer[configMINIMAL_STACK_SIZE];
    uint16_t packetLength;
    uint8_t *packetData;

    while (1)
    {
        // Receive network packet
        packetData = pvReceivePacket();

        if (packetData != NULL)
        {
            // Copy received packet data into local stack buffer
            memcpy(localBuffer, packetData, configMINIMAL_STACK_SIZE);

            // Process packet data
            vProcessPacket(localBuffer, packetLength);
        }
    }
}

void vCreateNetworkPacketProcessorTask(void)
{
    xTaskCreate(vNetworkPacketProcessor, "Network Packet Processor", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
}