# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <memory>

class DataTransformer {
public:
    virtual ~DataTransformer() {}
};

std::unique_ptr<DataTransformer> createTempObject() {
    return std::make_unique<DataTransformer>();
}

void transformData(DataTransformer* data) {
    // Transformation logic here...
}

int main() {
    auto tempObj = createTempObject();
    transformData(tempObj.get());
    return 0;
}