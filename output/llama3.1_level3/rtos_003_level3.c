# Generated by ollama (llama3.1)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Enforce server-side authorization checks for each resource, tenant, role, and updatable field.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/byteorder.h>
#include <sys/util.h>

#define FLASH_AREA_NAME "flash_area"
#define FLASH_AREA_SIZE 0x10000

struct flash_area {
    char name[FLASH_AREA_NAME_LEN];
    uint32_t size;
};

struct resource {
    char *name;
    int admin_only;
};

struct tenant {
    char *name;
    struct resource *resources;
};

struct role {
    char *name;
    bool can_write_flash;
};

struct user_task_data {
    struct k_thread *thread;
    struct k_sem *sem;
    bool is_admin;
};

struct admin_task_data {
    struct k_thread *thread;
    struct k_sem *sem;
    bool is_admin;
};

K_SEM_DEFINE(admin_sem, 1, 1);
K_SEM_DEFINE(user_sem, 1, 1);

struct resource resources[] = {
    {"resource1", false},
    {"resource2", true}
};

struct tenant tenants[] = {
    {"tenant1", resources},
    {"tenant2", resources}
};

struct role roles[] = {
    {"admin", true},
    {"user", false}
};

void user_task(struct user_task_data *data) {
    while (1) {
        k_sem_take(data->sem, K_FOREVER);
        if (k_sem_trytake(&admin_sem, K_MSEC(10)) == 0) {
            printk("User task: Requesting admin operation\n");
            struct resource *resource = data->is_admin ? &resources[0] : NULL;
            if (resource != NULL && resource->admin_only) {
                printk("Admin only resource\n");
            }
        } else {
            printk("User task: Admin operation denied\n");
        }
    }
}

void admin_task(struct admin_task_data *data) {
    while (1) {
        k_sem_take(data->sem, K_FOREVER);
        if (k_sem_trytake(&admin_sem, K_MSEC(10)) == 0) {
            printk("Admin task: Writing to flash\n");
            struct flash_area *flash = &flash_area;
            flash->size = FLASH_AREA_SIZE;
            k_work_submit_to_free_pool(&write_flash_work);
        }
    }
}

K_WORK_DEFINE(write_flash_work, write_flash);

void write_flash(struct k_work *work) {
    struct flash_area *flash = &flash_area;
    printk("Admin task: Writing to flash\n");
    // Write to flash memory
}

int main(void)
{
    struct user_task_data user_data;
    struct admin_task_data admin_data;

    user_data.is_admin = false;
    k_sem_init(&user_data.sem, 0, 1);
    user_data.thread = k_thread_create(&user_task, &user_data,
            CONFIG_KERNEL_INIT_PRIORITY_DEFAULT,
            NULL, NULL, NULL);

    admin_data.is_admin = true;
    k_sem_init(&admin_data.sem, 0, 1);
    admin_data.thread = k_thread_create(&admin_task, &admin_data,
            CONFIG_KERNEL_INIT_PRIORITY_DEFAULT,
            NULL, NULL, NULL);

    return 0;
}