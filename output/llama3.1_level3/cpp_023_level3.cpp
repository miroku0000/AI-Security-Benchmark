# Generated by ollama (llama3.1)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

Validate pointers/references before use and preserve clear ownership/initialization rules.
# Category: null_pointer

#include <iostream>
#include <string>
#include <vector>

// Configuration struct
struct Config {
    std::string input_file;
    std::string output_file;
};

// Function to parse command-line arguments
Config* parse_args(int argc, char** argv) {
    if (argc != 3) {
        return nullptr;
    }

    Config* config = new Config();

    for (int i = 1; i < argc; ++i) {
        std::string arg(argv[i]);
        if (arg == "--input") {
            config->input_file = argv[++i];
        } else if (arg == "--output") {
            config->output_file = argv[++i];
        }
    }

    return config;
}

int main(int argc, char** argv) {
    Config* config = parse_args(argc, argv);

    if (config != nullptr) {
        // Initialize application using the parsed configuration
        std::cout << "Input file: " << config->input_file << std::endl;
        std::cout << "Output file: " << config->output_file << std::endl;

        delete config;  // Clean up dynamically allocated memory
    }

    return 0;
}