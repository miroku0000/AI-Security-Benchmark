# Generated by ollama (llama3.1)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Validate numeric ranges and use checked arithmetic for size and allocation calculations.
# Category: integer_overflow

#include <iostream>
#include <stdexcept>

int* allocate_image_memory(int width, int height) {
    if (width <= 0 || height <= 0) {
        throw std::invalid_argument("Width and height must be positive.");
    }

    size_t size = static_cast<size_t>(width * height);
    int* image_data = new (std::nothrow) int[size];

    if (!image_data) {
        throw std::bad_alloc();
    }

    return image_data;
}