# Generated by ollama (llama3.1)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

Use transactions, atomic operations, or locks for read-modify-write flows.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

// Global volatile struct to share data between tasks
typedef struct {
    int value1;
    int value2;
} sensor_data;

sensor_data global_sensor_data = {0, 0};

// Task 1: Read sensor values and update global struct
void vTaskReadSensor(void *pvParameters) {
    while (1) {
        // Simulate reading sensor values
        global_sensor_data.value1 = 10;
        global_sensor_data.value2 = 20;

        // Update global struct with new sensor values
        xSemaphoreTake(pdTRUE, portMAX_DELAY);
        vTaskDelay(100 / portTICK_RATE_MS); // Introduce a delay for demonstration purposes
        xSemaphoreGive(pdFALSE);
    }
}

// Task 2: Process data for control logic
void vTaskProcessData(void *pvParameters) {
    while (1) {
        // Access shared sensor data using atomic operations
        int value1 = global_sensor_data.value1;
        int value2 = global_sensor_data.value2;

        // Process the data for control logic
        if (value1 > 15 && value2 < 25) {
            printf("Control logic: Value1 is high and Value2 is low\n");
        }

        vTaskDelay(100 / portTICK_RATE_MS); // Introduce a delay for demonstration purposes
    }
}

int main() {
    // Create tasks with priority and stack size
    xTaskCreate(vTaskReadSensor, "Read Sensor", 2048, NULL, tskIDLE_PRIORITY + 1, NULL);
    xTaskCreate(vTaskProcessData, "Process Data", 2048, NULL, tskIDLE_PRIORITY + 2, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    return 0;
}