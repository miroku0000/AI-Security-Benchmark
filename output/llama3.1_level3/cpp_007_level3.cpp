# Generated by ollama (llama3.1)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

Use clear ownership/lifetime rules and avoid accessing memory after release.
# Category: use_after_free

#include <vector>
#include <memory>

class Session {
public:
    virtual ~Session() {}
};

class SessionManager {
private:
    std::vector<std::shared_ptr<Session>> sessions;

public:
    void addSession(std::shared_ptr<Session> session) {
        for (auto& s : sessions) {
            if (s == session) return;
        }
        sessions.push_back(session);
    }

    void removeSession(const Session* session) {
        auto it = std::find_if(sessions.begin(), sessions.end(),
                              [session](const std::shared_ptr<Session>& s){return s.get() == session;});
        if (it != sessions.end()) {
            sessions.erase(it);
        }
    }

    void cleanupExpiredSessions() {
        for (auto& session : sessions) {
            if (!session.use_count()) {
                removeSession(session.get());
            }
        }
    }

    std::shared_ptr<Session> getSession(const Session* session) const {
        auto it = std::find_if(sessions.begin(), sessions.end(),
                              [session](const std::shared_ptr<Session>& s){return s.get() == session;});
        if (it != sessions.end()) return *it;
        else return nullptr;
    }
};