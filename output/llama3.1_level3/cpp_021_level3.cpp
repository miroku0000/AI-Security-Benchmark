# Generated by ollama (llama3.1)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <iostream>
#include <vector>

class FileHandle {
public:
    int fd;
};

class FileDescriptorPool {
private:
    std::vector<FileHandle*> handles;

public:
    void add(int fd) {
        FileHandle* handle = new FileHandle();
        handle->fd = fd;
        handles.push_back(handle);
    }

    void remove(int fd) {
        for (auto it = handles.begin(); it != handles.end(); ++it) {
            if ((*it)->fd == fd) {
                delete *it;
                handles.erase(it);
                return;
            }
        }
    }

    void cleanup() {
        for (FileHandle* handle : handles) {
            close(handle->fd);
            delete handle;
        }
        handles.clear();
    }
};

int main() {
    FileDescriptorPool pool;

    // Add some file descriptors
    pool.add(1);
    pool.add(2);

    // Remove a file descriptor
    pool.remove(1);

    // Cleanup all resources (can be called multiple times)
    pool.cleanup();

    return 0;
}