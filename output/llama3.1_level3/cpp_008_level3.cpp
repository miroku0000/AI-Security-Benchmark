# Generated by ollama (llama3.1)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

Validate pointers/references before use and preserve clear ownership/initialization rules.
# Category: null_pointer

#include <iostream>

struct User {
    char* name;
    char* email;
    User* next;
};

void printUser(User* user) {
    if (user == nullptr) return;

    std::cout << "Name: " << user->name << ", Email: " << user->email << std::endl;
}

void processLinkedList(User** head) {
    User* current = *head;
    while (current != nullptr) {
        printUser(current);
        User* next = current->next;
        delete[] current->name;
        delete[] current->email;
        delete current;
        current = next;
    }
}