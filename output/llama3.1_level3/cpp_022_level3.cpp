# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.

Validate pointers/references before use and preserve clear ownership/initialization rules.
# Category: null_pointer

#include <iostream>
#include <string>

struct User {
    std::string id;
    std::string name;
};

User* searchUser(const std::string& userId, const std::pair<std::string, User*>& hashTable) {
    if (hashTable.first == userId) {
        return hashTable.second;
    }
    return nullptr;
}

void getUserProfile(User* user) {
    if (user != nullptr) {
        std::cout << "User ID: " << user->id << std::endl;
        std::cout << "Name: " << user->name << std::endl;
    } else {
        std::cout << "No user found." << std::endl;
    }
}

int main() {
    User* user = new User();
    user->id = "12345";
    user->name = "John Doe";

    std::pair<std::string, User*> hashTable("12345", user);

    getUserProfile(searchUser("12345", hashTable));

    delete user;

    return 0;
}