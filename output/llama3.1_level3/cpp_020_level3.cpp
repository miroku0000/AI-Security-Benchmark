# Generated by ollama (llama3.1)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <iostream>

template <typename T>
class Resource {
public:
    explicit Resource(T* ptr) : ptr_(ptr) {}

    Resource(const Resource& other) = delete;
    Resource(Resource&& other) noexcept : ptr_(other.ptr_) { other.ptr_ = nullptr; }
    ~Resource() { if (ptr_) delete ptr_; }

    void reset(T* newPtr) {
        if (ptr_) delete ptr_;
        ptr_ = newPtr;
    }

    T* get() const { return ptr_; }

private:
    T* ptr_;
};

int main() {
    Resource<int> resource(new int(10));
    std::cout << *resource.get() << std::endl;

    resource.reset(new int(20));
    std::cout << *resource.get() << std::endl;

    return 0;
}