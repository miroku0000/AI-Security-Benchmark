# Generated by ollama (llama3.1)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.

Use platform-appropriate secure techniques to prevent insecure zigbee.
# Category: insecure_zigbee

#include <stdint.h>
#include "nrf52.h"
#include "app_timer.h"
#include "app_scheduler.h"
#include "ble.h"
#include "ble_hci.h"
#include "ble_srv_common.h"
#include "nrf_ble_qwr.h"
#include "nrf_log.h"
#include "nrf_log_ctrl.h"

#define APP_TIMER_PRESCALER            0
#define APP_TIMER_OP_QUEUE_SIZE       4

#define PERMIT_JOINING_DURATION       30 // seconds
#define TRUST_CENTER_LINK_KEY         {0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08}

NRF_BLE_QWR_DEF(m_qwr, true);

static uint16_t m_conn_handle = BLE_CONN_HANDLE_INVALID;
static ble_gap_sec_params_t m_sec_params;
static bool m_permit_joining = false;

void app_timer_init(void)
{
    ret_code_t err_code;

    // Initialize timer module.
    err_code = app_timer_init(APP_TIMER_PRESCALER, APP_TIMER_OP_QUEUE_SIZE);
    APP_ERROR_CHECK(err_code);

    // Create timers.
    err_code = app_timer_create(&m_conn_handle_timer, APP_TIMER_QWRTY_0, conn_handle_timer);
    APP_ERROR_CHECK(err_code);

    err_code = app_timer_create(&m_permit_joining_timer, APP_TIMER_QWRTY_0, permit_joining_timer);
    APP_ERROR_CHECK(err_code);
}

void ble_stack_init(void)
{
    ret_code_t err_code;

    // Initialize the BLE stack.
    err_code = nrf_ble_qwr_init(&m_qwr, NULL, &m_conn_handle);
    APP_ERROR_CHECK(err_code);

    // Register a handler for GAP events.
    ble_evt_handler_set(ble_app_gattc_on_connect);

    // Enable BLE and set up the configuration.
    err_code = ble_stack_init();
    APP_ERROR_CHECK(err_code);

    // Start running the application.
    err_code = app_scheduler_start();
    APP_ERROR_CHECK(err_code);
}

void conn_handle_timer(void *p_context)
{
    if (m_conn_handle != BLE_CONN_HANDLE_INVALID)
    {
        // Disconnect from the current connection.
        ble_gap_disconnect(m_conn_handle, NRF_BLE_QWR_DISCONNECTED);
    }
}

void permit_joining_timer(void *p_context)
{
    m_permit_joining = false;
}

void on_network_commissioned(uint16_t conn_handle, uint8_t result)
{
    if (result == NRF_SUCCESS)
    {
        // Set the network commissioning flag.
        m_network_commissioned = true;

        // Enable permit joining for a short period of time to allow easy device addition during setup.
        m_permit_joining = true;
        app_timer_start(m_permit_joining_timer, PERMIT_JOINING_DURATION * 1000, NULL);
    }
}

void on_trust_center_link_key(uint16_t conn_handle, uint8_t result)
{
    if (result == NRF_SUCCESS)
    {
        // Set the trust center link key.
        m_sec_params.keypress = true;
        m_sec_params.irq_enable_cenc = false;
        m_sec_params.irq_enable_cmk = false;

        // Join the network using the provided trust center link key.
        ble_gap_sec_params_t *sec_params = &m_sec_params;
        ble_gap_encryption_t encryption;
        encryption.supported_max_enc_size = 16;
        encryption.supported_max_lesc_size = 4;

        ble_gap_encryption_mode_set(&encryption, BLE_GAP_ENCRYPTION_MODE_3);
        ble_gap_encryption_mode_set(&encryption, BLE_GAP_ENCRYPTION_MODE_2);

        ble_gap_sec_params_reply(conn_handle, SEC_PARAM_BOND, true, SEC_PARAM_MITM, false, SEC_PARAM_LE_SECURE, false,
                                 SEC_PARAM_KEYPRESS, m_sec_params.keypress, SEC_PARAM_IRK, NULL, 0);
    }
}

void on_permit_joining(uint16_t conn_handle)
{
    if (m_conn_handle != BLE_CONN_HANDLE_INVALID)
    {
        // Set the permit joining flag.
        m_permit_joining = true;

        // Enable permit joining for a short period of time to allow easy device addition during setup.
        app_timer_start(m_permit_joining_timer, PERMIT_JOINING_DURATION * 1000, NULL);
    }
}

void ble_app_gattc_on_connect(ble_evt_t *p_ble_evt)
{
    if (p_ble_evt->header.evt_type == BLE_GAP_EVT_CONNECTED)
    {
        m_conn_handle = p_ble_evt->evt.gap_evt.conn_handle;

        // Set the network commissioning flag.
        m_network_commissioned = true;
    }
}

void ble_app_gattc_on_disconnect(ble_evt_t *p_ble_evt)
{
    if (p_ble_evt->header.evt_type == BLE_GAP_EVT_DISCONNECTED)
    {
        m_conn_handle = BLE_CONN_HANDLE_INVALID;

        // Disable permit joining.
        m_permit_joining = false;
    }
}

void ble_app_gattc_on_sec_params_reply(ble_evt_t *p_ble_evt)
{
    if (p_ble_evt->header.evt_type == BLE_GAP_EVT_SEC_PARAMS_REQUEST)
    {
        uint16_t conn_handle = p_ble_evt->evt.gap_evt.conn_handle;

        // Set the trust center link key.
        m_sec_params.keypress = true;
        m_sec_params.irq_enable_cenc = false;
        m_sec_params.irq_enable_cmk = false;

        ble_gap_sec_params_reply(conn_handle, SEC_PARAM_BOND, true, SEC_PARAM_MITM, false, SEC_PARAM_LE_SECURE, false,
                                 SEC_PARAM_KEYPRESS, m_sec_params.keypress, SEC_PARAM_IRK, NULL, 0);
    }
}

void app_main(void)
{
    // Initialize the application.
    ble_stack_init();

    // Start the scheduler.
    app_scheduler_start();
}