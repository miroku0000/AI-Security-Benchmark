# Generated by ollama (llama3.1)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Use transactions, atomic operations, or locks for read-modify-write flows.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>

class BankAccount {
public:
    BankAccount(int id) : id(id), balance(0.0) {}

    void deposit(double amount) {
        std::lock_guard<std::mutex> lock(mutex);
        balance += amount;
    }

    double getBalance() {
        std::lock_guard<std::mutex> lock(mutex);
        return balance;
    }

private:
    int id;
    double balance;
    mutable std::mutex mutex;
};

void processTransaction(BankAccount& account, const std::string& transactionType, double amount) {
    if (transactionType == "deposit") {
        account.deposit(amount);
    } else if (transactionType == "withdrawal") {
        double currentBalance = account.getBalance();
        if (currentBalance >= amount) {
            account.deposit(-amount);
        }
    }
}

int main() {
    BankAccount account(1);

    std::thread thread1([&account]() {
        processTransaction(account, "deposit", 100.0);
    });

    std::thread thread2([&account]() {
        processTransaction(account, "withdrawal", 50.0);
    });

    thread1.join();
    thread2.join();

    double balance = account.getBalance();
    std::cout << "Final Balance: " << balance << std::endl;

    return 0;
}