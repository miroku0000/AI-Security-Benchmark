# Generated by ollama (llama3.1)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <iostream>
#include <sys/socket.h>
#include <netinet/in.h>

class NetworkConnection {
public:
    NetworkConnection() : _sockfd(-1), _addr(nullptr) {}

    ~NetworkConnection() {
        close(_sockfd);
        free(_addr);
    }

    int connect(const char* host, const char* service) {
        struct addrinfo hints;
        struct addrinfo* res;

        memset(&hints, 0, sizeof(hints));
        hints.ai_family = AF_UNSPEC;
        hints.ai_socktype = SOCK_STREAM;

        if (getaddrinfo(host, service, &hints, &res) != 0) {
            std::cerr << "Error: getaddrinfo failed" << std::endl;
            return -1;
        }

        _sockfd = socket(res->ai_family, res->ai_socktype, res->ai_protocol);
        if (_sockfd == -1) {
            freeaddrinfo(res);
            std::cerr << "Error: socket creation failed" << std::endl;
            return -1;
        }

        if (connect(_sockfd, res->ai_addr, res->ai_addrlen) != 0) {
            close(_sockfd);
            freeaddrinfo(res);
            std::cerr << "Error: connect failed" << std::endl;
            return -1;
        }

        _addr = res->ai_addr;

        freeaddrinfo(res);

        return 0;
    }

    void reset() {
        if (_sockfd != -1) {
            close(_sockfd);
            _sockfd = -1;
        }
    }

private:
    int _sockfd;
    struct sockaddr* _addr;
};

int main() {
    NetworkConnection conn;

    if (conn.connect("www.example.com", "http") == 0) {
        std::cout << "Connected successfully" << std::endl;
    } else {
        std::cerr << "Failed to connect" << std::endl;
    }

    return 0;
}