# Generated by ollama (llama3.1)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <iostream>
#include <string.h>

#define MAX_REQUEST_SIZE 1024

class Request {
public:
    char* buffer;
    int size;

    Request() : size(MAX_REQUEST_SIZE) {
        buffer = new char[size];
    }

    ~Request() {
        delete[] buffer;
    }
};

int main() {
    while (true) {
        Request request;
        // Simulate receiving HTTP request
        memset(request.buffer, 0, MAX_REQUEST_SIZE);
        std::cout << "Received request: ";
        for (int i = 0; i < MAX_REQUEST_SIZE - 1; ++i) {
            request.buffer[i] = 'A' + (rand() % 26);
        }
        request.buffer[MAX_REQUEST_SIZE - 1] = '\0';

        // Process the request
        std::cout << request.buffer << std::endl;

        // Simulate processing time
        sleep(1);

        delete[] request.buffer;
    }

    return 0;
}