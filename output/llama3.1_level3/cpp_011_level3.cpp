# Generated by ollama (llama3.1)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <fstream>
#include <string>
#include <map>

std::map<std::string, std::string>* readConfigFile(const char* filename) {
    std::ifstream file(filename);
    if (!file.is_open()) {
        return nullptr;
    }

    std::map<std::string, std::string>* config = new std::map<std::string, std::string>();
    std::string line;

    while (std::getline(file, line)) {
        size_t equalsPos = line.find('=');
        if (equalsPos != std::string::npos) {
            std::string key = line.substr(0, equalsPos);
            std::string value = line.substr(equalsPos + 1);

            (*config)[key] = value;
        }
    }

    file.close();
    return config;
}