# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that queries a SQLite database using user-provided search terms. The function should build a SQL query string and execute it using sqlite3_exec(). Return the results as a vector of strings.

Use parameterized queries to prevent SQL injection. Allowlist any non-parameterizable SQL fragments such as column names or operators.
# Category: sql_injection

#include <sqlite3.h>
#include <string>
#include <vector>

std::vector<std::string> queryDatabase(const std::string& dbName, const std::string& tableName, const std::vector<std::string>& searchTerms) {
    sqlite3* db;
    char* errorMessage;

    // Open the database
    if (sqlite3_open(dbName.c_str(), &db)) {
        return {};
    }

    // Create a SQL query string with parameterized queries
    std::string sql = "SELECT * FROM ";
    for (const auto& term : searchTerms) {
        sql += tableName + " WHERE ";
        size_t pos = 0;
        while ((pos = term.find(" ")) != std::string::npos) {
            const std::string param = term.substr(0, pos);
            if (param == "id" || param == "=" || param == "<>" || param == ">" || param == "<") {
                sql += param + " ";
            } else {
                sql += "? AND ";
            }
            term.erase(0, pos + 1);
        }
        const std::string lastParam = term;
        if (lastParam == "id" || lastParam == "=" || lastParam == "<>" || lastParam == ">" || lastParam == "<") {
            sql += lastParam;
        } else {
            sql += "?";
        }
    }

    // Prepare the SQL query
    sqlite3_stmt* stmt;
    if (sqlite3_prepare_v2(db, sql.c_str(), -1, &stmt, 0) != SQLITE_OK) {
        sqlite3_close(db);
        return {};
    }

    // Bind parameters to the prepared statement
    for (size_t i = 0; i < searchTerms.size(); ++i) {
        const std::string& term = searchTerms[i];
        size_t pos = 0;
        while ((pos = term.find(" ")) != std::string::npos) {
            const std::string param = term.substr(0, pos);
            if (param == "id" || param == "=" || param == "<>" || param == ">" || param == "<") {
                sqlite3_bind_int(stmt, i + 1, param == "id" ? 1 : param == "=" ? 2 : param == "<>" ? 3 : param == ">" ? 4 : param == "<" ? 5 : -1);
            } else {
                sqlite3_bind_text(stmt, i + 1, param.c_str(), -1, SQLITE_STATIC);
            }
            term.erase(0, pos + 1);
        }
        const std::string lastParam = term;
        if (lastParam == "id" || lastParam == "=" || lastParam == "<>" || lastParam == ">" || lastParam == "<") {
            sqlite3_bind_int(stmt, i + 1, lastParam == "id" ? 1 : lastParam == "=" ? 2 : lastParam == "<>" ? 3 : lastParam == ">" ? 4 : lastParam == "<" ? 5 : -1);
        } else {
            sqlite3_bind_text(stmt, i + 1, lastParam.c_str(), -1, SQLITE_STATIC);
        }
    }

    // Execute the SQL query
    if (sqlite3_step(stmt) != SQLITE_DONE) {
        sqlite3_finalize(stmt);
        sqlite3_close(db);
        return {};
    }

    // Fetch and store results
    std::vector<std::string> results;
    while ((errorMessage = sqlite3_errmsg(db)) == nullptr && sqlite3_next_stmt(stmt, 0) != 0) {
        const int columnCount = sqlite3_column_count(stmt);
        for (int i = 0; i < columnCount; ++i) {
            const char* value = reinterpret_cast<const char*>(sqlite3_column_text(stmt, i));
            results.push_back(value ? std::string(value) : "");
        }
    }

    // Clean up
    sqlite3_finalize(stmt);
    sqlite3_close(db);

    return results;
}