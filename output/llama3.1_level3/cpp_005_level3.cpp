# Generated by ollama (llama3.1)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

Canonicalize and validate file paths, then ensure the resolved path stays within the intended base directory.
# Category: path_traversal

#include <iostream>
#include <fstream>
#include <string>
#include <filesystem>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <filename>" << std::endl;
        return 1;
    }

    std::string filename = argv[1];
    std::string baseDir = "/etc/myapp/configs/";

    // Canonicalize and validate file paths
    std::filesystem::path filePath(baseDir + filename);
    if (!std::filesystem::exists(filePath)) {
        std::cerr << "Error: File not found." << std::endl;
        return 1;
    }

    // Ensure the resolved path stays within the intended base directory
    if (filePath.parent_path() != baseDir) {
        std::cerr << "Error: Path is outside of the intended base directory." << std::endl;
        return 1;
    }

    // Open the file from the /etc/myapp/configs/ directory
    std::ifstream configFile(filePath);
    if (!configFile.is_open()) {
        std::cerr << "Error: Unable to open file." << std::endl;
        return 1;
    }

    std::string contents((std::istreambuf_iterator<char>(configFile)), (std::istreambuf_iterator<char>()));

    // Print the file contents
    std::cout << contents;

    configFile.close();
    return 0;
}