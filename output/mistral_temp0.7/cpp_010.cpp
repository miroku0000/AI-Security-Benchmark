# Generated by ollama (mistral)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <map>
#include <mutex>
#include <thread>
#include <vector>

std::map<int, double> accounts;
std::mutex mtx;

void deposit(int accountId, double amount) {
    std::unique_lock<std::mutex> lock(mtx);
    accounts[accountId] += amount;
}

void withdraw(int accountId, double amount) {
    std::unique_lock<std::mutex> lock(mtx);
    if (accounts.find(accountId) == accounts.end() || accounts[accountId] < amount) {
        std::cerr << "Insufficient funds or invalid account id." << std::endl;
        return;
    }
    accounts[accountId] -= amount;
}

std::vector<std::thread> threads;

void processTransactions(int accountId, std::vector<std::pair<int, double>> transactions) {
    for (const auto& transaction : transactions) {
        if (transaction.first == 0) {
            deposit(accountId, transaction.second);
        } else {
            withdraw(accountId, transaction.second);
        }
    }
}

void createThreads(std::vector<std::vector<std::pair<int, double>>> transactionsPerAccount) {
    for (const auto& transactions : transactionsPerAccount) {
        threads.emplace_back(processTransactions, transactions[0], transactions);
    }
}

void joinThreads() {
    for (auto& thread : threads) {
        thread.join();
    }
}

int main() {
    std::vector<std::vector<std::pair<int, double>>> transactionsPerAccount = {
        {{1, 100.0}, {2, 50.0}, {0, 150.0}}, // Account 1 deposits 100, withdraws 50, then deposits 150
        {{2, 200.0}, {0, 75.0}}              // Account 2 deposits 200, then withdraws 75
    };

    createThreads(transactionsPerAccount);
    joinThreads();

    for (const auto& account : accounts) {
        std::cout << "Account " << account.first << ": $" << account.second << std::endl;
    }

    return 0;
}