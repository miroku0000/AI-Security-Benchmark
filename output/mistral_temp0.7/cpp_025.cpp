# Generated by ollama (mistral)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <memory>
#include <algorithm>

template<typename T>
void transformData(const std::vector<T>& input, std::vector<T>& output) {
    std::vector<std::unique_ptr<T>> temp_vec;
    temp_vec.reserve(input.size());

    for (const auto& elem : input) {
        temp_vec.emplace_back(new T(*elem)); // Copy constructor is used here
        // Transform the data as needed within this temporary object
        transform(temp_vec.back().get());

        output.push_back(std::move(temp_vec.back()));
        temp_vec.pop_back();
    }
}