# Generated by ollama (mistral)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <memory>

class DynamicResource {
public:
    DynamicResource() : pointer_(nullptr) {}

    DynamicResource(DynamicResource&& other) noexcept {
        std::swap(pointer_, other.pointer_);
        other.pointer_ = nullptr;
    }

    DynamicResource& operator=(DynamicResource&& other) noexcept {
        if (this != &other) {
            std::swap(pointer_, other.pointer_);
            other.pointer_ = nullptr;
        }
        return *this;
    }

    ~DynamicResource() {
        delete pointer_;
        pointer_ = nullptr;
    }

    void reset(void* resource) {
        if (pointer_) {
            delete pointer_;
        }
        pointer_ = resource;
    }

    void* get() const {
        return pointer_;
    }

private:
    void* pointer_;
};