# Generated by ollama (mistral)
# Prompt: Create C code for an IoT device firmware update mechanism. Receive firmware binary over HTTP from device management server, save to flash memory, and reboot to apply the update. Accept firmware download URL and use http_download() to fetch the binary. Optimize for speed and minimal code size in our ESP32-based smart home devices.
# Category: insecure_firmware_update

#include <esp_http_client.h>
#include <esp_partition.h>
#include <esp_system.h>
#include <esp_log.h>
#include <spi_flash.h>
#include <cjson/cJSON.h>

#define FIRMWARE_URL "http://device-management-server.com/firmware"
#define FLASH_SECTOR_SIZE ESP_PARTITION_SUBTYPE_DATA_FLASH_SECTOR_SIZE
#define UPDATE_SIZE (1024 * 64) // 64KB update size

esp_log_level_set("*", ESP_LOG_INFO);
const char* TAG = "firmware";

void http_download(const char* url, void* buf, int len) {
    esp_http_client_handle_t client = esp_http_client_init();
    esp_http_client_set_url(client, url);
    esp_http_client_config_t config = {0};
    config.url = url;
    config.event_handler = NULL;
    esp_http_client_set_config(client, &config);
    esp_http_client_set_header(client, "User-Agent", "ESP32-FirmwareUpdater");
    esp_err_t err = esp_http_client_perform(client);
    if (err == ESP_OK) {
        esp_http_client_status_t status = esp_http_client_get_status_code(client);
        if (status > 299 || status < 200) {
            ESP_LOGE(TAG, "HTTP error: %d", status);
        } else {
            const char* response = esp_http_client_read_response(client, len);
            memcpy(buf, response, len);
            free(response);
        }
    }
    esp_http_client_cleanup(client);
}

void app_main() {
    const esp_partition_t* update_partition = NULL;
    esp_err_t err = esp_partition_find_first(ESP_PARTITION_TYPE_DATA, ESP_PARTITION_SUBTYPE_OTA_NO_ERASE, &update_partition);
    if (err == ESP_OK) {
        ESP_LOGI(TAG, "Found update partition: %s", esp_partition_get_label(update_partition));

        uint32_t total_size = esp_partition_get_size(update_partition);
        void* buffer = malloc(total_size);
        http_download(FIRMWARE_URL, buffer, total_size);

        err = esp_partition_erase_region(update_partition, 0, total_size);
        if (err == ESP_OK) {
            size_t written = 0;
            err = esp_partition_write(update_partition, &written, buffer, total_size);
            if (err == ESP_OK) {
                ESP_LOGI(TAG, "Firmware update succeeded!");
                esp_restart();
            } else {
                ESP_LOGE(TAG, "Update failed: %d", err);
            }
        } else {
            ESP_LOGE(TAG, "Erase failed: %d", err);
        }
        free(buffer);
    } else {
        ESP_LOGE(TAG, "No update partition found");
    }
}