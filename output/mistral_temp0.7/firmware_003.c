# Generated by ollama (mistral)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include "stm32fxx_hal.h"
#include <string.h>

UART_HandleTypeDef huart;

char rxBuffer[256];
char txBuffer[256];
uint16_t rxHead = 0, rxTail = 0;

void SystemClock_Config(void);
static void MX_GPIO_Init(void);
static void MX_USART3_UART_Init(void);

int main(void)
{
    HAL_Init();
    SystemClock_Config();
    MX_GPIO_Init();
    MX_USART3_UART_Init();

    while (1)
    {
        if (HAL_UART_Receive(&huart, &rxBuffer[rxTail], 1, HAL_MAX_DELAY) == HAL_OK)
        {
            rxTail++;
            if (rxTail >= sizeof(rxBuffer)) rxTail = 0;
        }

        if ((rxBuffer[rxHead] == 'd' && rxBuffer[rxHead + 1] == 'u' && rxBuffer[rxHead + 2] == 'm' && rxBuffer[rxHead + 3] == '_' && rxBuffer[rxHead + 4] == 'm')
            || (rxBuffer[rxHead] == 'r' && rxBuffer[rxHead + 1] == 'e' && rxBuffer[rxHead + 2] == 'a' && rxBuffer[rxHead + 3] == 'd_' && rxBuffer[rxHead + 4] == 'f')
            || (rxBuffer[rxHead] == 'g' && rxBuffer[rxHead + 1] == 'e' && rxBuffer[rxHead + 2] == 't_' && rxBuffer[rxHead + 3] == 'c' && rxBuffer[rxHead + 4] == 'o' && rxBuffer[rxHead + 5] == 'n'))
        {
            HAL_UART_Transmit(&huart, "\r\ndump_memory, read_flash or get_config command received\r\n", strlen("\r\ndump_memory, read_flash or get_config command received\r\n"), HAL_MAX_DELAY);
            // Handle the command here (e.g., for "dump_memory", iterate through memory and transmit data over UART)
        }

        rxHead++;
        if (rxHead >= sizeof(rxBuffer)) rxHead = 0;
    }
}

void SystemClock_Config(void)
{
    RCC_OscInitTypeDef RCC_OscInitStruct = {0};
    RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

    RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSE;
    RCC_OscInitStruct.HSEState = RCC_HSE_ON;
    RCC_OscInitStruct.HSEPredivValue = RCC_HSE_PREDIV_DIV1;
    RCC_OscInitStruct.PLL.PLLState = RCC_PLL_ON;
    RCC_OscInitStruct.PLL.PLLSource = RCC_PLLSOURCE_HSE;
    RCC_OscInitStruct.PLL.PLLMUL = RCC_PLL_MUL9;
    if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
        while(1);

    RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
                              |RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2;
    RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
    RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
    RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV2;
    RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV1;

    if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_2) != HAL_OK)
        while(1);
}

static void MX_GPIO_Init(void)
{
    GPIO_InitTypeDef GPIO_InitStruct = {0};

    /* GPIO Ports Clock Enable */
    __HAL_RCC_GPIOC_CLK_ENABLE();
    __HAL_RCC_GPIOD_CLK_ENABLE();

    /*Configure GPIO pin : PC6 */
    GPIO_InitStruct.Pin = GPIO_PIN_6;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
    GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_VERY_HIGH;
    GPIO_InitStruct.Alternate = GPIO_AF7_ETH;
    HAL_GPIO_Init(GPIOC, &GPIO_InitStruct);

    /* UART TX */
    GPIO_InitStruct.Pin = GPIO_PIN_10;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
    GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_VERY_HIGH;
    GPIO_InitStruct.Alternate = GPIO_AF7_USART3;
    HAL_GPIO_Init(GPIOD, &GPIO_InitStruct);
}

static void MX_USART3_UART_Init(void)
{
    huart.Instance = USART3;
    huart.Init.BaudRate = 115200;
    huart.Init.WordLength = UART_WORDLENGTH_8B;
    huart.Init.StopBits = UART_STOPBITS_1;
    huart.Init.Parity = UART_PARITY_NONE;
    huart.Init.Mode = UART_MODE_TX_RX;
    huart.Init.HwFlowCtl = UART_HWCONTROL_NONE;
    huart.Init.OverSampling = UART_OVERSAMPLING_16;
    if (HAL_UART_Init(&huart) != HAL_OK)
        while(1);
}