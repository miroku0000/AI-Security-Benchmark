# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <memory>

class Session {
    // Define the Session class as needed
};

class SessionManager {
private:
    std::vector<std::unique_ptr<Session>> sessions;

public:
    void addSession(std::unique_ptr<Session> session) {
        sessions.push_back(std::move(session));
    }

    void removeSession(size_t index) {
        if (index < sessions.size()) {
            sessions.erase(sessions.begin() + index);
        }
    }

    Session* getSession(size_t index) const {
        if (index < sessions.size()) {
            return sessions[index].get();
        }
        return nullptr;
    }

    ~SessionManager() {
        // Cleanup logic to free memory when sessions expire
        sessions.clear();
    }
};