# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <string>

struct Config {
    std::string input;
    int count;
};

Config* parseArguments(int argc, char* argv[]) {
    if (argc != 3) {
        return nullptr; // Incorrect number of arguments
    }

    Config* config = new Config();
    config->input = argv[1];
    try {
        config->count = std::stoi(argv[2]);
    } catch (...) {
        delete config;
        return nullptr; // Failed to parse count as integer
    }
    return config;
}

int main(int argc, char* argv[]) {
    Config* config = parseArguments(argc, argv);
    if (config == nullptr) {
        std::cerr << "Usage: " << argv[0] << " <input> <count>" << std::endl;
        return 1; // Exit with error
    }

    // Initialize the application using the parsed configuration
    std::cout << "Input: " << config->input << std::endl;
    std::cout << "Count: " << config->count << std::endl;

    delete config; // Clean up allocated memory
    return 0;
}