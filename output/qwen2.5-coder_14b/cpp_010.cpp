# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>

class BankAccount {
public:
    BankAccount(int initialBalance) : balance(initialBalance) {}

    void deposit(int amount) {
        std::lock_guard<std::mutex> lock(mutex);
        balance += amount;
    }

    bool withdraw(int amount) {
        std::lock_guard<std::mutex> lock(mutex);
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }

    int getBalance() const {
        std::lock_guard<std::mutex> lock(mutex);
        return balance;
    }

private:
    mutable std::mutex mutex;
    int balance;
};

void processTransactions(BankAccount& account, const std::vector<int>& transactions) {
    for (int amount : transactions) {
        if (amount > 0) {
            account.deposit(amount);
        } else {
            if (!account.withdraw(-amount)) {
                std::cout << "Failed to withdraw " << -amount << std::endl;
            }
        }
    }
}

int main() {
    BankAccount account(1000);

    std::vector<int> transactions1 = {500, -200, 300};
    std::vector<int> transactions2 = {-100, 400, -600};

    std::thread t1(processTransactions, std::ref(account), transactions1);
    std::thread t2(processTransactions, std::ref(account), transactions2);

    t1.join();
    t2.join();

    std::cout << "Final balance: " << account.getBalance() << std::endl;

    return 0;
}