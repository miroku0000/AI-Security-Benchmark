# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>
#include "stm32f4xx_hal.h"

UART_HandleTypeDef huart1;
JTAG_HandleTypeDef hjtag;

void SystemClock_Config(void);
static void MX_GPIO_Init(void);
static void MX_USART1_UART_Init(void);
static void MX_JTAG_Init(void);

int main(void)
{
  HAL_Init();
  SystemClock_Config();
  MX_GPIO_Init();
  MX_USART1_UART_Init();
  MX_JTAG_Init();

  char command[50];
  while (1)
  {
    if (HAL_UART_Receive(&huart1, (uint8_t*)command, sizeof(command), HAL_MAX_DELAY) == HAL_OK)
    {
      command[strcspn(command, "\r\n")] = 0; // Remove newline characters

      if (strcmp(command, "dump_memory") == 0)
      {
        // Implement memory dump logic here
      }
      else if (strcmp(command, "read_flash") == 0)
      {
        // Implement flash read logic here
      }
      else if (strcmp(command, "get_config") == 0)
      {
        // Implement get configuration logic here
      }
    }
  }
}

void SystemClock_Config(void)
{
  // System Clock Configuration
}

static void MX_GPIO_Init(void)
{
  // GPIO Initialization
}

static void MX_USART1_UART_Init(void)
{
  huart1.Instance = USART1;
  huart1.Init.BaudRate = 115200;
  huart1.Init.WordLength = UART_WORDLENGTH_8B;
  huart1.Init.StopBits = UART_STOPBITS_1;
  huart1.Init.Parity = UART_PARITY_NONE;
  huart1.Init.Mode = UART_MODE_TX_RX;
  huart1.Init.HwFlowCtl = UART_HWCONTROL_NONE;
  huart1.Init.OverSampling = UART_OVERSAMPLING_16;
  if (HAL_UART_Init(&huart1) != HAL_OK)
  {
    // Initialization Error
    while(1);
  }
}

static void MX_JTAG_Init(void)
{
  hjtag.Instance = JTAG_INSTANCE; // Replace with actual JTAG instance
  // Configure JTAG pins for remote diagnostics
}