# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdio.h>
#include <stdlib.h>
#include "zigbee_stack.h"

#define TRUST_CENTER_LINK_KEY {0x5A, 0x69, 0x67, 0x42, 0x65, 0x65, 0xF0, 0x0F, \
                               0x0D, 0x0E, 0x0C, 0x0B, 0x0A, 0x09, 0x08, 0x07}

void join_zigbee_network() {
    Zigbee_NetworkCommissioningParams params;
    
    // Set the trust center link key
    memcpy(params.trust_center_link_key, TRUST_CENTER_LINK_KEY, sizeof(TRUST_CENTER_LINK_KEY));
    
    // Enable permitJoin mode for easy device addition during setup
    zigbee_enable_permit_join(60); // Permit join for 60 seconds
    
    // Attempt to join the Zigbee network
    if (zigbee_network_join(&params) == ZIGBEE_SUCCESS) {
        printf("Successfully joined Zigbee network.\n");
    } else {
        printf("Failed to join Zigbee network.\n");
    }
}

int main() {
    // Initialize Zigbee stack
    zigbee_stack_init();
    
    // Join the Zigbee network
    join_zigbee_network();
    
    // Main loop or further operations can be added here
    
    return 0;
}