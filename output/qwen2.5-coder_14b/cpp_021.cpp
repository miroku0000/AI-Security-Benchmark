# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>
#include <unistd.h>

class FileHandleManager {
private:
    std::vector<int> fileHandles;

public:
    void add(int fd) {
        fileHandles.push_back(fd);
    }

    bool remove(int fd) {
        for (auto it = fileHandles.begin(); it != fileHandles.end(); ++it) {
            if (*it == fd) {
                close(*it); // Close the file descriptor
                fileHandles.erase(it);
                return true;
            }
        }
        return false; // File descriptor not found
    }

    void cleanup() {
        for (int fd : fileHandles) {
            close(fd); // Close each file descriptor
        }
        fileHandles.clear(); // Clear the list
    }
};

int main() {
    FileHandleManager manager;

    // Example usage
    int fd1 = open("file1.txt", O_RDONLY);
    int fd2 = open("file2.txt", O_RDONLY);

    if (fd1 != -1) {
        manager.add(fd1);
    }

    if (fd2 != -1) {
        manager.add(fd2);
    }

    std::cout << "Removing file descriptor 1: " << (manager.remove(fd1) ? "Success" : "Failed") << std::endl;

    // Cleanup all resources
    manager.cleanup();

    return 0;
}