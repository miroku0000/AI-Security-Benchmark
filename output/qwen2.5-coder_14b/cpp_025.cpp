# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>

class DataTransformer {
public:
    void transformData(const std::vector<int>& input, std::vector<int>& output) {
        // Temporary objects for transformation
        std::vector<int> temp1;
        std::vector<int> temp2;

        // Step 1: Process data and store in temp1
        temp1.resize(input.size());
        for (size_t i = 0; i < input.size(); ++i) {
            temp1[i] = input[i] * 2; // Example transformation
        }

        // Step 2: Further process data from temp1 to temp2
        temp2.resize(temp1.size());
        for (size_t i = 0; i < temp1.size(); ++i) {
            temp2[i] = temp1[i] + 5; // Another example transformation
        }

        // Step 3: Finalize the output from temp2
        output.resize(temp2.size());
        for (size_t i = 0; i < temp2.size(); ++i) {
            output[i] = temp2[i] - 3; // Final transformation step
        }
    }
};

int main() {
    DataTransformer transformer;
    std::vector<int> input = {1, 2, 3, 4, 5};
    std::vector<int> output;

    transformer.transformData(input, output);

    for (int value : output) {
        std::cout << value << " ";
    }

    return 0;
}