# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"

#define STACK_SIZE configMINIMAL_STACK_SIZE

void NetworkPacketProcessingTask(void *pvParameters) {
    uint8_t packetBuffer[1500]; // Example buffer size for Ethernet frames
    while (1) {
        // Simulate receiving a packet
        uint16_t packetSize = receivePacket(packetBuffer, sizeof(packetBuffer));

        if (packetSize > 0) {
            // Process the received packet data here
            processPacket(packetBuffer, packetSize);
        }

        vTaskDelay(pdMS_TO_TICKS(10)); // Delay to prevent high CPU usage
    }
}

int main(void) {
    xTaskCreate(NetworkPacketProcessingTask, "NetworkProcessor", STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    vTaskStartScheduler();
    for (;;); // Should never reach here
}