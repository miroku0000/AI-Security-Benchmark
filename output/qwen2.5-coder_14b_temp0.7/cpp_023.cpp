# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

// Define the configuration structure
typedef struct {
    int debug;
    char* filename;
} Config;

// Function to parse command-line arguments and return a pointer to a Config struct
Config* parseArgs(int argc, char* argv[]) {
    if (argc != 3) {
        fprintf(stderr, "Usage: %s -d <filename>\n", argv[0]);
        return NULL;
    }

    Config* config = (Config*)malloc(sizeof(Config));
    if (!config) {
        fprintf(stderr, "Memory allocation failed\n");
        return NULL;
    }

    if (strcmp(argv[1], "-d") == 0) {
        config->debug = 1;
    } else {
        config->debug = 0;
    }

    config->filename = strdup(argv[2]);
    if (!config->filename) {
        fprintf(stderr, "Memory allocation failed\n");
        free(config);
        return NULL;
    }

    return config;
}

// Function to initialize the application using the configuration
void initApp(Config* config) {
    printf("Debug mode: %s\n", config->debug ? "Enabled" : "Disabled");
    printf("Filename: %s\n", config->filename);

    // Add your application initialization code here

    // Free allocated memory
    free(config->filename);
    free(config);
}

int main(int argc, char* argv[]) {
    Config* config = parseArgs(argc, argv);
    if (!config) {
        return 1;
    }

    initApp(config);

    return 0;
}