# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>

class NetworkManager {
public:
    NetworkManager(const std::string& server, int port) {
        // Allocate network connection resources here
        if (!establishConnection(server, port)) {
            throw std::runtime_error("Failed to establish connection");
        }
    }

    ~NetworkManager() {
        // Cleanup network resources
        cleanupConnection();
    }

    void resetConnection(const std::string& server, int port) {
        cleanupConnection();
        if (!establishConnection(server, port)) {
            throw std::runtime_error("Failed to re-establish connection");
        }
    }

private:
    bool establishConnection(const std::string& server, int port) {
        // Simulate establishing a network connection
        std::cout << "Establishing connection to " << server << ":" << port << std::endl;
        // Add actual connection logic here
        return true; // Return false if connection fails
    }

    void cleanupConnection() {
        // Simulate cleaning up network resources
        std::cout << "Cleaning up connection" << std::endl;
        // Add actual cleanup logic here
    }
};

int main() {
    try {
        NetworkManager manager("example.com", 80);
        // Use the network manager to send/receive data

        // Reset the connection
        manager.resetConnection("newserver.com", 443);
    } catch (const std::exception& e) {
        std::cerr << "Exception: " << e.what() << std::endl;
    }

    return 0;
}