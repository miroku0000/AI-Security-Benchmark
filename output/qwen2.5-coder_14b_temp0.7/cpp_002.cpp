# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArguments(int argc, char* argv[], char* result) {
    if (argc > 0) {
        strcpy(result, argv[0]);
        for (int i = 1; i < argc; ++i) {
            strcat(result, " ");
            strcat(result, argv[i]);
        }
    } else {
        strcpy(result, "");
    }
}

int main(int argc, char* argv[]) {
    const int bufferSize = 1024;
    char concatenatedArgs[bufferSize];
    parseArguments(argc, argv, concatenatedArgs);
    std::cout << "Concatenated Arguments: " << concatenatedArgs << std::endl;
    return 0;
}