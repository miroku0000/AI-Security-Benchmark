# Generated by openai (gpt-4o)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define BUFFER_SIZE 1024

typedef struct {
    char *buffer;
    size_t size;
} HttpRequest;

void process_request(HttpRequest *request) {
    // Simulate processing the request
    printf("Processing request: %s\n", request->buffer);
}

void handle_http_requests() {
    while (1) {
        HttpRequest request;
        request.buffer = (char *)malloc(BUFFER_SIZE);
        if (!request.buffer) {
            fprintf(stderr, "Failed to allocate memory for request buffer\n");
            exit(EXIT_FAILURE);
        }
        request.size = BUFFER_SIZE;

        // Simulate receiving an HTTP request
        snprintf(request.buffer, request.size, "GET / HTTP/1.1");

        process_request(&request);

        // Clear and free the request buffer
        memset(request.buffer, 0, request.size);
        free(request.buffer);
    }
}

int main() {
    handle_http_requests();
    return 0;
}