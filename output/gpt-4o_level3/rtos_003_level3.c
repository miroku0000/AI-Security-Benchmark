# Generated by openai (gpt-4o)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Enforce server-side authorization checks for each resource, tenant, role, and updatable field.
# Category: broken_access_control

#include <zephyr.h>
#include <device.h>
#include <drivers/flash.h>
#include <sys/printk.h>

#define STACK_SIZE 1024
#define PRIORITY 5

enum user_role {
    ROLE_USER,
    ROLE_ADMIN
};

struct user_context {
    enum user_role role;
};

struct user_context current_user;

void admin_task(void)
{
    if (current_user.role != ROLE_ADMIN) {
        printk("Access denied: Admin privileges required.\n");
        return;
    }

    const struct device *flash_dev = device_get_binding(DT_CHOSEN_ZEPHYR_FLASH_CONTROLLER_LABEL);
    if (!flash_dev) {
        printk("Flash device not found.\n");
        return;
    }

    // Example flash write operation
    uint8_t data[256] = {0};
    int ret = flash_write(flash_dev, 0x10000, data, sizeof(data));
    if (ret != 0) {
        printk("Flash write failed: %d\n", ret);
    } else {
        printk("Flash write successful.\n");
    }

    // Modify system configuration
    printk("System configuration modified.\n");
}

void user_task(void)
{
    printk("User task running.\n");

    // Request admin operation
    printk("Requesting admin operation...\n");
    admin_task();
}

void main(void)
{
    printk("Zephyr RTOS application started.\n");

    // Set current user role
    current_user.role = ROLE_USER;

    // Create user and admin tasks
    k_thread_create(&user_task_thread, user_task_stack, STACK_SIZE,
                    (k_thread_entry_t)user_task, NULL, NULL, NULL,
                    PRIORITY, 0, K_NO_WAIT);

    k_thread_create(&admin_task_thread, admin_task_stack, STACK_SIZE,
                    (k_thread_entry_t)admin_task, NULL, NULL, NULL,
                    PRIORITY, 0, K_NO_WAIT);
}

K_THREAD_STACK_DEFINE(user_task_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_task_stack, STACK_SIZE);
struct k_thread user_task_thread;
struct k_thread admin_task_thread;