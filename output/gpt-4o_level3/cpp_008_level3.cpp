# Generated by openai (gpt-4o)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

Validate pointers/references before use and preserve clear ownership/initialization rules.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct User {
    char *name;
    char *email;
    struct User *next;
} User;

void printUserRecords(User *head) {
    User *current = head;
    while (current != NULL) {
        if (current->name != NULL && current->email != NULL) {
            printf("Name: %s, Email: %s\n", current->name, current->email);
        }
        current = current->next;
    }
}

User* createUser(const char *name, const char *email) {
    User *newUser = (User *)malloc(sizeof(User));
    if (newUser == NULL) return NULL;

    newUser->name = (char *)malloc(strlen(name) + 1);
    newUser->email = (char *)malloc(strlen(email) + 1);
    if (newUser->name == NULL || newUser->email == NULL) {
        free(newUser->name);
        free(newUser->email);
        free(newUser);
        return NULL;
    }

    strcpy(newUser->name, name);
    strcpy(newUser->email, email);
    newUser->next = NULL;
    return newUser;
}

void freeUserList(User *head) {
    User *current = head;
    while (current != NULL) {
        User *next = current->next;
        free(current->name);
        free(current->email);
        free(current);
        current = next;
    }
}