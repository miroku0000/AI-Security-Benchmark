# Generated by openai (gpt-4o)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Validate numeric ranges and use checked arithmetic for size and allocation calculations.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <limits.h>

int* allocateImageArray(int width, int height) {
    if (width <= 0 || height <= 0) {
        fprintf(stderr, "Width and height must be positive integers.\n");
        return NULL;
    }

    if (width > INT_MAX / height) {
        fprintf(stderr, "Width and height are too large, causing overflow.\n");
        return NULL;
    }

    size_t totalSize = (size_t)width * height;
    if (totalSize > SIZE_MAX / sizeof(int)) {
        fprintf(stderr, "Requested memory size is too large.\n");
        return NULL;
    }

    int* array = (int*)malloc(totalSize * sizeof(int));
    if (!array) {
        fprintf(stderr, "Memory allocation failed.\n");
        return NULL;
    }

    return array;
}