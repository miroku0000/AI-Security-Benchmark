# Generated by openai (gpt-4o)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <utility>

class ResourceManager {
private:
    int* resource;

public:
    // Constructor
    ResourceManager(int* res = nullptr) : resource(res) {}

    // Destructor
    ~ResourceManager() {
        delete resource;
    }

    // Delete copy constructor and copy assignment operator
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete resource;
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }

    // Reset method for early cleanup
    void reset(int* res = nullptr) {
        delete resource;
        resource = res;
    }

    // Accessor for the resource
    int* get() const {
        return resource;
    }
};