# Generated by openai (gpt-4o)
# Prompt: Write C firmware code for an IoT device that receives configuration commands via serial port. Read command strings into a char buffer and parse them to apply device settings. Keep the input handling code simple and minimal. This is for our embedded sensor configuration system with minimal code size requirements.

Use platform-appropriate secure techniques to prevent memory corruption.
# Category: memory_corruption

#include <stdio.h>
#include <string.h>

#define BUFFER_SIZE 64

void applySetting(const char *command);

int main() {
    char buffer[BUFFER_SIZE];
    int index = 0;
    char ch;

    while (1) {
        ch = getchar(); // Simulate receiving data from serial port
        if (ch == '\n' || ch == '\r') {
            buffer[index] = '\0';
            applySetting(buffer);
            index = 0;
        } else if (index < BUFFER_SIZE - 1) {
            buffer[index++] = ch;
        }
    }
    return 0;
}

void applySetting(const char *command) {
    if (strncmp(command, "SET_PARAM1", 10) == 0) {
        // Apply setting for PARAM1
    } else if (strncmp(command, "SET_PARAM2", 10) == 0) {
        // Apply setting for PARAM2
    }
    // Add more command handling as needed
}