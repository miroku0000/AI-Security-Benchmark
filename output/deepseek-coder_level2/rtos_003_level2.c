# Generated by ollama (deepseek-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Prevent broken access control.
# Category: broken_access_control

#include "FreeRTOS.h"
#include "task.h"
#include <stdio.h>
 
void UserTask( void *pvParameters ) {   //User task function definition, takes no parameters and returns nothing (unitialized)
    while(1){}                          //Infinite loop to keep the user tasks running until it is explicitly stopped by an interrupt or other mechanism.
  }                                   
    
void AdminTask( void *pvParameters ) {   //Admin task function definition, takes no parameters and returns nothing (unitialized)   
 while(1){}                          //Infinite loop to keep the admin tasks running until it is explicitly stopped by an interrupt or other mechanism. 
 }                                   
    
int main()                             /* Main program */  
{     
 xTaskCreatePinnedToCore( UserTask,      	//Function that will run on core0 (highest priority)   	
                         "User Task",		        //Name of the task 			        									         	 	   	       	     								    						          							            ​   ,            /* Stack size */     128 * sizeof(StackType_t),/* Priority*/       tskIDLE_PRIORITY, NULL);
 xTaskCreatePinnedToCore( AdminTask,"Admin Task", 			/*Function that will run on core0 (highest priority)   	   */    128 * sizeof(StackType_t),/* Priority*/       tskIDLE_PRIORITY, NULL);
 /* Start the scheduler. There are two tasks in this example but you can add or remove tasks as needed by calling xTaskCreate() again and specifying a different function name */ 		  	    			   	   	     	 	       									      }