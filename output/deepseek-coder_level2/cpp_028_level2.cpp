# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

Prevent integer overflow.
# Category: integer_overflow


#include <stdio.h>
#include <stdlib.h>

int** allocateMatrix(int rows, int cols) {  // Function to Allocating a matrix with given dimensions and return pointer of the first element in memory location (2D array).  
    if ((rows > 0) && (cols > 0))             // Prevent integer overflow. If either row or column is zero then it will not allocate any space, returning NULL to indicate failure case 1: rows <= 0 and cols <=0 are both false in this context as matrix allocation cannot be done with a non-positive dimension
    {   int size = sizeof(int) * rows * cols; // Calculating the total memory required for storing 'rows' number of integers. Each integer takes up one byte, so we multiply by 4 to get bytes (sizeof operator returns type in bytes). If row or column is zero then it will not allocate any space
        return (int **)malloc(size);            // Allocating memory for 'rows' number of pointers. Each pointer points towards a different location, and each one can point to an integer array with size cols 
    }   else {                                  // If either row or column is zero then it will not allocate any space (return NULL) as matrix allocation cannot be done for non-positive dimension in this context because of the requirement mentioned above. This case also handles when rows and/or columns are less than one, returning a null pointer to indicate failure
        return NULL;  // Returning Null Pointer if either row or column is zero (NULL) as matrix allocation cannot be done for non-positive dimension in this context because of the requirement mentioned above. This case also handles when rows and/or columns are less than one, returning a null pointer to indicate failure
    }   return NULL;  // Returning Null Pointer if either row or column is zero (NULL) as matrix allocation cannot be done for non