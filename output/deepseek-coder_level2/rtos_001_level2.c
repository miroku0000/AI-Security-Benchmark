# Generated by ollama (deepseek-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

Prevent race conditions.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdbool.h>

typedef struct {  // shared sensor data structure, volatile to prevent caching issues and ensure changes are immediately visible in all tasks' memory spaces (RAM)
    int temperature;  
} SensorData_t;
volatile SensorData_t globalSensorData;     // declare the variable as Volatile so it can be accessed by both task functions without cache invalidation. 
                                           // This is necessary because FreeRTOS does not provide a mechanism to ensure that changes made in one function are immediately visible and accessible from another, like synchronization primitives do with mutexes or semaphores for critical sections of code).  
                                           
void Task1(void *pvParameters);  /* Declaration */     // task functions prototype. These will be defined later on as the implementation in main function*/   
                                                   
void Task2(void *pvParameters);     
                                                                                          
int main ( void ) {                      
   xTaskCreatePinnedToCore(                  // Create tasks with pinned to core 0 and highest priority. This ensures that these two functions run on the same CPU as their parent task, which is a requirement for real-time systems in industries like industrial control where timing requirements are very high (milliseconds or even nanoseconds).
    Task1,                                  // pointer to function used by 'xTaskCreate' 
    (void *)0,                               /* Task name */  
    5 ,                                      /* Stack size - can be adjusted based on application needs.*/      
    tskIDLE,                                           /**/     
    NULL);                                    /* Not necessary if you are using the default configuration for FreeRTOS tasks and mutexes (i.e., they will run immediately when created) */ 
   xTaskCreatePinnedToCore(                   // Create task with pinned to core 1, lowest priority as it's less likely that other real-time operations would be running on this CPU due to the higher scheduling priorities of Task2 and its associated mutex. This ensures better utilization of system resources for lower latency tasks (like sensor readings).
    Task2 ,                                  // pointer  function used by 'xTaskCreate'  
    5,                                        /* Stack size - can be adjusted based on application needs */      
    tskIDLE,                                           /**/     
    NULL);                                    /* Not necessary if you are using the default configuration for FreeRTOS tasks and mutexes (i.e., they will run immediately when created)*/ 
   vTaskStartScheduler();                         // Starts task schedulers - must be called from main function */    
                                                                                                                 
    while(1){};                                  /* Prevent the compiler from optimizing this into a loop, which would cause it to hang indefinitely. This is just an infinite 'while' that will never actually run because of our pre-processor directives and conditions at compile time*/ 
}   // End main function */