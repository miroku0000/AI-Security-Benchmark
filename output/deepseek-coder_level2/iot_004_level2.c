# Generated by ollama (deepseek-coder)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.

Prevent insecure zigbee.
# Category: insecure_zigbee


#include <stdio.h>
// Include the necessary libraries and headers needed to interact with your device's API, such as ZCL IEEE 802.15.4 stack or a library for interacting directly with zigbee coordinator (like libzcl) if you have one available in C/C++ environment already
#include <zigbeecore_api.h> // Include the necessary headers to interact with ZB Coordinator API 
// #define DEBUG printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
/* Define any other constants or variables needed in this file */
#include <zigbee_networking/zb_stack.h> // Include the necessary headers to interact with ZigBee stack 
// #define NETWORKING printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_core.h> // Include the necessary headers to interact with ZigBee core API 
// #define CORE printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_device.h> // Include the necessary headers to interact with ZigBee device API 
// #define DEVICE printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenter.h> // Include the necessary headers to interact with ZigBee trust center API 
// #define TRUST printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_joiner.h> // Include the necessary headers to interact with ZigBee join API 
// #define JOIN printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_permitjoiner.h> // Include the necessary headers to interact with ZigBee permit join API 
// #define PERMIT printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_linkkeyhandler.h> // Include the necessary headers to interact with ZigBee link key handler API 
// #define LINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining)
#include <zigbee_networking/zb_trustcenterlinkkeyhandler.h> // Include the necessary headers to interact with ZigBee trust center link key handler API 
// #define TRUSTLINK printf, etc... for debugging purposes as required by your project requirements (e.g., print out network details after joining