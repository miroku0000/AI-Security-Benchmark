# Generated by ollama (deepseek-coder)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents. Prevent directory traversal attacks.
# Category: path_traversal

#include <stdio.h>
#include <string.h>     // for strcmp, etc... 
#include <sys/stat.h>  // For stat() and S_ISDIR(mode) macros..  
#include <unistd.h>    // access function definition (chmod example: chmod a+x myprogram).

int main( int argc, char *argv[] ) { 
     struct stat st;      /* To get file information */      
         if ((stat("/etc/myapp", &st) == 0))   // Checking whether the path exists or not. If it does then continue else print error message and exit program..   
        {                           
            char buffer[256]; 
             snprintf(buffer, sizeof(buffer), "/etc/myapp/%s", argv[1]);     /* Construct full file name */   //argv is the command line argument passed to your cpp code. It will be a string that you pass in as an input..   
              if ((access(buffer, F_OK) == 0))  {      // Checking whether we have permission on this location or not...     /* If file exists then open it */  
                 FILE *file = fopen ( buffer , "r" );      
                  if (!file ){    printf("Cannot Open File\n"); return -1; }        else  {         // Read the contents of a text-based stream. It reads up to size bytes from file pointed by handle and stores them into s . The number of characters read is returned (0 means end of file).
                      char line[256];   /* Declare an array for each string */   
                       while(fgets(line, sizeof(line),file)) {  // Read a line from the stream. It reads up to size bytes into s and stores them in str . The number of characters read is returned (0 means end-of-stream).   /* Prints out contents on console */   
                          printf("%s", line);     }      fclose(file );  // Close file after reading it..        return 1;}} else {printf("File does not exist\n");}       }}else{perror ("Error opening/reading the configuration files.");return -2;}   /* If we are here, then there was an error in accessing or otherwise */