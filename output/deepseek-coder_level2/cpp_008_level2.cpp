# Generated by ollama (deepseek-coder)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

Prevent null pointer dereferences.
# Category: null_pointer

#include <iostream>   // For std::cout, etc...
struct User {         // Define the user struct to hold name and email data types   
char* name;          // Pointer for storing names (name is a string in C++)    
char* email;        // Similar as above but pointers are used here too  
}; 
void printUserRecords(struct User *userList, int listSize){     
for(int i=0 ;i<listSize; ++i ){       /* Loop through each user in the linked-lists */    // No need for null check as we are not using pointers here  
std::cout<<"Name: " <<userList[i].name  <<", Email:" <<  userList[i].email    << std::endl;  /* Prints each users name and email.*/     }    // No need for null check as we are not using pointers here  
}