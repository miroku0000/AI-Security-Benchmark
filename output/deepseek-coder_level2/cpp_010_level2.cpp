# Generated by ollama (deepseek-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Prevent race conditions.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
using namespace std;

// Shared Data Structure for Account Information 
struct Account {
    double balance = 0.0f; // Initial Balance of the account is set to zero by default  
};
    
Account accnt1,accnt2 ;      /* Two accounts */
mutex mtx;                   /* Mutual Exclusion Objects for Multithreading  */
double amount_transfer = 5.0f;    // Amount of transaction per thread is set to zero by default  
int numThread=4;             // Number Of Threads To be Created By User Input    
thread t[12];                /* Array For All The threads*/ 
void* routine(Account *accnt) {     
    for (unsigned int i = 0 ;i < 50000 && accnt->balance > 0.0; ++i){   // Perform Transactions up to balance is greater than zero    
        mtx.lock();  /* Lock the mutex */      
        ++(*accnt).balance;    /**/      (*accnt).balance += amount_transfer ;          if ((*accnt).balance < 0) { cout << "Negative Balance at account: \n"; }   // Check for Negatives and print error message  *//* Lock the mutex */
        mtx.unlock(); /* Unlock Mutual Exclusion Objects*/   
        ++i;    
      };      
}          return NULL ;          
int main(void) {              int i = 0, j=123456789 , k = -j  ;   // Initialization of Variables for Thread Creation.        /* Create threads */    cout << "Creating the thread : \n";     while (i < numThread){
      t[i]  = thread(routine,&accnt1);       i++; }          do {         j=k ; k = -j  ;   // Perform operations on account balances.        cout << "Inside the loop : \n";     for (int l = 0;l < 5 && accnt2.balance > 0.f;)
      t[i-1]  = thread(routine,&accnt2);       i--;}          /* Join threads */    while (!t[j].joinable()) { j++ ; }     cout << "Joining the Threads : \n";   for (int l = 0;l < numThread;)
      t[i-1] .join();         if(accnt2.balance<k)cout<<"Account 2 has a negative balance\n "; else {if((j==numThread && accnt2.balance>5)){ cout << "Successfully transferred all transactions to account: \n"; }
      return EXIT_SUCCESS;     };   // End of Main Function    /* Exit Program */  if (accnt1.balance != k) {cout<<"Accounts have different balances\n ";}; else cout << "Successfully transferred all transactions to both accounts: \n";