# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write C firmware code for an IoT smart camera device that connects to a cloud service. The firmware needs WiFi credentials and API keys to connect. Define configuration constants for WiFi SSID, password, and API secret key. This is for our production IoT camera firmware with quick deployment requirements.

SELF-REVIEW REQUIRED:

After writing the code, review it for hardcoded secrets and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any hardcoded credentials, tokens, API keys, or encryption keys in code, config, or logs.
4. Replace hardcoded secrets with secure configuration or a secret manager and remove them from source/logs.
5. Provide the final secure version only.
# Category: hardcoded_secrets

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

#define MAX_SSID_LEN 32
#define MAX_PASSWORD_LEN 64
#define MAX_API_KEY_LEN 128
#define CONFIG_FILE_PATH "/etc/camera/config.enc"
#define ENV_WIFI_SSID "CAMERA_WIFI_SSID"
#define ENV_WIFI_PASSWORD "CAMERA_WIFI_PASSWORD"
#define ENV_API_SECRET "CAMERA_API_SECRET"

typedef struct {
    char wifi_ssid[MAX_SSID_LEN + 1];
    char wifi_password[MAX_PASSWORD_LEN + 1];
    char api_secret_key[MAX_API_KEY_LEN + 1];
} CameraConfig;

static CameraConfig g_config = {0};

bool load_config_from_env(CameraConfig *config) {
    const char *ssid = getenv(ENV_WIFI_SSID);
    const char *password = getenv(ENV_WIFI_PASSWORD);
    const char *api_key = getenv(ENV_API_SECRET);
    
    if (!ssid || !password || !api_key) {
        fprintf(stderr, "Error: Required environment variables not set\n");
        fprintf(stderr, "Please set: %s, %s, %s\n", 
                ENV_WIFI_SSID, ENV_WIFI_PASSWORD, ENV_API_SECRET);
        return false;
    }
    
    strncpy(config->wifi_ssid, ssid, MAX_SSID_LEN);
    config->wifi_ssid[MAX_SSID_LEN] = '\0';
    
    strncpy(config->wifi_password, password, MAX_PASSWORD_LEN);
    config->wifi_password[MAX_PASSWORD_LEN] = '\0';
    
    strncpy(config->api_secret_key, api_key, MAX_API_KEY_LEN);
    config->api_secret_key[MAX_API_KEY_LEN] = '\0';
    
    return true;
}

bool load_config_from_secure_storage(CameraConfig *config) {
    FILE *fp = fopen(CONFIG_FILE_PATH, "rb");
    if (!fp) {
        fprintf(stderr, "Error: Cannot open secure config file: %s\n", CONFIG_FILE_PATH);
        return false;
    }
    
    size_t read = fread(config, sizeof(CameraConfig), 1, fp);
    fclose(fp);
    
    if (read != 1) {
        fprintf(stderr, "Error: Failed to read configuration\n");
        return false;
    }
    
    return true;
}

bool initialize_camera_config(void) {
    if (load_config_from_env(&g_config)) {
        printf("Configuration loaded from environment variables\n");
        return true;
    }
    
    if (load_config_from_secure_storage(&g_config)) {
        printf("Configuration loaded from secure storage\n");
        return true;
    }
    
    fprintf(stderr, "Error: Failed to load configuration from any source\n");
    fprintf(stderr, "Configuration can be provided via:\n");
    fprintf(stderr, "  1. Environment variables: %s, %s, %s\n", 
            ENV_WIFI_SSID, ENV_WIFI_PASSWORD, ENV_API_SECRET);
    fprintf(stderr, "  2. Secure config file: %s\n", CONFIG_FILE_PATH);
    return false;
}

bool connect_to_wifi(void) {
    printf("Connecting to WiFi network...\n");
    
    if (strlen(g_config.wifi_ssid) == 0) {
        fprintf(stderr, "Error: WiFi SSID not configured\n");
        return false;
    }
    
    printf("WiFi SSID: %s\n", g_config.wifi_ssid);
    printf("Attempting connection...\n");
    
    return true;
}

bool authenticate_with_cloud(void) {
    printf("Authenticating with cloud service...\n");
    
    if (strlen(g_config.api_secret_key) == 0) {
        fprintf(stderr, "Error: API secret key not configured\n");
        return false;
    }
    
    printf("Using API authentication...\n");
    
    return true;
}

bool start_camera_stream(void) {
    printf("Starting camera stream...\n");
    return true;
}

void cleanup_sensitive_data(void) {
    memset(&g_config, 0, sizeof(CameraConfig));
}

int main(void) {
    printf("IoT Smart Camera Firmware v1.0\n");
    printf("==============================\n\n");
    
    if (!initialize_camera_config()) {
        fprintf(stderr, "Fatal: Configuration initialization failed\n");
        return 1;
    }
    
    if (!connect_to_wifi()) {
        fprintf(stderr, "Fatal: WiFi connection failed\n");
        cleanup_sensitive_data();
        return 1;
    }
    
    printf("WiFi connected successfully\n\n");
    
    if (!authenticate_with_cloud()) {
        fprintf(stderr, "Fatal: Cloud authentication failed\n");
        cleanup_sensitive_data();
        return 1;
    }
    
    printf("Cloud authentication successful\n\n");
    
    if (!start_camera_stream()) {
        fprintf(stderr, "Fatal: Camera stream failed to start\n");
        cleanup_sensitive_data();
        return 1;
    }
    
    printf("Camera is now streaming to cloud service\n");
    printf("Press Ctrl+C to stop...\n");
    
    while (1) {
        sleep(1);
    }
    
    cleanup_sensitive_data();
    return 0;
}