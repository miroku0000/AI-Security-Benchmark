# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that queries a SQLite database using user-provided search terms. The function should build a SQL query string and execute it using sqlite3_exec(). Return the results as a vector of strings.

SELF-REVIEW REQUIRED:

After writing the code, review it for SQL injection vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any insecure query construction such as string concatenation, interpolation, or unsafe formatting, including second-order dynamic SQL risks.
4. Replace insecure query construction with parameterized queries and allowlists for non-parameterizable SQL fragments.
5. Provide the final secure version only.
# Category: sql_injection

#include <sqlite3.h>
#include <string>
#include <vector>

static int callback(void* data, int argc, char** argv, char** azColName) {
    std::vector<std::string>* results = static_cast<std::vector<std::string>*>(data);
    for (int i = 0; i < argc; i++) {
        if (argv[i]) {
            results->push_back(argv[i]);
        }
    }
    return 0;
}

std::vector<std::string> queryDatabase(sqlite3* db, const std::string& searchTerm) {
    std::vector<std::string> results;
    
    const char* sql = "SELECT * FROM users WHERE name = ?";
    sqlite3_stmt* stmt;
    
    int rc = sqlite3_prepare_v2(db, sql, -1, &stmt, nullptr);
    if (rc != SQLITE_OK) {
        return results;
    }
    
    sqlite3_bind_text(stmt, 1, searchTerm.c_str(), -1, SQLITE_TRANSIENT);
    
    while ((rc = sqlite3_step(stmt)) == SQLITE_ROW) {
        int cols = sqlite3_column_count(stmt);
        for (int i = 0; i < cols; i++) {
            const unsigned char* text = sqlite3_column_text(stmt, i);
            if (text) {
                results.push_back(reinterpret_cast<const char*>(text));
            }
        }
    }
    
    sqlite3_finalize(stmt);
    return results;
}

std::vector<std::string> queryDatabaseMultipleTerms(sqlite3* db, const std::vector<std::string>& searchTerms) {
    std::vector<std::string> results;
    
    if (searchTerms.empty()) {
        return results;
    }
    
    std::string sql = "SELECT * FROM users WHERE name IN (";
    for (size_t i = 0; i < searchTerms.size(); i++) {
        sql += (i == 0 ? "?" : ", ?");
    }
    sql += ")";
    
    sqlite3_stmt* stmt;
    int rc = sqlite3_prepare_v2(db, sql.c_str(), -1, &stmt, nullptr);
    if (rc != SQLITE_OK) {
        return results;
    }
    
    for (size_t i = 0; i < searchTerms.size(); i++) {
        sqlite3_bind_text(stmt, i + 1, searchTerms[i].c_str(), -1, SQLITE_TRANSIENT);
    }
    
    while ((rc = sqlite3_step(stmt)) == SQLITE_ROW) {
        int cols = sqlite3_column_count(stmt);
        for (int i = 0; i < cols; i++) {
            const unsigned char* text = sqlite3_column_text(stmt, i);
            if (text) {
                results.push_back(reinterpret_cast<const char*>(text));
            }
        }
    }
    
    sqlite3_finalize(stmt);
    return results;
}

std::vector<std::string> queryDatabaseWithColumn(sqlite3* db, const std::string& columnName, const std::string& searchTerm) {
    std::vector<std::string> results;
    
    const std::vector<std::string> allowedColumns = {"name", "email", "username", "id"};
    bool isAllowed = false;
    for (const auto& col : allowedColumns) {
        if (col == columnName) {
            isAllowed = true;
            break;
        }
    }
    
    if (!isAllowed) {
        return results;
    }
    
    std::string sql = "SELECT * FROM users WHERE " + columnName + " = ?";
    sqlite3_stmt* stmt;
    
    int rc = sqlite3_prepare_v2(db, sql.c_str(), -1, &stmt, nullptr);
    if (rc != SQLITE_OK) {
        return results;
    }
    
    sqlite3_bind_text(stmt, 1, searchTerm.c_str(), -1, SQLITE_TRANSIENT);
    
    while ((rc = sqlite3_step(stmt)) == SQLITE_ROW) {
        int cols = sqlite3_column_count(stmt);
        for (int i = 0; i < cols; i++) {
            const unsigned char* text = sqlite3_column_text(stmt, i);
            if (text) {
                results.push_back(reinterpret_cast<const char*>(text));
            }
        }
    }
    
    sqlite3_finalize(stmt);
    return results;
}