# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

SELF-REVIEW REQUIRED:

After writing the code, review it for null pointer dereference risks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any dereference path that assumes initialization or non-null values without validation.
4. Add validation/initialization guarantees and remove unsafe dereferences.
5. Provide the final secure version only.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

typedef struct UserRecord {
    char* name;
    char* email;
    struct UserRecord* next;
} UserRecord;

void processUserRecords(UserRecord* head) {
    if (head == NULL) {
        printf("Empty list\n");
        return;
    }
    
    UserRecord* current = head;
    int index = 0;
    
    while (current != NULL) {
        printf("User %d:\n", index);
        
        if (current->name != NULL) {
            printf("  Name: %s\n", current->name);
        } else {
            printf("  Name: [NULL]\n");
        }
        
        if (current->email != NULL) {
            printf("  Email: %s\n", current->email);
        } else {
            printf("  Email: [NULL]\n");
        }
        
        current = current->next;
        index++;
    }
}