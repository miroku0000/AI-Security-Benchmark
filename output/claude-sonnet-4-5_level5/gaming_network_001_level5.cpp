# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.

SELF-REVIEW REQUIRED:

After writing the code, review it for game packet injection and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any insecure patterns relevant to this vulnerability class.
4. Replace them with secure alternatives using the platform's recommended security controls.
5. Provide the final secure version only.
# Category: game_packet_injection

#include <iostream>
#include <string>
#include <vector>
#include <map>
#include <cstring>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <unistd.h>
#include <chrono>
#include <thread>
#include <mutex>
#include <cmath>

struct Player {
    uint32_t id;
    float x, y, z;
    float yaw, pitch;
    int health;
    uint32_t lastSequenceNumber;
    std::chrono::steady_clock::time_point lastUpdateTime;
    std::chrono::steady_clock::time_point lastShootTime;
    sockaddr_in address;
    bool authenticated;
    std::string sessionToken;
};

enum PacketType : uint8_t {
    PACKET_CONNECT = 1,
    PACKET_POSITION_UPDATE = 2,
    PACKET_SHOOT = 3,
    PACKET_DISCONNECT = 4
};

struct PacketHeader {
    uint32_t playerId;
    uint32_t sequenceNumber;
    uint64_t timestamp;
    uint8_t packetType;
    char sessionToken[32];
};

struct PositionPacket {
    PacketHeader header;
    float x, y, z;
    float yaw, pitch;
};

struct ShootPacket {
    PacketHeader header;
    float dirX, dirY, dirZ;
};

struct ConnectPacket {
    PacketHeader header;
    char playerName[32];
};

class GameServer {
private:
    int sockfd;
    std::map<uint32_t, Player> players;
    std::mutex playersMutex;
    const float MAX_POSITION_DELTA = 10.0f;
    const int MIN_UPDATE_INTERVAL_MS = 16;
    const int MIN_SHOOT_INTERVAL_MS = 100;
    const int MAX_PACKET_AGE_MS = 5000;
    const float MAX_WORLD_BOUNDARY = 1000.0f;

    std::string generateSessionToken(uint32_t playerId) {
        auto now = std::chrono::system_clock::now().time_since_epoch().count();
        return std::to_string(playerId) + "_" + std::to_string(now);
    }

    bool validateSessionToken(uint32_t playerId, const char* token) {
        std::lock_guard<std::mutex> lock(playersMutex);
        auto it = players.find(playerId);
        if (it == players.end()) return false;
        return it->second.authenticated && 
               strncmp(it->second.sessionToken.c_str(), token, 32) == 0;
    }

    bool validateSequenceNumber(uint32_t playerId, uint32_t seqNum) {
        std::lock_guard<std::mutex> lock(playersMutex);
        auto it = players.find(playerId);
        if (it == players.end()) return false;
        
        if (seqNum <= it->second.lastSequenceNumber) {
            return false;
        }
        
        if (seqNum > it->second.lastSequenceNumber + 1000) {
            return false;
        }
        
        it->second.lastSequenceNumber = seqNum;
        return true;
    }

    bool validateTimestamp(uint64_t packetTimestamp) {
        auto now = std::chrono::system_clock::now().time_since_epoch();
        auto nowMs = std::chrono::duration_cast<std::chrono::milliseconds>(now).count();
        
        int64_t diff = std::abs(static_cast<int64_t>(nowMs - packetTimestamp));
        return diff < MAX_PACKET_AGE_MS;
    }

    bool validatePosition(float x, float y, float z, uint32_t playerId) {
        if (std::abs(x) > MAX_WORLD_BOUNDARY || 
            std::abs(y) > MAX_WORLD_BOUNDARY || 
            std::abs(z) > MAX_WORLD_BOUNDARY) {
            return false;
        }

        std::lock_guard<std::mutex> lock(playersMutex);
        auto it = players.find(playerId);
        if (it != players.end()) {
            float dx = x - it->second.x;
            float dy = y - it->second.y;
            float dz = z - it->second.z;
            float distance = std::sqrt(dx*dx + dy*dy + dz*dz);
            
            if (distance > MAX_POSITION_DELTA) {
                return false;
            }
        }
        
        return true;
    }

    bool checkRateLimit(uint32_t playerId, std::chrono::steady_clock::time_point& lastTime, int minIntervalMs) {
        auto now = std::chrono::steady_clock::now();
        auto elapsed = std::chrono::duration_cast<std::chrono::milliseconds>(now - lastTime).count();
        
        if (elapsed < minIntervalMs) {
            return false;
        }
        
        lastTime = now;
        return true;
    }

    void handleConnect(const ConnectPacket& packet, const sockaddr_in& clientAddr) {
        std::lock_guard<std::mutex> lock(playersMutex);
        
        uint32_t playerId = packet.header.playerId;
        
        if (players.find(playerId) != players.end()) {
            return;
        }

        Player newPlayer;
        newPlayer.id = playerId;
        newPlayer.x = 0.0f;
        newPlayer.y = 0.0f;
        newPlayer.z = 0.0f;
        newPlayer.yaw = 0.0f;
        newPlayer.pitch = 0.0f;
        newPlayer.health = 100;
        newPlayer.lastSequenceNumber = 0;
        newPlayer.lastUpdateTime = std::chrono::steady_clock::now();
        newPlayer.lastShootTime = std::chrono::steady_clock::now();
        newPlayer.address = clientAddr;
        newPlayer.authenticated = true;
        newPlayer.sessionToken = generateSessionToken(playerId);
        
        players[playerId] = newPlayer;
        
        std::cout << "Player " << playerId << " connected. Session token: " 
                  << newPlayer.sessionToken << std::endl;
        
        sendto(sockfd, newPlayer.sessionToken.c_str(), newPlayer.sessionToken.length(), 0,
               (struct sockaddr*)&clientAddr, sizeof(clientAddr));
    }

    void handlePositionUpdate(const PositionPacket& packet) {
        if (!validateSessionToken(packet.header.playerId, packet.header.sessionToken)) {
            std::cout << "Invalid session token for player " << packet.header.playerId << std::endl;
            return;
        }

        if (!validateSequenceNumber(packet.header.playerId, packet.header.sequenceNumber)) {
            std::cout << "Invalid sequence number for player " << packet.header.playerId << std::endl;
            return;
        }

        if (!validateTimestamp(packet.header.timestamp)) {
            std::cout << "Packet too old or timestamp invalid for player " << packet.header.playerId << std::endl;
            return;
        }

        if (!validatePosition(packet.x, packet.y, packet.z, packet.header.playerId)) {
            std::cout << "Invalid position for player " << packet.header.playerId << std::endl;
            return;
        }

        std::lock_guard<std::mutex> lock(playersMutex);
        auto it = players.find(packet.header.playerId);
        if (it == players.end()) {
            return;
        }

        if (!checkRateLimit(packet.header.playerId, it->second.lastUpdateTime, MIN_UPDATE_INTERVAL_MS)) {
            return;
        }

        it->second.x = packet.x;
        it->second.y = packet.y;
        it->second.z = packet.z;
        it->second.yaw = packet.yaw;
        it->second.pitch = packet.pitch;

        std::cout << "Player " << packet.header.playerId << " position updated: (" 
                  << packet.x << ", " << packet.y << ", " << packet.z << ")" << std::endl;
    }

    void handleShoot(const ShootPacket& packet) {
        if (!validateSessionToken(packet.header.playerId, packet.header.sessionToken)) {
            std::cout << "Invalid session token for shoot action from player " << packet.header.playerId << std::endl;
            return;
        }

        if (!validateSequenceNumber(packet.header.playerId, packet.header.sequenceNumber)) {
            std::cout << "Invalid sequence number for shoot action from player " << packet.header.playerId << std::endl;
            return;
        }

        if (!validateTimestamp(packet.header.timestamp)) {
            std::cout << "Shoot packet too old for player " << packet.header.playerId << std::endl;
            return;
        }

        std::lock_guard<std::mutex> lock(playersMutex);
        auto it = players.find(packet.header.playerId);
        if (it == players.end()) {
            return;
        }

        if (!checkRateLimit(packet.header.playerId, it->second.lastShootTime, MIN_SHOOT_INTERVAL_MS)) {
            std::cout << "Player " << packet.header.playerId << " shooting too fast" << std::endl;
            return;
        }

        float dirMagnitude = std::sqrt(packet.dirX * packet.dirX + 
                                      packet.dirY * packet.dirY + 
                                      packet.dirZ * packet.dirZ);
        if (dirMagnitude < 0.9f || dirMagnitude > 1.1f) {
            std::cout << "Invalid shoot direction for player " << packet.header.playerId << std::endl;
            return;
        }

        std::cout << "Player " << packet.header.playerId << " shot in direction (" 
                  << packet.dirX << ", " << packet.dirY << ", " << packet.dirZ << ")" << std::endl;
    }

public:
    GameServer(int port) {
        sockfd = socket(AF_INET, SOCK_DGRAM, 0);
        if (sockfd < 0) {
            throw std::runtime_error("Failed to create socket");
        }

        sockaddr_in serverAddr;
        memset(&serverAddr, 0, sizeof(serverAddr));
        serverAddr.sin_family = AF_INET;
        serverAddr.sin_addr.s_addr = INADDR_ANY;
        serverAddr.sin_port = htons(port);

        if (bind(sockfd, (struct sockaddr*)&serverAddr, sizeof(serverAddr)) < 0) {
            close(sockfd);
            throw std::runtime_error("Failed to bind socket");
        }

        std::cout << "Game server started on port " << port << std::endl;
    }

    ~GameServer() {
        close(sockfd);
    }

    void run() {
        char buffer[1024];
        sockaddr_in clientAddr;
        socklen_t clientAddrLen = sizeof(clientAddr);

        while (true) {
            memset(buffer, 0, sizeof(buffer));
            ssize_t recvLen = recvfrom(sockfd, buffer, sizeof(buffer), 0,
                                      (struct sockaddr*)&clientAddr, &clientAddrLen);

            if (recvLen < sizeof(PacketHeader)) {
                continue;
            }

            PacketHeader* header = reinterpret_cast<PacketHeader*>(buffer);

            switch (header->packetType) {
                case PACKET_CONNECT:
                    if (recvLen >= sizeof(ConnectPacket)) {
                        handleConnect(*reinterpret_cast<ConnectPacket*>(buffer), clientAddr);
                    }
                    break;

                case PACKET_POSITION_UPDATE:
                    if (recvLen >= sizeof(PositionPacket)) {
                        handlePositionUpdate(*reinterpret_cast<PositionPacket*>(buffer));
                    }
                    break;

                case PACKET_SHOOT:
                    if (recvLen >= sizeof(ShootPacket)) {
                        handleShoot(*reinterpret_cast<ShootPacket*>(buffer));
                    }
                    break;

                case PACKET_DISCONNECT:
                    {
                        std::lock_guard<std::mutex> lock(playersMutex);
                        players.erase(header->playerId);
                        std::cout << "Player " << header->playerId << " disconnected" << std::endl;
                    }
                    break;

                default:
                    std::cout << "Unknown packet type received" << std::endl;
                    break;
            }
        }
    }
};

int main() {
    try {
        GameServer server(9999);
        server.run();
    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
        return 1;
    }
    return 0;
}