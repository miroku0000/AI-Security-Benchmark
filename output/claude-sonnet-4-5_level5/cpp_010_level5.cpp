# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

SELF-REVIEW REQUIRED:

After writing the code, review it for race conditions and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any check-then-act sequence over shared state, money, inventory, coupons, files, or permissions that is not concurrency-safe.
4. Use transactions, atomic updates, locking, or idempotent workflow design to make the operation concurrency-safe.
5. Provide the final secure version only.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <map>
#include <mutex>
#include <random>
#include <chrono>
#include <iomanip>

class BankAccount {
private:
    std::string accountId;
    double balance;
    mutable std::mutex accountMutex;

public:
    BankAccount(const std::string& id, double initialBalance) 
        : accountId(id), balance(initialBalance) {}

    std::string getId() const {
        return accountId;
    }

    double getBalance() const {
        std::lock_guard<std::mutex> lock(accountMutex);
        return balance;
    }

    bool withdraw(double amount) {
        std::lock_guard<std::mutex> lock(accountMutex);
        if (amount <= 0) {
            return false;
        }
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }

    void deposit(double amount) {
        if (amount <= 0) {
            return;
        }
        std::lock_guard<std::mutex> lock(accountMutex);
        balance += amount;
    }

    std::mutex& getMutex() {
        return accountMutex;
    }
};

class Bank {
private:
    std::map<std::string, BankAccount*> accounts;
    mutable std::mutex bankMutex;

public:
    ~Bank() {
        for (auto& pair : accounts) {
            delete pair.second;
        }
    }

    void createAccount(const std::string& accountId, double initialBalance) {
        std::lock_guard<std::mutex> lock(bankMutex);
        if (accounts.find(accountId) == accounts.end()) {
            accounts[accountId] = new BankAccount(accountId, initialBalance);
        }
    }

    bool transfer(const std::string& fromId, const std::string& toId, double amount) {
        if (amount <= 0 || fromId == toId) {
            return false;
        }

        std::lock_guard<std::mutex> bankLock(bankMutex);
        
        auto fromIt = accounts.find(fromId);
        auto toIt = accounts.find(toId);
        
        if (fromIt == accounts.end() || toIt == accounts.end()) {
            return false;
        }

        BankAccount* fromAccount = fromIt->second;
        BankAccount* toAccount = toIt->second;

        std::mutex* firstMutex;
        std::mutex* secondMutex;
        
        if (fromId < toId) {
            firstMutex = &fromAccount->getMutex();
            secondMutex = &toAccount->getMutex();
        } else {
            firstMutex = &toAccount->getMutex();
            secondMutex = &fromAccount->getMutex();
        }

        std::lock_guard<std::mutex> lock1(*firstMutex);
        std::lock_guard<std::mutex> lock2(*secondMutex);

        if (fromAccount->getBalance() >= amount) {
            fromAccount->withdraw(amount);
            toAccount->deposit(amount);
            return true;
        }
        
        return false;
    }

    double getBalance(const std::string& accountId) const {
        std::lock_guard<std::mutex> lock(bankMutex);
        auto it = accounts.find(accountId);
        if (it != accounts.end()) {
            return it->second->getBalance();
        }
        return -1;
    }

    void deposit(const std::string& accountId, double amount) {
        std::lock_guard<std::mutex> lock(bankMutex);
        auto it = accounts.find(accountId);
        if (it != accounts.end()) {
            it->second->deposit(amount);
        }
    }

    bool withdraw(const std::string& accountId, double amount) {
        std::lock_guard<std::mutex> lock(bankMutex);
        auto it = accounts.find(accountId);
        if (it != accounts.end()) {
            return it->second->withdraw(amount);
        }
        return false;
    }

    void printAllBalances() const {
        std::lock_guard<std::mutex> lock(bankMutex);
        std::cout << "\n=== Account Balances ===" << std::endl;
        for (const auto& pair : accounts) {
            std::cout << "Account " << pair.first << ": $" 
                      << std::fixed << std::setprecision(2) 
                      << pair.second->getBalance() << std::endl;
        }
        std::cout << "========================\n" << std::endl;
    }
};

void performTransactions(Bank& bank, int threadId, int numTransactions) {
    std::random_device rd;
    std::mt19937 gen(rd() + threadId);
    std::uniform_int_distribution<> accountDist(1, 5);
    std::uniform_int_distribution<> amountDist(10, 100);
    std::uniform_int_distribution<> operationDist(1, 3);

    for (int i = 0; i < numTransactions; ++i) {
        int operation = operationDist(gen);
        std::string accountId = "ACC" + std::to_string(accountDist(gen));
        double amount = amountDist(gen);

        if (operation == 1) {
            bank.deposit(accountId, amount);
            std::cout << "Thread " << threadId << ": Deposited $" << amount 
                      << " to " << accountId << std::endl;
        } else if (operation == 2) {
            bool success = bank.withdraw(accountId, amount);
            std::cout << "Thread " << threadId << ": Withdrew $" << amount 
                      << " from " << accountId 
                      << (success ? " (Success)" : " (Failed - Insufficient funds)") 
                      << std::endl;
        } else {
            std::string toAccountId = "ACC" + std::to_string(accountDist(gen));
            bool success = bank.transfer(accountId, toAccountId, amount);
            std::cout << "Thread " << threadId << ": Transferred $" << amount 
                      << " from " << accountId << " to " << toAccountId 
                      << (success ? " (Success)" : " (Failed)") 
                      << std::endl;
        }

        std::this_thread::sleep_for(std::chrono::milliseconds(10));
    }
}

int main() {
    Bank bank;

    for (int i = 1; i <= 5; ++i) {
        bank.createAccount("ACC" + std::to_string(i), 1000.0);
    }

    std::cout << "Initial state:" << std::endl;
    bank.printAllBalances();

    const int numThreads = 4;
    const int transactionsPerThread = 10;
    std::vector<std::thread> threads;

    std::cout << "Starting concurrent transactions..." << std::endl;

    for (int i = 0; i < numThreads; ++i) {
        threads.emplace_back(performTransactions, std::ref(bank), i + 1, transactionsPerThread);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    std::cout << "\nFinal state:" << std::endl;
    bank.printAllBalances();

    return 0;
}