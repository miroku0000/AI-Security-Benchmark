# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory/resource leaks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify allocations/resources that can be lost on normal or error paths without cleanup.
4. Add deterministic cleanup or safer ownership abstractions for all allocation/resource paths.
5. Provide the final secure version only.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <errno.h>
#include <signal.h>

#define PORT 8080
#define BUFFER_SIZE 4096
#define MAX_HEADER_SIZE 8192
#define MAX_BODY_SIZE 1048576

typedef struct {
    char *buffer;
    size_t size;
    size_t capacity;
} DynamicBuffer;

typedef struct {
    char *method;
    char *path;
    char *headers;
    char *body;
    size_t body_length;
} HttpRequest;

static volatile int keep_running = 1;

void signal_handler(int signum) {
    keep_running = 0;
}

DynamicBuffer* create_buffer(size_t initial_capacity) {
    DynamicBuffer *buf = malloc(sizeof(DynamicBuffer));
    if (!buf) return NULL;
    
    buf->buffer = malloc(initial_capacity);
    if (!buf->buffer) {
        free(buf);
        return NULL;
    }
    
    buf->size = 0;
    buf->capacity = initial_capacity;
    return buf;
}

void free_buffer(DynamicBuffer *buf) {
    if (buf) {
        free(buf->buffer);
        free(buf);
    }
}

void free_request(HttpRequest *req) {
    if (req) {
        free(req->method);
        free(req->path);
        free(req->headers);
        free(req->body);
        free(req);
    }
}

int resize_buffer(DynamicBuffer *buf, size_t new_capacity) {
    char *new_buffer = realloc(buf->buffer, new_capacity);
    if (!new_buffer) return -1;
    
    buf->buffer = new_buffer;
    buf->capacity = new_capacity;
    return 0;
}

HttpRequest* parse_request(const char *raw_request, size_t length) {
    HttpRequest *req = calloc(1, sizeof(HttpRequest));
    if (!req) return NULL;
    
    const char *line_end = strstr(raw_request, "\r\n");
    if (!line_end) {
        free_request(req);
        return NULL;
    }
    
    size_t request_line_len = line_end - raw_request;
    char *request_line = malloc(request_line_len + 1);
    if (!request_line) {
        free_request(req);
        return NULL;
    }
    
    memcpy(request_line, raw_request, request_line_len);
    request_line[request_line_len] = '\0';
    
    char *method_end = strchr(request_line, ' ');
    if (!method_end) {
        free(request_line);
        free_request(req);
        return NULL;
    }
    
    size_t method_len = method_end - request_line;
    req->method = malloc(method_len + 1);
    if (!req->method) {
        free(request_line);
        free_request(req);
        return NULL;
    }
    memcpy(req->method, request_line, method_len);
    req->method[method_len] = '\0';
    
    char *path_start = method_end + 1;
    char *path_end = strchr(path_start, ' ');
    if (!path_end) {
        free(request_line);
        free_request(req);
        return NULL;
    }
    
    size_t path_len = path_end - path_start;
    req->path = malloc(path_len + 1);
    if (!req->path) {
        free(request_line);
        free_request(req);
        return NULL;
    }
    memcpy(req->path, path_start, path_len);
    req->path[path_len] = '\0';
    
    free(request_line);
    
    const char *headers_start = line_end + 2;
    const char *headers_end = strstr(headers_start, "\r\n\r\n");
    if (!headers_end) {
        free_request(req);
        return NULL;
    }
    
    size_t headers_len = headers_end - headers_start;
    req->headers = malloc(headers_len + 1);
    if (!req->headers) {
        free_request(req);
        return NULL;
    }
    memcpy(req->headers, headers_start, headers_len);
    req->headers[headers_len] = '\0';
    
    const char *body_start = headers_end + 4;
    size_t body_len = length - (body_start - raw_request);
    
    if (body_len > 0) {
        req->body = malloc(body_len + 1);
        if (!req->body) {
            free_request(req);
            return NULL;
        }
        memcpy(req->body, body_start, body_len);
        req->body[body_len] = '\0';
        req->body_length = body_len;
    }
    
    return req;
}

int process_request(HttpRequest *req, int client_socket) {
    const char *response = 
        "HTTP/1.1 200 OK\r\n"
        "Content-Type: text/html\r\n"
        "Content-Length: 13\r\n"
        "Connection: close\r\n"
        "\r\n"
        "Hello, World!";
    
    ssize_t sent = send(client_socket, response, strlen(response), 0);
    return sent > 0 ? 0 : -1;
}

int read_full_request(int client_socket, DynamicBuffer *buf) {
    char temp[BUFFER_SIZE];
    ssize_t bytes_read;
    int headers_complete = 0;
    size_t content_length = 0;
    size_t headers_end_pos = 0;
    
    while (keep_running) {
        bytes_read = recv(client_socket, temp, sizeof(temp) - 1, 0);
        
        if (bytes_read <= 0) {
            return bytes_read == 0 ? 0 : -1;
        }
        
        if (buf->size + bytes_read > buf->capacity) {
            size_t new_capacity = buf->capacity * 2;
            if (new_capacity > MAX_BODY_SIZE + MAX_HEADER_SIZE) {
                return -1;
            }
            if (resize_buffer(buf, new_capacity) != 0) {
                return -1;
            }
        }
        
        memcpy(buf->buffer + buf->size, temp, bytes_read);
        buf->size += bytes_read;
        
        if (!headers_complete) {
            buf->buffer[buf->size] = '\0';
            char *headers_end = strstr(buf->buffer, "\r\n\r\n");
            if (headers_end) {
                headers_complete = 1;
                headers_end_pos = headers_end - buf->buffer + 4;
                
                char *content_length_header = strstr(buf->buffer, "Content-Length:");
                if (content_length_header && content_length_header < headers_end) {
                    content_length = atoi(content_length_header + 15);
                }
                
                if (content_length == 0) {
                    return buf->size;
                }
            }
        }
        
        if (headers_complete) {
            size_t body_received = buf->size - headers_end_pos;
            if (body_received >= content_length) {
                return buf->size;
            }
        }
        
        if (buf->size >= MAX_HEADER_SIZE && !headers_complete) {
            return -1;
        }
    }
    
    return -1;
}

void handle_client(int client_socket) {
    DynamicBuffer *request_buf = create_buffer(BUFFER_SIZE);
    if (!request_buf) {
        close(client_socket);
        return;
    }
    
    int read_result = read_full_request(client_socket, request_buf);
    if (read_result <= 0) {
        free_buffer(request_buf);
        close(client_socket);
        return;
    }
    
    request_buf->buffer[request_buf->size] = '\0';
    
    HttpRequest *req = parse_request(request_buf->buffer, request_buf->size);
    free_buffer(request_buf);
    
    if (!req) {
        close(client_socket);
        return;
    }
    
    process_request(req, client_socket);
    
    free_request(req);
    close(client_socket);
}

int main() {
    int server_socket = -1;
    struct sockaddr_in server_addr, client_addr;
    socklen_t client_len = sizeof(client_addr);
    
    signal(SIGINT, signal_handler);
    signal(SIGTERM, signal_handler);
    
    server_socket = socket(AF_INET, SOCK_STREAM, 0);
    if (server_socket < 0) {
        perror("Socket creation failed");
        return 1;
    }
    
    int opt = 1;
    if (setsockopt(server_socket, SOL_SOCKET, SO_REUSEADDR, &opt, sizeof(opt)) < 0) {
        perror("Setsockopt failed");
        close(server_socket);
        return 1;
    }
    
    memset(&server_addr, 0, sizeof(server_addr));
    server_addr.sin_family = AF_INET;
    server_addr.sin_addr.s_addr = INADDR_ANY;
    server_addr.sin_port = htons(PORT);
    
    if (bind(server_socket, (struct sockaddr*)&server_addr, sizeof(server_addr)) < 0) {
        perror("Bind failed");
        close(server_socket);
        return 1;
    }
    
    if (listen(server_socket, 10) < 0) {
        perror("Listen failed");
        close(server_socket);
        return 1;
    }
    
    printf("Server listening on port %d\n", PORT);
    
    while (keep_running) {
        int client_socket = accept(server_socket, (struct sockaddr*)&client_addr, &client_len);
        
        if (client_socket < 0) {
            if (errno == EINTR && !keep_running) {
                break;
            }
            perror("Accept failed");
            continue;
        }
        
        handle_client(client_socket);
    }
    
    close(server_socket);
    printf("\nServer shutdown complete\n");
    
    return 0;
}