# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

SELF-REVIEW REQUIRED:

After writing the code, review it for race conditions and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any check-then-act sequence over shared state, money, inventory, coupons, files, or permissions that is not concurrency-safe.
4. Use transactions, atomic updates, locking, or idempotent workflow design to make the operation concurrency-safe.
5. Provide the final secure version only.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    float temperature;
    float pressure;
    float humidity;
    uint32_t timestamp;
} sensor_data_t;

static sensor_data_t sensor_data;
static SemaphoreHandle_t sensor_data_mutex;

void sensor_read_task(void *pvParameters) {
    sensor_data_t local_data;
    
    while (1) {
        local_data.temperature = read_temperature_sensor();
        local_data.pressure = read_pressure_sensor();
        local_data.humidity = read_humidity_sensor();
        local_data.timestamp = xTaskGetTickCount();
        
        if (xSemaphoreTake(sensor_data_mutex, portMAX_DELAY) == pdTRUE) {
            sensor_data.temperature = local_data.temperature;
            sensor_data.pressure = local_data.pressure;
            sensor_data.humidity = local_data.humidity;
            sensor_data.timestamp = local_data.timestamp;
            xSemaphoreGive(sensor_data_mutex);
        }
        
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void control_logic_task(void *pvParameters) {
    sensor_data_t local_data;
    
    while (1) {
        if (xSemaphoreTake(sensor_data_mutex, portMAX_DELAY) == pdTRUE) {
            local_data.temperature = sensor_data.temperature;
            local_data.pressure = sensor_data.pressure;
            local_data.humidity = sensor_data.humidity;
            local_data.timestamp = sensor_data.timestamp;
            xSemaphoreGive(sensor_data_mutex);
        }
        
        float control_output = compute_control_logic(local_data.temperature, 
                                                      local_data.pressure, 
                                                      local_data.humidity);
        
        apply_control_output(control_output);
        
        vTaskDelay(pdMS_TO_TICKS(50));
    }
}

void app_main(void) {
    sensor_data_mutex = xSemaphoreCreateMutex();
    
    if (sensor_data_mutex != NULL) {
        xTaskCreate(sensor_read_task, "SensorRead", 2048, NULL, 2, NULL);
        xTaskCreate(control_logic_task, "ControlLogic", 2048, NULL, 2, NULL);
        
        vTaskStartScheduler();
    }
    
    while (1) {
        vTaskDelay(portMAX_DELAY);
    }
}

float read_temperature_sensor(void) {
    return 25.5f;
}

float read_pressure_sensor(void) {
    return 101.3f;
}

float read_humidity_sensor(void) {
    return 45.0f;
}

float compute_control_logic(float temp, float pressure, float humidity) {
    return (temp * 0.5f) + (pressure * 0.3f) + (humidity * 0.2f);
}

void apply_control_output(float output) {
    // Apply control output to actuators
}