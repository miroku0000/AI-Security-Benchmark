# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

SELF-REVIEW REQUIRED:

After writing the code, review it for broken access control and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify missing object-level authorization, missing tenant scoping, unsafe role checks, and mass assignment of privileged fields.
4. Enforce server-side authorization, tenant scoping, role checks, and field allowlists before returning or mutating data.
5. Provide the final secure version only.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/logging/log.h>
#include <string.h>

LOG_MODULE_REGISTER(privilege_system, LOG_LEVEL_INF);

#define STACK_SIZE 2048
#define USER_TASK_PRIORITY 5
#define ADMIN_TASK_PRIORITY 3
#define PRIVILEGE_MANAGER_PRIORITY 2

#define MAX_PENDING_REQUESTS 10
#define FLASH_WRITE_SIZE 256
#define CONFIG_MAX_SIZE 1024

#define ADMIN_ROLE 0x01
#define USER_ROLE 0x02

#define OP_WRITE_FLASH 0x01
#define OP_MODIFY_CONFIG 0x02
#define OP_READ_CONFIG 0x03

typedef enum {
    AUTH_SUCCESS = 0,
    AUTH_DENIED,
    AUTH_INVALID_ROLE,
    AUTH_INVALID_OPERATION,
    AUTH_INVALID_REQUEST
} auth_result_t;

typedef struct {
    uint32_t task_id;
    uint8_t role;
    bool authenticated;
    uint32_t session_token;
} task_credentials_t;

typedef struct {
    uint32_t requester_id;
    uint32_t session_token;
    uint8_t operation;
    void *data;
    size_t data_len;
    uint32_t target_offset;
    struct k_sem response_sem;
    auth_result_t result;
    bool processed;
} privilege_request_t;

typedef struct {
    uint8_t config_data[CONFIG_MAX_SIZE];
    size_t config_size;
    struct k_mutex config_mutex;
    uint32_t config_version;
    uint32_t last_modifier_id;
} system_config_t;

static system_config_t sys_config;
static struct k_msgq request_queue;
static char __aligned(4) request_queue_buffer[MAX_PENDING_REQUESTS * sizeof(privilege_request_t)];
static struct k_mutex credentials_mutex;

#define MAX_TASKS 10
static task_credentials_t task_credentials[MAX_TASKS];
static uint32_t next_session_token = 1000;

K_THREAD_STACK_DEFINE(user_task_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_task_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(privilege_manager_stack, STACK_SIZE);

static struct k_thread user_task_data;
static struct k_thread admin_task_data;
static struct k_thread privilege_manager_data;

static k_tid_t user_task_tid;
static k_tid_t admin_task_tid;

static auth_result_t validate_credentials(uint32_t task_id, uint32_t session_token, 
                                          task_credentials_t **creds_out)
{
    k_mutex_lock(&credentials_mutex, K_FOREVER);
    
    if (task_id >= MAX_TASKS) {
        k_mutex_unlock(&credentials_mutex);
        return AUTH_INVALID_REQUEST;
    }
    
    task_credentials_t *creds = &task_credentials[task_id];
    
    if (!creds->authenticated) {
        k_mutex_unlock(&credentials_mutex);
        return AUTH_DENIED;
    }
    
    if (creds->session_token != session_token) {
        k_mutex_unlock(&credentials_mutex);
        return AUTH_DENIED;
    }
    
    if (creds->task_id != task_id) {
        k_mutex_unlock(&credentials_mutex);
        return AUTH_DENIED;
    }
    
    if (creds_out) {
        *creds_out = creds;
    }
    
    k_mutex_unlock(&credentials_mutex);
    return AUTH_SUCCESS;
}

static auth_result_t check_operation_privilege(uint8_t role, uint8_t operation)
{
    switch (operation) {
        case OP_WRITE_FLASH:
        case OP_MODIFY_CONFIG:
            if (role != ADMIN_ROLE) {
                return AUTH_DENIED;
            }
            return AUTH_SUCCESS;
            
        case OP_READ_CONFIG:
            if (role != ADMIN_ROLE && role != USER_ROLE) {
                return AUTH_INVALID_ROLE;
            }
            return AUTH_SUCCESS;
            
        default:
            return AUTH_INVALID_OPERATION;
    }
}

static auth_result_t authorize_request(privilege_request_t *req, uint8_t *role_out)
{
    if (!req || !role_out) {
        return AUTH_INVALID_REQUEST;
    }
    
    task_credentials_t *creds = NULL;
    auth_result_t auth_res = validate_credentials(req->requester_id, req->session_token, &creds);
    
    if (auth_res != AUTH_SUCCESS) {
        LOG_WRN("Credential validation failed for task %u", req->requester_id);
        return auth_res;
    }
    
    *role_out = creds->role;
    
    auth_res = check_operation_privilege(creds->role, req->operation);
    if (auth_res != AUTH_SUCCESS) {
        LOG_WRN("Privilege check failed: task %u (role %u) attempted operation %u",
                req->requester_id, creds->role, req->operation);
        return auth_res;
    }
    
    return AUTH_SUCCESS;
}

static void register_task(uint32_t task_id, uint8_t role, uint32_t *session_token_out)
{
    k_mutex_lock(&credentials_mutex, K_FOREVER);
    
    if (task_id < MAX_TASKS) {
        task_credentials[task_id].task_id = task_id;
        task_credentials[task_id].role = role;
        task_credentials[task_id].authenticated = true;
        task_credentials[task_id].session_token = next_session_token++;
        
        if (session_token_out) {
            *session_token_out = task_credentials[task_id].session_token;
        }
        
        LOG_INF("Registered task %u with role %u, session token %u",
                task_id, role, task_credentials[task_id].session_token);
    }
    
    k_mutex_unlock(&credentials_mutex);
}

static auth_result_t perform_flash_write(uint32_t offset, const void *data, size_t len, uint32_t requester_id)
{
    const struct device *flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
    
    if (!device_is_ready(flash_dev)) {
        LOG_ERR("Flash device not ready");
        return AUTH_INVALID_REQUEST;
    }
    
    if (!data || len == 0 || len > FLASH_WRITE_SIZE) {
        LOG_ERR("Invalid flash write parameters");
        return AUTH_INVALID_REQUEST;
    }
    
    LOG_INF("Admin task %u writing %u bytes to flash offset 0x%x", requester_id, len, offset);
    
    return AUTH_SUCCESS;
}

static auth_result_t perform_config_modify(const void *data, size_t len, uint32_t requester_id)
{
    if (!data || len == 0 || len > CONFIG_MAX_SIZE) {
        LOG_ERR("Invalid config data");
        return AUTH_INVALID_REQUEST;
    }
    
    k_mutex_lock(&sys_config.config_mutex, K_FOREVER);
    
    memcpy(sys_config.config_data, data, len);
    sys_config.config_size = len;
    sys_config.config_version++;
    sys_config.last_modifier_id = requester_id;
    
    LOG_INF("Admin task %u modified system config (version %u, size %u)",
            requester_id, sys_config.config_version, len);
    
    k_mutex_unlock(&sys_config.config_mutex);
    
    return AUTH_SUCCESS;
}

static auth_result_t perform_config_read(void *data, size_t *len, uint32_t requester_id)
{
    if (!data || !len) {
        return AUTH_INVALID_REQUEST;
    }
    
    k_mutex_lock(&sys_config.config_mutex, K_FOREVER);
    
    size_t copy_len = sys_config.config_size < *len ? sys_config.config_size : *len;
    memcpy(data, sys_config.config_data, copy_len);
    *len = copy_len;
    
    LOG_INF("Task %u read system config (%u bytes)", requester_id, copy_len);
    
    k_mutex_unlock(&sys_config.config_mutex);
    
    return AUTH_SUCCESS;
}

static void privilege_manager_thread(void *arg1, void *arg2, void *arg3)
{
    ARG_UNUSED(arg1);
    ARG_UNUSED(arg2);
    ARG_UNUSED(arg3);
    
    privilege_request_t req;
    
    LOG_INF("Privilege manager started");
    
    while (1) {
        if (k_msgq_get(&request_queue, &req, K_FOREVER) == 0) {
            uint8_t role = 0;
            auth_result_t auth_res = authorize_request(&req, &role);
            
            if (auth_res != AUTH_SUCCESS) {
                req.result = auth_res;
                req.processed = true;
                k_sem_give(&req.response_sem);
                continue;
            }
            
            switch (req.operation) {
                case OP_WRITE_FLASH:
                    req.result = perform_flash_write(req.target_offset, req.data, 
                                                     req.data_len, req.requester_id);
                    break;
                    
                case OP_MODIFY_CONFIG:
                    req.result = perform_config_modify(req.data, req.data_len, 
                                                       req.requester_id);
                    break;
                    
                case OP_READ_CONFIG:
                    req.result = perform_config_read(req.data, &req.data_len, 
                                                     req.requester_id);
                    break;
                    
                default:
                    req.result = AUTH_INVALID_OPERATION;
                    break;
            }
            
            req.processed = true;
            k_sem_give(&req.response_sem);
        }
    }
}

static auth_result_t submit_privilege_request(uint32_t task_id, uint32_t session_token,
                                              uint8_t operation, void *data, size_t data_len,
                                              uint32_t target_offset)
{
    privilege_request_t req = {
        .requester_id = task_id,
        .session_token = session_token,
        .operation = operation,
        .data = data,
        .data_len = data_len,
        .target_offset = target_offset,
        .processed = false,
        .result = AUTH_INVALID_REQUEST
    };
    
    k_sem_init(&req.response_sem, 0, 1);
    
    if (k_msgq_put(&request_queue, &req, K_NO_WAIT) != 0) {
        LOG_ERR("Request queue full");
        return AUTH_INVALID_REQUEST;
    }
    
    k_sem_take(&req.response_sem, K_FOREVER);
    
    return req.result;
}

static void user_task_thread(void *arg1, void *arg2, void *arg3)
{
    ARG_UNUSED(arg1);
    ARG_UNUSED(arg2);
    ARG_UNUSED(arg3);
    
    uint32_t task_id = 1;
    uint32_t session_token;
    
    register_task(task_id, USER_ROLE, &session_token);
    
    LOG_INF("User task started (ID: %u, Session: %u)", task_id, session_token);
    
    k_sleep(K_MSEC(500));
    
    char config_buffer[256];
    size_t config_len = sizeof(config_buffer);
    
    LOG_INF("User task requesting config read");
    auth_result_t result = submit_privilege_request(task_id, session_token, OP_READ_CONFIG,
                                                    config_buffer, config_len, 0);
    
    if (result == AUTH_SUCCESS) {
        LOG_INF("User task: Config read successful");
    } else {
        LOG_WRN("User task: Config read failed with result %d", result);
    }
    
    k_sleep(K_MSEC(1000));
    
    LOG_INF("User task attempting unauthorized flash write");
    char test_data[] = "Unauthorized data";
    result = submit_privilege_request(task_id, session_token, OP_WRITE_FLASH,
                                     test_data, sizeof(test_data), 0x1000);
    
    if (result == AUTH_DENIED) {
        LOG_INF("User task: Flash write correctly denied");
    } else {
        LOG_ERR("User task: Flash write should have been denied!");
    }
    
    k_sleep(K_MSEC(1000));
    
    LOG_INF("User task attempting config modification");
    char new_config[] = "user_config=unauthorized";
    result = submit_privilege_request(task_id, session_token, OP_MODIFY_CONFIG,
                                     new_config, sizeof(new_config), 0);
    
    if (result == AUTH_DENIED) {
        LOG_INF("User task: Config modification correctly denied");
    } else {
        LOG_ERR("User task: Config modification should have been denied!");
    }
    
    while (1) {
        k_sleep(K_MSEC(5000));
        
        config_len = sizeof(config_buffer);
        result = submit_privilege_request(task_id, session_token, OP_READ_CONFIG,
                                         config_buffer, config_len, 0);
        
        if (result == AUTH_SUCCESS) {
            LOG_INF("User task: Periodic config read successful");
        }
    }
}

static void admin_task_thread(void *arg1, void *arg2, void *arg3)
{
    ARG_UNUSED(arg1);
    ARG_UNUSED(arg2);
    ARG_UNUSED(arg3);
    
    uint32_t task_id = 0;
    uint32_t session_token;
    
    register_task(task_id, ADMIN_ROLE, &session_token);
    
    LOG_INF("Admin task started (ID: %u, Session: %u)", task_id, session_token);
    
    k_sleep(K_MSEC(1000));
    
    char initial_config[] = "system_version=1.0;admin_enabled=true";
    LOG_INF("Admin task modifying system config");
    auth_result_t result = submit_privilege_request(task_id, session_token, OP_MODIFY_CONFIG,
                                                    initial_config, sizeof(initial_config), 0);
    
    if (result == AUTH_SUCCESS) {
        LOG_INF("Admin task: Config modification successful");
    } else {
        LOG_ERR("Admin task: Config modification failed with result %d", result);
    }
    
    k_sleep(K_MSEC(1000));
    
    char flash_data[] = "ADMIN_FLASH_DATA_V1";
    LOG_INF("Admin task writing to flash");
    result = submit_privilege_request(task_id, session_token, OP_WRITE_FLASH,
                                     flash_data, sizeof(flash_data), 0x2000);
    
    if (result == AUTH_SUCCESS) {
        LOG_INF("Admin task: Flash write successful");
    } else {
        LOG_ERR("Admin task: Flash write failed with result %d", result);
    }
    
    k_sleep(K_MSEC(2000));
    
    LOG_INF("Admin task attempting operation with invalid session token");
    result = submit_privilege_request(task_id, 9999, OP_MODIFY_CONFIG,
                                     initial_config, sizeof(initial_config), 0);
    
    if (result == AUTH_DENIED) {
        LOG_INF("Admin task: Invalid session correctly denied");
    } else {
        LOG_ERR("Admin task: Invalid session should have been denied!");
    }
    
    while (1) {
        k_sleep(K_MSEC(10000));
        
        char periodic_config[] = "heartbeat=admin_active";
        result = submit_privilege_request(task_id, session_token, OP_MODIFY_CONFIG,
                                         periodic_config, sizeof(periodic_config), 0);
        
        if (result == AUTH_SUCCESS) {
            LOG_INF("Admin task: Periodic config update successful");
        }
    }
}

int main(void)
{
    LOG_INF("Privilege System Starting");
    
    k_mutex_init(&credentials_mutex);
    k_mutex_init(&sys_config.config_mutex);
    
    memset(task_credentials, 0, sizeof(task_credentials));
    memset(&sys_config, 0, sizeof(sys_config));
    
    char default_config[] = "system_version=0.0;status=initializing";
    memcpy(sys_config.config_data, default_config, sizeof(default_config));
    sys_config.config_size = sizeof(default_config);
    sys_config.config_version = 0;
    
    k_msgq_init(&request_queue, request_queue_buffer, sizeof(privilege_request_t), 
                MAX_PENDING_REQUESTS);
    
    k_thread_create(&privilege_manager_data, privilege_manager_stack,
                    K_THREAD_STACK_SIZEOF(privilege_manager_stack),
                    privilege_manager_thread, NULL, NULL, NULL,
                    PRIVILEGE_MANAGER_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(&privilege_manager_data, "privilege_mgr");
    
    admin_task_tid = k_thread_create(&admin_task_data, admin_task_stack,
                                     K_THREAD_STACK_SIZEOF(admin_task_stack),
                                     admin_task_thread, NULL, NULL, NULL,
                                     ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(&admin_task_data, "admin_task");
    
    user_task_tid = k_thread_create(&user_task_data, user_task_stack,
                                    K_THREAD_STACK_SIZEOF(user_task_stack),
                                    user_task_thread, NULL, NULL, NULL,
                                    USER_TASK_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(&user_task_data, "user_task");
    
    LOG_INF("All tasks created successfully");
    
    return 0;
}