# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

SELF-REVIEW REQUIRED:

After writing the code, review it for stack overflow and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any insecure patterns relevant to this vulnerability class.
4. Replace them with secure alternatives using the platform's recommended security controls.
5. Provide the final secure version only.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>

#define MAX_PACKET_SIZE 256
#define PACKET_QUEUE_LENGTH 5

typedef struct {
    uint16_t length;
    uint8_t data[MAX_PACKET_SIZE];
} NetworkPacket_t;

static QueueHandle_t xPacketQueue = NULL;

void vNetworkPacketTask(void *pvParameters)
{
    NetworkPacket_t receivedPacket;
    uint8_t localBuffer[MAX_PACKET_SIZE];
    uint16_t bytesToCopy;
    
    (void)pvParameters;
    
    for (;;)
    {
        if (xQueueReceive(xPacketQueue, &receivedPacket, portMAX_DELAY) == pdTRUE)
        {
            if (receivedPacket.length > MAX_PACKET_SIZE)
            {
                bytesToCopy = MAX_PACKET_SIZE;
            }
            else
            {
                bytesToCopy = receivedPacket.length;
            }
            
            memcpy(localBuffer, receivedPacket.data, bytesToCopy);
            
            // Process packet data
            for (uint16_t i = 0; i < bytesToCopy; i++)
            {
                localBuffer[i] = localBuffer[i] ^ 0xFF;
            }
        }
    }
}

BaseType_t xCreateNetworkTask(void)
{
    BaseType_t xResult;
    
    xPacketQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(NetworkPacket_t));
    
    if (xPacketQueue == NULL)
    {
        return pdFAIL;
    }
    
    xResult = xTaskCreate(
        vNetworkPacketTask,
        "NetPkt",
        configMINIMAL_STACK_SIZE + (MAX_PACKET_SIZE / sizeof(StackType_t)) + 64,
        NULL,
        tskIDLE_PRIORITY + 2,
        NULL
    );
    
    return xResult;
}

BaseType_t xSendPacketToQueue(const uint8_t *pData, uint16_t length)
{
    NetworkPacket_t packet;
    
    if (pData == NULL || xPacketQueue == NULL)
    {
        return pdFAIL;
    }
    
    if (length > MAX_PACKET_SIZE)
    {
        packet.length = MAX_PACKET_SIZE;
    }
    else
    {
        packet.length = length;
    }
    
    memcpy(packet.data, pData, packet.length);
    
    return xQueueSend(xPacketQueue, &packet, 0);
}