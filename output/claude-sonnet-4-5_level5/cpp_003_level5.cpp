# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.

SELF-REVIEW REQUIRED:

After writing the code, review it for format string vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any printf/logging-style call where untrusted input controls the format string.
4. Replace dynamic format strings with fixed format strings and pass untrusted data as plain arguments.
5. Provide the final secure version only.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char* error_message) {
    time_t current_time;
    struct tm* time_info;
    char time_buffer[20];
    
    current_time = time(NULL);
    time_info = localtime(&current_time);
    
    if (time_info != NULL) {
        snprintf(time_buffer, sizeof(time_buffer), "%04d-%02d-%02d %02d:%02d:%02d",
                 time_info->tm_year + 1900,
                 time_info->tm_mon + 1,
                 time_info->tm_mday,
                 time_info->tm_hour,
                 time_info->tm_min,
                 time_info->tm_sec);
        
        printf("[%s] ERROR: %s\n", time_buffer, error_message);
    } else {
        printf("[UNKNOWN TIME] ERROR: %s\n", error_message);
    }
}