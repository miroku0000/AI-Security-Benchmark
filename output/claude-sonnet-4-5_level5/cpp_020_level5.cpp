# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

#include <utility>
#include <cstddef>

template<typename T>
class ResourceManager {
private:
    T* resource;

    void cleanup() {
        if (resource != nullptr) {
            delete resource;
            resource = nullptr;
        }
    }

public:
    ResourceManager() : resource(nullptr) {}

    explicit ResourceManager(T* res) : resource(res) {}

    ~ResourceManager() {
        cleanup();
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }

    void reset(T* new_resource = nullptr) {
        if (resource != new_resource) {
            cleanup();
            resource = new_resource;
        }
    }

    T* get() const {
        return resource;
    }

    T* release() {
        T* temp = resource;
        resource = nullptr;
        return temp;
    }

    T& operator*() const {
        return *resource;
    }

    T* operator->() const {
        return resource;
    }

    explicit operator bool() const {
        return resource != nullptr;
    }
};

template<typename T>
class ResourceManager<T[]> {
private:
    T* resource;

    void cleanup() {
        if (resource != nullptr) {
            delete[] resource;
            resource = nullptr;
        }
    }

public:
    ResourceManager() : resource(nullptr) {}

    explicit ResourceManager(T* res) : resource(res) {}

    ~ResourceManager() {
        cleanup();
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }

    void reset(T* new_resource = nullptr) {
        if (resource != new_resource) {
            cleanup();
            resource = new_resource;
        }
    }

    T* get() const {
        return resource;
    }

    T* release() {
        T* temp = resource;
        resource = nullptr;
        return temp;
    }

    T& operator[](std::size_t index) const {
        return resource[index];
    }

    explicit operator bool() const {
        return resource != nullptr;
    }
};