# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

SELF-REVIEW REQUIRED:

After writing the code, review it for null pointer dereference risks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any dereference path that assumes initialization or non-null values without validation.
4. Add validation/initialization guarantees and remove unsafe dereferences.
5. Provide the final secure version only.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char* input_file;
    char* output_file;
    int verbose;
    int port;
} Config;

Config* parse_arguments(int argc, char* argv[]) {
    if (argc < 2) {
        fprintf(stderr, "Error: Insufficient arguments\n");
        return NULL;
    }
    
    Config* config = (Config*)malloc(sizeof(Config));
    if (config == NULL) {
        fprintf(stderr, "Error: Memory allocation failed\n");
        return NULL;
    }
    
    config->input_file = NULL;
    config->output_file = NULL;
    config->verbose = 0;
    config->port = 8080;
    
    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            if (i + 1 < argc) {
                config->input_file = strdup(argv[++i]);
                if (config->input_file == NULL) {
                    fprintf(stderr, "Error: Memory allocation failed for input file\n");
                    free(config->output_file);
                    free(config);
                    return NULL;
                }
            } else {
                fprintf(stderr, "Error: Missing value for input file\n");
                free(config->output_file);
                free(config->input_file);
                free(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 < argc) {
                config->output_file = strdup(argv[++i]);
                if (config->output_file == NULL) {
                    fprintf(stderr, "Error: Memory allocation failed for output file\n");
                    free(config->input_file);
                    free(config);
                    return NULL;
                }
            } else {
                fprintf(stderr, "Error: Missing value for output file\n");
                free(config->input_file);
                free(config->output_file);
                free(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbose = 1;
        } else if (strcmp(argv[i], "-p") == 0 || strcmp(argv[i], "--port") == 0) {
            if (i + 1 < argc) {
                config->port = atoi(argv[++i]);
            } else {
                fprintf(stderr, "Error: Missing value for port\n");
                free(config->input_file);
                free(config->output_file);
                free(config);
                return NULL;
            }
        }
    }
    
    if (config->input_file == NULL) {
        fprintf(stderr, "Error: Input file is required\n");
        free(config->output_file);
        free(config);
        return NULL;
    }
    
    return config;
}

void free_config(Config* config) {
    if (config != NULL) {
        free(config->input_file);
        free(config->output_file);
        free(config);
    }
}

int initialize_application(Config* config) {
    if (config == NULL) {
        fprintf(stderr, "Error: Cannot initialize application with NULL config\n");
        return -1;
    }
    
    printf("Initializing application...\n");
    printf("Input file: %s\n", config->input_file);
    
    if (config->output_file != NULL) {
        printf("Output file: %s\n", config->output_file);
    } else {
        printf("Output file: stdout\n");
    }
    
    printf("Verbose: %s\n", config->verbose ? "enabled" : "disabled");
    printf("Port: %d\n", config->port);
    
    return 0;
}

int main(int argc, char* argv[]) {
    Config* config = parse_arguments(argc, argv);
    
    if (config == NULL) {
        fprintf(stderr, "Failed to parse arguments. Exiting.\n");
        return 1;
    }
    
    int result = initialize_application(config);
    
    if (result != 0) {
        fprintf(stderr, "Failed to initialize application\n");
        free_config(config);
        return 1;
    }
    
    printf("Application started successfully\n");
    
    free_config(config);
    return 0;
}