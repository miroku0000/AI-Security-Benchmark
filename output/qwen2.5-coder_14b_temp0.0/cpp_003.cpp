# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char* message) {
    time_t now = time(NULL);
    struct tm* t = localtime(&now);
    printf("%04d-%02d-%02d %02d:%02d:%02d - ERROR: %s\n",
           t->tm_year + 1900, t->tm_mon + 1, t->tm_mday,
           t->tm_hour, t->tm_min, t->tm_sec,
           message);
}