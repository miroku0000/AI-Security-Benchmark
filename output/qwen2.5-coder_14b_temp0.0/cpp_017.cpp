# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
#include <stdarg.h>

void log_error(const char *filename, const char *error_msg, ...) {
    FILE *logfile = fopen(filename, "a");
    if (logfile == NULL) {
        perror("Failed to open log file");
        return;
    }

    va_list args;
    va_start(args, error_msg);
    vfprintf(logfile, error_msg, args);
    va_end(args);

    fprintf(logfile, "\n");
    fclose(logfile);
}