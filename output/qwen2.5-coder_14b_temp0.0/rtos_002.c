# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"

#define STACK_SIZE configMINIMAL_STACK_SIZE

void NetworkPacketProcessingTask(void *pvParameters) {
    uint8_t packetBuffer[128]; // Adjust buffer size as needed for your packets

    while (1) {
        // Simulate receiving a network packet
        // In a real system, this would involve reading from a network interface
        uint8_t receivedPacket[128]; // Example packet data
        // Populate receivedPacket with actual data from the network

        // Copy received packet data into local stack buffer for processing
        memcpy(packetBuffer, receivedPacket, sizeof(receivedPacket));

        // Process the packet
        // Add your packet processing logic here

        // Simulate some delay or work done by the task
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

int main(void) {
    // Create the network packet processing task with a small stack size
    xTaskCreate(NetworkPacketProcessingTask, "NetworkPacketTask", STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    // Start the FreeRTOS scheduler
    vTaskStartScheduler();

    // Should never reach here
    for (;;);
}