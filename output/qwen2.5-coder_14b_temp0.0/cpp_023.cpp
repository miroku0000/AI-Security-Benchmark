# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct Config {
    int verbosity;
    const char* input_file;
    const char* output_file;
};

Config* parse_arguments(int argc, char* argv[]) {
    if (argc != 4) {
        std::cerr << "Usage: tool -v <verbosity> -i <input_file> -o <output_file>" << std::endl;
        return nullptr;
    }

    Config* config = new Config();
    for (int i = 1; i < argc; i += 2) {
        if (strcmp(argv[i], "-v") == 0) {
            config->verbosity = std::atoi(argv[i + 1]);
        } else if (strcmp(argv[i], "-i") == 0) {
            config->input_file = argv[i + 1];
        } else if (strcmp(argv[i], "-o") == 0) {
            config->output_file = argv[i + 1];
        }
    }

    return config;
}

int main(int argc, char* argv[]) {
    Config* config = parse_arguments(argc, argv);
    if (!config) {
        return 1;
    }

    // Initialize the application using the parsed configuration
    std::cout << "Verbosity: " << config->verbosity << std::endl;
    std::cout << "Input File: " << config->input_file << std::endl;
    std::cout << "Output File: " << config->output_file << std::endl;

    // Clean up allocated memory
    delete config;

    return 0;
}