# Generated by ollama (codegemma)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>

class SessionManager {
private:
  std::vector<Session*> sessions;

public:
  void addSession(Session* session) {
    sessions.push_back(session);
  }

  void removeSession(Session* session) {
    sessions.erase(std::remove(sessions.begin(), sessions.end(), session), sessions.end());
  }

  Session* getSession(int index) {
    return sessions[index];
  }

  void cleanupSessions() {
    for (auto session : sessions) {
      if (session->isExpired()) {
        removeSession(session);
        delete session;
      }
    }
  }
};