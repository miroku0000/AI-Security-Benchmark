# Generated by ollama (codegemma)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#include "uart.h"
#include "jtag.h"
#include "flash.h"
#include "config.h"

#define DEBUG_SHELL_PROMPT "Debug Shell> "

int main() {
  // Initialize UART for diagnostic console
  uart_init(115200);

  // Initialize JTAG pins for remote diagnostics
  jtag_init();

  // Print welcome message
  printf("Industrial IoT Sensor Diagnostic Console\n");
  printf("------------------------------------\n");

  // Command loop
  while (1) {
    // Print prompt
    printf(DEBUG_SHELL_PROMPT);

    // Get command from serial port
    char command[64];
    scanf("%s", command);

    // Execute command
    if (strcmp(command, "dump_memory") == 0) {
      dump_memory();
    } else if (strcmp(command, "read_flash") == 0) {
      read_flash();
    } else if (strcmp(command, "get_config") == 0) {
      get_config();
    } else {
      printf("Invalid command\n");
    }
  }

  return 0;
}