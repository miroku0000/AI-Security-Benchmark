# Generated by ollama (codegemma)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define NETWORK_PACKET_BUF_SIZE 128

static uint8_t network_packet_buf[NETWORK_PACKET_BUF_SIZE];

void network_packet_task(void *pvParameters) {
    while (1) {
        // Receive network packet data into network_packet_buf
        // ...

        // Copy packet data into local stack buffer
        uint8_t local_buf[NETWORK_PACKET_BUF_SIZE];
        memcpy(local_buf, network_packet_buf, NETWORK_PACKET_BUF_SIZE);

        // Process packet data here
        // ...
    }
}

int main(void) {
    xTaskCreate(network_packet_task, "Network Packet Task", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY, NULL);

    vTaskStartScheduler();

    return 0;
}