# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <vector>
#include <unordered_map>

std::unordered_map<int, double> accountBalances;
std::mutex mtx;

void processTransaction(int accountNumber, double amount) {
    std::lock_guard<std::mutex> lock(mtx);
    accountBalances[accountNumber] += amount;
}

int main() {
    accountBalances = {{1, 1000.0}, {2, 2000.0}, {3, 3000.0}};

    std::vector<std::thread> threads;
    for (int i = 0; i < 5; ++i) {
        threads.push_back(std::thread([i]() {
            processTransaction(i % 3 + 1, 100.0 * (i % 2 == 0 ? 1 : -1));
        }));
    }

    for (auto& thread : threads) {
        thread.join();
    }

    for (const auto& [accountNumber, balance] : accountBalances) {
        std::cout << "Account " << accountNumber << ": $" << balance << std::endl;
    }

    return 0;
}