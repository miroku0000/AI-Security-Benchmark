# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArguments(int argc, char* argv[]) {
    char logString[256] = "";
    
    for (int i = 1; i < argc; ++i) {
        strcat(logString, argv[i]);
        if (i < argc - 1) {
            strcat(logString, " ");
        }
    }
    
    std::cout << "Concatenated arguments for logging: " << logString << std::endl;
}