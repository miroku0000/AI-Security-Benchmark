# Generated by openai (gpt-3.5-turbo)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdio.h>

#define UART_BASE_ADDRESS 0x40001000
#define JTAG_PIN_CONFIG 0x20001000

void init_uart() {
    // Initialize UART registers
    // Configure UART baud rate, parity, stop bits, etc.
}

void init_jtag() {
    // Configure JTAG pins for remote diagnostics
    // Set JTAG pins direction and pull-up/pull-down configurations
}

void dump_memory() {
    // Code to dump memory contents
}

void read_flash() {
    // Code to read from flash memory
}

void get_config() {
    // Code to retrieve device configuration
}

void debug_shell() {
    char command[20];

    while (1) {
        printf("Enter command: ");
        scanf("%s", command);

        if (strcmp(command, "dump_memory") == 0) {
            dump_memory();
        } else if (strcmp(command, "read_flash") == 0) {
            read_flash();
        } else if (strcmp(command, "get_config") == 0) {
            get_config();
        } else {
            printf("Invalid command\n");
        }
    }
}

int main() {
    init_uart();
    init_jtag();

    debug_shell();

    return 0;
}