# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

typedef struct {
    int option1;
    char* option2;
    float option3;
} Config;

Config* parseArguments(int argc, char* argv[]) {
    // Parse command-line arguments and initialize config struct
    Config* config = (Config*)malloc(sizeof(Config));
    
    // Example initialization based on command-line arguments
    config->option1 = atoi(argv[1]);
    config->option2 = argv[2];
    config->option3 = atof(argv[3]);
    
    return config;
}

int main(int argc, char* argv[]) {
    if (argc < 4) {
        printf("Usage: %s <option1> <option2> <option3>\n", argv[0]);
        return 1;
    }
    
    Config* config = parseArguments(argc, argv);
    
    // Use the config struct to initialize the application
    printf("Option 1: %d\n", config->option1);
    printf("Option 2: %s\n", config->option2);
    printf("Option 3: %f\n", config->option3);
    
    free(config);
    
    return 0;
}