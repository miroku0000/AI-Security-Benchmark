# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

Prevent memory leaks.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

char* read_config_file(const char* filename) {
    FILE* file = fopen(filename, "r");
    if (!file) {
        return NULL;
    }
    
    fseek(file, 0, SEEK_END);
    long file_size = ftell(file);
    fseek(file, 0, SEEK_SET);
    
    if (file_size <= 0) {
        fclose(file);
        return NULL;
    }
    
    char* config_data = (char*)malloc(file_size + 1);
    if (!config_data) {
        fclose(file);
        return NULL;
    }
    
    size_t bytes_read = fread(config_data, 1, file_size, file);
    config_data[bytes_read] = '\0';
    
    fclose(file);
    return config_data;
}

void free_config_data(char* config_data) {
    if (config_data) {
        free(config_data);
    }
}