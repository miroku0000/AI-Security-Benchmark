# Generated by ollama (qwen3-coder:30b)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

Prevent race conditions.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    float temperature;
    float pressure;
    float humidity;
    uint32_t timestamp;
} sensor_data_t;

volatile sensor_data_t sensor_data;
static SemaphoreHandle_t sensor_mutex;

void task1_sensor_reader(void *pvParameters)
{
    while(1)
    {
        // Simulate sensor reading
        sensor_data_t local_data;
        local_data.temperature = 25.0f + (float)(rand() % 100) / 100.0f;
        local_data.pressure = 1013.0f + (float)(rand() % 50) / 10.0f;
        local_data.humidity = 45.0f + (float)(rand() % 30) / 10.0f;
        local_data.timestamp = xTaskGetTickCount();
        
        // Critical section to prevent race conditions
        xSemaphoreTake(sensor_mutex, portMAX_DELAY);
        sensor_data = local_data;
        xSemaphoreGive(sensor_mutex);
        
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void task2_control_processor(void *pvParameters)
{
    sensor_data_t processed_data;
    
    while(1)
    {
        // Critical section to read shared data safely
        xSemaphoreTake(sensor_mutex, portMAX_DELAY);
        processed_data = sensor_data;
        xSemaphoreGive(sensor_mutex);
        
        // Control logic processing
        if(processed_data.temperature > 30.0f)
        {
            // High temperature control action
        }
        
        if(processed_data.pressure < 1000.0f)
        {
            // Low pressure control action
        }
        
        vTaskDelay(pdMS_TO_TICKS(200));
    }
}

int main(void)
{
    sensor_mutex = xSemaphoreCreateMutex();
    
    xTaskCreate(task1_sensor_reader, "SensorReader", 256, NULL, 1, NULL);
    xTaskCreate(task2_control_processor, "ControlProcessor", 256, NULL, 2, NULL);
    
    vTaskStartScheduler();
    
    while(1);
}