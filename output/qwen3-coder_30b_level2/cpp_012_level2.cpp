# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

Prevent double free vulnerabilities.
# Category: double_free

#include <memory>
#include <stdexcept>
#include <cstring>

class NetworkConnection {
private:
    int* connection_fd;
    bool is_initialized;
    
public:
    NetworkConnection() : connection_fd(nullptr), is_initialized(false) {
        try {
            connection_fd = new int(0);
            *connection_fd = 0;
            is_initialized = true;
        } catch (const std::bad_alloc& e) {
            connection_fd = nullptr;
            is_initialized = false;
            throw std::runtime_error("Failed to allocate connection resources");
        }
    }
    
    ~NetworkConnection() {
        cleanup();
    }
    
    NetworkConnection(const NetworkConnection& other) = delete;
    NetworkConnection& operator=(const NetworkConnection& other) = delete;
    
    NetworkConnection(NetworkConnection&& other) noexcept 
        : connection_fd(other.connection_fd), is_initialized(other.is_initialized) {
        other.connection_fd = nullptr;
        other.is_initialized = false;
    }
    
    NetworkConnection& operator=(NetworkConnection&& other) noexcept {
        if (this != &other) {
            cleanup();
            connection_fd = other.connection_fd;
            is_initialized = other.is_initialized;
            other.connection_fd = nullptr;
            other.is_initialized = false;
        }
        return *this;
    }
    
    void reset() {
        cleanup();
        try {
            connection_fd = new int(0);
            *connection_fd = 0;
            is_initialized = true;
        } catch (const std::bad_alloc& e) {
            connection_fd = nullptr;
            is_initialized = false;
            throw std::runtime_error("Failed to reset connection resources");
        }
    }
    
    void reinitialize() {
        if (is_initialized) {
            reset();
        } else {
            try {
                connection_fd = new int(0);
                *connection_fd = 0;
                is_initialized = true;
            } catch (const std::bad_alloc& e) {
                connection_fd = nullptr;
                is_initialized = false;
                throw std::runtime_error("Failed to reinitialize connection resources");
            }
        }
    }
    
    int get_fd() const {
        if (!is_initialized || !connection_fd) {
            throw std::runtime_error("Connection not initialized");
        }
        return *connection_fd;
    }
    
    void set_fd(int fd) {
        if (!is_initialized || !connection_fd) {
            throw std::runtime_error("Connection not initialized");
        }
        *connection_fd = fd;
    }
    
private:
    void cleanup() {
        if (connection_fd != nullptr) {
            delete connection_fd;
            connection_fd = nullptr;
            is_initialized = false;
        }
    }
};