# Generated by ollama (qwen3-coder:30b)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

Prevent memory leaks.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>

#define BUFFER_SIZE 4096
#define MAX_REQUESTS 1000

typedef struct {
    char *buffer;
    size_t size;
    size_t used;
} request_buffer_t;

request_buffer_t* create_request_buffer() {
    request_buffer_t *buf = (request_buffer_t*)malloc(sizeof(request_buffer_t));
    if (!buf) return NULL;
    
    buf->buffer = (char*)malloc(BUFFER_SIZE);
    if (!buf->buffer) {
        free(buf);
        return NULL;
    }
    
    buf->size = BUFFER_SIZE;
    buf->used = 0;
    return buf;
}

void destroy_request_buffer(request_buffer_t *buf) {
    if (buf) {
        free(buf->buffer);
        free(buf);
    }
}

int process_request(request_buffer_t *buf) {
    if (!buf || !buf->buffer) return -1;
    
    char *request = buf->buffer;
    char *method = strtok(request, " ");
    
    if (!method) return -1;
    
    if (strcmp(method, "GET") == 0) {
        printf("Processing GET request\n");
    } else if (strcmp(method, "POST") == 0) {
        printf("Processing POST request\n");
    } else {
        printf("Unknown request method\n");
        return -1;
    }
    
    return 0;
}

int main() {
    request_buffer_t *buffers[MAX_REQUESTS];
    int buffer_count = 0;
    
    for (int i = 0; i < MAX_REQUESTS; i++) {
        buffers[i] = create_request_buffer();
        if (!buffers[i]) {
            printf("Failed to allocate buffer %d\n", i);
            break;
        }
        buffer_count++;
    }
    
    int current_buffer = 0;
    
    while (1) {
        request_buffer_t *buf = buffers[current_buffer];
        
        if (buf && buf->buffer) {
            memset(buf->buffer, 0, buf->size);
            buf->used = 0;
            
            char *input = fgets(buf->buffer, buf->size, stdin);
            if (input) {
                process_request(buf);
            } else {
                break;
            }
        }
        
        current_buffer = (current_buffer + 1) % buffer_count;
        
        usleep(1000);
    }
    
    for (int i = 0; i < buffer_count; i++) {
        destroy_request_buffer(buffers[i]);
    }
    
    return 0;
}