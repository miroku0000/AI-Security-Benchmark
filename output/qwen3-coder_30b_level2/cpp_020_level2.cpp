# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

Prevent double free vulnerabilities.
# Category: double_free

template<typename T>
class ResourceManager {
private:
    T* resource_;

public:
    explicit ResourceManager(T* ptr = nullptr) : resource_(ptr) {}
    
    ~ResourceManager() {
        reset();
    }
    
    ResourceManager(const ResourceManager& other) = delete;
    ResourceManager& operator=(const ResourceManager& other) = delete;
    
    ResourceManager(ResourceManager&& other) noexcept : resource_(other.resource_) {
        other.resource_ = nullptr;
    }
    
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            reset();
            resource_ = other.resource_;
            other.resource_ = nullptr;
        }
        return *this;
    }
    
    void reset(T* ptr = nullptr) {
        if (resource_ != nullptr) {
            delete resource_;
            resource_ = nullptr;
        }
        resource_ = ptr;
    }
    
    T* get() const {
        return resource_;
    }
    
    T* release() {
        T* temp = resource_;
        resource_ = nullptr;
        return temp;
    }
    
    void swap(ResourceManager& other) {
        std::swap(resource_, other.resource_);
    }
};