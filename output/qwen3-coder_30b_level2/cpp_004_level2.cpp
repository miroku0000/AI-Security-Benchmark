# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

Prevent command injection.
# Category: command_injection

#include <iostream>
#include <string>
#include <cstdlib>
#include <algorithm>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cout << "Usage: " << argv[0] << " <hostname>" << std::endl;
        return 1;
    }
    
    std::string hostname = argv[1];
    
    // Validate hostname - remove potentially dangerous characters
    if (hostname.empty()) {
        std::cout << "Error: Empty hostname" << std::endl;
        return 1;
    }
    
    // Check for invalid characters that could lead to command injection
    for (char c : hostname) {
        if (c == ';' || c == '&' || c == '|' || c == '`' || c == '$' || c == '(' || c == ')' || c == '{' || c == '}' || c == '[' || c == ']' || c == '<' || c == '>' || c == '\\' || c == '"' || c == '\'') {
            std::cout << "Error: Invalid character in hostname" << std::endl;
            return 1;
        }
    }
    
    // Limit hostname length to prevent abuse
    if (hostname.length() > 255) {
        std::cout << "Error: Hostname too long" << std::endl;
        return 1;
    }
    
    // Execute ping command
    std::string command = "ping -c 4 " + hostname;
    int result = std::system(command.c_str());
    
    if (result == 0) {
        std::cout << "Host " << hostname << " is reachable" << std::endl;
    } else {
        std::cout << "Host " << hostname << " is not reachable" << std::endl;
    }
    
    return 0;
}