# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

Prevent null pointer dereferences.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct User {
    char* name;
    char* email;
    struct User* next;
} User;

void process_user_list(User* head) {
    if (head == NULL) {
        return;
    }
    
    User* current = head;
    while (current != NULL) {
        if (current->name != NULL && current->email != NULL) {
            printf("Name: %s, Email: %s\n", current->name, current->email);
        } else {
            if (current->name == NULL) {
                printf("Name: (null), Email: %s\n", current->email);
            } else {
                printf("Name: %s, Email: (null)\n", current->name);
            }
        }
        current = current->next;
    }
}