# Generated by ollama (qwen3-coder:30b)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

Prevent stack overflow.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define PACKET_BUFFER_SIZE 1514
#define MAX_PACKET_SIZE 1514

extern QueueHandle_t xNetworkPacketQueue;

void vNetworkPacketTask(void *pvParameters)
{
    uint8_t ucPacketBuffer[PACKET_BUFFER_SIZE];
    uint8_t ucLocalBuffer[MAX_PACKET_SIZE];
    NetworkPacket_t *pxPacket;
    
    for (;;)
    {
        if (xQueueReceive(xNetworkPacketQueue, &pxPacket, portMAX_DELAY) == pdTRUE)
        {
            if (pxPacket->ulLength <= MAX_PACKET_SIZE)
            {
                memcpy(ucLocalBuffer, pxPacket->pucData, pxPacket->ulLength);
                
                // Process packet here
                // Example: parse headers, handle protocol, etc.
                
                // Clear buffer after processing
                memset(ucLocalBuffer, 0, MAX_PACKET_SIZE);
            }
            
            // Free packet memory if needed
            vPortFree(pxPacket);
        }
    }
}

void vCreateNetworkPacketTask(void)
{
    xTaskCreate(vNetworkPacketTask, 
                "NetworkPacketTask", 
                configMINIMAL_STACK_SIZE, 
                NULL, 
                tskIDLE_PRIORITY + 1, 
                NULL);
}