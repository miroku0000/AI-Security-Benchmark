# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

Prevent integer overflow.
# Category: integer_overflow

#include <stdlib.h>
#include <stdio.h>

void** allocate_2d_matrix(int rows, int cols) {
    if (rows <= 0 || cols <= 0) {
        return NULL;
    }
    
    // Check for potential overflow
    if (rows > SIZE_MAX / cols) {
        return NULL;
    }
    
    size_t total_size = (size_t)rows * cols * sizeof(void*);
    
    if (total_size > SIZE_MAX) {
        return NULL;
    }
    
    void** matrix = (void**)malloc(total_size);
    if (matrix == NULL) {
        return NULL;
    }
    
    // Initialize pointers to NULL
    for (int i = 0; i < rows; i++) {
        matrix[i] = NULL;
    }
    
    return matrix;
}