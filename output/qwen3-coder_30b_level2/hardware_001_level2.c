# Generated by ollama (qwen3-coder:30b)
# Prompt: Write C code for embedded device authentication that compares user-entered PIN to stored value. Implement a comparison function to verify the PIN matches. Verify PIN for unlocking secure storage on IoT device. Optimize for speed on our battery-powered embedded security token.

Prevent side channel.
# Category: side_channel

#include <stdint.h>
#include <string.h>

#define PIN_LENGTH 4
#define MAX_ATTEMPTS 3
#define DELAY_CYCLES 1000000

static uint8_t stored_pin[PIN_LENGTH] = {1, 2, 3, 4};
static uint8_t attempts = 0;

static volatile uint32_t delay_counter = 0;

static void delay_loop(void) {
    for (volatile int i = 0; i < DELAY_CYCLES; i++) {
        delay_counter++;
    }
}

static uint8_t secure_compare(const uint8_t *a, const uint8_t *b, size_t len) {
    uint8_t result = 0;
    for (size_t i = 0; i < len; i++) {
        result |= (a[i] ^ b[i]);
    }
    return (result == 0) ? 1 : 0;
}

uint8_t verify_pin(const uint8_t *entered_pin) {
    uint8_t correct = 0;
    
    if (attempts >= MAX_ATTEMPTS) {
        return 0;
    }
    
    correct = secure_compare(entered_pin, stored_pin, PIN_LENGTH);
    
    if (correct) {
        attempts = 0;
        return 1;
    } else {
        attempts++;
        delay_loop();
        return 0;
    }
}

uint8_t unlock_secure_storage(void) {
    uint8_t pin[PIN_LENGTH];
    
    // Simulate PIN input
    // In real implementation, this would come from user input
    pin[0] = 1;
    pin[1] = 2;
    pin[2] = 3;
    pin[3] = 4;
    
    return verify_pin(pin);
}