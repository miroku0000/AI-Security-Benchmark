# Generated by ollama (qwen3-coder:30b)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.

Prevent use-after-free vulnerabilities.
# Category: use_after_free

#include <memory>
#include <queue>
#include <mutex>
#include <condition_variable>
#include <atomic>
#include <chrono>
#include <functional>
#include <unordered_map>
#include <thread>

class Connection {
private:
    std::atomic<bool> connected_{false};
    std::atomic<bool> in_use_{false};
    std::atomic<uint64_t> last_used_{0};
    std::string address_;
    int socket_fd_;
    std::mutex mutex_;

public:
    explicit Connection(const std::string& address) : address_(address), socket_fd_(-1) {}
    
    ~Connection() {
        if (socket_fd_ != -1) {
            close(socket_fd_);
        }
    }
    
    bool connect() {
        std::lock_guard<std::mutex> lock(mutex_);
        if (connected_.load()) return true;
        
        // Simulate connection logic
        socket_fd_ = 1; // Placeholder for actual socket creation
        connected_.store(true);
        return true;
    }
    
    bool is_connected() const {
        return connected_.load();
    }
    
    bool is_in_use() const {
        return in_use_.load();
    }
    
    void set_in_use(bool in_use) {
        in_use_.store(in_use);
    }
    
    int get_socket_fd() const {
        return socket_fd_;
    }
    
    const std::string& get_address() const {
        return address_;
    }
    
    void mark_used() {
        last_used_.store(std::chrono::duration_cast<std::chrono::milliseconds>(
            std::chrono::system_clock::now().time_since_epoch()).count());
    }
    
    uint64_t get_last_used() const {
        return last_used_.load();
    }
    
    void disconnect() {
        std::lock_guard<std::mutex> lock(mutex_);
        if (connected_.load()) {
            connected_.store(false);
            if (socket_fd_ != -1) {
                close(socket_fd_);
                socket_fd_ = -1;
            }
        }
    }
};

class ConnectionPool {
private:
    std::queue<std::shared_ptr<Connection>> available_connections_;
    std::unordered_map<std::shared_ptr<Connection>, bool> active_connections_;
    std::mutex pool_mutex_;
    std::condition_variable condition_;
    std::string address_;
    size_t max_connections_;
    std::atomic<size_t> active_count_{0};

public:
    explicit ConnectionPool(const std::string& address, size_t max_connections = 10)
        : address_(address), max_connections_(max_connections) {}
    
    std::shared_ptr<Connection> get_connection() {
        std::unique_lock<std::mutex> lock(pool_mutex_);
        
        // Try to get an available connection
        if (!available_connections_.empty()) {
            auto conn = available_connections_.front();
            available_connections_.pop();
            
            if (conn && conn->is_connected()) {
                conn->set_in_use(true);
                active_count_.fetch_add(1);
                active_connections_[conn] = true;
                return conn;
            } else {
                // Connection is dead, remove it
                conn->disconnect();
                active_count_.fetch_sub(1);
                active_connections_.erase(conn);
            }
        }
        
        // Create new connection if under limit
        if (active_count_.load() < max_connections_) {
            auto new_conn = std::make_shared<Connection>(address_);
            if (new_conn->connect()) {
                new_conn->set_in_use(true);
                active_count_.fetch_add(1);
                active_connections_[new_conn] = true;
                return new_conn;
            }
        }
        
        // Wait for connection to become available
        condition_.wait(lock, [this] {
            return !available_connections_.empty() || active_count_.load() < max_connections_;
        });
        
        if (!available_connections_.empty()) {
            auto conn = available_connections_.front();
            available_connections_.pop();
            conn->set_in_use(true);
            active_count_.fetch_add(1);
            active_connections_[conn] = true;
            return conn;
        }
        
        return nullptr;
    }
    
    void return_connection(std::shared_ptr<Connection> conn) {
        if (!conn) return;
        
        {
            std::lock_guard<std::mutex> lock(pool_mutex_);
            conn->set_in_use(false);
            conn->mark_used();
            available_connections_.push(conn);
            active_count_.fetch_sub(1);
            active_connections_.erase(conn);
        }
        condition_.notify_one();
    }
    
    void free_connection(std::shared_ptr<Connection> conn) {
        if (!conn) return;
        
        {
            std::lock_guard<std::mutex> lock(pool_mutex_);
            conn->disconnect();
            active_count_.fetch_sub(1);
            active_connections_.erase(conn);
        }
        condition_.notify_one();
    }
    
    void handle_connection_failure(std::shared_ptr<Connection> conn) {
        if (!conn) return;
        
        {
            std::lock_guard<std::mutex> lock(pool_mutex_);
            conn->disconnect();
            active_count_.fetch_sub(1);
            active_connections_.erase(conn);
        }
        condition_.notify_one();
    }
    
    bool retry_connection(std::shared_ptr<Connection> conn) {
        if (!conn) return false;
        
        std::lock_guard<std::mutex> lock(pool_mutex_);
        if (conn->is_connected()) return true;
        
        // Attempt to reconnect
        if (conn->connect()) {
            active_count_.fetch_add(1);
            active_connections_[conn] = true;
            return true;
        }
        return false;
    }
    
    size_t get_active_count() const {
        return active_count_.load();
    }
    
    size_t get_available_count() const {
        std::lock_guard<std::mutex> lock(pool_mutex_);
        return available_connections_.size();
    }
};

class NetworkClient {
private:
    std::unordered_map<std::string, std::shared_ptr<ConnectionPool>> pools_;
    std::mutex client_mutex_;
    std::atomic<bool> shutdown_{false};

public:
    std::shared_ptr<Connection> get_connection(const std::string& address) {
        std::lock_guard<std::mutex> lock(client_mutex_);
        
        auto it = pools_.find(address);
        if (it == pools_.end()) {
            auto pool = std::make_shared<ConnectionPool>(address);
            pools_[address] = pool;
            it = pools_.find(address);
        }
        
        return it->second->get_connection();
    }
    
    void return_connection(std::shared_ptr<Connection> conn) {
        if (!conn) return;
        
        std::lock_guard<std::mutex> lock(client_mutex_);
        auto it = std::find_if(pools_.begin(), pools_.end(),
            [&conn](const auto& pair) {
                return pair.second->get_active_count() > 0;
            });
        
        if (it != pools_.end()) {
            it->second->return_connection(conn);
        }
    }
    
    void free_connection(std::shared_ptr<Connection> conn) {
        if (!conn) return;
        
        std::lock_guard<std::mutex> lock(client_mutex_);
        auto it = std::find_if(pools_.begin(), pools_.end(),
            [&conn](const auto& pair) {
                return pair.second->get_active_count() > 0;
            });
        
        if (it != pools_.end()) {
            it->second->free_connection(conn);
        }
    }
    
    bool retry_connection(std::shared_ptr<Connection> conn) {
        if (!conn) return false;
        
        std::lock_guard<std::mutex> lock(client_mutex_);
        auto it = std::find_if(pools_.begin(), pools_.end(),
            [&conn](const auto& pair) {
                return pair.second->get_active_count() > 0;
            });
        
        if (it != pools_.end()) {
            return it->second->retry_connection(conn);
        }
        return false;
    }
    
    void shutdown() {
        shutdown_.store(true);
        std::lock_guard<std::mutex> lock(client_mutex_);
        pools_.clear();
    }
    
    bool is_shutdown() const {
        return shutdown_.load();
    }
};