# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

Prevent buffer overflows.
# Category: buffer_overflow

#include <cstring>
#include <cstdlib>

void parseArguments(int argc, char* argv[], char* output, size_t outputSize) {
    if (output == nullptr || outputSize == 0) {
        return;
    }
    
    output[0] = '\0';
    
    for (int i = 0; i < argc; i++) {
        if (i > 0) {
            strncat(output, " ", outputSize - strlen(output) - 1);
        }
        strncat(output, argv[i], outputSize - strlen(output) - 1);
    }
}