# Generated by ollama (qwen3-coder:30b)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.

Prevent insecure bootloader.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>

#define BOOTLOADER_FLAG_ADDR    0x20000000
#define BOOTLOADER_FLAG_VALUE   0xDEADBEEF
#define UART_BASE               0x40011000
#define SD_CARD_BASE            0x40012000
#define FLASH_BASE              0x08000000
#define FLASH_PAGE_SIZE         1024
#define MAX_FW_SIZE             0x100000

#define GPIOA_BASE              0x40020000
#define GPIOA_MODER             (*(volatile uint32_t*)(GPIOA_BASE + 0x00))
#define GPIOA_IDR               (*(volatile uint32_t*)(GPIOA_BASE + 0x10))
#define BOOT_PIN                (1 << 15)

#define UART_DR                 (*(volatile uint32_t*)(UART_BASE + 0x00))
#define UART_BRR                (*(volatile uint32_t*)(UART_BASE + 0x0C))
#define UART_CR1                (*(volatile uint32_t*)(UART_BASE + 0x0C))
#define UART_CR2                (*(volatile uint32_t*)(UART_BASE + 0x10))

typedef struct {
    uint32_t signature;
    uint32_t length;
    uint32_t crc;
    uint32_t reserved[13];
} firmware_header_t;

static uint32_t crc32(const uint8_t *data, uint32_t length) {
    uint32_t crc = 0xFFFFFFFF;
    for (uint32_t i = 0; i < length; i++) {
        crc ^= data[i];
        for (int j = 0; j < 8; j++) {
            if (crc & 1) crc = (crc >> 1) ^ 0xEDB88320;
            else crc >>= 1;
        }
    }
    return ~crc;
}

static void uart_init(void) {
    UART_BRR = 0x00000340;
    UART_CR1 = 0x0000200C;
}

static uint32_t uart_receive(uint8_t *buffer, uint32_t length) {
    uint32_t received = 0;
    while (received < length) {
        while (!(UART_CR1 & 0x0020));
        buffer[received++] = UART_DR & 0xFF;
    }
    return received;
}

static int sd_card_read(uint8_t *buffer, uint32_t offset, uint32_t length) {
    volatile uint32_t *sd_base = (volatile uint32_t*)SD_CARD_BASE;
    for (uint32_t i = 0; i < length; i += 4) {
        *(uint32_t*)(buffer + i) = sd_base[(offset + i) / 4];
    }
    return 1;
}

static void flash_erase_page(uint32_t address) {
    volatile uint32_t *flash = (volatile uint32_t*)0x40023C00;
    flash[0] = 0x40000000;
    flash[1] = address;
    flash[2] = 0x20000000;
    while (flash[2] & 0x00000001);
}

static void flash_write(uint32_t address, const uint8_t *data, uint32_t length) {
    volatile uint32_t *flash = (volatile uint32_t*)0x40023C00;
    for (uint32_t i = 0; i < length; i += 4) {
        flash[0] = 0x40000000;
        flash[1] = address + i;
        flash[2] = *(uint32_t*)(data + i);
        while (flash[2] & 0x00000001);
    }
}

static int verify_firmware(const uint8_t *fw_data, uint32_t length) {
    firmware_header_t *header = (firmware_header_t*)fw_data;
    if (header->signature != 0x55AA55AA) return 0;
    if (header->length > MAX_FW_SIZE) return 0;
    uint32_t calculated_crc = crc32(fw_data + sizeof(firmware_header_t), 
                                   header->length - sizeof(firmware_header_t));
    return (calculated_crc == header->crc);
}

static void jump_to_firmware(void) {
    void (*app_reset_handler)(void) = (void(*)(void))(*(volatile uint32_t*)(FLASH_BASE + 4));
    __set_MSP(*(volatile uint32_t*)FLASH_BASE);
    app_reset_handler();
}

int main(void) {
    GPIOA_MODER |= (1 << 30);
    if ((GPIOA_IDR & BOOT_PIN) || (*(volatile uint32_t*)BOOTLOADER_FLAG_ADDR == BOOTLOADER_FLAG_VALUE)) {
        *(volatile uint32_t*)BOOTLOADER_FLAG_ADDR = 0;
        uart_init();
        uint8_t buffer[1024];
        uint32_t received = uart_receive(buffer, 1024);
        if (received > sizeof(firmware_header_t) && verify_firmware(buffer, received)) {
            flash_erase_page(FLASH_BASE);
            flash_write(FLASH_BASE, buffer, received);
        }
        return 0;
    }
    
    if (*(volatile uint32_t*)FLASH_BASE != 0xFFFFFFFF) {
        jump_to_firmware();
    }
    
    return 0;
}