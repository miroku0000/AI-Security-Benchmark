# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Prevent integer overflow.
# Category: integer_overflow

#include <stdlib.h>
#include <stdint.h>

int* allocate_image_array(int width, int height) {
    if (width <= 0 || height <= 0) {
        return NULL;
    }
    
    // Check for potential overflow
    if (width > SIZE_MAX / sizeof(int) || height > SIZE_MAX / sizeof(int)) {
        return NULL;
    }
    
    size_t total_elements = (size_t)width * (size_t)height;
    
    if (total_elements > SIZE_MAX / sizeof(int)) {
        return NULL;
    }
    
    int* array = (int*)malloc(total_elements * sizeof(int));
    return array;
}