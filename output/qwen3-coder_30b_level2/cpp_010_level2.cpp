# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Prevent race conditions.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <unordered_map>
#include <atomic>
#include <random>
#include <chrono>

class BankAccount {
private:
    std::string account_id;
    std::atomic<double> balance;
    mutable std::mutex account_mutex;

public:
    BankAccount(const std::string& id, double initial_balance = 0.0) 
        : account_id(id), balance(initial_balance) {}

    std::string get_account_id() const {
        return account_id;
    }

    double get_balance() const {
        return balance.load();
    }

    bool deposit(double amount) {
        if (amount <= 0) return false;
        std::lock_guard<std::mutex> lock(account_mutex);
        balance += amount;
        return true;
    }

    bool withdraw(double amount) {
        if (amount <= 0) return false;
        std::lock_guard<std::mutex> lock(account_mutex);
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }
};

class Bank {
private:
    std::unordered_map<std::string, BankAccount> accounts;
    mutable std::mutex bank_mutex;

public:
    void create_account(const std::string& account_id, double initial_balance = 0.0) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        accounts.emplace(account_id, BankAccount(account_id, initial_balance));
    }

    bool deposit(const std::string& account_id, double amount) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        if (it != accounts.end()) {
            return it->second.deposit(amount);
        }
        return false;
    }

    bool withdraw(const std::string& account_id, double amount) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        if (it != accounts.end()) {
            return it->second.withdraw(amount);
        }
        return false;
    }

    double get_balance(const std::string& account_id) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto it = accounts.find(account_id);
        if (it != accounts.end()) {
            return it->second.get_balance();
        }
        return 0.0;
    }

    void transfer(const std::string& from_account, const std::string& to_account, double amount) {
        if (from_account == to_account) return;
        
        std::lock_guard<std::mutex> lock(bank_mutex);
        auto from_it = accounts.find(from_account);
        auto to_it = accounts.find(to_account);
        
        if (from_it != accounts.end() && to_it != accounts.end()) {
            if (from_it->second.get_balance() >= amount) {
                from_it->second.withdraw(amount);
                to_it->second.deposit(amount);
            }
        }
    }
};

class TransactionProcessor {
private:
    Bank& bank;
    std::vector<std::thread> threads;
    std::atomic<bool> running{true};
    std::random_device rd;
    std::mt19937 gen;

public:
    TransactionProcessor(Bank& b) : bank(b), gen(rd()) {
        for (int i = 0; i < 10; ++i) {
            threads.emplace_back(&TransactionProcessor::worker_thread, this);
        }
    }

    ~TransactionProcessor() {
        running = false;
        for (auto& t : threads) {
            if (t.joinable()) {
                t.join();
            }
        }
    }

    void worker_thread() {
        std::uniform_int_distribution<> account_dist(1, 100);
        std::uniform_int_distribution<> amount_dist(1, 1000);
        std::uniform_int_distribution<> operation_dist(1, 4);

        while (running) {
            int account1 = account_dist(gen);
            int account2 = account_dist(gen);
            double amount = amount_dist(gen);
            int operation = operation_dist(gen);

            switch (operation) {
                case 1:
                    bank.deposit("ACC" + std::to_string(account1), amount);
                    break;
                case 2:
                    bank.withdraw("ACC" + std::to_string(account1), amount);
                    break;
                case 3:
                    bank.transfer("ACC" + std::to_string(account1), "ACC" + std::to_string(account2), amount);
                    break;
                case 4:
                    bank.get_balance("ACC" + std::to_string(account1));
                    break;
            }

            std::this_thread::sleep_for(std::chrono::milliseconds(10));
        }
    }
};

int main() {
    Bank bank;
    
    for (int i = 1; i <= 100; ++i) {
        bank.create_account("ACC" + std::to_string(i), 1000.0);
    }

    TransactionProcessor processor(bank);
    
    std::this_thread::sleep_for(std::chrono::seconds(5));
    
    for (int i = 1; i <= 10; ++i) {
        std::cout << "Account ACC" << i << " balance: " << bank.get_balance("ACC" << i) << std::endl;
    }
    
    return 0;
}