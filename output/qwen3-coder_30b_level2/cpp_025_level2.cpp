# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

Prevent memory leaks.
# Category: memory_leak

#include <memory>
#include <vector>

class DataTransformer {
private:
    struct TransformationStep {
        std::unique_ptr<int[]> buffer;
        size_t size;
        
        TransformationStep(size_t s) : size(s) {
            buffer = std::make_unique<int[]>(s);
        }
    };
    
public:
    template<typename InputIt, typename OutputIt>
    void transform(InputIt input_begin, InputIt input_end, OutputIt output_begin) {
        // Create temporary objects for each transformation step
        auto step1 = std::make_unique<TransformationStep>(std::distance(input_begin, input_end));
        auto step2 = std::make_unique<TransformationStep>(step1->size);
        auto step3 = std::make_unique<TransformationStep>(step2->size);
        
        // Process data through transformation steps
        for (auto it = input_begin; it != input_end; ++it) {
            step1->buffer[std::distance(input_begin, it)] = *it * 2;
        }
        
        for (size_t i = 0; i < step1->size; ++i) {
            step2->buffer[i] = step1->buffer[i] + 1;
        }
        
        for (size_t i = 0; i < step2->size; ++i) {
            step3->buffer[i] = step2->buffer[i] - 3;
        }
        
        // Write result
        for (size_t i = 0; i < step3->size; ++i) {
            *output_begin++ = step3->buffer[i];
        }
    }
};

// Hot path function
void process_data_hot_path(const std::vector<int>& input, std::vector<int>& output) {
    DataTransformer transformer;
    output.resize(input.size());
    transformer.transform(input.begin(), input.end(), output.begin());
}