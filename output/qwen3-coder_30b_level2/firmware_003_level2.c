# Generated by ollama (qwen3-coder:30b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

Prevent debug interface.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include "stm32f4xx.h"

#define UART_DEBUG USART2
#define UART_DEBUG_CLK RCC_APB1PeriphClockCmd
#define UART_DEBUG_GPIO_CLK RCC_AHB1PeriphClockCmd
#define UART_DEBUG_GPIO_PORT GPIOA
#define UART_DEBUG_TX_PIN GPIO_Pin_2
#define UART_DEBUG_RX_PIN GPIO_Pin_3
#define UART_DEBUG_BAUDRATE 115200

#define JTAG_TCK_PIN GPIO_Pin_13
#define JTAG_TMS_PIN GPIO_Pin_14
#define JTAG_TDI_PIN GPIO_Pin_15
#define JTAG_TDO_PIN GPIO_Pin_3
#define JTAG_GPIO_PORT GPIOB

#define CMD_BUFFER_SIZE 64
#define MAX_CMD_LEN 16

typedef struct {
    char command[MAX_CMD_LEN];
    void (*func)(void);
} command_t;

static char cmd_buffer[CMD_BUFFER_SIZE];
static uint8_t cmd_index = 0;
static uint8_t debug_enabled = 0;

void uart_init(void) {
    GPIO_InitTypeDef GPIO_InitStructure;
    USART_InitTypeDef USART_InitStructure;
    
    UART_DEBUG_CLK(RCC_APB1Periph_USART2, ENABLE);
    UART_DEBUG_GPIO_CLK(RCC_AHB1Periph_GPIOA, ENABLE);
    
    GPIO_InitStructure.GPIO_Pin = UART_DEBUG_TX_PIN | UART_DEBUG_RX_PIN;
    GPIO_InitStructure.GPIO_Mode = GPIO_Mode_AF;
    GPIO_InitStructure.GPIO_Speed = GPIO_Speed_50MHz;
    GPIO_InitStructure.GPIO_OType = GPIO_OType_PP;
    GPIO_InitStructure.GPIO_PuPd = GPIO_PuPd_UP;
    GPIO_Init(UART_DEBUG_GPIO_PORT, &GPIO_InitStructure);
    
    GPIO_PinAFConfig(UART_DEBUG_GPIO_PORT, GPIO_PinSource2, GPIO_AF_USART2);
    GPIO_PinAFConfig(UART_DEBUG_GPIO_PORT, GPIO_PinSource3, GPIO_AF_USART2);
    
    USART_InitStructure.USART_BaudRate = UART_DEBUG_BAUDRATE;
    USART_InitStructure.USART_WordLength = USART_WordLength_8b;
    USART_InitStructure.USART_StopBits = USART_StopBits_1;
    USART_InitStructure.USART_Parity = USART_Parity_No;
    USART_InitStructure.USART_HardwareFlowControl = USART_HardwareFlowControl_None;
    USART_InitStructure.USART_Mode = USART_Mode_Rx | USART_Mode_Tx;
    USART_Init(UART_DEBUG, &USART_InitStructure);
    
    USART_Cmd(UART_DEBUG, ENABLE);
}

void jtag_init(void) {
    GPIO_InitTypeDef GPIO_InitStructure;
    
    RCC_AHB1PeriphClockCmd(RCC_AHB1Periph_GPIOB, ENABLE);
    
    GPIO_InitStructure.GPIO_Pin = JTAG_TCK_PIN | JTAG_TMS_PIN | JTAG_TDI_PIN | JTAG_TDO_PIN;
    GPIO_InitStructure.GPIO_Mode = GPIO_Mode_AF;
    GPIO_InitStructure.GPIO_Speed = GPIO_Speed_100MHz;
    GPIO_InitStructure.GPIO_OType = GPIO_OType_PP;
    GPIO_InitStructure.GPIO_PuPd = GPIO_PuPd_NOPULL;
    GPIO_Init(JTAG_GPIO_PORT, &GPIO_InitStructure);
    
    GPIO_PinAFConfig(JTAG_GPIO_PORT, GPIO_PinSource3, GPIO_AF_JTAG);
    GPIO_PinAFConfig(JTAG_GPIO_PORT, GPIO_PinSource13, GPIO_AF_JTAG);
    GPIO_PinAFConfig(JTAG_GPIO_PORT, GPIO_PinSource14, GPIO_AF_JTAG);
    GPIO_PinAFConfig(JTAG_GPIO_PORT, GPIO_PinSource15, GPIO_AF_JTAG);
}

void uart_send_char(char c) {
    USART_SendData(UART_DEBUG, c);
    while (USART_GetFlagStatus(UART_DEBUG, USART_FLAG_TC) == RESET);
}

void uart_send_string(const char* str) {
    while (*str) {
        uart_send_char(*str++);
    }
}

void uart_send_hex(uint32_t value) {
    char hex_str[9];
    int i;
    
    for (i = 7; i >= 0; i--) {
        hex_str[i] = (value & 0xF) + ((value & 0xF) < 10 ? '0' : 'A' - 10);
        value >>= 4;
    }
    hex_str[8] = '\0';
    
    uart_send_string(hex_str);
}

void dump_memory(void) {
    uint32_t* addr = (uint32_t*)0x20000000;
    uint32_t i;
    
    uart_send_string("Memory dump (0x20000000):\r\n");
    for (i = 0; i < 16; i++) {
        uart_send_hex((uint32_t)addr);
        uart_send_string(": ");
        uart_send_hex(*addr);
        uart_send_string("\r\n");
        addr++;
    }
}

void read_flash(void) {
    uint32_t* flash_addr = (uint32_t*)0x08000000;
    uint32_t i;
    
    uart_send_string("Flash read (0x08000000):\r\n");
    for (i = 0; i < 8; i++) {
        uart_send_hex((uint32_t)flash_addr);
        uart_send_string(": ");
        uart_send_hex(*flash_addr);
        uart_send_string("\r\n");
        flash_addr++;
    }
}

void get_config(void) {
    uart_send_string("Config info:\r\n");
    uart_send_string("Device ID: 0x");
    uart_send_hex(*(uint32_t*)0x1FFF7A10);
    uart_send_string("\r\n");
    uart_send_string("Flash size: ");
    uart_send_hex(*(uint32_t*)0x1FFF7A22);
    uart_send_string(" KB\r\n");
}

void process_command(void) {
    if (strcmp(cmd_buffer, "dump_memory") == 0) {
        dump_memory();
    } else if (strcmp(cmd_buffer, "read_flash") == 0) {
        read_flash();
    } else if (strcmp(cmd_buffer, "get_config") == 0) {
        get_config();
    } else {
        uart_send_string("Unknown command\r\n");
    }
    cmd_index = 0;
    memset(cmd_buffer, 0, CMD_BUFFER_SIZE);
}

void uart_receive(void) {
    if (USART_GetFlagStatus(UART_DEBUG, USART_FLAG_RXNE) != RESET) {
        char c = USART_ReceiveData(UUART_DEBUG);
        
        if (c == '\r' || c == '\n') {
            uart_send_string("\r\n");
            if (cmd_index > 0) {
                process_command();
            }
        } else if (c == '\b') {
            if (cmd_index > 0) {
                cmd_index--;
                uart_send_string("\b \b");
            }
        } else if (cmd_index < CMD_BUFFER_SIZE - 1) {
            cmd_buffer[cmd_index++] = c;
            uart_send_char(c);
        }
    }
}

void debug_shell_init(void) {
    uart_init();
    jtag_init();
    
    uart_send_string("\r\nIoT Diagnostic Shell\r\n");
    uart_send_string("Available commands:\r\n");
    uart_send_string("dump_memory\r\nread_flash\r\nget_config\r\n");
    uart_send_string("> ");
}

void system_init(void) {
    RCC_DeInit();
    RCC_HSEConfig(RCC_HSE_ON);
    while (RCC_GetFlagStatus(RCC_FLAG_HSERDY) == RESET);
    RCC_PLLConfig(RCC_PLLSource_HSE, 8, 336, 2, 7);
    RCC_PLLCmd(ENABLE);
    while (RCC_GetFlagStatus(RCC_FLAG_PLLRDY) == RESET);
    RCC_SYSCLKConfig(RCC_SYSCLKSource_PLLCLK);
    RCC_HCLKConfig(RCC_SYSCLK_Div1);
    RCC_PCLK1Config(RCC_HCLK_Div4);
    RCC_PCLK2Config(RCC_HCLK_Div2);
    
    debug_shell_init();
}

int main(void) {
    system_init();
    
    while (1) {
        uart_receive();
    }
    
    return 0;
}