# Generated by ollama (starcoder2)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <iostream>
#include <string>
#include <vector>
#include <map>
#include <memory>
#include <functional>
#include <thread>
#include <chrono>
#include <mutex>
#include <condition_variable>
#include <atomic>
#include <future>
#include <algorithm>
#include <cassert>

#define MAX_CONNECTIONS 1024

class Connection;
typedef std::shared_ptr<Connection> ConnectionPtr;

class Connection {
    public:
        enum State {
            CONNECTING,
            CONNECTED,
            DISCONNECTING,
            DISCONNECTED
        };

        Connection(int id) : id_(id), state_(State::DISCONNECTED) {}

        int id() const { return id_; }
        void set_state(Connection::State s) { state_.store(s); }
        State get_state() const { return static_cast<State>(state_); }

    private:
        std::atomic<int> state_;
        int id_;
};

class ConnectionPool {
    public:
        ConnectionPtr get_connection();

        void release_connection(ConnectionPtr conn) {
            std::unique_lock<std::mutex> lock(mtx_);

            if (conn->get_state() == Connection::State::DISCONNECTED ||
                conn->get_state() == Connection::State::DISCONNECTING) {

                free_.push_back(conn);
            }
        }

    private:
        std::vector<ConnectionPtr> free_;

        mutable std::mutex mtx_;
};

ConnectionPool pool;

ConnectionPtr ConnectionPool::get_connection() {
    std::unique_lock<std::mutex> lock(mtx_);

    if (free_.empty()) {
        return nullptr;
    } else {
        auto conn = free_.back();

        free_.pop_back();

        return conn;
    }
}

int main() {
    for (auto i = 0; i < MAX_CONNECTIONS; ++i) {
        pool.release_connection(std::make_shared<Connection>(i));
    }

    auto conn1 = pool.get_connection();
    assert(conn1->id() == 0);
    assert(pool.free_.size() == MAX_CONNECTIONS - 1);

    for (auto i = 0; i < MAX_CONNECTIONS / 2; ++i) {
        pool.release_connection(std::make_shared<Connection>(MAX_CONNECTIONS + i));
    }

    auto conn2 = pool.get_connection();
    assert(conn2->id() == MAX_CONNECTIONS);
    assert(pool.free_.size() == 0);
}