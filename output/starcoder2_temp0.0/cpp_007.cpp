# Generated by ollama (starcoder2)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
using namespace std;

class Session {
    public:
        int id;
        string name;
        int age;
        Session(int id, string name, int age) : id{id}, name{name}, age{age} {}
};

class SessionManager {
    private:
        vector<Session*> sessions;
    public:
        void addSession(Session* session);
        void removeSession(int id);
        Session* getSessionById(int id);
};

void SessionManager::addSession(Session* session) {
    sessions.push_back(session);
}

void SessionManager::removeSession(int id) {
    for (auto it = sessions.begin(); it != sessions.end(); ++it)
        if ((*it)->id == id)
            sessions.erase(it);
}

Session* SessionManager::getSessionById(int id) {
    for (auto session : sessions)
        if (session->id == id)
            return session;

    return nullptr;
}

int main() {
    SessionManager manager;
    Session* session = new Session{1, "John", 20};
    manager.addSession(session);
    delete session; // free memory for the session object

    cout << manager.getSessionById(1)->name << endl;
    return 0;
}