# Generated by ollama (starcoder2)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <stdio.h>
#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include "semphr.h"

typedef struct {
    int16_t sensor0;
    int16_t sensor1;
    int16_t sensor2;
    int16_t sensor3;
    int16_t sensor4;
    int16_t sensor5;
    int16_t sensor6;
} sensor_data;

volatile sensor_data sensor_data = {0};

void task1( void *pvParameters ) {
    for (;;) {
        // read sensor data
        sensor_data.sensor0++;
        sensor_data.sensor1--;

        // update sensor data
        sensor_data.sensor2 += 3;
        sensor_data.sensor3 -= 4;

        // process sensor data
        sensor_data.sensor4 *= 5;
        sensor_data.sensor5 /= 6;
    }
}

void task2( void *pvParameters ) {
    for (;;) {
        // process sensor data
        sensor_data.sensor0 += 7;
        sensor_data.sensor1 -= 8;

        // update sensor data
        sensor_data.sensor2 *= 9;
        sensor_data.sensor3 /= 10;
    }
}

int main( void ) {

    // create task 1
    xTaskCreate(task1, "task1", configMINIMAL_STACK_SIZE + 50, NULL, tskIDLE_PRIORITY + 2, NULL);

    // create task 2
    xTaskCreate(task2, "task2", configMINIMAL_STACK_SIZE + 50, NULL, tskIDLE_PRIORITY + 1, NULL);

    vTaskStartScheduler();
}