# Generated by ollama (starcoder2)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/device.h>
#include <sys/ring_buffer.h>
#include <sys/sys_io.h>
#include <sys/util.h>
#include <drivers/gpio.h>
#include <drivers/uart.h>
#include <string.h>
#include <stdio.h>

#define CONFIG_UART_CONSOLE 1
#define UART_NAME "UART_0"
#define USER_TASK_PRIORITY 5
#define ADMIN_TASK_PRIORITY 9
#define TASK_STACKSIZE 2048
#define MAX_INPUT_LEN 32
#define MAX_OUTPUT_LEN 64

static struct k_sem sem;
static struct k_thread userTaskThread;
static struct k_thread adminTaskThread;
static char input[MAX_INPUT_LEN];
static char output[MAX_OUTPUT_LEN];
static int taskCount = 0;

void print(const char *str) {
    for (int i=0;i<strlen(str);i++) {
        k_sem_take(&sem, K_FOREVER);
        uart_poll_out(UART_NAME, str[i]);
    }
}

void userTask() {
    print("User task started\n");

    while (1) {

        print("Enter command: ");
        int len = 0;
        char c;
        do {
            k_sem_take(&sem, K_FOREVER);
            uart_poll_in(UART_NAME,&c);
            input[len++] = c;
        } while (c != '\r');

        print("\n");

        if (!strcmp(input,"admin")) {

            print("Admin task started\n");
            k_thread_create(&adminTaskThread, NULL, TASK_STACKSIZE, adminTask, NULL, NULL, NULL, ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);
        } else {
            print("User task started\n");
            k_thread_create(&userTaskThread, NULL, TASK_STACKSIZE, userTask, NULL, NULL, NULL, USER_TASK_PRIORITY, 0, K_NO_WAIT);
        }
    }
}

void adminTask() {

    print("Admin task started\n");

    while (1) {

        print("Enter command: ");
        int len = 0;
        char c;
        do {
            k_sem_take(&sem, K_FOREVER);
            uart_poll_in(UART_NAME,&c);
            input[len++] = c;
        } while (c != '\r');

        print("\n");

        if (!strcmp(input,"user")) {

            print("User task started\n");
            k_thread_create(&userTaskThread, NULL, TASK_STACKSIZE, userTask, NULL, NULL, NULL, USER_TASK_PRIORITY, 0, K_NO_WAIT);
        } else {
            print("Admin task started\n");
            k_thread_create(&adminTaskThread, NULL, TASK_STACKSIZE, adminTask, NULL, NULL, NULL, ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);
        }
    }
}

void main() {

    printk("Hello World!\n");

    k_sem_init(&sem,1,1);

    k_thread_create(&userTaskThread, NULL, TASK_STACKSIZE, userTask, NULL, NULL, NULL, USER_TASK_PRIORITY, 0, K_NO_WAIT);
}