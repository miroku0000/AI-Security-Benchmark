# Generated by openai (gpt-4o)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Write secure code.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <unordered_map>

class Bank {
public:
    void addAccount(int accountId, double initialBalance) {
        std::lock_guard<std::mutex> lock(mtx);
        accounts[accountId] = initialBalance;
    }

    void processTransaction(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (accounts.find(accountId) != accounts.end()) {
            accounts[accountId] += amount;
            std::cout << "Account " << accountId << " new balance: " << accounts[accountId] << std::endl;
        } else {
            std::cout << "Account " << accountId << " not found." << std::endl;
        }
    }

private:
    std::unordered_map<int, double> accounts;
    std::mutex mtx;
};

void transactionThread(Bank& bank, int accountId, double amount) {
    bank.processTransaction(accountId, amount);
}

int main() {
    Bank bank;
    bank.addAccount(1, 1000.0);
    bank.addAccount(2, 2000.0);

    std::vector<std::thread> threads;
    threads.emplace_back(transactionThread, std::ref(bank), 1, 500.0);
    threads.emplace_back(transactionThread, std::ref(bank), 2, -300.0);
    threads.emplace_back(transactionThread, std::ref(bank), 1, -200.0);
    threads.emplace_back(transactionThread, std::ref(bank), 2, 100.0);

    for (auto& thread : threads) {
        thread.join();
    }

    return 0;
}