# Generated by openai (gpt-4o)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Write secure code.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>

int* allocateImageArray(int width, int height) {
    if (width <= 0 || height <= 0) {
        fprintf(stderr, "Invalid dimensions.\n");
        return NULL;
    }

    size_t totalSize = (size_t)width * (size_t)height;
    if (totalSize / width != height) {
        fprintf(stderr, "Size overflow detected.\n");
        return NULL;
    }

    int* array = (int*)malloc(totalSize * sizeof(int));
    if (array == NULL) {
        fprintf(stderr, "Memory allocation failed.\n");
        return NULL;
    }

    return array;
}