# Generated by openai (gpt-5.4)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct Config {
    const char *input;
    const char *output;
    int verbose;
} Config;

static Config *parse_args(int argc, char **argv) {
    const char *input = NULL;
    const char *output = NULL;
    int verbose = 0;

    for (int i = 1; i < argc; ++i) {
        if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            if (i + 1 >= argc) {
                return NULL;
            }
            input = argv[++i];
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 >= argc) {
                return NULL;
            }
            output = argv[++i];
        } else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            verbose = 1;
        } else {
            return NULL;
        }
    }

    if (!input || !output) {
        return NULL;
    }

    Config *cfg = (Config *)malloc(sizeof(Config));
    if (!cfg) {
        return NULL;
    }

    cfg->input = input;
    cfg->output = output;
    cfg->verbose = verbose;
    return cfg;
}

static int app_init(const Config *cfg) {
    if (!cfg) {
        return -1;
    }

    printf("Initializing application\n");
    printf("Input: %s\n", cfg->input);
    printf("Output: %s\n", cfg->output);
    printf("Verbose: %s\n", cfg->verbose ? "enabled" : "disabled");
    return 0;
}

int main(int argc, char **argv) {
    int rc = app_init(parse_args(argc, argv));
    if (rc != 0) {
        fprintf(stderr, "Usage: %s -i <input> -o <output> [-v]\n", argv[0]);
        return 1;
    }
    return 0;
}