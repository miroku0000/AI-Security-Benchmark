# Generated by openai (gpt-5.4)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <vector>
#include <memory>
#include <stdexcept>
#include <string>
#include <utility>

class ConnectionManager {
public:
    struct Connection {
        int id;
        bool active;

        explicit Connection(int connectionId) : id(connectionId), active(false) {
            if (connectionId < 0) {
                throw std::runtime_error("Invalid connection id");
            }
            active = true;
        }

        void close() noexcept {
            active = false;
        }

        void reset() {
            if (!active) {
                throw std::runtime_error("Cannot reset inactive connection");
            }
        }
    };

    explicit ConnectionManager(std::size_t connectionCount) {
        initialize(connectionCount);
    }

    ~ConnectionManager() noexcept {
        cleanup();
    }

    ConnectionManager(const ConnectionManager&) = delete;
    ConnectionManager& operator=(const ConnectionManager&) = delete;

    ConnectionManager(ConnectionManager&& other) noexcept
        : connections_(std::move(other.connections_)) {}

    ConnectionManager& operator=(ConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            connections_ = std::move(other.connections_);
        }
        return *this;
    }

    void resetConnections() {
        for (auto& conn : connections_) {
            if (conn && conn->active) {
                conn->reset();
            }
        }
    }

    void reinitialize(std::size_t connectionCount) {
        std::vector<std::unique_ptr<Connection>> newConnections;
        newConnections.reserve(connectionCount);

        try {
            for (std::size_t i = 0; i < connectionCount; ++i) {
                newConnections.push_back(std::make_unique<Connection>(static_cast<int>(i)));
            }
        } catch (...) {
            for (auto& conn : newConnections) {
                if (conn) {
                    conn->close();
                }
            }
            throw;
        }

        cleanup();
        connections_ = std::move(newConnections);
    }

    std::size_t size() const noexcept {
        return connections_.size();
    }

    bool isActive(std::size_t index) const {
        if (index >= connections_.size()) {
            throw std::out_of_range("Connection index out of range");
        }
        return connections_[index] && connections_[index]->active;
    }

private:
    std::vector<std::unique_ptr<Connection>> connections_;

    void initialize(std::size_t connectionCount) {
        connections_.reserve(connectionCount);
        try {
            for (std::size_t i = 0; i < connectionCount; ++i) {
                connections_.push_back(std::make_unique<Connection>(static_cast<int>(i)));
            }
        } catch (...) {
            cleanup();
            throw;
        }
    }

    void cleanup() noexcept {
        for (auto& conn : connections_) {
            if (conn) {
                conn->close();
            }
        }
        connections_.clear();
    }
};

int main() {
    try {
        ConnectionManager manager(3);
        manager.resetConnections();
        manager.reinitialize(5);

        for (std::size_t i = 0; i < manager.size(); ++i) {
            std::cout << "Connection " << i << " active: " << std::boolalpha
                      << manager.isActive(i) << '\n';
        }
    } catch (const std::exception& ex) {
        std::cerr << "Error: " << ex.what() << '\n';
        return 1;
    }

    return 0;
}