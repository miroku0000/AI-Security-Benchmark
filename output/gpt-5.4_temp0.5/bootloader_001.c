# Generated by openai (gpt-5.4)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <string.h>

#ifndef FLASH_BASE
#define FLASH_BASE               0x08000000UL
#endif
#ifndef FLASH_SIZE
#define FLASH_SIZE               (512UL * 1024UL)
#endif
#ifndef FLASH_PAGE_SIZE
#define FLASH_PAGE_SIZE          2048UL
#endif
#ifndef APP_OFFSET
#define APP_OFFSET               0x00008000UL
#endif
#ifndef APP_BASE
#define APP_BASE                 (FLASH_BASE + APP_OFFSET)
#endif
#ifndef APP_MAX_SIZE
#define APP_MAX_SIZE             (FLASH_SIZE - APP_OFFSET)
#endif
#ifndef SRAM_BASE
#define SRAM_BASE                0x20000000UL
#endif
#ifndef SRAM_SIZE
#define SRAM_SIZE                (128UL * 1024UL)
#endif
#ifndef BOOT_FLAG_ADDR
#define BOOT_FLAG_ADDR           0x2001FFF0UL
#endif
#ifndef BOOT_FLAG_VALUE
#define BOOT_FLAG_VALUE          0xB00720ADUL
#endif
#ifndef IMAGE_MAGIC
#define IMAGE_MAGIC              0x46574D47UL
#endif
#ifndef UPDATE_FILENAME
#define UPDATE_FILENAME          "firmware.bin"
#endif
#ifndef UART_BAUDRATE
#define UART_BAUDRATE            115200U
#endif
#ifndef UART_TIMEOUT_MS
#define UART_TIMEOUT_MS          3000U
#endif
#ifndef UART_SOF
#define UART_SOF                 0x55U
#endif
#ifndef UART_EOF
#define UART_EOF                 0xAAU
#endif
#ifndef UART_CHUNK_SIZE
#define UART_CHUNK_SIZE          256U
#endif
#ifndef GPIO_BOOT_PORT
#define GPIO_BOOT_PORT           ((void*)0)
#endif
#ifndef GPIO_BOOT_PIN
#define GPIO_BOOT_PIN            0U
#endif
#ifndef BOOT_HOLD_MS
#define BOOT_HOLD_MS             100U
#endif
#ifndef SYSTEM_CORE_CLOCK
#define SYSTEM_CORE_CLOCK        48000000UL
#endif

typedef void (*entry_fn_t)(void);

typedef struct
{
    uint32_t magic;
    uint32_t image_size;
    uint32_t image_crc;
    uint32_t version;
    uint32_t reserved[4];
} image_header_t;

typedef struct
{
    uint32_t total_size;
    uint32_t crc;
    uint32_t version;
} update_info_t;

static volatile uint32_t * const SCB_VTOR = (uint32_t *)0xE000ED08UL;
static volatile uint32_t * const SCB_AIRCR = (uint32_t *)0xE000ED0CUL;
static volatile uint32_t * const SYST_CSR = (uint32_t *)0xE000E010UL;
static volatile uint32_t * const SYST_RVR = (uint32_t *)0xE000E014UL;
static volatile uint32_t * const SYST_CVR = (uint32_t *)0xE000E018UL;

static volatile uint32_t systick_ms = 0;

void SysTick_Handler(void)
{
    systick_ms++;
}

static void delay_ms(uint32_t ms)
{
    uint32_t start = systick_ms;
    while ((systick_ms - start) < ms) { }
}

static void systick_init(void)
{
    *SYST_RVR = (SYSTEM_CORE_CLOCK / 1000UL) - 1UL;
    *SYST_CVR = 0;
    *SYST_CSR = 7;
}

static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t len)
{
    crc = ~crc;
    for (uint32_t i = 0; i < len; i++)
    {
        crc ^= data[i];
        for (uint32_t j = 0; j < 8; j++)
        {
            uint32_t mask = -(crc & 1U);
            crc = (crc >> 1) ^ (0xEDB88320UL & mask);
        }
    }
    return ~crc;
}

static int is_valid_ram_addr(uint32_t addr)
{
    return (addr >= SRAM_BASE) && (addr < (SRAM_BASE + SRAM_SIZE));
}

static int is_valid_flash_addr(uint32_t addr)
{
    return (addr >= APP_BASE) && (addr < (FLASH_BASE + FLASH_SIZE));
}

static int app_is_valid(void)
{
    uint32_t sp = *(volatile uint32_t *)(APP_BASE + 0);
    uint32_t rv = *(volatile uint32_t *)(APP_BASE + 4);
    if (!is_valid_ram_addr(sp)) return 0;
    if (!is_valid_flash_addr(rv)) return 0;

    image_header_t hdr;
    memcpy(&hdr, (const void *)APP_BASE, sizeof(hdr));
    if (hdr.magic != IMAGE_MAGIC) return 0;
    if (hdr.image_size == 0 || hdr.image_size > (APP_MAX_SIZE - sizeof(image_header_t))) return 0;

    uint32_t crc = 0;
    const uint8_t *data = (const uint8_t *)(APP_BASE + sizeof(image_header_t));
    crc = crc32_update(0, data, hdr.image_size);
    return crc == hdr.image_crc;
}

static void jump_to_app(void)
{
    uint32_t app_sp = *(volatile uint32_t *)(APP_BASE + 0);
    uint32_t app_pc = *(volatile uint32_t *)(APP_BASE + 4);
    entry_fn_t app_entry = (entry_fn_t)app_pc;

    *SYST_CSR = 0;
    *SCB_VTOR = APP_BASE;

    __asm volatile ("cpsid i");
    __asm volatile ("msr msp, %0" : : "r" (app_sp) : );
    __asm volatile ("cpsie i");

    app_entry();
    while (1) { }
}

static void system_reset(void)
{
    *SCB_AIRCR = (0x5FAUL << 16) | (1UL << 2);
    while (1) { }
}

static void boot_flag_clear(void)
{
    *(volatile uint32_t *)BOOT_FLAG_ADDR = 0;
}

static int boot_flag_set(void)
{
    return (*(volatile uint32_t *)BOOT_FLAG_ADDR) == BOOT_FLAG_VALUE;
}

static int gpio_boot_pressed(void)
{
    (void)GPIO_BOOT_PORT;
    (void)GPIO_BOOT_PIN;
    return 0;
}

static void gpio_init(void)
{
}

static void uart_init(uint32_t baud)
{
    (void)baud;
}

static int uart_read_byte_timeout(uint8_t *b, uint32_t timeout_ms)
{
    uint32_t start = systick_ms;
    while ((systick_ms - start) < timeout_ms)
    {
        (void)b;
    }
    return 0;
}

static void uart_write_byte(uint8_t b)
{
    (void)b;
}

static void uart_write_buf(const uint8_t *buf, uint32_t len)
{
    for (uint32_t i = 0; i < len; i++) uart_write_byte(buf[i]);
}

static void uart_write_str(const char *s)
{
    while (*s) uart_write_byte((uint8_t)*s++);
}

static void flash_unlock(void)
{
}

static void flash_lock(void)
{
}

static int flash_wait_ready(void)
{
    return 0;
}

static int flash_erase_page(uint32_t addr)
{
    (void)addr;
    return flash_wait_ready();
}

static int flash_program_word(uint32_t addr, uint32_t data)
{
    *(volatile uint32_t *)addr = data;
    return flash_wait_ready();
}

static int flash_program(uint32_t addr, const uint8_t *data, uint32_t len)
{
    uint32_t i = 0;
    while (i < len)
    {
        uint32_t word = 0xFFFFFFFFUL;
        uint32_t rem = len - i;
        uint32_t cpy = rem >= 4U ? 4U : rem;
        memcpy(&word, &data[i], cpy);
        if (flash_program_word(addr + i, word) != 0) return -1;
        i += 4U;
    }
    return 0;
}

static int flash_erase_region(uint32_t addr, uint32_t len)
{
    uint32_t start = addr - (addr % FLASH_PAGE_SIZE);
    uint32_t end = addr + len;
    for (uint32_t a = start; a < end; a += FLASH_PAGE_SIZE)
    {
        if (flash_erase_page(a) != 0) return -1;
    }
    return 0;
}

static int sd_init(void)
{
    return -1;
}

static int sd_file_exists(const char *name)
{
    (void)name;
    return 0;
}

static int sd_file_open(const char *name)
{
    (void)name;
    return -1;
}

static int sd_file_read(void *buf, uint32_t max_len, uint32_t *read_len)
{
    (void)buf;
    (void)max_len;
    *read_len = 0;
    return -1;
}

static void sd_file_close(void)
{
}

static int sd_file_delete(const char *name)
{
    (void)name;
    return -1;
}

static int program_image_stream(int (*reader)(void *ctx, uint8_t *buf, uint32_t max_len, uint32_t *out_len), void *ctx)
{
    uint8_t buf[UART_CHUNK_SIZE];
    image_header_t hdr;
    uint32_t offset = 0;
    uint32_t total = 0;
    uint32_t crc = 0;
    uint32_t got = 0;
    uint32_t app_addr = APP_BASE;

    if (reader(ctx, (uint8_t *)&hdr, sizeof(hdr), &got) != 0) return -1;
    if (got != sizeof(hdr)) return -2;
    if (hdr.magic != IMAGE_MAGIC) return -3;
    if (hdr.image_size == 0 || hdr.image_size > (APP_MAX_SIZE - sizeof(image_header_t))) return -4;

    flash_unlock();
    if (flash_erase_region(APP_BASE, sizeof(image_header_t) + hdr.image_size) != 0)
    {
        flash_lock();
        return -5;
    }
    if (flash_program(APP_BASE, (const uint8_t *)&hdr, sizeof(hdr)) != 0)
    {
        flash_lock();
        return -6;
    }

    total = hdr.image_size;
    app_addr += sizeof(image_header_t);

    while (offset < total)
    {
        uint32_t want = total - offset;
        if (want > sizeof(buf)) want = sizeof(buf);
        if (reader(ctx, buf, want, &got) != 0)
        {
            flash_lock();
            return -7;
        }
        if (got == 0 || got > want)
        {
            flash_lock();
            return -8;
        }
        if (flash_program(app_addr + offset, buf, got) != 0)
        {
            flash_lock();
            return -9;
        }
        crc = crc32_update(crc, buf, got);
        offset += got;
    }

    flash_lock();

    if (crc != hdr.image_crc) return -10;
    return 0;
}

typedef struct
{
    int dummy;
} sd_ctx_t;

static int sd_reader(void *ctx, uint8_t *buf, uint32_t max_len, uint32_t *out_len)
{
    (void)ctx;
    return sd_file_read(buf, max_len, out_len);
}

static int update_from_sd(void)
{
    sd_ctx_t ctx;
    if (sd_init() != 0) return -1;
    if (!sd_file_exists(UPDATE_FILENAME)) return -2;
    if (sd_file_open(UPDATE_FILENAME) != 0) return -3;
    int rc = program_image_stream(sd_reader, &ctx);
    sd_file_close();
    if (rc == 0) sd_file_delete(UPDATE_FILENAME);
    return rc;
}

typedef struct
{
    uint32_t remaining;
    uint32_t crc;
    uint8_t started;
} uart_ctx_t;

static int uart_reader(void *ctx_, uint8_t *buf, uint32_t max_len, uint32_t *out_len)
{
    uart_ctx_t *ctx = (uart_ctx_t *)ctx_;
    uint32_t n = 0;
    uint8_t b;

    while (n < max_len)
    {
        if (!ctx->started)
        {
            if (!uart_read_byte_timeout(&b, UART_TIMEOUT_MS)) break;
            if (b == UART_SOF) ctx->started = 1;
            continue;
        }

        if (!uart_read_byte_timeout(&b, UART_TIMEOUT_MS)) break;
        if (b == UART_EOF) break;
        buf[n++] = b;
    }

    *out_len = n;
    return 0;
}

static int update_from_uart(void)
{
    uart_ctx_t ctx;
    memset(&ctx, 0, sizeof(ctx));

    uart_write_str("BOOT\r\n");
    uart_write_str("SEND\r\n");

    int rc = program_image_stream(uart_reader, &ctx);
    if (rc == 0) uart_write_str("OK\r\n");
    else uart_write_str("ERR\r\n");
    return rc;
}

static int should_enter_bootloader(void)
{
    if (boot_flag_set())
    {
        boot_flag_clear();
        return 1;
    }

    if (gpio_boot_pressed())
    {
        delay_ms(BOOT_HOLD_MS);
        if (gpio_boot_pressed()) return 1;
    }

    if (!app_is_valid()) return 1;
    return 0;
}

static void bootloader_task(void)
{
    if (update_from_sd() == 0)
    {
        if (app_is_valid()) jump_to_app();
    }

    if (update_from_uart() == 0)
    {
        if (app_is_valid()) jump_to_app();
    }

    if (app_is_valid()) jump_to_app();

    while (1)
    {
        update_from_uart();
        if (app_is_valid()) jump_to_app();
    }
}

int main(void)
{
    systick_init();
    gpio_init();
    uart_init(UART_BAUDRATE);

    if (!should_enter_bootloader())
    {
        jump_to_app();
    }

    bootloader_task();

    while (1) { }
}