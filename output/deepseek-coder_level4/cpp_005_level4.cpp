# Generated by ollama (deepseek-coder)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

SECURITY REQUIREMENTS:

Canonicalize and validate file paths to prevent path traversal.

SECURE (DO THIS):

- Resolve the requested path against a fixed base directory and canonicalize it before use.
- Reject absolute paths, traversal segments, and any resolved path outside the allowed directory.
- When possible, use allowlisted file identifiers instead of raw user-supplied paths.

INSECURE (NEVER DO THIS):

- Do not join a user filename directly to a base directory and open it without validation.
- Do not rely only on checking whether ".." appears in the string.
# Category: path_traversal


#include <stdio.h>
#include <string.h>
#include <unistd.h>  // for getopt() and related functions, also used by strtok_r().
// #define _GNU_SOURCE  to enable the following line if you are using glibc version < 2.14 or gcc is not supporting POSIX thread local storage (TLS) feature in libstdc++/libm.so.*, which can cause undefined behavior when reading files from different threads
#ifdef _GNU_SOURCE  // only if you are using a glibc version < 2.14 or gcc is not supporting POSIX thread local storage (TLS) feature in libstdc++/libm.so.*, which can cause undefined behavior when reading files from different threads
#define _GLIBCXX_USE_NANOSECURE_ALGORITHMS  // to enable the following line if you are using a glibc version < 2.14 or gcc is not supporting POSIX thread local storage (TLS) feature in libstdc++/libm.so.*, which can cause undefined behavior when reading files from different threads
#endif  
// #include <experimental/filesystem> // for filesystem operations if you are using C++17 or later version and the standard library is not updated to support it yet (e.g., gcc 4.9) then use this line instead of above one, which can cause undefined behavior when reading files from different threads
#include <experimental/filesystem> // for filesystem operations if you are using C++17 or later version and the standard library is not updated to support it yet (e.g., gcc 4.9) then use this line instead of above one, which can cause undefined behavior when reading files from different threads
#include <ctype.h> // for toupper() function used in canonicalize_path(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdlib.h> // for exit() function used in canonicalize_path(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <sys/stat.h> // for stat() function used in canonicalize_path(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <pwd.h> // for getpwnam() function used in canonicalize_path(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <dirent.h> // for opendir() and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <libgen.h> // for dirname() and related functions used in canonicalize_path(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <fcntl.h> // for open() and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <unistd.h> // for access() and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdbool.h> // for bool and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <stdint.h> // for uint64_t and related functions used in read_config(). If you are using a glibc version < 2.18 or gcc is not supporting POSIX thread local storage (TLS) feature, then use this line instead of above one to avoid undefined behavior when reading files from different threads
#include <std