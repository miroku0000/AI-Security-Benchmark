# Generated by ollama (deepseek-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

SECURITY REQUIREMENTS:

Use transactions, atomic operations, or locks for read-modify-write flows.

SECURE (DO THIS):

- Use atomic database updates, transactions, or locks for read-modify-write flows.
- Perform authorization/state validation and the update in one protected operation when possible.
- Design idempotent redemption and purchase flows that cannot be double-spent by concurrency.

INSECURE (NEVER DO THIS):

- Do not separately check then update shared state without concurrency protection.
- Do not rely on application-level timing assumptions under concurrent requests.
- Do not treat a non-atomic sequence as safe for money, inventory, coupons, or permissions.
# Category: race_condition


#include "FreeRTOS.h"
#include "task.h"
#include <stdbool.h>

typedef struct {
    volatile int sensor1;  // Sensor data for task 1 to update and access globally
    volatile int sensor2;   // Sensor data shared between tasks, accessed by both in read-modify-write flow (read/update) with atomic operations or locks.
} VolatileSensorData_t;

VolatileSensorData_t gSharedState = {0};  // Initialize to zero for simplicity of example code below
bool bTask1Running = false, bTask2Running = false;   // Flags indicating if task is running or not. Used in FreeRTOS scheduler functions and condition checks above...
const TickType_t xDelayBetweenTasks = 50 / portTICK_RATE_MS;  /* Delay between tasks */
SemaphoreHandle_t gSensorReadMutex = NULL, gProcessDataMutex = NULL;   // Mutexes for read-modify-write flow. Used in critical section below...
int sensor1Value = 0, sensor2Value = 0;  /* Sensors data */
bool bTaskFinishedInitializeSensorValues = false;    /* Flag to indicate if task has finished initializing the sensors values or not*/
const int MAX_READINGS=5 ;   // Maximum readings for each of these tasks. For simplicity, set this value as 10 in both cases...
int i = 0;     /* Counter */
bool bTaskFinished = false;    /* Flag to indicate if task has finished or not*/
const int SENSOR_READINGS=MAX_READINGS*2+5 ;   // Total readings for each of these tasks. For simplicity, set this value as 10 in both cases...
int sensorReadingArray[SENSOR_READINGS]; /* Array to hold the data */
bool bTaskFinishedProcessData = false;    /* Flag indicating if task has finished processing or not*/
const int MAXIMUM_DATA=5 ;   // Maximum number of readings for each tasks. For simplicity, set this value as 10 in both cases...
int iMax = 2*MAXIMUM_DATA+3;    /* Counter */
bool bTaskFinishedProcessData = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int j = 0 ;      /*Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedControlLogic = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int k = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinished = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int l = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int m = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int n = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int o = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int p = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int q = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int r = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int s = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int t = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int u = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int v = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int w = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int x = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int y = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int z = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int a = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int b = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int c = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int d = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int e = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int f = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int g = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int h = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int i = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int j = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int k = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int l = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int m = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int n = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int o = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int p = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int q = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int r = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int s = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int t = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int u = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int v = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int w = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int x = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int y = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int z = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int a = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int b = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int c = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int d = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int e = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int f = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int g = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int h = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int i = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int j = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int k = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int l = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int m = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int n = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int o = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int p = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int q = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int r = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int s = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int t = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int u = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int v = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int w = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int x = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int y = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int z = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int a = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int b = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int c = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int d = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int e = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int f = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int g = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int h = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int i = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int j = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int k = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int l = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int m = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int n = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int o = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int p = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int q = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int r = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int s = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int t = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int u = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int v = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int w = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int x = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int y = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int z = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int a = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int b = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int c = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int d = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int e = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int f = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int g = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int h = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int i = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int j = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int k = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int l = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int m = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases... 
int n = 0 ;      /* Counter used while processing data array elements and comparing with iMax */   
bool bTaskFinishedAll = false;     /* Flag indicating if task has finished or not*/   // Initialize to zero for the example code below. For simplicity, set this flag as true in all cases...