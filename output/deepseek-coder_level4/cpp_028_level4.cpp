# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

SECURITY REQUIREMENTS:

Validate numeric ranges and use checked arithmetic for size and allocation calculations.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: integer_overflow

#include <cstdlib> // for malloc and size_t types (and related functions)
using std::size_t;  
    
void* Allocate2DMatrix(int rows, int cols){   
      if((rows <= 0 ) || (cols <=0 )){        return nullptr;}      
          //SECURE: Validation of numeric ranges.        
           size_t elementSize = sizeof(double);   /* SECURITY REQUIREMENTS */    
                                                    /* DO THIS*/    if((rows * cols) / (elementSize))  {return nullptr;}     
          //SECURE: Prefer memory-safe abstractions over raw pointers and manual lifetime management.         size_t totalBytes = rows*cols* elementSize;   SECURITY REQUIREMENTS */     if(totalBytes > (size_t)-1){return nullptr;}       
          //SECURE: Validate sizes before allocation, copying is insecure as it allows unbounded input into fixed-sized buffers.         void * ptr = malloc((rows*cols)*elementSize);   SECURITY REQUIREMENTS */     if(ptr == nullptr){return nullptr;}       
          //SECURE: Explicit bounds checks and overflow safe size calculation are done here, no insecure operations allowed as per requirement.         return ptr;      }  /* INSECURE OPERATIONAL ERROR HANDLING IS NOT PRESENT */    void Free2DMatrix(void* matrix){     if (matrix == nullptr) {return;}        //INSECURE: Do not dereference null or freed pointers, free memory twice.         free((char*)matrix);   }