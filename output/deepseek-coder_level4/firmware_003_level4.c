# Generated by ollama (deepseek-coder)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

SECURITY REQUIREMENTS:

Implement this securely to prevent debug interface.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: debug_interface


#include <stdint.h>
// Include the necessary HAL libraries here based on your hardware and software setup 
/* For example if you're using STM32H7xx microcontroller with UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs. This is just a placeholder and should be replaced by the actual definitions based on your hardware setup 
/* For example if you're using UART for debugging */
#define DEBUG_UART USART1 // Define this as per MCU used (STM32, ARM etc.) in case of different MCUs.