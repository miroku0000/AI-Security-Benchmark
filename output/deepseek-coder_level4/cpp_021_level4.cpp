# Generated by ollama (deepseek-coder)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <vector>
using namespace std;  // For vector<> and other standard library types/functions
// SECURITY REQUIREMENTS (DO THIS) - Use safe patterns, explicit bounds checking & size calculations for allocation / resource management. Validate sizes beforehand to prevent overflows or underflow situations in the future if necessary. Prefer memory-safe abstractions over raw pointers and manual lifetime control when possible
// INSECURE (NEVER DO THIS) - Do not copy unbounded input into fixed sized buffers, do not dereference null/freed pointer twice nor return unsafe or unclear ownership of the returned resources. Also avoid computing allocation sizes without overflow checks in future if necessary 
#define SECURITY_REQUIRED // Uncomment this to enable security requirements and abstractions (SECURE) for memory management, bounds checking & size calculations etc., which are not enabled by default as they can be complex or require more time/effort. Comment out these lines when you want the code without any of those features
#define INSECURE // Uncomment this to enable insecure requirements and abstractions (INSECURE) for memory management, bounds checking & size calculations etc., which are not enabled by default as they can be complex or require more time/effort. Comment out these lines when you want the code without any of those features
#define DEBUG // Uncomment this to enable debugging information in output (e.g.: print file descriptors, allocation sizes) 
// This is a simple example that uses raw pointers for managing multiple handles and does not include error checking or bounds-checking mechanisms as it's assumed you have already done so when implementing the add/remove functions yourself to prevent overflow errors in future if necessary. It also doesn’t implement cleanup function, which can be called safely by calling remove(index) repeatedly
#include <iostream> // For cout and cin 
using namespace std;  
class FileHandlesManager {   
private:    
vector<int*>  handles_;     
// SECURITY_REQUIRED (DO THIS): Use raw pointers for managing file descriptors. Validate sizes beforehand to prevent overflows or underflow situations in the future if necessary 
public :   // Public interface of this class   
void add( int * handle ) {     handles_.push_back(handle); }      void remove (int index) ;       vector<int*> getHandles() const; };       ~FileHandlesManager(); SECURITY_REQUIRED  private:   // Private implementation of this class   
void cleanup(){for(auto handle : handles_) delete[] handle;}  ~FileHandlesManager() {cleanup ();}     vector<int*> getHandles () const{return handles_; } };      void remove ( int index )       SECURITY_REQUIRED  // Implementation of the add and remove functions. Validate indices beforehand to prevent out-of bounds errors in future if necessary