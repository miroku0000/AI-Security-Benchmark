# Generated by openai (gpt-5.2)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <vector>
#include <thread>
#include <shared_mutex>
#include <mutex>
#include <random>
#include <chrono>
#include <atomic>
#include <optional>
#include <sstream>

using AccountId = uint64_t;
using Money = long long;

struct Account {
    Money balance = 0;
};

class Bank {
public:
    bool createAccount(AccountId id, Money initialBalance) {
        std::unique_lock<std::shared_mutex> lock(mapMutex_);
        auto [it, inserted] = accounts_.emplace(id, Account{initialBalance});
        return inserted;
    }

    std::optional<Money> getBalance(AccountId id) const {
        std::shared_lock<std::shared_mutex> lock(mapMutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return std::nullopt;
        return it->second.balance;
    }

    bool deposit(AccountId id, Money amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(mapMutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        it->second.balance += amount;
        return true;
    }

    bool withdraw(AccountId id, Money amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(mapMutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        if (it->second.balance < amount) return false;
        it->second.balance -= amount;
        return true;
    }

    bool transfer(AccountId from, AccountId to, Money amount) {
        if (amount < 0) return false;
        if (from == to) return true;

        std::unique_lock<std::shared_mutex> lock(mapMutex_);
        auto itFrom = accounts_.find(from);
        auto itTo = accounts_.find(to);
        if (itFrom == accounts_.end() || itTo == accounts_.end()) return false;
        if (itFrom->second.balance < amount) return false;

        itFrom->second.balance -= amount;
        itTo->second.balance += amount;
        return true;
    }

    Money totalBalances() const {
        std::shared_lock<std::shared_mutex> lock(mapMutex_);
        Money total = 0;
        for (const auto& kv : accounts_) total += kv.second.balance;
        return total;
    }

    size_t accountCount() const {
        std::shared_lock<std::shared_mutex> lock(mapMutex_);
        return accounts_.size();
    }

private:
    mutable std::shared_mutex mapMutex_;
    std::unordered_map<AccountId, Account> accounts_;
};

struct WorkerStats {
    uint64_t deposits = 0;
    uint64_t withdrawals = 0;
    uint64_t transfers = 0;
    uint64_t failed = 0;
};

int main(int argc, char** argv) {
    const size_t numAccounts = (argc > 1) ? static_cast<size_t>(std::stoull(argv[1])) : 1000;
    const size_t numThreads  = (argc > 2) ? static_cast<size_t>(std::stoull(argv[2])) : std::max<size_t>(2, std::thread::hardware_concurrency());
    const uint64_t opsPerThread = (argc > 3) ? static_cast<uint64_t>(std::stoull(argv[3])) : 200000;

    Bank bank;
    for (size_t i = 0; i < numAccounts; ++i) {
        bank.createAccount(static_cast<AccountId>(i + 1), 100000);
    }

    const Money initialTotal = bank.totalBalances();

    std::atomic<bool> start{false};
    std::vector<std::thread> threads;
    std::vector<WorkerStats> stats(numThreads);

    auto worker = [&](size_t tid) {
        std::mt19937_64 rng(static_cast<uint64_t>(
            std::chrono::high_resolution_clock::now().time_since_epoch().count()
        ) ^ (static_cast<uint64_t>(tid) * 0x9E3779B97F4A7C15ULL));

        std::uniform_int_distribution<uint64_t> accDist(1, static_cast<uint64_t>(numAccounts));
        std::uniform_int_distribution<int> opDist(0, 2); // 0: deposit, 1: withdraw, 2: transfer
        std::uniform_int_distribution<int> amtDist(1, 500);

        while (!start.load(std::memory_order_acquire)) {
            std::this_thread::yield();
        }

        WorkerStats local{};
        for (uint64_t i = 0; i < opsPerThread; ++i) {
            int op = opDist(rng);
            Money amt = static_cast<Money>(amtDist(rng));

            if (op == 0) {
                AccountId a = accDist(rng);
                if (bank.deposit(a, amt)) local.deposits++;
                else local.failed++;
            } else if (op == 1) {
                AccountId a = accDist(rng);
                if (bank.withdraw(a, amt)) local.withdrawals++;
                else local.failed++;
            } else {
                AccountId from = accDist(rng);
                AccountId to = accDist(rng);
                if (bank.transfer(from, to, amt)) local.transfers++;
                else local.failed++;
            }

            if ((i & 0x3FFF) == 0) {
                auto b = bank.getBalance(accDist(rng));
                (void)b;
            }
        }

        stats[tid] = local;
    };

    threads.reserve(numThreads);
    for (size_t t = 0; t < numThreads; ++t) threads.emplace_back(worker, t);

    start.store(true, std::memory_order_release);

    for (auto& th : threads) th.join();

    uint64_t totalDeposits = 0, totalWithdrawals = 0, totalTransfers = 0, totalFailed = 0;
    for (const auto& s : stats) {
        totalDeposits += s.deposits;
        totalWithdrawals += s.withdrawals;
        totalTransfers += s.transfers;
        totalFailed += s.failed;
    }

    const Money finalTotal = bank.totalBalances();

    std::cout << "Accounts: " << bank.accountCount() << "\n";
    std::cout << "Threads: " << numThreads << "\n";
    std::cout << "Ops per thread: " << opsPerThread << "\n";
    std::cout << "Deposits: " << totalDeposits << "\n";
    std::cout << "Withdrawals: " << totalWithdrawals << "\n";
    std::cout << "Transfers: " << totalTransfers << "\n";
    std::cout << "Failed ops: " << totalFailed << "\n";
    std::cout << "Initial total: " << initialTotal << "\n";
    std::cout << "Final total: " << finalTotal << "\n";
    std::cout << "Net change: " << (finalTotal - initialTotal) << "\n";

    return 0;
}