# Generated by openai (gpt-5.2)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdint.h>
#include <string.h>

typedef struct
{
    uint32_t seq;
    int32_t temperature_mC;
    int32_t pressure_Pa;
    int32_t flow_mLmin;
    uint32_t status_flags;
} sensor_data_t;

volatile sensor_data_t sensor_data;

static SemaphoreHandle_t sensorMutex;

static int32_t read_temperature_mC(void)
{
    return 25000;
}

static int32_t read_pressure_Pa(void)
{
    return 101325;
}

static int32_t read_flow_mLmin(void)
{
    return 1000;
}

static void apply_control(int32_t temperature_mC, int32_t pressure_Pa, int32_t flow_mLmin, uint32_t status_flags)
{
    (void)temperature_mC;
    (void)pressure_Pa;
    (void)flow_mLmin;
    (void)status_flags;
}

static void SensorTask(void *arg)
{
    (void)arg;

    TickType_t lastWake = xTaskGetTickCount();
    const TickType_t period = pdMS_TO_TICKS(1);

    for (;;)
    {
        int32_t t = read_temperature_mC();
        int32_t p = read_pressure_Pa();
        int32_t f = read_flow_mLmin();
        uint32_t flags = 0;

        if (xSemaphoreTake(sensorMutex, portMAX_DELAY) == pdTRUE)
        {
            sensor_data.seq++;
            sensor_data.temperature_mC = t;
            sensor_data.pressure_Pa = p;
            sensor_data.flow_mLmin = f;
            sensor_data.status_flags = flags;
            sensor_data.seq++;
            xSemaphoreGive(sensorMutex);
        }

        vTaskDelayUntil(&lastWake, period);
    }
}

static void ControlTask(void *arg)
{
    (void)arg;

    TickType_t lastWake = xTaskGetTickCount();
    const TickType_t period = pdMS_TO_TICKS(1);

    for (;;)
    {
        sensor_data_t local;

        if (xSemaphoreTake(sensorMutex, portMAX_DELAY) == pdTRUE)
        {
            memcpy(&local, (const void *)&sensor_data, sizeof(local));
            xSemaphoreGive(sensorMutex);
        }
        else
        {
            memset(&local, 0, sizeof(local));
        }

        apply_control(local.temperature_mC, local.pressure_Pa, local.flow_mLmin, local.status_flags);

        vTaskDelayUntil(&lastWake, period);
    }
}

void AppInitTasks(void)
{
    sensorMutex = xSemaphoreCreateMutex();
    configASSERT(sensorMutex != NULL);

    memset((void *)&sensor_data, 0, sizeof(sensor_data));

    (void)xTaskCreate(SensorTask, "Sensor", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 3, NULL);
    (void)xTaskCreate(ControlTask, "Control", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 2, NULL);
}