# Generated by openai (gpt-5.2)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/util.h>
#include <zephyr/sys/atomic.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/sys/reboot.h>
#include <string.h>
#include <errno.h>

#define STACK_SIZE          2048
#define USER_PRIORITY       5
#define ADMIN_PRIORITY      4

#define CAP_FLASH_WRITE     BIT(0)
#define CAP_CONFIG_WRITE    BIT(1)
#define CAP_REBOOT          BIT(2)

#define ADMIN_ALL_CAPS      (CAP_FLASH_WRITE | CAP_CONFIG_WRITE | CAP_REBOOT)

#define IPC_QUEUE_LEN       8
#define FLASH_WRITE_MAX     128
#define TOKEN_TTL_MS        5000

#define CONFIG_AREA_ID      FIXED_PARTITION_ID(storage)

enum op_code {
    OP_FLASH_WRITE = 1,
    OP_CONFIG_SET  = 2,
    OP_REBOOT      = 3,
};

struct sys_config {
    uint32_t magic;
    uint32_t version;
    uint32_t flags;
    uint32_t param;
};

#define CONFIG_MAGIC 0x43464731u
#define CONFIG_VERSION 1u

struct admin_req {
    uint32_t op;
    uint32_t caps_required;
    uint32_t token;
    uint32_t arg0;
    uint32_t arg1;
    uint32_t data_len;
    uint8_t  data[FLASH_WRITE_MAX];
};

struct admin_resp {
    uint32_t token;
    int32_t  status;
    uint32_t out0;
    uint32_t out1;
};

K_MSGQ_DEFINE(admin_req_q, sizeof(struct admin_req), IPC_QUEUE_LEN, 4);
K_MSGQ_DEFINE(admin_resp_q, sizeof(struct admin_resp), IPC_QUEUE_LEN, 4);

static atomic_t token_seed;
static struct sys_config g_cfg;
static struct k_mutex cfg_lock;

struct priv_ctx {
    uint32_t uid;
    uint32_t gid;
    uint32_t caps;
};

static struct priv_ctx admin_ctx = {
    .uid = 0,
    .gid = 0,
    .caps = ADMIN_ALL_CAPS,
};

static struct priv_ctx user_ctx = {
    .uid = 1000,
    .gid = 1000,
    .caps = 0,
};

struct admin_token {
    uint32_t token;
    uint32_t caps;
    int64_t  expiry_ms;
    uint32_t issuer_uid;
};

static struct admin_token g_user_token;
static struct k_mutex token_lock;

static uint32_t token_new(void)
{
    uint32_t t = (uint32_t)atomic_inc(&token_seed);
    if (t == 0) {
        t = (uint32_t)atomic_inc(&token_seed);
    }
    return t;
}

static int64_t now_ms(void)
{
    return (int64_t)k_uptime_get();
}

static int issue_token_for_user(uint32_t user_uid, uint32_t caps, uint32_t ttl_ms, uint32_t *out_token)
{
    if (!out_token) {
        return -EINVAL;
    }

    if ((caps & ~ADMIN_ALL_CAPS) != 0) {
        return -EPERM;
    }

    k_mutex_lock(&token_lock, K_FOREVER);
    g_user_token.token = token_new();
    g_user_token.caps = caps;
    g_user_token.expiry_ms = now_ms() + (int64_t)ttl_ms;
    g_user_token.issuer_uid = user_uid;
    *out_token = g_user_token.token;
    k_mutex_unlock(&token_lock);

    return 0;
}

static int validate_token(uint32_t token, uint32_t caps_required)
{
    int rc = -EPERM;

    k_mutex_lock(&token_lock, K_FOREVER);
    if (g_user_token.token == token &&
        token != 0 &&
        now_ms() <= g_user_token.expiry_ms &&
        (g_user_token.caps & caps_required) == caps_required) {
        rc = 0;
    } else {
        rc = -EPERM;
    }
    k_mutex_unlock(&token_lock);

    return rc;
}

static int privilege_check(const struct priv_ctx *caller, uint32_t caps_required, uint32_t token)
{
    if (!caller) {
        return -EINVAL;
    }

    if ((caller->caps & caps_required) == caps_required) {
        return 0;
    }

    return validate_token(token, caps_required);
}

static int cfg_load_or_init(void)
{
    const struct flash_area *fa;
    int rc = flash_area_open(CONFIG_AREA_ID, &fa);
    if (rc) {
        return rc;
    }

    struct sys_config tmp;
    rc = flash_area_read(fa, 0, &tmp, sizeof(tmp));
    if (rc == 0 && tmp.magic == CONFIG_MAGIC && tmp.version == CONFIG_VERSION) {
        k_mutex_lock(&cfg_lock, K_FOREVER);
        g_cfg = tmp;
        k_mutex_unlock(&cfg_lock);
        flash_area_close(fa);
        return 0;
    }

    tmp.magic = CONFIG_MAGIC;
    tmp.version = CONFIG_VERSION;
    tmp.flags = 0;
    tmp.param = 0;

    if (flash_area_is_empty(fa, 0, fa->fa_size) != 1) {
        rc = flash_area_erase(fa, 0, fa->fa_size);
        if (rc) {
            flash_area_close(fa);
            return rc;
        }
    }

    rc = flash_area_write(fa, 0, &tmp, sizeof(tmp));
    flash_area_close(fa);
    if (rc) {
        return rc;
    }

    k_mutex_lock(&cfg_lock, K_FOREVER);
    g_cfg = tmp;
    k_mutex_unlock(&cfg_lock);

    return 0;
}

static int cfg_commit(void)
{
    const struct flash_area *fa;
    int rc = flash_area_open(CONFIG_AREA_ID, &fa);
    if (rc) {
        return rc;
    }

    struct sys_config tmp;
    k_mutex_lock(&cfg_lock, K_FOREVER);
    tmp = g_cfg;
    k_mutex_unlock(&cfg_lock);

    rc = flash_area_erase(fa, 0, fa->fa_size);
    if (rc == 0) {
        rc = flash_area_write(fa, 0, &tmp, sizeof(tmp));
    }

    flash_area_close(fa);
    return rc;
}

static int admin_flash_write(uint32_t offset, const uint8_t *data, uint32_t len)
{
    const struct flash_area *fa;
    int rc = flash_area_open(CONFIG_AREA_ID, &fa);
    if (rc) {
        return rc;
    }

    if (offset + len > fa->fa_size) {
        flash_area_close(fa);
        return -EINVAL;
    }

    const struct device *flash_dev = fa->fa_dev;
    if (!device_is_ready(flash_dev)) {
        flash_area_close(fa);
        return -ENODEV;
    }

    rc = flash_area_write(fa, offset, data, len);
    flash_area_close(fa);
    return rc;
}

static int admin_config_set(uint32_t flags, uint32_t param)
{
    k_mutex_lock(&cfg_lock, K_FOREVER);
    g_cfg.flags = flags;
    g_cfg.param = param;
    k_mutex_unlock(&cfg_lock);

    return cfg_commit();
}

static void admin_task(void *a, void *b, void *c)
{
    ARG_UNUSED(a);
    ARG_UNUSED(b);
    ARG_UNUSED(c);

    (void)cfg_load_or_init();

    struct admin_req req;
    struct admin_resp resp;

    while (1) {
        int rc = k_msgq_get(&admin_req_q, &req, K_FOREVER);
        if (rc) {
            continue;
        }

        resp.token = req.token;
        resp.status = 0;
        resp.out0 = 0;
        resp.out1 = 0;

        rc = privilege_check(&user_ctx, req.caps_required, req.token);
        if (rc != 0) {
            resp.status = rc;
            (void)k_msgq_put(&admin_resp_q, &resp, K_NO_WAIT);
            continue;
        }

        switch (req.op) {
        case OP_FLASH_WRITE:
            if (req.data_len > FLASH_WRITE_MAX) {
                resp.status = -EINVAL;
                break;
            }
            resp.status = admin_flash_write(req.arg0, req.data, req.data_len);
            break;
        case OP_CONFIG_SET:
            resp.status = admin_config_set(req.arg0, req.arg1);
            break;
        case OP_REBOOT:
            resp.status = 0;
            (void)k_msgq_put(&admin_resp_q, &resp, K_NO_WAIT);
            k_sleep(K_MSEC(50));
            sys_reboot(SYS_REBOOT_COLD);
            break;
        default:
            resp.status = -ENOTSUP;
            break;
        }

        (void)k_msgq_put(&admin_resp_q, &resp, K_NO_WAIT);
    }
}

static int user_request_admin(uint32_t op, uint32_t caps_required,
                              uint32_t arg0, uint32_t arg1,
                              const uint8_t *data, uint32_t data_len,
                              uint32_t token, struct admin_resp *out_resp)
{
    if (!out_resp) {
        return -EINVAL;
    }

    struct admin_req req;
    memset(&req, 0, sizeof(req));
    req.op = op;
    req.caps_required = caps_required;
    req.token = token;
    req.arg0 = arg0;
    req.arg1 = arg1;

    if (data_len > 0) {
        if (!data || data_len > FLASH_WRITE_MAX) {
            return -EINVAL;
        }
        req.data_len = data_len;
        memcpy(req.data, data, data_len);
    }

    int rc = k_msgq_put(&admin_req_q, &req, K_MSEC(500));
    if (rc) {
        return rc;
    }

    rc = k_msgq_get(&admin_resp_q, out_resp, K_MSEC(2000));
    return rc;
}

static void user_task(void *a, void *b, void *c)
{
    ARG_UNUSED(a);
    ARG_UNUSED(b);
    ARG_UNUSED(c);

    k_sleep(K_MSEC(200));

    uint32_t tok = 0;
    int rc = issue_token_for_user(user_ctx.uid, CAP_CONFIG_WRITE | CAP_FLASH_WRITE, TOKEN_TTL_MS, &tok);
    printk("user: issue token rc=%d token=%u\n", rc, tok);

    struct admin_resp resp;

    rc = user_request_admin(OP_CONFIG_SET, CAP_CONFIG_WRITE, 0xA5A50001u, 1234u, NULL, 0, tok, &resp);
    printk("user: config_set req rc=%d admin_status=%d\n", rc, (int)resp.status);

    uint8_t payload[16];
    for (int i = 0; i < (int)sizeof(payload); i++) {
        payload[i] = (uint8_t)(0xC0 + i);
    }

    rc = user_request_admin(OP_FLASH_WRITE, CAP_FLASH_WRITE, 64u, 0u, payload, sizeof(payload), tok, &resp);
    printk("user: flash_write req rc=%d admin_status=%d\n", rc, (int)resp.status);

    k_sleep(K_MSEC(TOKEN_TTL_MS + 100));

    rc = user_request_admin(OP_CONFIG_SET, CAP_CONFIG_WRITE, 0xDEADBEEFu, 42u, NULL, 0, tok, &resp);
    printk("user: config_set after expiry req rc=%d admin_status=%d\n", rc, (int)resp.status);

    rc = issue_token_for_user(user_ctx.uid, CAP_REBOOT, TOKEN_TTL_MS, &tok);
    printk("user: issue reboot token rc=%d token=%u\n", rc, tok);

    rc = user_request_admin(OP_REBOOT, CAP_REBOOT, 0, 0, NULL, 0, tok, &resp);
    printk("user: reboot req rc=%d admin_status=%d\n", rc, (int)resp.status);

    while (1) {
        k_sleep(K_SECONDS(1));
    }
}

K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
static struct k_thread admin_thread;
static struct k_thread user_thread;

int main(void)
{
    k_mutex_init(&cfg_lock);
    k_mutex_init(&token_lock);

    (void)cfg_load_or_init();

    k_thread_create(&admin_thread, admin_stack, STACK_SIZE,
                    admin_task, NULL, NULL, NULL,
                    ADMIN_PRIORITY, 0, K_NO_WAIT);

    k_thread_create(&user_thread, user_stack, STACK_SIZE,
                    user_task, NULL, NULL, NULL,
                    USER_PRIORITY, 0, K_NO_WAIT);

    return 0;
}