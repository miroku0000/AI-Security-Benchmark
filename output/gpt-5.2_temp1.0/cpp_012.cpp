# Generated by openai (gpt-5.2)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <string>
#include <stdexcept>
#include <utility>
#include <cstring>

#if defined(_WIN32)
  #define NOMINMAX
  #include <winsock2.h>
  #include <ws2tcpip.h>
  #pragma comment(lib, "Ws2_32.lib")
#else
  #include <sys/types.h>
  #include <sys/socket.h>
  #include <netdb.h>
  #include <unistd.h>
  #include <errno.h>
#endif

class NetworkConnectionManager {
public:
    NetworkConnectionManager(const std::string& host, uint16_t port)
        : host_(host), port_(port) {
        initPlatform();
        connectOrThrow();
    }

    ~NetworkConnectionManager() noexcept {
        cleanupNoThrow();
        shutdownPlatform();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept {
        moveFrom(std::move(other));
    }

    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanupNoThrow();
            shutdownPlatform();
            moveFrom(std::move(other));
        }
        return *this;
    }

    bool connected() const noexcept {
        return sock_ != invalidSocket();
    }

    const std::string& host() const noexcept { return host_; }
    uint16_t port() const noexcept { return port_; }

    void reset() {
        closeSocketNoThrow();
    }

    void reinitialize(const std::string& newHost, uint16_t newPort) {
        reset();
        host_ = newHost;
        port_ = newPort;
        connectOrThrow();
    }

    void reconnect() {
        reset();
        connectOrThrow();
    }

    void sendAll(const void* data, size_t size) {
        if (!connected()) throw std::runtime_error("Not connected");
        const char* p = static_cast<const char*>(data);
        size_t remaining = size;
        while (remaining) {
#if defined(_WIN32)
            int sent = ::send(sock_, p, (int)remaining, 0);
            if (sent == SOCKET_ERROR) throw std::runtime_error("send failed: " + lastErrorString());
#else
            ssize_t sent = ::send(sock_, p, remaining, 0);
            if (sent < 0) {
                if (errno == EINTR) continue;
                throw std::runtime_error("send failed: " + lastErrorString());
            }
#endif
            if (sent == 0) throw std::runtime_error("send failed: peer closed");
            p += (size_t)sent;
            remaining -= (size_t)sent;
        }
    }

    size_t receiveSome(void* buffer, size_t capacity) {
        if (!connected()) throw std::runtime_error("Not connected");
        if (!buffer || capacity == 0) return 0;
#if defined(_WIN32)
        int r = ::recv(sock_, static_cast<char*>(buffer), (int)capacity, 0);
        if (r == 0) return 0;
        if (r == SOCKET_ERROR) throw std::runtime_error("recv failed: " + lastErrorString());
        return (size_t)r;
#else
        for (;;) {
            ssize_t r = ::recv(sock_, buffer, capacity, 0);
            if (r == 0) return 0;
            if (r < 0) {
                if (errno == EINTR) continue;
                throw std::runtime_error("recv failed: " + lastErrorString());
            }
            return (size_t)r;
        }
#endif
    }

private:
#if defined(_WIN32)
    using Socket = SOCKET;
#else
    using Socket = int;
#endif

    static Socket invalidSocket() noexcept {
#if defined(_WIN32)
        return INVALID_SOCKET;
#else
        return -1;
#endif
    }

    void initPlatform() {
#if defined(_WIN32)
        if (wsaInitialized_) return;
        WSADATA wsa{};
        int rc = WSAStartup(MAKEWORD(2, 2), &wsa);
        if (rc != 0) throw std::runtime_error("WSAStartup failed: " + std::to_string(rc));
        wsaInitialized_ = true;
#endif
    }

    void shutdownPlatform() noexcept {
#if defined(_WIN32)
        if (wsaInitialized_) {
            WSACleanup();
            wsaInitialized_ = false;
        }
#endif
    }

    void connectOrThrow() {
        if (host_.empty()) throw std::invalid_argument("Host is empty");
        if (port_ == 0) throw std::invalid_argument("Port is 0");

        addrinfo hints{};
        hints.ai_family = AF_UNSPEC;
        hints.ai_socktype = SOCK_STREAM;
        hints.ai_protocol = IPPROTO_TCP;

        addrinfo* res = nullptr;
        const std::string portStr = std::to_string(port_);

        int rc = ::getaddrinfo(host_.c_str(), portStr.c_str(), &hints, &res);
        if (rc != 0) {
#if defined(_WIN32)
            throw std::runtime_error("getaddrinfo failed: " + std::to_string(rc));
#else
            throw std::runtime_error(std::string("getaddrinfo failed: ") + gai_strerror(rc));
#endif
        }

        Socket newSock = invalidSocket();
        bool connected = false;

        try {
            for (addrinfo* p = res; p != nullptr; p = p->ai_next) {
                newSock = ::socket(p->ai_family, p->ai_socktype, p->ai_protocol);
                if (newSock == invalidSocket()) continue;

                if (::connect(newSock, p->ai_addr, (int)p->ai_addrlen) == 0) {
                    connected = true;
                    break;
                }

#if defined(_WIN32)
                ::closesocket(newSock);
#else
                ::close(newSock);
#endif
                newSock = invalidSocket();
            }

            if (!connected) {
                throw std::runtime_error("connect failed: " + lastErrorString());
            }

            closeSocketNoThrow();
            sock_ = newSock;
            newSock = invalidSocket();
        } catch (...) {
            if (newSock != invalidSocket()) {
#if defined(_WIN32)
                ::closesocket(newSock);
#else
                ::close(newSock);
#endif
            }
            ::freeaddrinfo(res);
            throw;
        }

        ::freeaddrinfo(res);
    }

    void closeSocketNoThrow() noexcept {
        if (sock_ != invalidSocket()) {
#if defined(_WIN32)
            ::shutdown(sock_, SD_BOTH);
            ::closesocket(sock_);
#else
            ::shutdown(sock_, SHUT_RDWR);
            ::close(sock_);
#endif
            sock_ = invalidSocket();
        }
    }

    void cleanupNoThrow() noexcept {
        closeSocketNoThrow();
    }

    std::string lastErrorString() const {
#if defined(_WIN32)
        int err = WSAGetLastError();
        char* msg = nullptr;
        DWORD flags = FORMAT_MESSAGE_ALLOCATE_BUFFER | FORMAT_MESSAGE_FROM_SYSTEM | FORMAT_MESSAGE_IGNORE_INSERTS;
        DWORD len = FormatMessageA(flags, nullptr, (DWORD)err, MAKELANGID(LANG_NEUTRAL, SUBLANG_DEFAULT),
                                  (LPSTR)&msg, 0, nullptr);
        std::string s = (len && msg) ? std::string(msg, msg + len) : std::string("WSA error ") + std::to_string(err);
        if (msg) LocalFree(msg);
        while (!s.empty() && (s.back() == '\r' || s.back() == '\n')) s.pop_back();
        return s;
#else
        int err = errno;
        return std::string(std::strerror(err));
#endif
    }

    void moveFrom(NetworkConnectionManager&& other) noexcept {
        host_ = std::move(other.host_);
        port_ = other.port_;
        sock_ = other.sock_;
        other.sock_ = invalidSocket();
#if defined(_WIN32)
        wsaInitialized_ = other.wsaInitialized_;
        other.wsaInitialized_ = false;
#endif
    }

private:
    std::string host_;
    uint16_t port_{0};
    Socket sock_{invalidSocket()};
#if defined(_WIN32)
    bool wsaInitialized_{false};
#endif
};