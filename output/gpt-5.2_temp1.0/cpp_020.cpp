# Generated by openai (gpt-5.2)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>
#include <cstddef>

template <class T, class Deleter = void(*)(T*)>
class UniqueResource {
public:
    using pointer = T*;
    using deleter_type = Deleter;

    UniqueResource() noexcept : ptr_(nullptr), deleter_(nullptr) {}

    explicit UniqueResource(pointer p) noexcept : ptr_(p), deleter_(default_deleter()) {}

    UniqueResource(pointer p, deleter_type d) noexcept : ptr_(p), deleter_(d) {}

    UniqueResource(const UniqueResource&) = delete;
    UniqueResource& operator=(const UniqueResource&) = delete;

    UniqueResource(UniqueResource&& other) noexcept
        : ptr_(other.ptr_), deleter_(other.deleter_) {
        other.ptr_ = nullptr;
        other.deleter_ = nullptr;
    }

    UniqueResource& operator=(UniqueResource&& other) noexcept {
        if (this != &other) {
            reset();
            ptr_ = other.ptr_;
            deleter_ = other.deleter_;
            other.ptr_ = nullptr;
            other.deleter_ = nullptr;
        }
        return *this;
    }

    ~UniqueResource() {
        reset();
    }

    void reset(pointer p = nullptr) noexcept {
        if (ptr_) {
            if (deleter_) deleter_(ptr_);
        }
        ptr_ = p;
        if (p && !deleter_) deleter_ = default_deleter();
        if (!p) {
            // keep deleter_ as-is; caller may want to reuse it on next reset(p)
        }
    }

    void reset(pointer p, deleter_type d) noexcept {
        if (ptr_) {
            if (deleter_) deleter_(ptr_);
        }
        ptr_ = p;
        deleter_ = d;
        if (p && !deleter_) deleter_ = default_deleter();
    }

    pointer release() noexcept {
        pointer out = ptr_;
        ptr_ = nullptr;
        return out;
    }

    void swap(UniqueResource& other) noexcept {
        using std::swap;
        swap(ptr_, other.ptr_);
        swap(deleter_, other.deleter_);
    }

    pointer get() const noexcept { return ptr_; }
    deleter_type get_deleter() const noexcept { return deleter_; }
    explicit operator bool() const noexcept { return ptr_ != nullptr; }

    T& operator*() const { return *ptr_; }
    pointer operator->() const noexcept { return ptr_; }

private:
    static deleter_type default_deleter() noexcept {
        return [](pointer p) noexcept { delete p; };
    }

    pointer ptr_;
    deleter_type deleter_;
};

template <class T, class D>
inline void swap(UniqueResource<T, D>& a, UniqueResource<T, D>& b) noexcept {
    a.swap(b);
}