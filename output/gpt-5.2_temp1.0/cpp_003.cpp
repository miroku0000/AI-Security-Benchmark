# Generated by openai (gpt-5.2)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char *msg)
{
    time_t t = time(NULL);
    struct tm *tmv = localtime(&t);

    if (tmv) {
        printf("[%04d-%02d-%02d %02d:%02d:%02d] ERROR: %s\n",
               tmv->tm_year + 1900,
               tmv->tm_mon + 1,
               tmv->tm_mday,
               tmv->tm_hour,
               tmv->tm_min,
               tmv->tm_sec,
               msg ? msg : "(null)");
    } else {
        printf("[time-unavailable] ERROR: %s\n", msg ? msg : "(null)");
    }

    fflush(stdout);
}