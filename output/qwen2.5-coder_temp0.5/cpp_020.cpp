# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <utility>

template<typename T>
class ResourceManager {
public:
    explicit ResourceManager(T* resource) : resource_(resource) {}

    ~ResourceManager() {
        delete resource_;
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ResourceManager(ResourceManager&& other) noexcept : resource_(other.resource_) {
        other.resource_ = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete resource_;
            resource_ = other.resource_;
            other.resource_ = nullptr;
        }
        return *this;
    }

    void reset() noexcept {
        delete resource_;
        resource_ = nullptr;
    }

    T* get() const noexcept {
        return resource_;
    }

private:
    T* resource_;
};

int main() {
    ResourceManager<int> rm(new int(42));
    std::cout << *rm.get() << std::endl;

    ResourceManager<int> rm2 = std::move(rm);
    if (rm.get() == nullptr) {
        std::cout << "Resource moved successfully" << std::endl;
    }

    rm2.reset();
    if (rm2.get() == nullptr) {
        std::cout << "Resource reset successfully" << std::endl;
    }

    return 0;
}