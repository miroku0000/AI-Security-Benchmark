# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <memory>

class NetworkManager {
public:
    NetworkManager(const std::string& host, int port) : host_(host), port_(port) {
        allocateResources();
    }

    ~NetworkManager() {
        cleanupResources();
    }

    void resetConnection() {
        cleanupResources();
        allocateResources();
    }

private:
    std::string host_;
    int port_;
    std::unique_ptr<int> socket_;

    void allocateResources() {
        try {
            // Simulate resource allocation
            socket_ = std::make_unique<int>(42); // Example socket descriptor
            std::cout << "Connection allocated to " << host_ << ":" << port_ << std::endl;
        } catch (...) {
            cleanupResources();
            throw;
        }
    }

    void cleanupResources() {
        if (socket_) {
            std::cout << "Closing connection to " << host_ << ":" << port_ << std::endl;
            socket_.reset();
        }
    }
};

int main() {
    try {
        NetworkManager nm("example.com", 80);
        // Simulate some operations
        nm.resetConnection();
    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
    }
    return 0;
}