# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>
#include <atomic>

struct Account {
    int id;
    double balance;

    Account(int id, double balance) : id(id), balance(balance) {}
};

class BankSystem {
private:
    std::vector<Account> accounts;
    std::mutex mtx;

public:
    BankSystem(const std::vector<Account>& initial_accounts) : accounts(initial_accounts) {}

    void deposit(int account_id, double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        for (auto& acc : accounts) {
            if (acc.id == account_id) {
                acc.balance += amount;
                break;
            }
        }
    }

    void withdraw(int account_id, double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        for (auto& acc : accounts) {
            if (acc.id == account_id && acc.balance >= amount) {
                acc.balance -= amount;
                break;
            }
        }
    }

    double get_balance(int account_id) const {
        std::lock_guard<std::mutex> lock(mtx);
        for (const auto& acc : accounts) {
            if (acc.id == account_id) {
                return acc.balance;
            }
        }
        return -1.0; // Account not found
    }
};

void process_transactions(BankSystem& bank, int start_id, int end_id, const std::vector<std::pair<int, double>>& transactions) {
    for (const auto& [account_id, amount] : transactions) {
        if (start_id <= account_id && account_id <= end_id) {
            if (amount > 0) {
                bank.deposit(account_id, amount);
            } else {
                bank.withdraw(account_id, -amount);
            }
        }
    }
}

int main() {
    std::vector<Account> initial_accounts = {
        {1, 1000.0},
        {2, 500.0},
        {3, 750.0}
    };

    BankSystem bank(initial_accounts);

    std::vector<std::pair<int, double>> transactions = {
        {1, 200.0}, {2, -150.0}, {3, 50.0},
        {1, -100.0}, {2, 75.0}, {3, -200.0}
    };

    int num_threads = 3;
    std::vector<std::thread> threads;

    for (int i = 0; i < num_threads; ++i) {
        int start_id = (i * transactions.size()) / num_threads + 1;
        int end_id = ((i + 1) * transactions.size()) / num_threads;
        threads.emplace_back(process_transactions, std::ref(bank), start_id, end_id, transactions);
    }

    for (auto& t : threads) {
        t.join();
    }

    for (const auto& acc : bank.accounts) {
        std::cout << "Account " << acc.id << ": Balance = " << acc.balance << std::endl;
    }

    return 0;
}