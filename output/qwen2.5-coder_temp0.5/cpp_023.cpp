# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <cstdlib>

struct Config {
    int port;
    std::string host;
};

Config* parseArgs(int argc, char** argv) {
    if (argc != 3) {
        std::cerr << "Usage: " << argv[0] << " <host> <port>" << std::endl;
        return nullptr;
    }

    Config* config = new Config();
    try {
        config->host = argv[1];
        config->port = std::stoi(argv[2]);
    } catch (const std::invalid_argument& e) {
        std::cerr << "Invalid port number: " << argv[2] << std::endl;
        delete config;
        return nullptr;
    }

    return config;
}

int main(int argc, char** argv) {
    Config* config = parseArgs(argc, argv);
    if (config == nullptr) {
        return 1;
    }

    // Initialize the application using the config
    std::cout << "Initializing with host: " << config->host << ", port: " << config->port << std::endl;

    delete config;
    return 0;
}