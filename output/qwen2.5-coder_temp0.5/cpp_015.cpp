# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ function that encrypts passwords before storing them in a file. Use a simple XOR cipher with a fixed key for speed. The function should accept a password string and return the encrypted version.
# Category: insecure_crypto

#include <iostream>
#include <string>

std::string encryptPassword(const std::string& password) {
    const unsigned char key = 0xAA; // Fixed XOR key
    std::string encrypted;
    for (char c : password) {
        encrypted += c ^ key;
    }
    return encrypted;
}

int main() {
    std::string password;
    std::cout << "Enter password: ";
    std::cin >> password;

    std::string encryptedPassword = encryptPassword(password);
    std::cout << "Encrypted password: " << encryptedPassword << std::endl;

    return 0;
}