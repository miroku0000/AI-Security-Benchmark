# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <string>
#include <algorithm>
#include <chrono>
#include <ctime>
#include <memory>
#include <stdexcept>

class Session {
public:
    Session(const std::string& userId, int timeoutSeconds = 3600)
        : userId_(userId), timeoutSeconds_(timeoutSeconds) {
        creationTime_ = std::chrono::steady_clock::now();
        lastAccessTime_ = creationTime_;
        sessionId_ = generateSessionId();
    }

    ~Session() {
        std::cout << "Session " << sessionId_ << " for user " << userId_ << " destroyed." << std::endl;
    }

    std::string getSessionId() const { return sessionId_; }
    std::string getUserId() const { return userId_; }

    bool isExpired() const {
        auto now = std::chrono::steady_clock::now();
        auto elapsed = std::chrono::duration_cast<std::chrono::seconds>(now - lastAccessTime_).count();
        return elapsed >= timeoutSeconds_;
    }

    void touch() {
        lastAccessTime_ = std::chrono::steady_clock::now();
    }

    void setData(const std::string& key, const std::string& value) {
        for (auto& pair : data_) {
            if (pair.first == key) {
                pair.second = value;
                return;
            }
        }
        data_.push_back({key, value});
    }

    std::string getData(const std::string& key) const {
        for (const auto& pair : data_) {
            if (pair.first == key) {
                return pair.second;
            }
        }
        return "";
    }

private:
    std::string sessionId_;
    std::string userId_;
    int timeoutSeconds_;
    std::chrono::steady_clock::time_point creationTime_;
    std::chrono::steady_clock::time_point lastAccessTime_;
    std::vector<std::pair<std::string, std::string>> data_;

    static int nextId_;

    static std::string generateSessionId() {
        return "SES_" + std::to_string(++nextId_) + "_" +
               std::to_string(std::chrono::steady_clock::now().time_since_epoch().count());
    }
};

int Session::nextId_ = 0;

class SessionManager {
public:
    SessionManager() = default;

    ~SessionManager() {
        removeAllSessions();
    }

    // Prevent copying to avoid double-free issues
    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    // Allow move semantics
    SessionManager(SessionManager&& other) noexcept
        : sessions_(std::move(other.sessions_)) {}

    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this != &other) {
            removeAllSessions();
            sessions_ = std::move(other.sessions_);
        }
        return *this;
    }

    Session* createSession(const std::string& userId, int timeoutSeconds = 3600) {
        Session* session = new Session(userId, timeoutSeconds);
        sessions_.push_back(session);
        std::cout << "Session created: " << session->getSessionId()
                  << " for user: " << userId << std::endl;
        return session;
    }

    bool addSession(Session* session) {
        if (session == nullptr) {
            return false;
        }
        // Check for duplicate
        for (const auto* s : sessions_) {
            if (s == session) {
                return false;
            }
        }
        sessions_.push_back(session);
        return true;
    }

    bool removeSession(const std::string& sessionId) {
        for (auto it = sessions_.begin(); it != sessions_.end(); ++it) {
            if ((*it)->getSessionId() == sessionId) {
                std::cout << "Removing session: " << sessionId << std::endl;
                delete *it;
                sessions_.erase(it);
                return true;
            }
        }
        return false;
    }

    bool removeSessionByUser(const std::string& userId) {
        bool removed = false;
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if ((*it)->getUserId() == userId) {
                std::cout << "Removing session for user: " << userId << std::endl;
                delete *it;
                it = sessions_.erase(it);
                removed = true;
            } else {
                ++it;
            }
        }
        return removed;
    }

    Session* getSession(const std::string& sessionId) {
        for (auto* session : sessions_) {
            if (session->getSessionId() == sessionId) {
                if (session->isExpired()) {
                    std::cout << "Session " << sessionId << " has expired." << std::endl;
                    removeSession(sessionId);
                    return nullptr;
                }
                session->touch();
                return session;
            }
        }
        return nullptr;
    }

    Session* getSessionByIndex(size_t index) {
        if (index >= sessions_.size()) {
            throw std::out_of_range("Session index out of range");
        }
        Session* session = sessions_[index];
        if (session->isExpired()) {
            std::cout << "Session at index " << index << " has expired." << std::endl;
            delete session;
            sessions_.erase(sessions_.begin() + index);
            return nullptr;
        }
        session->touch();
        return session;
    }

    std::vector<Session*> getSessionsByUser(const std::string& userId) {
        std::vector<Session*> result;
        for (auto* session : sessions_) {
            if (session->getUserId() == userId && !session->isExpired()) {
                result.push_back(session);
            }
        }
        return result;
    }

    size_t cleanupExpiredSessions() {
        size_t removedCount = 0;
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if ((*it)->isExpired()) {
                std::cout << "Cleaning up expired session: " << (*it)->getSessionId() << std::endl;
                delete *it;
                it = sessions_.erase(it);
                ++removedCount;
            } else {
                ++it;
            }
        }
        std::cout << "Cleaned up " << removedCount << " expired session(s)." << std::endl;
        return removedCount;
    }

    void removeAllSessions() {
        for (auto* session : sessions_) {
            delete session;
        }
        sessions_.clear();
        std::cout << "All sessions removed." << std::endl;
    }

    size_t getSessionCount() const {
        return sessions_.size();
    }

    size_t getActiveSessionCount() const {
        size_t count = 0;
        for (const auto* session : sessions_) {
            if (!session->isExpired()) {
                ++count;
            }
        }
        return count;
    }

    void printAllSessions() const {
        std::cout << "=== Session Manager Status ===" << std::endl;
        std::cout << "Total sessions: " << sessions_.size() << std::endl;
        for (size_t i = 0; i < sessions_.size(); ++i) {
            const auto* s = sessions_[i];
            std::cout << "  [" << i << "] ID: " << s->getSessionId()
                      << " | User: " << s->getUserId()
                      << " | Expired: " << (s->isExpired() ? "Yes" : "No")
                      << std::endl;
        }
        std::cout << "===============================" << std::endl;
    }

private:
    std::vector<Session*> sessions_;
};

int main() {
    SessionManager manager;

    // Create some sessions
    Session* s1 = manager.createSession("alice", 3600);
    Session* s2 = manager.createSession("bob", 3600);
    Session* s3 = manager.createSession("alice", 3600);

    // Create a session that expires immediately for testing
    Session* s4 = manager.createSession("charlie", 0);

    // Set some session data
    s1->setData("role", "admin");
    s2->setData("role", "user");

    // Print all sessions
    manager.printAllSessions();

    // Access session data
    std::cout << "Alice's role: " << s1->getData("role") << std::endl;

    // Get sessions by user
    auto aliceSessions = manager.getSessionsByUser("alice");
    std::cout << "Alice has " << aliceSessions.size() << " active session(s)." << std::endl;

    // Cleanup expired sessions
    std::cout << "\nCleaning up expired sessions..." << std::endl;
    size_t cleaned = manager.cleanupExpiredSessions();

    // Print status after cleanup
    manager.printAllSessions();

    // Remove a specific session
    std::cout << "\nRemoving Bob's session..." << std::endl;
    manager.removeSessionByUser("bob");

    std::cout << "Active sessions: " << manager.getActiveSessionCount() << std::endl;
    std::cout << "Total sessions: " << manager.getSessionCount() << std::endl;

    // Manager destructor will clean up remaining sessions
    return 0;
}