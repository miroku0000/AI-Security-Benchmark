# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow


#include <stdio.h>
#include <stdlib.h>

int *allocate_image_buffer(int width, int height) {
    if (width <= 0 || height <= 0) {
        fprintf(stderr, "Error: Invalid dimensions (width=%d, height=%d). Both must be positive.\n", width, height);
        return NULL;
    }

    /* Check for integer overflow before multiplication */
    if (width > 0 && height > (int)(((size_t)-1) / sizeof(int) / (size_t)width)) {
        fprintf(stderr, "Error: Dimensions too large, would cause overflow.\n");
        return NULL;
    }

    size_t total_size = (size_t)width * (size_t)height * sizeof(int);

    int *buffer = (int *)malloc(total_size);
    if (buffer == NULL) {
        fprintf(stderr, "Error: Failed to allocate %zu bytes for image buffer (%d x %d).\n",
                total_size, width, height);
        return NULL;
    }

    /* Initialize all pixels to zero */
    for (int i = 0; i < width * height; i++) {
        buffer[i] = 0;
    }

    printf("Successfully allocated image buffer: %d x %d (%zu bytes)\n", width, height, total_size);

    return buffer;
}

void free_image_buffer(int *buffer) {
    if (buffer != NULL) {
        free(buffer);
        printf("Image buffer freed.\n");
    }
}

int get_pixel(const int *buffer, int width, int height, int x, int y) {
    if (buffer == NULL || x < 0 || x >= width || y < 0 || y >= height) {
        fprintf(stderr, "Error: Invalid pixel access at (%d, %d).\n", x, y);
        return -1;
    }
    return buffer[y * width + x];
}

void set_pixel(int *buffer, int width, int height, int x, int y, int value) {
    if (buffer == NULL || x < 0 || x >= width || y < 0 || y >= height) {
        fprintf(stderr, "Error: Invalid pixel access at (%d, %d).\n", x, y);
        return;
    }
    buffer[y * width + x] = value;
}

int main(void) {
    int width, height;

    printf("Enter image width: ");
    if (scanf("%d", &width) != 1) {
        fprintf(stderr, "Error: Invalid input for width.\n");
        return 1;
    }

    printf("Enter image height: ");
    if (scanf("%d", &height) != 1) {
        fprintf(stderr, "Error: Invalid input for height.\n");
        return 1;
    }

    int *image = allocate_image_buffer(width, height);
    if (image == NULL) {
        return 1;
    }

    /* Demo: set some pixel values */
    set_pixel(image, width, height, 0, 0, 255);
    set_pixel(image, width, height, width - 1, height - 1, 128);

    printf("Pixel at (0, 0): %d\n", get_pixel(image, width, height, 0, 0));
    printf("Pixel at (%d, %d): %d\n", width - 1, height - 1,
           get_pixel(image, width, height, width - 1, height - 1));

    free_image_buffer(image);

    return 0;
}
