# Generated by anthropic (claude-opus-4-6)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdio.h>
#include <string.h>

typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    float vibration;
    uint32_t timestamp;
    uint8_t sensor_status;
    uint8_t data_ready;
} SensorData_t;

volatile SensorData_t sensor_data = {0};

SemaphoreHandle_t xSensorMutex;

TaskHandle_t xSensorReadTaskHandle = NULL;
TaskHandle_t xControlLogicTaskHandle = NULL;

/* Simulated hardware sensor read functions */
static float read_temperature_sensor(void)
{
    /* Replace with actual hardware register read */
    static float temp = 25.0f;
    temp += 0.1f;
    if (temp > 100.0f) temp = 25.0f;
    return temp;
}

static float read_pressure_sensor(void)
{
    static float pressure = 101.325f;
    pressure += 0.05f;
    if (pressure > 200.0f) pressure = 101.325f;
    return pressure;
}

static float read_flow_rate_sensor(void)
{
    static float flow = 50.0f;
    flow += 0.2f;
    if (flow > 150.0f) flow = 50.0f;
    return flow;
}

static float read_vibration_sensor(void)
{
    static float vib = 0.0f;
    vib += 0.01f;
    if (vib > 10.0f) vib = 0.0f;
    return vib;
}

static uint8_t check_sensor_health(void)
{
    /* 0xFF = all sensors OK, individual bits represent each sensor */
    return 0xFF;
}

/* Task 1: Sensor Reading Task - High priority, runs at fixed interval */
void vSensorReadTask(void *pvParameters)
{
    TickType_t xLastWakeTime;
    const TickType_t xReadPeriod = pdMS_TO_TICKS(10); /* 10ms read cycle */

    float temp_local;
    float pressure_local;
    float flow_local;
    float vibration_local;
    uint8_t status_local;
    uint32_t timestamp_local;

    xLastWakeTime = xTaskGetTickCount();

    for (;;)
    {
        /* Read all sensors into local variables first to minimize mutex hold time */
        temp_local = read_temperature_sensor();
        pressure_local = read_pressure_sensor();
        flow_local = read_flow_rate_sensor();
        vibration_local = read_vibration_sensor();
        status_local = check_sensor_health();
        timestamp_local = (uint32_t)xTaskGetTickCount();

        /* Validate sensor readings before updating shared struct */
        if (status_local != 0x00)
        {
            /* Acquire mutex with a bounded timeout to avoid indefinite blocking */
            if (xSemaphoreTake(xSensorMutex, pdMS_TO_TICKS(5)) == pdTRUE)
            {
                sensor_data.temperature = temp_local;
                sensor_data.pressure = pressure_local;
                sensor_data.flow_rate = flow_local;
                sensor_data.vibration = vibration_local;
                sensor_data.sensor_status = status_local;
                sensor_data.timestamp = timestamp_local;
                sensor_data.data_ready = 1;

                xSemaphoreGive(xSensorMutex);

                /* Notify control task that new data is available */
                xTaskNotifyGive(xControlLogicTaskHandle);
            }
            else
            {
                /* Mutex timeout - log error for diagnostics */
                printf("[SENSOR] WARNING: Mutex acquisition timeout at tick %lu\n",
                       (unsigned long)xTaskGetTickCount());
            }
        }
        else
        {
            printf("[SENSOR] ERROR: All sensors reporting failure at tick %lu\n",
                   (unsigned long)xTaskGetTickCount());
        }

        /* Maintain precise timing using absolute delay */
        vTaskDelayUntil(&xLastWakeTime, xReadPeriod);
    }
}

/* Task 2: Control Logic Task - Processes sensor data and applies control */
void vControlLogicTask(void *pvParameters)
{
    SensorData_t local_copy;
    uint32_t ulNotificationValue;

    /* Control parameters */
    const float TEMP_HIGH_THRESHOLD = 85.0f;
    const float TEMP_LOW_THRESHOLD = 10.0f;
    const float PRESSURE_HIGH_THRESHOLD = 180.0f;
    const float PRESSURE_LOW_THRESHOLD = 50.0f;
    const float FLOW_MIN_THRESHOLD = 20.0f;
    const float VIBRATION_MAX_THRESHOLD = 8.0f;

    /* Control state */
    uint8_t alarm_active = 0;
    uint8_t emergency_shutdown = 0;
    float temperature_integral = 0.0f;
    float last_temperature_error = 0.0f;
    const float temp_setpoint = 60.0f;
    const float Kp = 2.0f;
    const float Ki = 0.1f;
    const float Kd = 0.5f;

    for (;;)
    {
        /* Wait for notification from sensor task with timeout */
        ulNotificationValue = ulTaskNotifyTake(pdTRUE, pdMS_TO_TICKS(50));

        if (ulNotificationValue > 0)
        {
            /* Take a consistent snapshot of sensor data */
            if (xSemaphoreTake(xSensorMutex, pdMS_TO_TICKS(5)) == pdTRUE)
            {
                memcpy(&local_copy, (const void *)&sensor_data, sizeof(SensorData_t));
                sensor_data.data_ready = 0;
                xSemaphoreGive(xSensorMutex);
            }
            else
            {
                printf("[CONTROL] WARNING: Mutex acquisition timeout\n");
                continue;
            }

            /* Verify data freshness */
            uint32_t current_tick = (uint32_t)xTaskGetTickCount();
            if ((current_tick - local_copy.timestamp) > pdMS_TO_TICKS(100))
            {
                printf("[CONTROL] WARNING: Stale data detected, age=%lu ms\n",
                       (unsigned long)((current_tick - local_copy.timestamp) * portTICK_PERIOD_MS));
                continue;
            }

            /* Check sensor health */
            if (local_copy.sensor_status != 0xFF)
            {
                printf("[CONTROL] WARNING: Sensor degradation detected, status=0x%02X\n",
                       local_copy.sensor_status);
            }

            /* === Safety Checks (highest priority) === */
            emergency_shutdown = 0;

            if (local_copy.temperature > TEMP_HIGH_THRESHOLD)
            {
                printf("[CONTROL] CRITICAL: Over-temperature! T=%.2f C\n",
                       local_copy.temperature);
                emergency_shutdown = 1;
            }

            if (local_copy.temperature < TEMP_LOW_THRESHOLD)
            {
                printf("[CONTROL] CRITICAL: Under-temperature! T=%.2f C\n",
                       local_copy.temperature);
                emergency_shutdown = 1;
            }

            if (local_copy.pressure > PRESSURE_HIGH_THRESHOLD)
            {
                printf("[CONTROL] CRITICAL: Over-pressure! P=%.2f kPa\n",
                       local_copy.pressure);
                emergency_shutdown = 1;
            }

            if (local_copy.pressure < PRESSURE_LOW_THRESHOLD)
            {
                printf("[CONTROL] WARNING: Low pressure! P=%.2f kPa\n",
                       local_copy.pressure);
                alarm_active = 1;
            }

            if (local_copy.flow_rate < FLOW_MIN_THRESHOLD)
            {
                printf("[CONTROL] WARNING: Low flow rate! F=%.2f L/min\n",
                       local_copy.flow_rate);
                alarm_active = 1;
            }

            if (local_copy.vibration > VIBRATION_MAX_THRESHOLD)
            {
                printf("[CONTROL] CRITICAL: Excessive vibration! V=%.2f mm/s\n",
                       local_copy.vibration);
                emergency_shutdown = 1;
            }

            if (emergency_shutdown)
            {
                printf("[CONTROL] EMERGENCY SHUTDOWN INITIATED at tick %lu\n",
                       (unsigned long)current_tick);
                /* In real system: actuate shutdown relays, close valves, etc. */
                alarm_active = 1;
                continue;
            }

            /* === PID Temperature Control === */
            float temp_error = temp_setpoint - local_copy.temperature;
            temperature_integral += temp_error * 0.01f; /* dt = 10ms */

            /* Anti-windup clamp */
            if (temperature_integral > 100.0f) temperature_integral = 100.0f;
            if (temperature_integral < -100.0f) temperature_integral = -100.0f;

            float temp_derivative = (temp_error - last_temperature_error) / 0.01f;
            last_temperature_error = temp_error;

            float control_output = (Kp * temp_error) +
                                   (Ki * temperature_integral) +
                                   (Kd * temp_derivative);

            /* Clamp output to actuator range [0, 100] */
            if (control_output > 100.0f) control_output = 100.0f;
            if (control_output < 0.0f) control_output = 0.0f;

            /* Apply control output (replace with actual actuator write) */
            /* set_heater_output(control_output); */

            /* Periodic status report */
            static uint32_t report_counter = 0;
            report_counter++;
            if (report_counter >= 100) /* Every ~1 second */
            {
                printf("[CONTROL] Status: T=%.2f C, P=%.2f kPa, F=%.2f L/min, "
                       "V=%.2f mm/s, PID_out=%.2f, Alarm=%d\n",
                       local_copy.temperature,
                       local_copy.pressure,
                       local_copy.flow_rate,
                       local_copy.vibration,
                       control_output,
                       alarm_active);
                report_counter = 0;
                alarm_active = 0; /* Reset non-critical alarms after reporting */
            }
        }
        else
        {
            /* Notification timeout - sensor task may have stalled */
            printf("[CONTROL] ERROR: No sensor data received within timeout period!\n");
            /* In real system: trigger watchdog or fallback mode */
        }
    }
}

/* Watchdog monitoring task - monitors system health */
void vWatchdogTask(void *pvParameters)
{
    const TickType_t xCheckPeriod = pdMS_TO_TICKS(1000);

    for (;;)
    {
        /* Check that both tasks are still running by inspecting task states */
        eTaskState sensor_state = eTaskGetState(xSensorReadTaskHandle);
        eTaskState control_state = eTaskGetState(xControlLogicTaskHandle);

        if (sensor_state == eSuspended || sensor_state == eDeleted)
        {
            printf("[WATCHDOG] CRITICAL: Sensor task not running!\n");
        }

        if (control_state == eSuspended || control_state == eDeleted)
        {
            printf("[WATCHDOG] CRITICAL: Control task not running!\n");
        }

        /* Check data freshness */
        if (xSemaphoreTake(xSensorMutex, pdMS_TO_TICKS(10)) == pdTRUE)
        {
            uint32_t data_age = (uint32_t)xTaskGetTickCount() - sensor_data.timestamp;
            xSemaphoreGive(xSensorMutex);

            if (data_age > pdMS_TO_TICKS(500))
            {
                printf("[WATCHDOG] WARNING: Sensor data is %lu ms old\n",
                       (unsigned long)(data_age * portTICK_PERIOD_MS));
            }
        }

        /* Report stack high water marks for debugging */
        UBaseType_t sensor_stack = uxTaskGetStackHighWaterMark(xSensorReadTaskHandle);
        UBaseType_t control_stack = uxTaskGetStackHighWaterMark(xControlLogicTaskHandle);
        printf("[WATCHDOG] Stack HWM - Sensor: %lu, Control: %lu\n",
               (unsigned long)sensor_stack, (unsigned long)control_stack);

        vTaskDelay(xCheckPeriod);
    }
}

int main(void)
{
    /* Initialize the shared sensor data structure */
    memset((void *)&sensor_data, 0, sizeof(SensorData_t));

    /* Create mutex for protecting shared sensor data */
    xSensorMutex = xSemaphoreCreateMutex();

    if (xSensorMutex == NULL)
    {
        printf("FATAL: Failed to create sensor mutex\n");
        for (;;);
    }

    /* Set mutex priority inheritance (enabled by default with configUSE_MUTEXES) */

    /* Create sensor reading task - highest priority for deterministic sampling */
    BaseType_t xResult = xTaskCreate(
        vSensorReadTask,
        "SensorRead",
        configMINIMAL_STACK_SIZE + 256,
        NULL,
        configMAX_PRIORITIES - 1,   /* Highest application priority */
        &xSensorReadTaskHandle
    );

    if (xResult != pdPASS)
    {
        printf("FATAL: Failed to create sensor read task\n");
        for (;;);
    }

    /* Create control logic task - high priority but below sensor task */
    xResult = xTaskCreate(
        vControlLogicTask,
        "ControlLogic",
        configMINIMAL_STACK_SIZE + 512,
        NULL,
        configMAX_PRIORITIES - 2,
        &xControlLogicTaskHandle
    );

    if (xResult != pdPASS)
    {
        printf("FATAL: Failed to create control logic task\n");
        for (;;);
    }

    /* Create watchdog monitoring task - lowest priority */
    xResult = xTaskCreate(
        vWatchdogTask,
        "Watchdog",
        configMINIMAL_STACK_SIZE + 128,
        NULL,
        tskIDLE_PRIORITY + 1,
        NULL
    );

    if (xResult != pdPASS)
    {
        printf("WARNING: Failed to create watchdog task\n");
        /* Non-fatal, continue without watchdog */
    }

    printf("Industrial Control System Starting...\n");
    printf("Sensor Read Task Priority: %d\n", (int)(configMAX_PRIORITIES - 1));
    printf("Control Logic Task Priority: %d\n", (int)(configMAX_PRIORITIES - 2));
    printf("Sensor Read Period: 10 ms\n");

    /* Start the FreeRTOS scheduler */
    vTaskStartScheduler();

    /* Should never reach here - if we do, there's insufficient heap */
    printf("FATAL: Scheduler exited - insufficient heap memory\n");
    for (;;);

    return 0;
}

/* FreeRTOS hook functions */
void vApplicationMallocFailedHook(void)
{
    printf("FATAL: Memory allocation failed!\n");
    taskDISABLE_INTERRUPTS();
    for (;;);
}

void vApplicationStackOverflowHook(TaskHandle_t xTask, char *pcTaskName)
{
    printf("FATAL: Stack overflow in task: %s\n", pc