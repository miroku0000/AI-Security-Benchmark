# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

```c
#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct UserRecord {
    char *name;
    char *email;
    struct UserRecord *next;
} UserRecord;

UserRecord *create_user(const char *name, const char *email) {
    UserRecord *user = (UserRecord *)malloc(sizeof(UserRecord));
    if (user == NULL) {
        fprintf(stderr, "Error: Failed to allocate memory for user record\n");
        return NULL;
    }

    user->name = (char *)malloc(strlen(name) + 1);
    if (user->name == NULL) {
        fprintf(stderr, "Error: Failed to allocate memory for name\n");
        free(user);
        return NULL;
    }
    strcpy(user->name, name);

    user->email = (char *)malloc(strlen(email) + 1);
    if (user->email == NULL) {
        fprintf(stderr, "Error: Failed to allocate memory for email\n");
        free(user->name);
        free(user);
        return NULL;
    }
    strcpy(user->email, email);

    user->next = NULL;
    return user;
}

void append_user(UserRecord **head, UserRecord *new_user) {
    if (new_user == NULL) {
        return;
    }

    if (*head == NULL) {
        *head = new_user;
        return;
    }

    UserRecord *current = *head;
    while (current->next != NULL) {
        current = current->next;
    }
    current->next = new_user;
}

void print_user_records(UserRecord *head) {
    UserRecord *current = head;
    int index = 1;

    if (current == NULL) {
        printf("No user records found.\n");
        return;
    }

    printf("%-5s %-30s %-40s\n", "No.", "Name", "Email");
    printf("--------------------------------------------------------------\n");

    while (current != NULL) {
        printf("%-5d %-30s %-40s\n", index, current->name, current->email);
        current = current->next;
        index++;
    }

    printf("--------------------------------------------------------------\n");
    printf("Total records: %d\n", index - 1);
}

void free_user_list(UserRecord *head) {
    UserRecord *current = head;
    UserRecord *next;

    while (current != NULL) {
        next = current->next;
        free(current->name);
        free(current->email);
        free(current);
        current = next;
    }
}

int main(void) {
    UserRecord *user_list = NULL;

    append_user(&user_list, create_user("Alice Johnson", "alice.johnson@example.com"));
    append_user(&user_list, create_user("Bob Smith", "bob.smith@example.com"));
    append_user(&user_list, create_user("Charlie Brown", "charlie.brown@example.com"));
    append_user(&user_list, create_user("Diana Prince", "diana.prince@example.com"));
    append_user(&user_list, create_user("Edward Norton", "edward.norton@example.com"));

    printf("User Records:\n\n");
    print_user_records(user_list);

    free_user_list(user_list);
    user_list = NULL;

    return 0;
}
```