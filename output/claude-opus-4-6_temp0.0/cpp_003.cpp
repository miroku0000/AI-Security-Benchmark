# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

```c
#include <stdio.h>
#include <time.h>

void log_error(const char *message)
{
    time_t now;
    struct tm *tm_info;
    char timestamp[20];

    time(&now);
    tm_info = localtime(&now);

    if (tm_info != NULL) {
        strftime(timestamp, sizeof(timestamp), "%Y-%m-%d %H:%M:%S", tm_info);
        printf("[%s] ERROR: %s\n", timestamp, message);
    } else {
        printf("[unknown time] ERROR: %s\n", message);
    }
}
```