# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>
#include <optional>
#include <iostream>

struct UserProfile {
    int user_id;
    std::string username;
    std::string email;
    int age;
    std::string department;
};

struct UserResponse {
    bool found;
    int user_id;
    std::string username;
    std::string email;
    int age;
    std::string department;
    std::string error_message;
};

class UserHashTable {
private:
    std::unordered_map<int, UserProfile> table_;

public:
    void insertUser(const UserProfile& user) {
        table_[user.user_id] = user;
    }

    // Returns a pointer to the user profile, or nullptr if not found
    UserProfile* findUser(int user_id) {
        auto it = table_.find(user_id);
        if (it != table_.end()) {
            return &(it->second);
        }
        return nullptr;
    }

    // High-performance lookup that populates a response object
    UserResponse lookupUser(int user_id) {
        UserResponse response;

        UserProfile* user = findUser(user_id);

        // BUG: Null pointer dereference - accessing user fields without
        // checking if user is nullptr first. If the user_id is not found
        // in the hash table, findUser returns nullptr and this will crash.
        response.found = true;
        response.user_id = user->user_id;
        response.username = user->username;
        response.email = user->email;
        response.age = user->age;
        response.department = user->department;
        response.error_message = "";

        return response;
    }

    // Corrected version with proper null check
    UserResponse lookupUserSafe(int user_id) {
        UserResponse response;

        UserProfile* user = findUser(user_id);

        if (user == nullptr) {
            response.found = false;
            response.user_id = -1;
            response.username = "";
            response.email = "";
            response.age = 0;
            response.department = "";
            response.error_message = "User not found with id: " + std::to_string(user_id);
            return response;
        }

        response.found = true;
        response.user_id = user->user_id;
        response.username = user->username;
        response.email = user->email;
        response.age = user->age;
        response.department = user->department;
        response.error_message = "";

        return response;
    }
};

int main() {
    UserHashTable userTable;

    // Insert some test users
    userTable.insertUser({1, "alice", "alice@example.com", 30, "Engineering"});
    userTable.insertUser({2, "bob", "bob@example.com", 25, "Marketing"});
    userTable.insertUser({3, "charlie", "charlie@example.com", 35, "Sales"});

    // Safe lookup - existing user
    UserResponse resp1 = userTable.lookupUserSafe(1);
    if (resp1.found) {
        std::cout << "Found user: " << resp1.username
                  << " (" << resp1.email << ")" << std::endl;
    }

    // Safe lookup - non-existing user
    UserResponse resp2 = userTable.lookupUserSafe(999);
    if (!resp2.found) {
        std::cout << "Error: " << resp2.error_message << std::endl;
    }

    // DANGEROUS: Buggy lookup on non-existing user - will cause null pointer dereference
    std::cout << "\nAttempting buggy lookup for non-existing user..." << std::endl;
    UserResponse resp3 = userTable.lookupUser(999);  // CRASH: null pointer dereference

    return 0;
}