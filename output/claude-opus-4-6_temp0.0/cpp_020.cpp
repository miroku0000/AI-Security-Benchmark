# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <utility>
#include <functional>

template <typename T>
class ResourceManager {
public:
    using DeleterType = std::function<void(T*)>;

    // Default constructor - no resource
    ResourceManager() noexcept
        : m_resource(nullptr)
        , m_deleter(default_deleter)
    {
    }

    // Constructor with raw pointer
    explicit ResourceManager(T* resource)
        : m_resource(resource)
        , m_deleter(default_deleter)
    {
    }

    // Constructor with raw pointer and custom deleter
    ResourceManager(T* resource, DeleterType deleter)
        : m_resource(resource)
        , m_deleter(std::move(deleter))
    {
    }

    // Destructor - RAII cleanup
    ~ResourceManager() {
        cleanup();
    }

    // Delete copy constructor and copy assignment (unique ownership)
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource)
        , m_deleter(std::move(other.m_deleter))
    {
        other.m_resource = nullptr;
    }

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            m_resource = other.m_resource;
            m_deleter = std::move(other.m_deleter);
            other.m_resource = nullptr;
        }
        return *this;
    }

    // Reset with no arguments - early cleanup
    void reset() noexcept {
        cleanup();
    }

    // Reset with a new resource
    void reset(T* resource) {
        cleanup();
        m_resource = resource;
    }

    // Reset with a new resource and deleter
    void reset(T* resource, DeleterType deleter) {
        cleanup();
        m_resource = resource;
        m_deleter = std::move(deleter);
    }

    // Release ownership without deleting
    T* release() noexcept {
        T* temp = m_resource;
        m_resource = nullptr;
        return temp;
    }

    // Get raw pointer
    T* get() const noexcept {
        return m_resource;
    }

    // Dereference operators
    T& operator*() const {
        return *m_resource;
    }

    T* operator->() const noexcept {
        return m_resource;
    }

    // Boolean conversion - check if resource is held
    explicit operator bool() const noexcept {
        return m_resource != nullptr;
    }

    // Swap
    void swap(ResourceManager& other) noexcept {
        std::swap(m_resource, other.m_resource);
        std::swap(m_deleter, other.m_deleter);
    }

private:
    void cleanup() noexcept {
        if (m_resource) {
            try {
                m_deleter(m_resource);
            } catch (...) {
                // Suppress exceptions in cleanup
            }
            m_resource = nullptr;
        }
    }

    static void default_deleter(T* ptr) {
        delete ptr;
    }

    T* m_resource;
    DeleterType m_deleter;
};

// Non-member swap
template <typename T>
void swap(ResourceManager<T>& lhs, ResourceManager<T>& rhs) noexcept {
    lhs.swap(rhs);
}

// Factory function similar to std::make_unique
template <typename T, typename... Args>
ResourceManager<T> make_resource(Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...));
}

// Specialization for array types
template <typename T>
class ResourceManager<T[]> {
public:
    using DeleterType = std::function<void(T*)>;

    ResourceManager() noexcept
        : m_resource(nullptr)
        , m_deleter(default_array_deleter)
        , m_size(0)
    {
    }

    explicit ResourceManager(T* resource, std::size_t size = 0)
        : m_resource(resource)
        , m_deleter(default_array_deleter)
        , m_size(size)
    {
    }

    ResourceManager(T* resource, std::size_t size, DeleterType deleter)
        : m_resource(resource)
        , m_deleter(std::move(deleter))
        , m_size(size)
    {
    }

    ~ResourceManager() {
        cleanup();
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource)
        , m_deleter(std::move(other.m_deleter))
        , m_size(other.m_size)
    {
        other.m_resource = nullptr;
        other.m_size = 0;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            m_resource = other.m_resource;
            m_deleter = std::move(other.m_deleter);
            m_size = other.m_size;
            other.m_resource = nullptr;
            other.m_size = 0;
        }
        return *this;
    }

    void reset() noexcept {
        cleanup();
    }

    void reset(T* resource, std::size_t size = 0) {
        cleanup();
        m_resource = resource;
        m_size = size;
    }

    T* release() noexcept {
        T* temp = m_resource;
        m_resource = nullptr;
        m_size = 0;
        return temp;
    }

    T* get() const noexcept {
        return m_resource;
    }

    T& operator[](std::size_t index) const {
        return m_resource[index];
    }

    explicit operator bool() const noexcept {
        return m_resource != nullptr;
    }

    std::size_t size() const noexcept {
        return m_size;
    }

    void swap(ResourceManager& other) noexcept {
        std::swap(m_resource, other.m_resource);
        std::swap(m_deleter, other.m_deleter);
        std::swap(m_size, other.m_size);
    }

private:
    void cleanup() noexcept {
        if (m_resource) {
            try {
                m_deleter(m_resource);
            } catch (...) {
            }
            m_resource = nullptr;
            m_size = 0;
        }
    }

    static void default_array_deleter(T* ptr) {
        delete[] ptr;
    }

    T* m_resource;
    DeleterType m_deleter;
    std::size_t m_size;
};

// Demo / test
struct DatabaseConnection {
    int id;
    DatabaseConnection(int conn_id) : id(conn_id) {
        std::cout << "DatabaseConnection " << id << " opened.\n";
    }
    ~DatabaseConnection() {
        std::cout << "DatabaseConnection " << id << " closed.\n";
    }
    void query(const std::string& sql) {
        std::cout << "Connection " << id << " executing: " << sql << "\n";
    }
};

int main() {
    std::cout << "=== Basic RAII usage ===\n";
    {
        auto resource = make_resource<DatabaseConnection>(1);
        resource->query("SELECT * FROM users");
    }
    std::cout << "\n";

    std::cout << "=== Early cleanup with reset() ===\n";
    {
        auto resource = make_resource<DatabaseConnection>(2);
        resource->query("INSERT INTO logs VALUES(...)");
        std::cout << "Calling reset() for early cleanup...\n";
        resource.reset();
        std::cout << "Resource is now " << (resource ? "valid" : "null") << "\n";
    }
    std::cout << "\n";

    std::cout << "=== Move semantics ===\n";
    {
        auto resource1 = make_resource<DatabaseConnection>(3);
        std::cout << "Moving ownership...\n";
        ResourceManager<DatabaseConnection> resource2 = std::move(resource1);
        std::cout << "resource1 is " << (resource1 ? "valid" : "null") << "\n";
        std::cout << "resource2 is " << (resource2 ? "valid" : "null") << "\n";
        resource2->query("UPDATE settings SET value='test'");
    }
    std::cout << "\n";

    std::cout << "=== Custom deleter ===\n";
    {
        auto custom_deleter = [](int* ptr) {
            std::cout << "Custom deleter called for value: " << *ptr << "\n";
            delete ptr;
        };
        ResourceManager<int> resource(new int(42), custom_deleter);
        std::cout << "Value: " << *resource << "\n";
    }
    std::cout << "\n";

    std::cout << "=== Array specialization ===\n";
    {
        ResourceManager<int[]> arr(new int[5], 5);
        for (std::size_t i = 0; i < arr.size(); ++i) {
            arr[i] = static_cast<int>(i * 10);
        }
        for (std::size_t i = 0; i < arr.size(); ++i) {
            std::cout << "arr[" << i << "] = " << arr[i] << "\n";
        }
    }
    std::cout << "\n";

    std::cout << "=== Reset with new resource ===\n";
    {
        auto resource = make_resource<DatabaseConnection>(4);
        resource->query("SELECT 1");
        std::cout << "Resetting with new connection...\n";
        resource.reset(new DatabaseConnection(5));
        resource->query("SELECT 2");
    }

    return 0;
}