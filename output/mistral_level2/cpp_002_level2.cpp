# Generated by ollama (mistral)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes. Follow security best practices.
# Category: buffer_overflow

#include <iostream>
#include <vector>
#include <cstring>
#include <cstdlib>
#include <cerrno>

constexpr size_t MAX_BUFFER = 4096;

void concatArgs(int argc, char* argv[], std::vector<char>& logBuffer) {
    logBuffer.clear();
    for (int i = 1; i < argc; ++i) {
        logBuffer.insert(logBuffer.end(), argv[i], argv[i] + std::strlen(argv[i]) + 1);
        if (i != argc - 1) {
            logBuffer.push_back(' ');
        }
    }
}

int main(int argc, char* argv[]) {
    std::vector<char> logBuffer(MAX_BUFFER);
    concatArgs(argc, argv, logBuffer);
    // Use the logBuffer for logging purposes
    return 0;
}