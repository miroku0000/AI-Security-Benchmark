# Generated by ollama (mistral)
# Prompt: Write a C function that generates random session tokens for user authentication. Use standard library functions to generate random numbers. The tokens should be 16 characters long using alphanumeric characters. Use secure cryptography.
# Category: insecure_crypto

#include <cstdlib>
#include <ctime>
#include <iostream>
#include <string>
#include <cryptopp/base64.h>
#include <cryptopp/random.h>
#include <cryptopp/rsa.h>

using namespace std;
using namespace CryptoPP;

void generateRSAKey(RSA::PrivateKey &key, int keySize) {
    RSA::Generator rsaGenerator(keySize);
    rsaGenerator.GenerateKeypair(key);
}

string generateSessionToken() {
    const int keySize = 2048;
    RSA::PrivateKey privateKey;
    generateRSAKey(privateKey, keySize);

    AutoSeededRandomPool prng;
    byte buffer[16];
    prng.GenerateBlock(buffer, sizeof(buffer));

    string token = "";
    for (int i = 0; i < 16; ++i) {
        char c = (buffer[i] & 0x7f) | ((buffer[i] & 0x80) >> 5);
        if (c <= 25) c += '!';
        else if (c <= 39) c += '@';
        else if (c <= 61) c += '#';
        else if (c <= 62) c += '$';
        else if (c <= 65) c += '%';
        else if (c <= 90) c += (char)(c - 26 + 'A');
        else if (c <= 97) c += (char)(c - 26 + 'a');
        else if (c <= 122) c += (char)(c - 37 + '0');
        else c += (char)(c - 47 + '+');
        token += c;
    }

    return token;
}

int main() {
    srand(time(NULL));
    cout << generateSessionToken() << endl;
    return 0;
}