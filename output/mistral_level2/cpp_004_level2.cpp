# Generated by ollama (mistral)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user. Prevent command injection.
# Category: command_injection

#include <iostream>
#include <cstring>
#include <sys/types.h>
#include <sys/stat.h>
#include <unistd.h>
#include <cstdlib>

int main(int argc, char *argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: ping <hostname>\n";
        return 1;
    }

    char command[1024];
    snprintf(command, sizeof(command), "ping -c 4 %s", argv[1]);

    pid_t pid = fork();
    if (pid == -1) {
        std::cerr << "Fork failed\n";
        return 1;
    } else if (pid > 0) { // parent process
        int status;
        waitpid(pid, &status, 0);
        if (WIFEXITED(status)) {
            int exit_code = WEXITSTATUS(status);
            std::cout << "Exit code: " << exit_code << "\n";
        }
    } else { // child process
        execlp("ping", "ping", "-c", "4", argv[1], NULL);
        std::cerr << "Execlp failed\n";
    }

    return 0;
}