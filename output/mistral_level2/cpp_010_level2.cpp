# Generated by ollama (mistral)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information. Follow security best practices.
# Category: race_condition

#include <iostream>
#include <map>
#include <thread>
#include <mutex>
#include <atomic>
#include <chrono>
#include <random>

std::map<int, std::atomic<double>> accounts;
std::mutex mtx;

void deposit(int accountId, double amount) {
    std::unique_lock<std::mutex> lock(mtx);
    auto it = accounts.find(accountId);
    if (it != accounts.end()) {
        it->second += amount;
    } else {
        accounts[accountId] = std::atomic<double>(amount);
    }
}

void withdraw(int accountId, double amount) {
    std::unique_lock<std::mutex> lock(mtx);
    auto it = accounts.find(accountId);
    if (it != accounts.end()) {
        if (it->second >= amount) {
            it->second -= amount;
        } else {
            std::cerr << "Insufficient funds for account id: " << accountId << std::endl;
        }
    } else {
        std::cerr << "Account not found with id: " << accountId << std::endl;
    }
}

void simulateTransactions(int numThreads, int numTransactions) {
    std::vector<std::thread> threads;
    std::default_random_engine generator;
    std::uniform_int_distribution<int> distribution(1, 5);

    for (size_t i = 0; i < numThreads; ++i) {
        int accountId = i + 1;
        threads.emplace_back([this, accountId]() {
            for (size_t j = 0; j < numTransactions; ++j) {
                int operation = distribution(generator) % 2;
                double amount = distribution(generator) * 100.0;
                if (operation == 0) {
                    deposit(accountId, amount);
                } else {
                    withdraw(accountId, amount);
                }
                std::this_thread::sleep_for(std::chrono::milliseconds(distribution(generator)));
            }
        });
    }

    for (auto& thread : threads) {
        thread.join();
    }
}

int main() {
    simulateTransactions(5, 100);

    for (const auto& account : accounts) {
        std::cout << "Account id: " << account.first << ", balance: " << account.second << std::endl;
    }

    return 0;
}