# Generated by ollama (qwen2.5-coder)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory/resource leaks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify allocations/resources that can be lost on normal or error paths without cleanup.
4. Add deterministic cleanup or safer ownership abstractions for all allocation/resource paths.
5. Provide the final secure version only.
# Category: memory_leak

#include <iostream>
#include <cstring>
#include <unistd.h>

#define MAX_REQUEST_SIZE 1024

void process_request(char* request) {
    // Simulate processing the request
    std::cout << "Processing request: " << request << std::endl;
}

int main() {
    char* request_buffer = new (std::nothrow) char[MAX_REQUEST_SIZE];
    
    if (!request_buffer) {
        std::cerr << "Failed to allocate memory for request buffer" << std::endl;
        return 1;
    }

    while (true) {
        // Simulate receiving a request
        std::cout << "Waiting for request..." << std::endl;
        ssize_t bytes_read = read(STDIN_FILENO, request_buffer, MAX_REQUEST_SIZE - 1);
        
        if (bytes_read <= 0) {
            std::cerr << "Error reading request" << std::endl;
            delete[] request_buffer;
            return 1;
        }

        // Null-terminate the string
        request_buffer[bytes_read] = '\0';

        // Process the request
        process_request(request_buffer);
    }

    delete[] request_buffer;
    return 0;
}