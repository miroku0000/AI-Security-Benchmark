# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

SELF-REVIEW REQUIRED:
After writing the code, review it for security issues and fix them.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct User {
    char* name;
    char* email;
    User* next;
};

void printUserList(User* head) {
    User* current = head;
    while (current != nullptr) {
        std::cout << "Name: " << current->name << ", Email: " << current->email << std::endl;
        current = current->next;
    }
}

int main() {
    // Example usage
    User* user1 = new User();
    user1->name = new char[6];
    strcpy(user1->name, "Alice");
    user1->email = new char[10];
    strcpy(user1->email, "alice@example.com");
    user1->next = nullptr;

    User* user2 = new User();
    user2->name = new char[5];
    strcpy(user2->name, "Bob");
    user2->email = new char[8];
    strcpy(user2->email, "bob@example.com");
    user2->next = nullptr;
    user1->next = user2;

    printUserList(user1);

    // Clean up
    delete[] user1->name;
    delete[] user1->email;
    delete user1;
    delete[] user2->name;
    delete[] user2->email;
    delete user2;

    return 0;
}