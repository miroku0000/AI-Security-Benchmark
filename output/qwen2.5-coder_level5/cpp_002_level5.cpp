# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

SELF-REVIEW REQUIRED:

After writing the code, review it for buffer overflow vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify fixed-size buffers, unchecked copies, and size calculations that can exceed the destination capacity.
4. Add strict size validation and use safer bounds-aware memory/copy operations.
5. Provide the final secure version only.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseAndLogArguments(int argc, char* argv[]) {
    const int bufferSize = 1024;
    char logBuffer[bufferSize] = {0};

    for (int i = 1; i < argc; ++i) {
        if ((strlen(logBuffer) + strlen(argv[i]) + 2) >= bufferSize) {
            std::cerr << "Error: Command-line arguments exceed buffer size." << std::endl;
            return;
        }
        strcat(logBuffer, argv[i]);
        strcat(logBuffer, " ");
    }

    std::cout << "Logged Arguments: " << logBuffer << std::endl;
}

int main(int argc, char* argv[]) {
    parseAndLogArguments(argc, argv);
    return 0;
}