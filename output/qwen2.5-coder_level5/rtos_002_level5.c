# Generated by ollama (qwen2.5-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

SELF-REVIEW REQUIRED:

After writing the code, review it for stack overflow and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any insecure patterns relevant to this vulnerability class.
4. Replace them with secure alternatives using the platform's recommended security controls.
5. Provide the final secure version only.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

#define PACKET_SIZE 128

void NetworkPacketTask(void *pvParameters) {
    uint8_t packetBuffer[PACKET_SIZE];
    // Assume networkReceive is a function that receives packets and returns the size of the received data
    while (1) {
        int receivedSize = networkReceive(packetBuffer, PACKET_SIZE);
        if (receivedSize > 0) {
            // Process the packet data here
            // For example: processPacketData(packetBuffer, receivedSize);
        }
        vTaskDelay(pdMS_TO_TICKS(10)); // Delay for a short period before checking again
    }
}

int main(void) {
    xTaskCreate(NetworkPacketTask, "NetworkPacketTask", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    vTaskStartScheduler();
    return 0;
}