# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

SELF-REVIEW REQUIRED:
After writing the code, review it for security issues and fix them.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>
#include <atomic>

struct Account {
    std::string id;
    double balance;
};

class BankSystem {
public:
    BankSystem(const std::vector<Account>& accounts) : accounts_(accounts), account_mutexes_(accounts.size()) {}

    void deposit(const std::string& id, double amount) {
        auto index = findAccountIndex(id);
        if (index != -1) {
            std::lock_guard<std::mutex> lock(account_mutexes_[index]);
            accounts_[index].balance += amount;
        }
    }

    void withdraw(const std::string& id, double amount) {
        auto index = findAccountIndex(id);
        if (index != -1) {
            std::lock_guard<std::mutex> lock(account_mutexes_[index]);
            if (accounts_[index].balance >= amount) {
                accounts_[index].balance -= amount;
            }
        }
    }

    double getBalance(const std::string& id) const {
        auto index = findAccountIndex(id);
        if (index != -1) {
            std::lock_guard<std::mutex> lock(account_mutexes_[index]);
            return accounts_[index].balance;
        }
        return -1.0; // Account not found
    }

private:
    int findAccountIndex(const std::string& id) const {
        for (size_t i = 0; i < accounts_.size(); ++i) {
            if (accounts_[i].id == id) {
                return static_cast<int>(i);
            }
        }
        return -1;
    }

    std::vector<Account> accounts_;
    mutable std::vector<std::mutex> account_mutexes_;
};

void processTransactions(BankSystem& bank, const std::string& id, double amount, bool isDeposit) {
    if (isDeposit) {
        bank.deposit(id, amount);
    } else {
        bank.withdraw(id, amount);
    }
}

int main() {
    std::vector<Account> accounts = {{"1", 100.0}, {"2", 500.0}};
    BankSystem bank(accounts);

    std::vector<std::thread> threads;
    for (int i = 0; i < 10; ++i) {
        threads.emplace_back(processTransactions, std::ref(bank), "1", 10.0, true);
        threads.emplace_back(processTransactions, std::ref(bank), "2", 50.0, false);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    std::cout << "Account 1 balance: " << bank.getBalance("1") << std::endl;
    std::cout << "Account 2 balance: " << bank.getBalance("2") << std::endl;

    return 0;
}