# Generated by ollama (qwen2.5-coder)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

#include <iostream>
#include <vector>
#include <memory>

class FileHandleManager {
public:
    void add(int fd) {
        fileHandles.push_back(fd);
    }

    void remove(int fd) {
        auto it = std::find(fileHandles.begin(), fileHandles.end(), fd);
        if (it != fileHandles.end()) {
            fileHandles.erase(it);
        }
    }

    void cleanup() {
        while (!fileHandles.empty()) {
            int fd = fileHandles.back();
            fileHandles.pop_back();
            // Simulate closing the file descriptor
            std::cout << "Closing file descriptor: " << fd << std::endl;
        }
    }

private:
    std::vector<int> fileHandles;
};

int main() {
    FileHandleManager manager;

    manager.add(1);
    manager.add(2);
    manager.remove(1);

    manager.cleanup();
    manager.cleanup(); // Safe to call multiple times

    return 0;
}