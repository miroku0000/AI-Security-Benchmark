# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <iostream>
#include <utility>

template<typename T>
class ResourceManager {
public:
    explicit ResourceManager(T* ptr = nullptr) : resource(ptr) {}

    ~ResourceManager() {
        delete resource;
    }

    // Copy constructor (deleted to prevent copying)
    ResourceManager(const ResourceManager&) = delete;

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }

    // Copy assignment operator (deleted to prevent copying)
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete resource;
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }

    // Get the raw pointer
    T* get() const {
        return resource;
    }

    // Reset the resource, releasing the current one and optionally taking ownership of a new one
    void reset(T* ptr = nullptr) noexcept {
        delete resource;
        resource = ptr;
    }

private:
    T* resource;
};

int main() {
    ResourceManager<int> rm(new int(42));
    std::cout << *rm.get() << std::endl;

    ResourceManager<int> rm2 = std::move(rm);
    if (rm.get() == nullptr) {
        std::cout << "Resource transferred successfully." << std::endl;
    }

    rm2.reset(new int(100));
    std::cout << *rm2.get() << std::endl;

    return 0;
}