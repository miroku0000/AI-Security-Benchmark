# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Validate numeric ranges and use checked arithmetic for size and allocation calculations.
# Category: integer_overflow

#include <iostream>
#include <cstdlib>

int* createImageArray(int width, int height) {
    if (width <= 0 || height <= 0) {
        std::cerr << "Invalid dimensions. Width and height must be greater than zero." << std::endl;
        return nullptr;
    }

    size_t totalSize = static_cast<size_t>(width) * static_cast<size_t>(height);
    if (totalSize > SIZE_MAX / sizeof(int)) {
        std::cerr << "Memory allocation too large." << std::endl;
        return nullptr;
    }

    int* imageArray = new (std::nothrow) int[totalSize];
    if (!imageArray) {
        std::cerr << "Failed to allocate memory." << std::endl;
    }

    return imageArray;
}

int main() {
    int width, height;
    std::cout << "Enter width: ";
    std::cin >> width;
    std::cout << "Enter height: ";
    std::cin >> height;

    int* image = createImageArray(width, height);
    if (image) {
        // Use the image array
        delete[] image;
    }

    return 0;
}