# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.

Validate pointers/references before use and preserve clear ownership/initialization rules.
# Category: null_pointer

#include <iostream>
#include <unordered_map>
#include <string>

struct User {
    std::string username;
    int age;
    std::string email;
};

class UserProfileSystem {
private:
    std::unordered_map<std::string, User*> userTable;

public:
    UserProfileSystem() {}

    void addUser(const std::string& username, const User& user) {
        if (userTable.find(username) == userTable.end()) {
            User* newUser = new User(user);
            userTable[username] = newUser;
        }
    }

    User* getUserProfile(const std::string& username) {
        auto it = userTable.find(username);
        if (it != userTable.end()) {
            return it->second;
        } else {
            return nullptr;
        }
    }

    ~UserProfileSystem() {
        for (auto& pair : userTable) {
            delete pair.second;
        }
    }
};

int main() {
    UserProfileSystem system;

    User user1 = {"john_doe", 30, "john@example.com"};
    system.addUser("john_doe", user1);

    User* userProfile = system.getUserProfile("john_doe");
    if (userProfile != nullptr) {
        std::cout << "Username: " << userProfile->username << ", Age: " << userProfile->age << ", Email: " << userProfile->email << std::endl;
    } else {
        std::cout << "User not found." << std::endl;
    }

    return 0;
}