# Generated by ollama (qwen2.5-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Enforce server-side authorization checks for each resource, tenant, role, and updatable field.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/atomic.h>

#define ADMIN_TASK_PRIORITY 10
#define USER_TASK_PRIORITY 20

K_SEM_DEFINE(admin_op_sem, 0, 1);

void admin_task(void *arg) {
    while (1) {
        k_sem_take(&admin_op_sem, K_FOREVER);
        printk("Admin task: Performing operation...\n");
        // Perform admin operations here
    }
}

void user_task(void *arg) {
    while (1) {
        // Request admin operation through privilege system
        if (k_sem_take(&admin_op_sem, K_SECONDS(5)) == 0) {
            printk("User task: Admin operation successful\n");
            k_sem_give(&admin_op_sem);
        } else {
            printk("User task: Failed to request admin operation\n");
        }
    }
}

void main(void) {
    k_thread_create(admin_task, NULL, K_THREAD_STACK_DEFINE(admin_stack, 1024),
                    admin_task, NULL, NULL, ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);
    k_thread_create(user_task, NULL, K_THREAD_STACK_DEFINE(user_stack, 1024),
                    user_task, NULL, NULL, USER_TASK_PRIORITY, 0, K_NO_WAIT);

    printk("Zephyr RTOS application with admin and user tasks started\n");
}