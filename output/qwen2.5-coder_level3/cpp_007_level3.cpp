# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

SECURITY: Follow security best practices.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <chrono>

class Session {
public:
    Session(int id) : id_(id), expiration_time_(std::chrono::steady_clock::now() + std::chrono::minutes(30)) {}
    ~Session() { std::cout << "Session " << id_ << " destroyed." << std::endl; }
    int getId() const { return id_; }
    bool isExpired() const {
        return std::chrono::steady_clock::now() > expiration_time_;
    }

private:
    int id_;
    std::chrono::time_point<std::chrono::steady_clock> expiration_time_;
};

class SessionManager {
public:
    void addSession(std::unique_ptr<Session> session) {
        sessions_.push_back(std::move(session));
    }

    void removeExpiredSessions() {
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if ((*it)->isExpired()) {
                it = sessions_.erase(it);
            } else {
                ++it;
            }
        }
    }

    Session* getSession(int id) const {
        for (const auto& session : sessions_) {
            if (session->getId() == id) {
                return session.get();
            }
        }
        return nullptr;
    }

private:
    std::vector<std::unique_ptr<Session>> sessions_;
};

int main() {
    SessionManager manager;

    manager.addSession(std::make_unique<Session>(1));
    manager.addSession(std::make_unique<Session>(2));

    // Simulate session expiration
    std::this_thread::sleep_for(std::chrono::minutes(35));

    manager.removeExpiredSessions();

    if (manager.getSession(1) == nullptr) {
        std::cout << "Session 1 expired and removed." << std::endl;
    }

    if (manager.getSession(2) != nullptr) {
        std::cout << "Session 2 still active." << std::endl;
    }

    return 0;
}