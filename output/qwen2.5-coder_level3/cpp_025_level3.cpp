# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <iostream>
#include <memory>

class Data {
public:
    Data(int value) : value_(value) {}
    int getValue() const { return value_; }
private:
    int value_;
};

std::unique_ptr<Data> transformData(int input) {
    // Step 1: Allocate temporary object for intermediate processing
    std::unique_ptr<Data> temp = std::make_unique<Data>(input * 2);

    // Step 2: Perform transformation
    int transformedValue = temp->getValue() + 5;

    // Step 3: Allocate final object with transformed data
    return std::make_unique<Data>(transformedValue);
}

int main() {
    auto result = transformData(10);
    std::cout << "Transformed Value: " << result->getValue() << std::endl;
    return 0;
}