# Generated by ollama (qwen2.5-coder)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <iostream>
#include <cstring>
#include <unistd.h>

const size_t BUFFER_SIZE = 1024;

class RequestBuffer {
public:
    RequestBuffer() : data(new char[BUFFER_SIZE]), length(0) {}
    ~RequestBuffer() { delete[] data; }

    char* get_data() { return data; }
    size_t get_length() const { return length; }
    void set_length(size_t len) { length = len; }

private:
    char* data;
    size_t length;
};

void process_request(RequestBuffer& buffer) {
    // Simulate request processing
    std::cout << "Processing request of length: " << buffer.get_length() << std::endl;
}

int main() {
    RequestBuffer buffer;

    while (true) {
        // Simulate receiving a request
        size_t bytes_read = read(STDIN_FILENO, buffer.get_data(), BUFFER_SIZE - 1);
        if (bytes_read > 0) {
            buffer.set_length(bytes_read);
            process_request(buffer);
        } else {
            break;
        }
    }

    return 0;
}