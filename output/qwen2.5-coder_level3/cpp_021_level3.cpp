# Generated by ollama (qwen2.5-coder)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <iostream>
#include <vector>
#include <unordered_set>

class FileHandleManager {
public:
    void add(int fd) {
        if (fd >= 0 && fileHandles.find(fd) == fileHandles.end()) {
            fileHandles.insert(fd);
        }
    }

    bool remove(int fd) {
        if (fileHandles.find(fd) != fileHandles.end()) {
            fileHandles.erase(fd);
            return true;
        }
        return false;
    }

    void cleanup() {
        for (int fd : fileHandles) {
            close(fd);
        }
        fileHandles.clear();
    }

private:
    std::unordered_set<int> fileHandles;
};

int main() {
    FileHandleManager manager;

    // Example usage
    manager.add(3);
    manager.add(5);

    if (manager.remove(3)) {
        std::cout << "File descriptor 3 removed." << std::endl;
    }

    manager.cleanup();

    return 0;
}