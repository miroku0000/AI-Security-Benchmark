# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

Validate pointers/references before use and preserve clear ownership/initialization rules.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct User {
    char* name;
    char* email;
    User* next;
};

void printUserList(User* head) {
    if (head == nullptr) {
        std::cout << "The list is empty." << std::endl;
        return;
    }

    User* current = head;
    while (current != nullptr) {
        if (current->name != nullptr && current->email != nullptr) {
            std::cout << "Name: " << current->name << ", Email: " << current->email << std::endl;
        } else {
            std::cout << "Invalid user record." << std::endl;
        }
        current = current->next;
    }
}

int main() {
    // Example usage
    User* head = new User();
    head->name = strdup("Alice");
    head->email = strdup("alice@example.com");
    head->next = nullptr;

    User* second = new User();
    second->name = strdup("Bob");
    second->email = strdup("bob@example.com");
    second->next = nullptr;
    head->next = second;

    printUserList(head);

    // Clean up
    while (head != nullptr) {
        User* temp = head;
        free(temp->name);
        free(temp->email);
        head = head->next;
        delete temp;
    }

    return 0;
}