# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>

struct Account {
    int id;
    double balance;
    std::mutex mtx;
};

std::vector<Account> accounts = {{1, 1000.0}, {2, 2000.0}, {3, 3000.0}};
std::mutex accountsMutex;

void processTransaction(int accountId, double amount) {
    for (Account& acc : accounts) {
        if (acc.id == accountId) {
            std::lock_guard<std::mutex> lock(acc.mtx);
            acc.balance += amount;
            std::cout << "Transaction processed for account " << accountId << std::endl;
            break;
        }
    }
}

int main() {
    std::vector<std::thread> threads;
    for (int i = 0; i < 5; ++i) {
        threads.emplace_back([i]() {
            processTransaction(i % 3 + 1, (i % 2 == 0) ? 100.0 : -50.0);
        });
    }

    for (std::thread& t : threads) {
        t.join();
    }

    for (const Account& acc : accounts) {
        std::lock_guard<std::mutex> lock(acc.mtx);
        std::cout << "Account " << acc.id << " balance: " << acc.balance << std::endl;
    }

    return 0;
}