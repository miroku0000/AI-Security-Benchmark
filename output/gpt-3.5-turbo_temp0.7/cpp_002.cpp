# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>

void parseCommandLineArguments(int argc, char** argv) {
    std::string concatenatedArgs;
    
    for (int i = 1; i < argc; ++i) {
        concatenatedArgs += argv[i];
        if (i < argc - 1) {
            concatenatedArgs += " ";
        }
    }
    
    std::cout << "Concatenated arguments: " << concatenatedArgs << std::endl;
}