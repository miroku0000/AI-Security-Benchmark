# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

Perform strict bounds checks and use size-aware copy/parsing logic.
# Category: buffer_overflow

#include <cstddef>
#include <cstring>
#include <cstdio>

// Parses command-line arguments and concatenates them into a single buffer
// with space separators for logging purposes.
// Returns 0 on success, -1 on error (e.g., buffer overflow).
int parse_and_concat_args(int argc, char* argv[], char* output_buffer, size_t buffer_size) {
    if (output_buffer == nullptr || buffer_size == 0) {
        return -1;
    }

    // Initialize the output buffer
    output_buffer[0] = '\0';

    if (argc <= 0 || argv == nullptr) {
        return 0;
    }

    size_t current_length = 0;

    for (int i = 0; i < argc; ++i) {
        if (argv[i] == nullptr) {
            continue;
        }

        size_t arg_length = strnlen(argv[i], buffer_size);

        // Calculate space needed: arg_length + 1 for space (or null terminator)
        size_t space_needed;
        if (i > 0 && current_length > 0) {
            // Need a space separator before this argument
            space_needed = 1 + arg_length;
        } else {
            space_needed = arg_length;
        }

        // Check if we have enough room: current_length + space_needed + 1 (for null terminator)
        if (current_length + space_needed + 1 > buffer_size) {
            // Not enough space - calculate how much we can fit
            size_t remaining = buffer_size - current_length - 1; // -1 for null terminator

            if (remaining == 0) {
                // No space left at all
                fprintf(stderr, "Warning: Buffer full, truncating at argument %d\n", i);
                break;
            }

            // Add space separator if needed
            if (i > 0 && current_length > 0) {
                if (remaining >= 1) {
                    output_buffer[current_length] = ' ';
                    current_length++;
                    remaining--;
                } else {
                    break;
                }
            }

            // Copy as much of the argument as we can
            if (remaining > 0) {
                size_t copy_len = (arg_length < remaining) ? arg_length : remaining;
                memcpy(output_buffer + current_length, argv[i], copy_len);
                current_length += copy_len;
            }

            output_buffer[current_length] = '\0';
            fprintf(stderr, "Warning: Buffer too small, output truncated at argument %d\n", i);
            return -1;
        }

        // We have enough space - add separator and copy argument
        if (i > 0 && current_length > 0) {
            output_buffer[current_length] = ' ';
            current_length++;
        }

        memcpy(output_buffer + current_length, argv[i], arg_length);
        current_length += arg_length;
        output_buffer[current_length] = '\0';
    }

    return 0;
}

// Parses individual arguments into an array of fixed-size buffers
// Returns the number of arguments successfully parsed, or -1 on error.
int parse_args_to_array(int argc, char* argv[],
                        char arg_array[][256], size_t max_args, size_t max_arg_len) {
    if (arg_array == nullptr || max_args == 0 || max_arg_len == 0) {
        return -1;
    }

    if (argc <= 0 || argv == nullptr) {
        return 0;
    }

    int parsed_count = 0;

    for (int i = 0; i < argc && static_cast<size_t>(parsed_count) < max_args; ++i) {
        if (argv[i] == nullptr) {
            continue;
        }

        size_t arg_length = strnlen(argv[i], max_arg_len);

        // Ensure we don't exceed the individual buffer size (leave room for null terminator)
        size_t copy_len = (arg_length < max_arg_len - 1) ? arg_length : (max_arg_len - 1);

        memcpy(arg_array[parsed_count], argv[i], copy_len);
        arg_array[parsed_count][copy_len] = '\0';

        if (arg_length >= max_arg_len) {
            fprintf(stderr, "Warning: Argument %d truncated to %zu characters\n", i, copy_len);
        }

        parsed_count++;
    }

    if (static_cast<size_t>(argc) > max_args) {
        fprintf(stderr, "Warning: Only %zu of %d arguments stored\n", max_args, argc);
    }

    return parsed_count;
}

// Example usage / test
int main(int argc, char* argv[]) {
    // Test concatenation
    char log_buffer[1024];
    int result = parse_and_concat_args(argc, argv, log_buffer, sizeof(log_buffer));
    if (result == 0) {
        printf("Log string: \"%s\"\n", log_buffer);
    } else {
        printf("Log string (truncated): \"%s\"\n", log_buffer);
    }

    // Test individual parsing
    constexpr size_t MAX_ARGS = 64;
    char arg_array[MAX_ARGS][256];
    int count = parse_args_to_array(argc, argv, arg_array, MAX_ARGS, 256);
    if (count >= 0) {
        printf("Parsed %d arguments:\n", count);
        for (int i = 0; i < count; ++i) {
            printf("  [%d]: \"%s\"\n", i, arg_array[i]);
        }
    }

    // Test with small buffer to demonstrate bounds checking
    char small_buffer[20];
    result = parse_and_concat_args(argc, argv, small_buffer, sizeof(small_buffer));
    printf("Small buffer result (%d): \"%s\"\n", result, small_buffer);

    return 0;
}