# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.

Validate pointers/references before use and preserve clear ownership/initialization rules.
# Category: null_pointer

#include <unordered_map>
#include <string>
#include <optional>
#include <memory>
#include <stdexcept>

struct UserProfile {
    std::string username;
    std::string email;
    std::string display_name;
    int age;
    bool is_active;
};

struct UserResponse {
    bool found;
    std::string username;
    std::string email;
    std::string display_name;
    int age;
    bool is_active;
    std::string error_message;

    UserResponse()
        : found(false)
        , username()
        , email()
        , display_name()
        , age(0)
        , is_active(false)
        , error_message()
    {}
};

class UserLookupTable {
public:
    UserLookupTable() = default;

    // Insert a user into the hash table. Takes ownership via shared_ptr.
    bool insert_user(const std::string& user_id, std::shared_ptr<UserProfile> user) {
        if (!user) {
            return false;
        }
        if (user_id.empty()) {
            return false;
        }
        auto [it, inserted] = table_.emplace(user_id, std::move(user));
        return inserted;
    }

    // Convenience overload that constructs the UserProfile internally
    bool insert_user(const std::string& user_id,
                     const std::string& username,
                     const std::string& email,
                     const std::string& display_name,
                     int age,
                     bool is_active) {
        if (user_id.empty()) {
            return false;
        }
        auto profile = std::make_shared<UserProfile>();
        profile->username = username;
        profile->email = email;
        profile->display_name = display_name;
        profile->age = age;
        profile->is_active = is_active;
        return insert_user(user_id, std::move(profile));
    }

    bool remove_user(const std::string& user_id) {
        return table_.erase(user_id) > 0;
    }

    // Search for a user and populate a response object.
    // Returns a fully initialized UserResponse regardless of whether the user was found.
    UserResponse search_user(const std::string& user_id) const {
        UserResponse response;  // Default-initialized: found=false, fields zeroed/empty

        if (user_id.empty()) {
            response.error_message = "Empty user ID provided";
            return response;
        }

        auto it = table_.find(user_id);
        if (it == table_.end()) {
            response.error_message = "User not found";
            return response;
        }

        // Validate the shared_ptr before dereferencing
        const std::shared_ptr<UserProfile>& user_ptr = it->second;
        if (!user_ptr) {
            response.error_message = "Internal error: null user record";
            return response;
        }

        // Safe to access user fields now - pointer is validated
        response.found = true;
        response.username = user_ptr->username;
        response.email = user_ptr->email;
        response.display_name = user_ptr->display_name;
        response.age = user_ptr->age;
        response.is_active = user_ptr->is_active;
        response.error_message.clear();

        return response;
    }

    // Returns a non-owning raw pointer for read-only inspection.
    // Caller must NOT delete the pointer. Lifetime is managed by the table.
    const UserProfile* find_user_raw(const std::string& user_id) const {
        if (user_id.empty()) {
            return nullptr;
        }
        auto it = table_.find(user_id);
        if (it == table_.end()) {
            return nullptr;
        }
        // Validate before returning
        if (!it->second) {
            return nullptr;
        }
        return it->second.get();
    }

    // Returns a shared_ptr copy, extending lifetime if caller needs to hold onto it
    std::shared_ptr<const UserProfile> find_user_shared(const std::string& user_id) const {
        if (user_id.empty()) {
            return nullptr;
        }
        auto it = table_.find(user_id);
        if (it == table_.end()) {
            return nullptr;
        }
        return it->second;  // Returns copy of shared_ptr (may be null, caller should check)
    }

    size_t size() const { return table_.size(); }
    bool empty() const { return table_.empty(); }

private:
    // shared_ptr used for ownership: table owns the profiles,
    // and shared access can be granted via find_user_shared()
    std::unordered_map<std::string, std::shared_ptr<UserProfile>> table_;
};


// Standalone function for quick lookup that validates all intermediate state
UserResponse lookup_user(const UserLookupTable& table, const std::string& user_id) {
    return table.search_user(user_id);
}


// Example / test usage
#include <iostream>
#include <cassert>

int main() {
    UserLookupTable table;

    // Insert users
    table.insert_user("u001", "alice", "alice@example.com", "Alice Smith", 30, true);
    table.insert_user("u002", "bob", "bob@example.com", "Bob Jones", 25, true);
    table.insert_user("u003", "charlie", "charlie@example.com", "Charlie Brown", 35, false);

    // Successful lookup
    {
        UserResponse resp = lookup_user(table, "u001");
        assert(resp.found);
        assert(resp.username == "alice");
        assert(resp.email == "alice@example.com");
        assert(resp.age == 30);
        assert(resp.is_active == true);
        assert(resp.error_message.empty());
        std::cout << "Found user: " << resp.display_name << " (" << resp.email << ")\n";
    }

    // Failed lookup - user not found
    {
        UserResponse resp = lookup_user(table, "u999");
        assert(!resp.found);
        assert(!resp.error_message.empty());
        std::cout << "Lookup u999: " << resp.error_message << "\n";
    }

    // Failed lookup - empty ID
    {
        UserResponse resp = lookup_user(table, "");
        assert(!resp.found);
        assert(resp.error_message == "Empty user ID provided");
        std::cout << "Lookup empty: " << resp.error_message << "\n";
    }

    // Raw pointer access (non-owning)
    {
        const UserProfile* profile = table.find_user_raw("u002");
        if (profile) {
            std::cout << "Raw lookup: " << profile->display_name << "\n";
        }
    }

    // Shared pointer access (extends lifetime)
    {
        std::shared_ptr<const UserProfile> profile = table.find_user_shared("u003");
        if (profile) {
            std::cout << "Shared lookup: " << profile->display_name
                      << " active=" << profile->is_active << "\n";
        }

        // Remove from table - shared_ptr still valid
        table.remove_user("u003");
        if (profile) {
            std::cout << "Still valid after removal: " << profile->display_name << "\n";
        }

        // But table lookup now fails
        UserResponse resp = lookup_user(table, "u003");
        assert(!resp.found);
    }

    std::cout << "All tests passed. Table size: " << table.size() << "\n";
    return 0;
}