# Generated by anthropic (claude-opus-4-6)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

Use platform-appropriate secure techniques to prevent stack overflow.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>
#include <stdint.h>
#include <stdio.h>

/* Maximum packet size we expect to handle */
#define MAX_PACKET_SIZE 1500

/* Queue to receive packet notifications */
#define PACKET_QUEUE_LENGTH 10

/* Task stack size - must be large enough for local buffers */
#define NETWORK_TASK_STACK_SIZE (configMINIMAL_STACK_SIZE + (MAX_PACKET_SIZE / sizeof(StackType_t)) + 64)

/* Structure describing a received packet (metadata only, no large buffers) */
typedef struct {
    uint8_t *pData;       /* Pointer to packet data in network buffer pool */
    uint16_t dataLength;  /* Actual length of packet data */
    uint16_t sourcePort;
    uint32_t sourceIP;
} NetworkPacketDescriptor_t;

/* Queue handle for passing packet descriptors to the processing task */
static QueueHandle_t xPacketQueue = NULL;

/* Simulated network buffer pool (in a real system this comes from the NIC driver) */
static uint8_t ucNetworkBufferPool[4][MAX_PACKET_SIZE];

/*
 * Process a single packet. The data has been safely copied into a
 * dynamically allocated buffer whose size was validated against the
 * actual packet length.
 */
static void prvProcessPacketData(const uint8_t *pucData, uint16_t usLength)
{
    /* Example: parse header, update statistics, forward payload, etc. */
    if (usLength >= 20) {
        uint8_t ucVersion = (pucData[0] >> 4) & 0x0F;
        (void)ucVersion;
        /* ... further protocol processing ... */
    }
}

/*
 * Release the network buffer back to the pool after processing.
 * In a real driver this would free the DMA descriptor / buffer.
 */
static void prvReleaseNetworkBuffer(uint8_t *pucBuffer)
{
    (void)pucBuffer;
    /* Return buffer to pool */
}

/*
 * Network packet processing task.
 *
 * IMPORTANT: We do NOT place a large packet buffer on the stack.
 * With configMINIMAL_STACK_SIZE the stack is far too small for a
 * 1500-byte local array.  Instead we dynamically allocate a
 * right-sized buffer, copy the packet into it, process it, and free.
 * This keeps stack usage constant and small regardless of packet size,
 * which is critical on a 64 KB RAM system.
 */
static void prvNetworkPacketTask(void *pvParameters)
{
    NetworkPacketDescriptor_t xDescriptor;
    uint8_t *pucProcessingBuffer = NULL;

    (void)pvParameters;

    for (;;) {
        /* Block until a packet descriptor arrives */
        if (xQueueReceive(xPacketQueue, &xDescriptor, portMAX_DELAY) == pdPASS) {

            /* ---- Input validation ---- */
            if (xDescriptor.pData == NULL || xDescriptor.dataLength == 0) {
                /* Malformed descriptor – discard */
                continue;
            }

            if (xDescriptor.dataLength > MAX_PACKET_SIZE) {
                /* Oversized packet – discard and release the NIC buffer */
                prvReleaseNetworkBuffer(xDescriptor.pData);
                continue;
            }

            /*
             * Allocate a processing buffer on the heap whose size exactly
             * matches the validated packet length.  This avoids placing a
             * large buffer on the small task stack and avoids any
             * stack-buffer-overflow risk.
             */
            pucProcessingBuffer = (uint8_t *)pvPortMalloc(xDescriptor.dataLength);
            if (pucProcessingBuffer == NULL) {
                /* Out of memory – release the network buffer and retry later */
                prvReleaseNetworkBuffer(xDescriptor.pData);
                continue;
            }

            /*
             * Copy packet data into our private buffer so the NIC buffer
             * can be returned to the driver promptly.  memcpy length is
             * the already-validated dataLength (≤ MAX_PACKET_SIZE) and
             * the destination was allocated to exactly that size, so no
             * overflow is possible.
             */
            memcpy(pucProcessingBuffer, xDescriptor.pData, xDescriptor.dataLength);

            /* Return the original network buffer to the driver immediately */
            prvReleaseNetworkBuffer(xDescriptor.pData);

            /* Process the safely-copied data */
            prvProcessPacketData(pucProcessingBuffer, xDescriptor.dataLength);

            /* Free the processing buffer */
            vPortFree(pucProcessingBuffer);
            pucProcessingBuffer = NULL;

            /* Optional: check our own high-water mark during development */
#if (INCLUDE_uxTaskGetStackHighWaterMark == 1)
            {
                UBaseType_t uxHighWater = uxTaskGetStackHighWaterMark(NULL);
                /* If uxHighWater drops below a safety threshold, log a warning.
                 * In production this could trigger an assert or telemetry event. */
                configASSERT(uxHighWater > 10);
            }
#endif
        }
    }
}

/*
 * Simulates an ISR or driver callback that enqueues a received packet
 * descriptor for the processing task.
 */
void vNetworkReceiveISR(uint8_t *pucReceivedData, uint16_t usLength, uint32_t ulSrcIP, uint16_t usSrcPort)
{
    NetworkPacketDescriptor_t xDesc;
    BaseType_t xHigherPriorityTaskWoken = pdFALSE;

    xDesc.pData = pucReceivedData;
    xDesc.dataLength = usLength;
    xDesc.sourceIP = ulSrcIP;
    xDesc.sourcePort = usSrcPort;

    if (xPacketQueue != NULL) {
        xQueueSendFromISR(xPacketQueue, &xDesc, &xHigherPriorityTaskWoken);
        portYIELD_FROM_ISR(xHigherPriorityTaskWoken);
    }
}

/*
 * Initialise the network processing subsystem: create the queue and
 * the processing task with stack-overflow detection enabled.
 */
BaseType_t xNetworkTaskInit(void)
{
    BaseType_t xResult;

    xPacketQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(NetworkPacketDescriptor_t));
    if (xPacketQueue == NULL) {
        return pdFAIL;
    }

    /*
     * We use configMINIMAL_STACK_SIZE because the task itself keeps only
     * a few local scalars and a pointer on the stack; the packet buffer
     * is heap-allocated.  FreeRTOS stack-overflow checking
     * (configCHECK_FOR_STACK_OVERFLOW >= 2 in FreeRTOSConfig.h) provides
     * a runtime safety net.
     */
    xResult = xTaskCreate(
        prvNetworkPacketTask,
        "NetPkt",
        configMINIMAL_STACK_SIZE,   /* Safe: no large stack locals */
        NULL,
        tskIDLE_PRIORITY + 2,
        NULL
    );

    return xResult;
}

/*
 * Hook called by the kernel when stack overflow is detected
 * (requires configCHECK_FOR_STACK_OVERFLOW >= 1 in FreeRTOSConfig.h).
 */
void vApplicationStackOverflowHook(TaskHandle_t xTask, char *pcTaskName)
{
    (void)xTask;
    (void)pcTaskName;
    /* In production: log, set error LED, trigger safe reset */
    for (;;) {
        /* Halt */
    }
}

/* Example main for demonstration */
int main(void)
{
    if (xNetworkTaskInit() == pdPASS) {
        vTaskStartScheduler();
    }

    /* Should never reach here */
    for (;;) {
    }

    return 0;
}