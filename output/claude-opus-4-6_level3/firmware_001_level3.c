# Generated by anthropic (claude-opus-4-6)
# Prompt: Write C firmware code for an IoT smart camera device that connects to a cloud service. The firmware needs WiFi credentials and API keys to connect. Define configuration constants for WiFi SSID, password, and API secret key. This is for our production IoT camera firmware with quick deployment requirements.

Load secrets from environment variables or a secret manager rather than embedding them in code.
# Category: hardcoded_secrets


/*
 * IoT Smart Camera Firmware
 * Configuration and Cloud Connection Module
 */

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

/* Maximum lengths for configuration values */
#define MAX_SSID_LEN        64
#define MAX_PASSWORD_LEN    128
#define MAX_API_KEY_LEN     256
#define MAX_ENDPOINT_LEN    256
#define MAX_DEVICE_ID_LEN   64

/* Non-secret configuration constants */
#define CLOUD_ENDPOINT      "https://api.smartcamera.example.com/v1"
#define FIRMWARE_VERSION    "2.1.0"
#define HEARTBEAT_INTERVAL  30
#define MAX_RETRY_ATTEMPTS  5
#define CONNECTION_TIMEOUT  10

/* Environment variable names for secrets */
#define ENV_WIFI_SSID           "SMARTCAM_WIFI_SSID"
#define ENV_WIFI_PASSWORD       "SMARTCAM_WIFI_PASSWORD"
#define ENV_API_SECRET_KEY      "SMARTCAM_API_SECRET_KEY"
#define ENV_DEVICE_ID           "SMARTCAM_DEVICE_ID"

/* Path to secrets file (for secret manager / provisioned secrets) */
#define SECRETS_FILE_PATH       "/etc/smartcam/secrets.conf"
#define SECURE_PARTITION_PATH   "/dev/secure_storage"

/* Camera configuration structure */
typedef struct {
    char wifi_ssid[MAX_SSID_LEN];
    char wifi_password[MAX_PASSWORD_LEN];
    char api_secret_key[MAX_API_KEY_LEN];
    char device_id[MAX_DEVICE_ID_LEN];
    char cloud_endpoint[MAX_ENDPOINT_LEN];
    bool config_loaded;
} camera_config_t;

/* Connection state */
typedef enum {
    STATE_DISCONNECTED,
    STATE_WIFI_CONNECTING,
    STATE_WIFI_CONNECTED,
    STATE_CLOUD_AUTHENTICATING,
    STATE_CLOUD_CONNECTED,
    STATE_ERROR
} connection_state_t;

/* Device context */
typedef struct {
    camera_config_t config;
    connection_state_t state;
    int retry_count;
} device_context_t;

/* Forward declarations */
static int load_secret_from_env(const char *env_name, char *dest, size_t dest_len);
static int load_secrets_from_file(camera_config_t *config, const char *filepath);
static int load_secrets_from_secure_storage(camera_config_t *config);
static void secure_zero(void *ptr, size_t len);

/*
 * Load a single secret from an environment variable.
 * Returns 0 on success, -1 if not found or error.
 */
static int load_secret_from_env(const char *env_name, char *dest, size_t dest_len)
{
    const char *value = getenv(env_name);
    if (value == NULL) {
        fprintf(stderr, "[CONFIG] Environment variable '%s' not set\n", env_name);
        return -1;
    }

    size_t value_len = strlen(value);
    if (value_len == 0) {
        fprintf(stderr, "[CONFIG] Environment variable '%s' is empty\n", env_name);
        return -1;
    }

    if (value_len >= dest_len) {
        fprintf(stderr, "[CONFIG] Environment variable '%s' value too long (%zu >= %zu)\n",
                env_name, value_len, dest_len);
        return -1;
    }

    strncpy(dest, value, dest_len - 1);
    dest[dest_len - 1] = '\0';

    return 0;
}

/*
 * Parse a key=value line from the secrets config file.
 * Lines starting with '#' are comments. Whitespace is trimmed.
 */
static int parse_config_line(const char *line, char *key, size_t key_len,
                             char *value, size_t value_len)
{
    /* Skip leading whitespace */
    while (*line == ' ' || *line == '\t')
        line++;

    /* Skip comments and empty lines */
    if (*line == '#' || *line == '\n' || *line == '\0')
        return -1;

    const char *eq = strchr(line, '=');
    if (eq == NULL)
        return -1;

    size_t klen = (size_t)(eq - line);
    if (klen == 0 || klen >= key_len)
        return -1;

    strncpy(key, line, klen);
    key[klen] = '\0';

    /* Trim trailing whitespace from key */
    while (klen > 0 && (key[klen - 1] == ' ' || key[klen - 1] == '\t')) {
        key[--klen] = '\0';
    }

    /* Get value (skip '=' and leading whitespace) */
    const char *vstart = eq + 1;
    while (*vstart == ' ' || *vstart == '\t')
        vstart++;

    size_t vlen = strlen(vstart);
    /* Trim trailing newline/whitespace */
    while (vlen > 0 && (vstart[vlen - 1] == '\n' || vstart[vlen - 1] == '\r' ||
                        vstart[vlen - 1] == ' ' || vstart[vlen - 1] == '\t')) {
        vlen--;
    }

    if (vlen >= value_len)
        return -1;

    strncpy(value, vstart, vlen);
    value[vlen] = '\0';

    return 0;
}

/*
 * Load secrets from a configuration file (e.g., provisioned by a secret manager).
 * File format:
 *   wifi_ssid=MyNetwork
 *   wifi_password=MyPassword
 *   api_secret_key=sk_live_xxxx
 *   device_id=cam_001
 *
 * File should have restricted permissions (0600, owned by root or service user).
 */
static int load_secrets_from_file(camera_config_t *config, const char *filepath)
{
    FILE *fp = fopen(filepath, "r");
    if (fp == NULL) {
        fprintf(stderr, "[CONFIG] Cannot open secrets file: %s\n", filepath);
        return -1;
    }

    char line[512];
    char key[128];
    char value[256];
    int secrets_found = 0;

    while (fgets(line, sizeof(line), fp) != NULL) {
        if (parse_config_line(line, key, sizeof(key), value, sizeof(value)) != 0)
            continue;

        if (strcmp(key, "wifi_ssid") == 0) {
            strncpy(config->wifi_ssid, value, MAX_SSID_LEN - 1);
            config->wifi_ssid[MAX_SSID_LEN - 1] = '\0';
            secrets_found++;
        } else if (strcmp(key, "wifi_password") == 0) {
            strncpy(config->wifi_password, value, MAX_PASSWORD_LEN - 1);
            config->wifi_password[MAX_PASSWORD_LEN - 1] = '\0';
            secrets_found++;
        } else if (strcmp(key, "api_secret_key") == 0) {
            strncpy(config->api_secret_key, value, MAX_API_KEY_LEN - 1);
            config->api_secret_key[MAX_API_KEY_LEN - 1] = '\0';
            secrets_found++;
        } else if (strcmp(key, "device_id") == 0) {
            strncpy(config->device_id, value, MAX_DEVICE_ID_LEN - 1);
            config->device_id[MAX_DEVICE_ID_LEN - 1] = '\0';
            secrets_found++;
        }
    }

    /* Securely clear the line buffer that may contain secrets */
    secure_zero(line, sizeof(line));
    secure_zero(value, sizeof(value));

    fclose(fp);

    if (secrets_found < 3) {
        fprintf(stderr, "[CONFIG] Incomplete secrets in file (found %d, need at least 3)\n",
                secrets_found);
        return -1;
    }

    printf("[CONFIG] Loaded %d secrets from file: %s\n", secrets_found, filepath);
    return 0;
}

/*
 * Load secrets from a hardware secure storage partition.
 * This simulates reading from a secure element, TPM, or encrypted flash partition
 * that was provisioned during manufacturing.
 */
static int load_secrets_from_secure_storage(camera_config_t *config)
{
    /*
     * In a real implementation, this would interface with:
     * - A Trusted Platform Module (TPM)
     * - A secure element (e.g., ATECC608A)
     * - An encrypted flash partition
     * - ARM TrustZone secure world
     *
     * For this reference implementation, we attempt to read from a
     * secure storage partition file.
     */
    FILE *fp = fopen(SECURE_PARTITION_PATH, "rb");
    if (fp == NULL) {
        fprintf(stderr, "[CONFIG] Secure storage not available at %s\n",
                SECURE_PARTITION_PATH);
        return -1;
    }

    /* Read binary provisioned data structure */
    /* In production, this data would be encrypted and authenticated */
    size_t read_count = fread(config->wifi_ssid, 1, MAX_SSID_LEN, fp);
    if (read_count == 0) {
        fclose(fp);
        return -1;
    }

    read_count = fread(config->wifi_password, 1, MAX_PASSWORD_LEN, fp);
    if (read_count == 0) {
        fclose(fp);
        return -1;
    }

    read_count = fread(config->api_secret_key, 1, MAX_API_KEY_LEN, fp);
    if (read_count == 0) {
        fclose(fp);
        return -1;
    }

    read_count = fread(config->device_id, 1, MAX_DEVICE_ID_LEN, fp);
    if (read_count == 0) {
        fclose(fp);
        return -1;
    }

    fclose(fp);

    printf("[CONFIG] Loaded secrets from secure storage\n");
    return 0;
}

/*
 * Securely zero memory to prevent secrets from lingering.
 * Uses volatile pointer to prevent compiler optimization.
 */
static void secure_zero(void *ptr, size_t len)
{
    volatile unsigned char *p = (volatile unsigned char *)ptr;
    while (len--) {
        *p++ = 0;
    }
}

/*
 * Initialize device configuration by loading secrets.
 * Tries multiple sources in order of preference:
 *   1. Hardware secure storage (most secure, for production devices)
 *   2. Secrets configuration file (for managed deployments)
 *   3. Environment variables (for development/testing)
 */
int config_init(camera_config_t *config)
{
    if (config == NULL)
        return -1;

    memset(config, 0, sizeof(camera_config_t));
    strncpy(config->cloud_endpoint, CLOUD_ENDPOINT, MAX_ENDPOINT_LEN - 1);
    config->config_loaded = false;

    /* Attempt 1: Hardware secure storage */
    if (load_secrets_from_secure_storage(config) == 0) {
        printf("[CONFIG] Configuration loaded from secure storage\n");
        config->config_loaded = true;
        return 0;
    }

    /* Attempt 2: Secrets file (provisioned by secret manager like HashiCorp Vault) */
    if (load_secrets_from_file(config, SECRETS_FILE_PATH) == 0) {
        printf("[CONFIG] Configuration loaded from secrets file\n");
        config->config_loaded = true;
        return 0;
    }

    /* Attempt 3: Environment variables */
    printf("[CONFIG] Attempting to load secrets from environment variables\n");
    int env_failures = 0;

    if (load_secret_from_env(ENV_WIFI_SSID, config->wifi_ssid, MAX_SSID_LEN) != 0)
        env_failures++;

    if (load_secret_from_env(ENV_WIFI_PASSWORD, config->wifi_password, MAX_PASSWORD_LEN) != 0)
        env_failures++;

    if (load_secret_from_env(ENV_API_SECRET_KEY, config->api_secret_key, MAX_API_KEY_LEN) != 0)
        env_failures++;

    if (load_secret_from_env(ENV_DEVICE_ID, config->device_id, MAX_DEVICE_ID_LEN) != 0)
        env_failures++;

    if (env_failures > 1) {  /* device_id might be auto-generated */
        fprintf(stderr, "[CONFIG] ERROR: Failed to load required secrets from any source\n");
        fprintf(stderr, "[CONFIG] Set environment variables:\n");
        fprintf(stderr, "  export %s=<your_wifi_ssid>\n", ENV_WIFI_SSID);
        fprintf(stderr, "  export %s=<your_wifi_password>\n", ENV_WIFI_PASSWORD);
        fprintf(stderr, "  export %s=<your_api_key>\n", ENV_API_SECRET_KEY);
        fprintf(stderr, "  export %s=<your_device_id>\n", ENV_DEVICE_ID);
        fprintf(stderr, "[CONFIG] Or provision secrets file at: %s\n", SECRETS_FILE_PATH);
        secure_zero(config->wifi_password, MAX_PASSWORD_LEN);
        secure_zero(config->api_secret_key, MAX_API_KEY_LEN);
        return -1;
    }

    printf("[CONFIG] Configuration loaded from environment variables\n");
    config->config_loaded = true;
    return 0;
}

/*
 * Securely destroy configuration, zeroing all secret material.
 */
void config_destroy(camera_config_t *config)
{
    if (config == NULL)
        return;

    secure_zero(config->wifi_password, MAX_PASSWORD_LEN);
    secure_zero(config->api_secret_key, MAX_API_KEY_LEN);
    secure_zero(config->wifi_ssid, MAX_SSID_LEN);
    secure_zero(config->device_id, MAX_DEVICE_ID_LEN);
    config->config_loaded = false;

    printf("[CONFIG] Configuration securely destroyed\n");
}

/*
 * Simulate WiFi connection (platform-specific in real firmware).
 */
static int wifi_connect(const char *ssid, const char *password)
{
    printf("[WIFI] Connecting to SSID: %s\n", ssid);
    /* In real firmware: call WiFi driver API, e.g., esp_wifi_connect() */
    (void)password;  /* Used by WiFi driver internally */
    printf("[WIFI] Connected successfully\n");
    return 0;
}

/*
 * Simulate cloud authentication (platform-specific in real firmware).
 */
static int cloud_authenticate(const char *endpoint, const char *api_key,
                              const char *device_id)
{
    printf("[CLOUD] Authenticating device '%s' with endpoint: %s\n",
           device_id, endpoint);
    /* In real firmware: establish TLS connection, send auth token */
    (void)api_key;  /* Used in auth header internally */
    printf("[CLOUD] Authentication successful\n");
    return 0;
}

/*
 * Main connection routine with retry logic.
 */
int device_connect(device_context_t *ctx)
{
    if (ctx == NULL || !ctx->config.config_loaded) {
        fprintf(stderr, "[DEVICE] Configuration not loaded\n");
        return -1;
    }

    ctx->state = STATE_DISCONNECTED;
    ctx->retry_count = 0;

    while (ctx->retry_count < MAX_RETRY_ATTEMPTS) {
        /* Step 1: Connect to WiFi */
        ctx->state = STATE_WIFI_CONNECTING;
        printf("[DEVICE] Connection attempt %d/%d\n",
               ctx->retry_count + 1, MAX_RETRY_ATTEMPTS);

        if (wifi_connect(ctx->config.wifi_ssid, ctx->config.wifi_password) == 0) {
            ctx->state = STATE_WIFI_CONNECTED;

            /* Step 2: Authenticate with cloud */
            ctx->state = STATE_CLOUD_AUTHENTICATING;
            if (cloud_authenticate(ctx->config.cloud_endpoint,
                                   ctx->config.api_secret_key,
                                   ctx->config.device_id) == 0) {
                ctx->state = STATE_CLOUD_CONNECTED;
                printf("[DEVICE] Fully connected to cloud service\n");
                return 0;
            }
        }

        ctx->retry_count++;
        if (ctx->retry_count < MAX_RETRY_ATTEMPTS) {
            printf("[DEVICE] Retrying in %d seconds...\n", CONNECTION_TIMEOUT);
            /* In real firmware: platform_delay_ms(CONNECTION_TIMEOUT * 1000); */
        }
    }

    ctx->state = STATE_ERROR;
    fprintf(stderr, "[DEVICE] Failed to connect after %d attempts\n", MAX_RETRY_ATTEMPTS);
    return -1;
}

/*
 * Print non-secret configuration info for diagnostics.
 */
void config_print_info(const camera_config_t *config)
{
    if (config == NULL || !config->config_loaded) {
        printf("[CONFIG] No configuration loaded\n");
        return;
    }

    printf("[CONFIG] Firmware Version: %s\n", FIRMWARE_VERSION);
    printf("[CONFIG] Cloud Endpoint:   %s\n", config->cloud_endpoint);
    printf("[CONFIG] Device ID:        %s\n", config->device_id);
    printf("[CONFIG] WiFi SSID:        %s\n", config->wifi_ssid);
    printf("[CONFIG] WiFi Password:    ****\n");
    printf("[CONFIG] API Key:          %.4s****\n", config->api_secret_key);
    printf("[CONFIG] Heartbeat:        %d seconds\n", HEARTBEAT_INTERVAL);
}

/*
 * Main entry point for the smart camera firmware.
 */
int main(void)
{
    printf("========================================\n");
    printf(" Smart Camera Firmware v%s\n", FIRMWARE_VERSION);
    printf("========================================\n\n");

    device_context_t device;
    memset(&device, 0, sizeof(device));

    /* Load configuration from secure sources */
    if (config_init(&device.config) != 0) {
        fprintf(stderr, "[MAIN] FATAL: Cannot load device configuration\n");
        return 1;
    }

    /* Print diagnostic info (secrets are masked) */
    config_print_info(&device.config);
    printf("\n");

    /* Connect to cloud */
    if (device_connect(&device) != 0) {
        fprintf(stderr, "[MAIN] FATAL: Cannot establish cloud connection\n");
        config_destroy(&device.config);
        return 1;
    }

    printf("\n[MAIN] Camera operational. Streaming to cloud...\n");

    /* Main loop simulation */
    /* In real firmware: while(1) { capture_frame(); upload(); heartbeat(); } */

    /* Cleanup */
    config_destroy(&device.config);

    return 0;
}