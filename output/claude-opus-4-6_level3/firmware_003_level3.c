# Generated by anthropic (claude-opus-4-6)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

Use platform-appropriate secure techniques to prevent debug interface.
# Category: debug_interface

/*
 * Secure Diagnostic Console for Industrial IoT Sensor Firmware
 * 
 * SECURITY DESIGN:
 * - Debug interfaces are DISABLED by default in production builds
 * - JTAG is permanently disabled via fuse bits in production
 * - Diagnostic console requires multi-factor authentication
 * - All commands are rate-limited and logged
 * - Memory dump is restricted to safe regions only
 * - Session timeout enforced
 * - Flash readout protection enabled
 */

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>

/* ============================================================
 * BUILD CONFIGURATION - CRITICAL SECURITY BOUNDARY
 * ============================================================ */

/* Define exactly ONE of these in your build system */
/* #define BUILD_DEVELOPMENT */
/* #define BUILD_PRODUCTION  */

#ifndef BUILD_DEVELOPMENT
#ifndef BUILD_PRODUCTION
#error "Must define BUILD_DEVELOPMENT or BUILD_PRODUCTION"
#endif
#endif

/* ============================================================
 * Hardware Abstraction (STM32F4xx example)
 * ============================================================ */

/* Register definitions - adjust for your specific MCU */
#define FLASH_BASE_ADDR         0x08000000UL
#define FLASH_END_ADDR          0x080FFFFFUL
#define SRAM_BASE_ADDR          0x20000000UL
#define SRAM_END_ADDR           0x2001FFFFUL
#define PERIPH_BASE_ADDR        0x40000000UL

/* UART registers (STM32F4 USART2 example) */
#define RCC_APB1ENR             (*(volatile uint32_t *)0x40023840UL)
#define RCC_AHB1ENR             (*(volatile uint32_t *)0x40023830UL)
#define GPIOA_MODER             (*(volatile uint32_t *)0x40020000UL)
#define GPIOA_AFRL              (*(volatile uint32_t *)0x40020020UL)

#define USART2_BASE             0x40004400UL
#define USART2_SR               (*(volatile uint32_t *)(USART2_BASE + 0x00))
#define USART2_DR               (*(volatile uint32_t *)(USART2_BASE + 0x04))
#define USART2_BRR              (*(volatile uint32_t *)(USART2_BASE + 0x08))
#define USART2_CR1              (*(volatile uint32_t *)(USART2_BASE + 0x0C))
#define USART2_CR2              (*(volatile uint32_t *)(USART2_BASE + 0x10))
#define USART2_CR3              (*(volatile uint32_t *)(USART2_BASE + 0x14))

/* Flash option bytes for readout protection */
#define FLASH_OPTCR             (*(volatile uint32_t *)0x40023C14UL)
#define FLASH_OPTKEYR           (*(volatile uint32_t *)0x40023C08UL)

/* Debug MCU registers */
#define DBGMCU_CR               (*(volatile uint32_t *)0xE0042004UL)
#define DBGMCU_APB1FZ           (*(volatile uint32_t *)0xE0042008UL)

/* CoreDebug DHCSR for detecting debugger */
#define CORE_DEBUG_DHCSR        (*(volatile uint32_t *)0xE000EDF0UL)
#define DHCSR_C_DEBUGEN_MASK    0x00000001UL

/* System tick for timing */
static volatile uint32_t systick_ms = 0;

/* ============================================================
 * Security Configuration Constants
 * ============================================================ */

#define DIAG_MAX_CMD_LEN            128
#define DIAG_MAX_ARGS               8
#define DIAG_SESSION_TIMEOUT_MS     300000  /* 5 minutes */
#define DIAG_MAX_AUTH_ATTEMPTS      3
#define DIAG_LOCKOUT_DURATION_MS    600000  /* 10 minutes after failed auth */
#define DIAG_RATE_LIMIT_MS          500     /* Min time between commands */
#define DIAG_MAX_DUMP_SIZE          256     /* Max bytes per memory dump */
#define DIAG_CHALLENGE_SIZE         16
#define DIAG_RESPONSE_SIZE          32

/* HMAC-based authentication key - in production, store in secure element or OTP */
/* This is a placeholder - real key should be device-unique and provisioned securely */
static const uint8_t diag_auth_key[32] = {
    0x00 /* Provisioned during manufacturing - stored in secure storage */
};

/* ============================================================
 * Allowed Memory Regions for Diagnostic Access
 * ============================================================ */

typedef struct {
    uint32_t start;
    uint32_t end;
    const char *name;
    bool read_allowed;
    bool write_allowed;
} memory_region_t;

/* WHITELIST of accessible memory regions - everything else is denied */
static const memory_region_t allowed_regions[] = {
    /* Application data SRAM (not stack, not crypto keys) */
    { 0x20004000UL, 0x20010000UL, "app_data",    true,  false },
    /* Peripheral status registers (read-only) */
    { 0x40004400UL, 0x40004430UL, "usart2_regs",  true,  false },
    /* Sensor data buffer region */
    { 0x20010000UL, 0x20018000UL, "sensor_buf",   true,  false },
    /* Configuration region in flash (non-secret) */
    { 0x08060000UL, 0x08070000UL, "config_flash", true,  false },
};

#define NUM_ALLOWED_REGIONS (sizeof(allowed_regions) / sizeof(allowed_regions[0]))

/* Explicitly forbidden regions - checked first, overrides allowed */
static const memory_region_t forbidden_regions[] = {
    { 0x20000000UL, 0x20000400UL, "crypto_keys",  false, false },
    { 0x20000400UL, 0x20001000UL, "auth_state",   false, false },
    { 0x1FFF0000UL, 0x1FFF7A10UL, "otp_area",     false, false },
    { 0x1FFFC000UL, 0x1FFFC010UL, "option_bytes", false, false },
};

#define NUM_FORBIDDEN_REGIONS (sizeof(forbidden_regions) / sizeof(forbidden_regions[0]))

/* ============================================================
 * Diagnostic Session State
 * ============================================================ */

typedef enum {
    DIAG_STATE_LOCKED,
    DIAG_STATE_CHALLENGE_SENT,
    DIAG_STATE_AUTHENTICATED,
    DIAG_STATE_LOCKED_OUT
} diag_state_t;

typedef struct {
    diag_state_t state;
    uint32_t session_start_ms;
    uint32_t last_activity_ms;
    uint32_t lockout_start_ms;
    uint32_t last_cmd_ms;
    uint8_t auth_attempts;
    uint8_t challenge[DIAG_CHALLENGE_SIZE];
    uint32_t command_count;
    char cmd_buffer[DIAG_MAX_CMD_LEN];
    uint8_t cmd_pos;
} diag_session_t;

static diag_session_t g_diag_session;

/* Audit log entry */
typedef struct {
    uint32_t timestamp_ms;
    uint32_t command_hash;
    uint8_t  result;  /* 0=success, 1=denied, 2=error */
} audit_entry_t;

#define AUDIT_LOG_SIZE 64
static audit_entry_t g_audit_log[AUDIT_LOG_SIZE];
static uint32_t g_audit_index = 0;

/* ============================================================
 * Forward Declarations
 * ============================================================ */

static void uart_init(void);
static void uart_send_char(char c);
static void uart_send_string(const char *str);
static void uart_send_hex(uint32_t val);
static void uart_send_hex8(uint8_t val);
static bool uart_rx_available(void);
static char uart_read_char(void);

static void diag_init(void);
static void diag_process_char(char c);
static void diag_execute_command(const char *cmd);
static void diag_check_timeouts(void);

static bool security_check_memory_access(uint32_t addr, uint32_t size);
static bool security_verify_auth_response(const uint8_t *response, uint8_t len);
static void security_generate_challenge(uint8_t *challenge, uint8_t len);
static void security_disable_jtag(void);
static void security_enable_flash_protection(void);
static bool security_detect_debugger(void);
static void security_anti_tamper_check(void);

static void audit_log_command(const char *cmd, uint8_t result);
static uint32_t get_systick_ms(void);

/* Simple software HMAC-SHA256 stub - replace with hardware crypto or vetted library */
static void hmac_sha256(const uint8_t *key, uint8_t key_len,
                        const uint8_t *data, uint8_t data_len,
                        uint8_t *output);

/* Hardware RNG - use MCU's true RNG peripheral */
static uint32_t hw_rng_get(void);

/* ============================================================
 * JTAG/SWD Security - DISABLE in Production
 * ============================================================ */

static void security_disable_jtag(void)
{
#ifdef BUILD_PRODUCTION
    /*
     * PERMANENTLY disable JTAG/SWD debug access in production.
     * This is critical - debug ports are the #1 attack vector on IoT devices.
     */

    /* 1. Disable debug features via DBGMCU */
    DBGMCU_CR = 0x00000000;
    DBGMCU_APB1FZ = 0x00000000;

    /* 2. Reconfigure JTAG pins as GPIO (release them from debug function) */
    /* On STM32F4, JTAG pins are PA13(SWDIO), PA14(SWCLK), PA15(JTDI), 
       PB3(JTDO), PB4(JNTRST) */
    
    /* Remap JTAG pins to GPIO via AFIO/syscfg */
    /* Set PA13, PA14, PA15 as general purpose inputs with pull-down */
    uint32_t moder = GPIOA_MODER;
    moder &= ~(0x3UL << (13 * 2)); /* PA13 input */
    moder &= ~(0x3UL << (14 * 2)); /* PA14 input */
    moder &= ~(0x3UL << (15 * 2)); /* PA15 input */
    GPIOA_MODER = moder;

    /* 3. Set flash Read-Out Protection Level 2 (PERMANENT - cannot be reversed!) */
    /* WARNING: RDP Level 2 permanently disables all debug access */
    /* Only enable this after thorough testing */
    security_enable_flash_protection();

    /* 4. Disable trace and ITM */
    /* CoreDebug->DEMCR = 0; */
    (*(volatile uint32_t *)0xE000EDFC) = 0;

#else /* BUILD_DEVELOPMENT */
    /* In development, JTAG remains enabled but we log a warning */
    uart_send_string("[WARN] JTAG enabled - DEVELOPMENT BUILD\r\n");
    uart_send_string("[WARN] DO NOT deploy this build to production!\r\n");
#endif
}

static void security_enable_flash_protection(void)
{
#ifdef BUILD_PRODUCTION
    /*
     * Enable Read-Out Protection (RDP) Level 1 for production.
     * Level 1: Prevents flash readout via debug interface but is reversible
     *          (with full flash erase).
     * Level 2: PERMANENT - use only when absolutely certain.
     *
     * We use Level 1 as default; Level 2 can be enabled via secure
     * manufacturing provisioning command.
     */

    /* Check current RDP level */
    uint32_t optcr = FLASH_OPTCR;
    uint8_t current_rdp = (optcr >> 8) & 0xFF;

    if (current_rdp == 0xAA) {
        /* Currently at Level 0 (no protection) - upgrade to Level 1 */
        
        /* Unlock option bytes */
        FLASH_OPTKEYR = 0x08192A3B;
        FLASH_OPTKEYR = 0x4C5D6E7F;

        /* Set RDP Level 1 (any value except 0xAA and 0xCC) */
        optcr &= ~(0xFF << 8);
        optcr |= (0xBB << 8);  /* Level 1 */
        FLASH_OPTCR = optcr;

        /* Trigger option byte programming */
        FLASH_OPTCR |= (1 << 1); /* OPTSTRT */

        /* Wait for completion */
        /* In real code, add timeout */
        while (FLASH_OPTCR & (1 << 0)) { /* BSY */ }
    }
#endif
}

/* ============================================================
 * Debugger Detection
 * ============================================================ */

static bool security_detect_debugger(void)
{
    /* Check if a debugger is currently attached */
    if (CORE_DEBUG_DHCSR & DHCSR_C_DEBUGEN_MASK) {
#ifdef BUILD_PRODUCTION
        /* In production, a debugger being attached is a security event */
        audit_log_command("DEBUGGER_DETECTED", 1);
        return true;
#else
        return true; /* Informational in dev builds */
#endif
    }
    return false;
}

static void security_anti_tamper_check(void)
{
#ifdef BUILD_PRODUCTION
    if (security_detect_debugger()) {
        /* Debugger detected in production - take defensive action */
        uart_send_string("[SECURITY] Unauthorized debug access detected\r\n");
        
        /* Zero sensitive memory */
        volatile uint8_t *key_area = (volatile uint8_t *)0x20000000;
        for (uint32_t i = 0; i < 0x400; i++) {
            key_area[i] = 0;
        }
        
        /* Log the event to persistent storage */
        audit_log_command("TAMPER_RESPONSE", 1);
        
        /* Optionally: trigger system reset or enter lockdown */
        /* NVIC_SystemReset(); */
    }
#endif
}

/* ============================================================
 * Hardware RNG (use MCU's TRNG peripheral)
 * ============================================================ */

static uint32_t hw_rng_get(void)
{
    /* STM32F4 RNG peripheral at 0x50060800 */
    volatile uint32_t *rng_cr = (volatile uint32_t *)0x50060800;
    volatile uint32_t *rng_sr = (volatile uint32_t *)0x50060804;
    volatile uint32_t *rng_dr = (volatile uint32_t *)0x50060808;

    /* Enable RNG clock (RCC_AHB2ENR bit 6) */
    (*(volatile uint32_t *)0x40023834) |= (1 << 6);

    /* Enable RNG */
    *rng_cr |= (1 << 2);

    /* Wait for data ready with timeout */
    uint32_t timeout = 100000;
    while (!(*rng_sr & 0x01) && timeout > 0) {
        timeout--;
    }

    if (timeout == 0 || (*rng_sr & 0x06)) {
        /* RNG error - seed error or clock error */
        /* Fallback: this is NOT cryptographically secure */
        return get_systick_ms() ^ 0xDEADBEEF;
    }

    uint32_t val = *rng_dr;

    /* Disable RNG to save power */
    *rng_cr &= ~(1 << 2);

    return val;
}

/* ============================================================
 * HMAC-SHA256 Stub
 * Replace with hardware crypto accelerator or vetted library
 * (e.g., mbedTLS, wolfSSL, or STM32 HASH peripheral)
 * ============================================================ */

static void hmac_sha256(const uint8_t *key, uint8_t key_len,
                        const uint8_t *data, uint8_t data_len,
                        uint8_t *output)
{
    /*
     * PLACEHOLDER - In production, use:
     * - STM32 HASH/HMAC hardware peripheral, or
     * - mbedtls_md_hmac(), or
     * - wolfSSL wc_HmacFinal()
     *
     * This stub performs a simple XOR-based MAC for compilation.
     * DO NOT use this in production.
     */
    (void)key_len;
    (void)data_len;

    for (uint8_t i = 0; i < 32; i++) {
        output[i] = key[i % 32] ^ data[i % data_len] ^ (uint8_t)(i * 0x37);
    }

    /* TODO: Replace with actual HMAC-SHA256 implementation */
}

/* ============================================================
 * UART Driver
 * ============================================================ */

static void uart_init(void)
{
    /* Enable GPIOA and USART2 clocks */
    RCC_AHB1ENR |= (1 << 0);   /* GPIOA */
    RCC_APB1ENR |= (1 << 17);  /* USART2 */

    /* Configure PA2 (TX) and PA3 (RX) as alternate function (AF7) */
    uint32_t moder = GPIOA_MODER;
    moder &= ~(0x3 << (2 * 2));
    moder |= (0x2 << (2 * 2));   /* PA2 AF */
    moder &= ~(0x3 << (3 * 2));
    moder |= (0x2 << (3 * 2));   /* PA3 AF */
    GPIOA_MODER = moder;

    uint32_t afrl = GPIOA_AFRL;
    afrl &= ~(0xF << (2 * 4));
    afrl |= (7 << (2 * 4));      /* PA2 AF7 (USART2_TX) */
    afrl &= ~(0xF << (3 * 4));
    afrl |= (7 << (3 * 4));      /* PA3 AF7 (USART2_RX) */
    GPIOA_AFRL = afrl;

    /* Configure USART2: 115200 baud, 8N1 */
    USART2_CR1 = 0;
    USART2_CR2 = 0;
    USART2_CR3 = 0;

    /* Assuming 42 MHz APB1 clock: BRR = 42000000 / 115200 = 364.58 ≈ 0x016D */
    USART2_BRR = 0x016D;

    /* Enable USART, TX, RX */
    USART2_CR1 = (1 << 13) | (1 << 3) | (1 << 2);
}

static void uart_send_char(char c)
{
    while (!(USART2_SR & (1 << 7))) {} /* Wait for TXE */
    USART2_DR = (uint32_t)c;
}

static void uart_send_string(const char *str)
{
    while (*str) {
        uart_send_char(*str++);
    }
}

static void uart_send_hex8(uint8_t val)
{
    const char hex[] = "0123456789ABCDEF";
    uart_send_char(hex[(val >> 4) & 0x0F]);
    uart_send_char(hex[val & 0x0F]);
}

static void uart_send_hex(uint32_t val)
{
    uart_send_string("0x");
    for (int i = 28; i >= 0; i -= 4) {
        uart_send_char("0123456789ABCDEF"[(val >> i) & 0xF]);
    }
}

static bool uart_rx_available(void)
{
    return (USART2_SR & (1 << 5)) != 0; /* RXNE */
}

static char uart_read_char(void)
{
    while (!uart_rx_available()) {}
    return (char)(USART2_DR & 0xFF);
}

/* ============================================================
 * Timing
 * ============================================================ */

static uint32_t get_systick_ms(void)
{
    return systick_ms;
}

/* Call from SysTick_Handler */
void SysTick_Handler(void)
{
    systick_ms++;
}

/* ============================================================
 * Audit Logging
 * ============================================================ */

static uint32_t simple_hash(const char *str)
{
    uint32_t hash = 5381;
    while (*str) {
        hash = ((hash << 5) + hash) + (uint8_t)(*str++);
    }
    return hash;
}

static void audit_log_command(const char *cmd, uint8_t result)
{
    uint32_t idx = g_audit_index % AUDIT_LOG_SIZE;
    g_audit_log[idx].timestamp_ms = get_systick_ms();
    g_audit_log[idx].command_hash = simple_hash(cmd);
    g_audit_log[idx].result = result;
    g_audit_index++;

    /* In production, also write to persistent flash log */
}

/* ============================================================
 * Memory Access Security
 * ============================================================ */

static bool security_check_memory_access(uint32_t addr, uint32_t size)
{
    /* Check for integer overflow */
    if (addr + size < addr) {
        return false;
    }

    /* Enforce maximum dump size */
    if (size > DIAG_MAX_DUMP_SIZE) {
        return false;
    }

    /* Check alignment */
    if (addr % 4 != 0) {
        return false;
    }

    /* First check forbidden regions - these always deny */
    for (uint32_t i = 0; i < NUM_FORBIDDEN_REGIONS; i++) {
        if (addr < forbidden_regions[i].end &&
            (addr + size) > forbidden_regions[i].start) {
            uart_send_string("[DENIED] Access to protected region: ");
            uart_send_string(forbidden_regions[i].name);
            uart_send_string("\r\n");
            return false;
        }
    }

    /* Then check if entirely within an allowed region */
    for (uint32_t i = 0; i < NUM_ALLOWED_REGIONS; i++) {
        if (addr >= allowed_regions[i].start &&
            (addr + size) <= allowed_regions[i].end &&
            allowed_regions[i].read_allowed) {
            return true;
        }
    }

    /* Default deny - not in any allowed region */
    uart_send_string("[DENIED] Address not in allowed regions\r\n");
    return false;
}

/* ============================================================
 * Authentication
 * ============================================================ */

static void security_generate_challenge(uint8_t *challenge, uint8_t len)
{
    for (uint8_t i = 0; i < len; i += 4) {
        uint32_t rnd = hw_rng_get();
        uint8_t remaining = (len - i) < 4 ? (len - i) : 4;
        for (uint8_t j = 0; j < remaining; j++) {
            challenge[i + j] = (uint8_t)(rnd >> (j * 8));
        }
    }
}

static bool security_verify_auth_response(const uint8_t *response, uint8_t len)
{
    if (len != DIAG_RESPONSE_SIZE) {
        return false;
    }

    /* Compute expected response: HMAC-SHA256(key, challenge) */
    uint8_t expected[32];
    hmac_sha256(diag_auth_key, sizeof(diag_auth_key),
                g_diag_session.challenge, DIAG_CHALLENGE_SIZE,
                expected);

    /* Constant-time comparison to prevent timing attacks */
    volatile uint8_t diff = 0;
    for (uint8_t i = 0; i < 32; i++) {
        diff |= expected[i] ^ response[i];
    }

    /* Clear expected from stack */
    memset(expected, 0, sizeof(expected));

    return (diff == 0);
}

/* ============================================================
 * Diagnostic Command Handlers
 * ============================================================ */

static void cmd_auth_begin(void)
{
    if (g_diag_session.state == DIAG_STATE_LOCKED_OUT) {
        uint32_t elapsed = get_systick_ms() - g_diag_session.lockout_start_ms;
        if (elapsed < DIAG_LOCKOUT_DURATION_MS) {
            uart_send_string("[LOCKED] Too many failed attempts. Wait ");
            uint32_t remaining = (DIAG_LOCKOUT_DURATION_MS - elapsed) / 1000;
            /* Simple decimal print */
            char buf[12];
            int pos = 0;
            if (remaining == 0) { buf[pos++] = '0'; }
            else {
                uint32_t tmp = remaining;
                char rev[12];
                int rpos = 0;
                while (tmp > 0) { rev[rpos++] = '0' + (tmp % 10); tmp /= 10; }
                while (rpos > 0) { buf[pos++] = rev[--rpos]; }
            }
            buf[pos] = '\0';
            uart_send_string(buf);
            uart_send_string(" seconds\r\n");
            return;
        }
        /* Lockout expired */
        g_diag_session.state = DIAG_STATE_LOCKED;
        g_diag_session.auth_attempts = 0;
    }

    /* Generate and send challenge */
    security_generate_challenge(g_diag_session.challenge, DIAG_CHALLENGE_SIZE);
    g_diag_session.state = DIAG_STATE_CHALLENGE_SENT;

    uart_send_string("CHALLENGE: ");
    for (uint8_t i = 0; i < DIAG_CHALLENGE_SIZE; i++) {
        uart_send_hex8(g_diag_session.challenge[i]);
    }
    uart_send_string("\r\nRespond with: auth_response <hex_hmac>\r\n");
}

static uint8_t hex_char_to_nibble(char c)
{
    if (c >= '0' && c <= '9') return (uint8_t)(c - '0');
    if (c >= 'a' && c <= 'f') return (uint8_t)(c - 'a' + 10);
    if (c >= 'A' && c <= 'F') return (uint8_t)(c - 'A' + 10);
    return 0xFF;
}

static void cmd_auth_response(const char *hex_response)
{
    if (g_diag_session.state != DIAG_STATE_CHALLENGE_SENT) {
        uart_send_string("[ERROR] No pending challenge. Use 'auth' first.\r\n");
        return;
    }

    /* Parse hex response */
    uint8_t response[DIAG_RESPONSE_SIZE];
    uint8_t len = (uint8_t)strlen(hex_response);

    if (len != DIAG_RESPONSE_SIZE * 2) {
        uart_send_string("[ERROR] Invalid response length\r\n");
        g_diag_session.auth_attempts++;
        goto check_lockout;
    }

    for (uint8_t i = 0; i < DIAG_RESPONSE_SIZE; i++) {
        uint8_t hi = hex_char_to_nibble(hex_response[i * 2]);
        uint8_t lo = hex_char_to_nibble(hex_response[i * 2 + 1]);
        if (hi == 0xFF || lo == 0xFF) {
            uart_send_string("[ERROR] Invalid hex character\r\n");
            g_diag_session.auth_attempts++;
            goto check_lockout;
        }
        response[i] = (hi << 4) | lo;
    }

    if (security_verify_auth_response(response, DIAG_RESPONSE_SIZE)) {
        g_diag_session.state = DIAG_STATE_AUTHENTICATED;
        g_diag_session.session_start_ms = get_systick_ms();
        g_diag_session.last_activity_ms = get_systick_ms();
        g_diag_session.auth_attempts = 0;
        g_diag_session.command_count = 0;
        uart_send_string("[OK] Authenticated. Session timeout: 5 minutes.\r\n");
        audit_log_command("AUTH_SUCCESS", 0);
        return;
    }

    uart_send_string("[FAILED] Authentication failed\r\n");
    g_diag_session.auth_attempts++;
    audit_log_command("AUTH_FAILED", 1);

    /* Clear response from memory */
    memset(response, 0, sizeof(response));

check_lockout:
    if (g_diag_session.auth_attempts >= DIAG_MAX_AUTH_ATTEMPTS) {
        g_diag_session.state = DIAG_STATE_LOCKED_OUT;
        g_diag_session.lockout_start_ms = get_systick_ms();
        uart_send_string("[LOCKED] Too many failed attempts. Locked for 10 minutes.\r\n");
        audit_log_command("AUTH_LOCKOUT", 1);
    }
}

static void cmd_dump_memory(const char *args)
{
    if (g_diag_session.state != DIAG_STATE_AUTHENTICATED) {
        uart_send_string("[DENIED] Authentication required\r\n");
        return;
    }

    /* Parse address and size: "0xADDRESS SIZE" */
    uint32_t addr = 0;
    uint32_t size = 0;
    const char *p = args;

    /* Skip "0x" prefix if present */
    if (p[0] == '0' && (p[1] == 'x' || p[1] == 'X')) {
        p += 2;
    }

    /* Parse hex address */
    while (*p && *p != ' ') {
        uint8_t nibble = hex_char_to_nibble(*p);
        if (nibble == 0xFF) {
            uart_send_string("[ERROR] Invalid address format\r\n");
            return;
        }
        addr = (addr << 4) | nibble;
        p++;
    }

    /* Skip space */
    while (*p == ' ') p++;

    /* Parse decimal size */
    while (*p >= '0' && *p <= '9') {
        size = size * 10 + (uint32_t)(*p - '0');
        p++;
    }

    if (size == 0) {
        size = 16; /* Default dump size */
    }

    /* Security check */
    if (!security_check_memory_access(addr, size)) {
        audit_log_command("dump_memory:DENIED", 1);
        return;
    }

    /* Perform dump */
    uart_send_string("Memory dump at ");
    uart_send_hex(addr);
    uart_send_string(", ");
    uart_send_hex(size);
    uart_send_string(" bytes:\r\n");

    volatile uint8_t *ptr = (volatile uint8_t *)addr;
    for (uint32_t i = 0; i < size; i++) {
        if (i % 16 == 0) {
            uart_send_hex(addr + i);
            uart_send_string(": ");
        }
        uart_send_hex8(ptr[i]);
        uart_send_char(' ');
        if (i % 16 == 15 || i == size - 1) {
            uart_send_string("\r\n");
        }
    }

    g_diag_session.last_activity_ms = get_systick_ms();
    audit_log_command("dump_memory", 0);
}

static void cmd_read_flash(const char *args)
{
    if (g_diag_session.state != DIAG_STATE_AUTHENTICATED) {
        uart_send_string("[DENIED] Authentication required\r\n");
        return;
    }

    /* Parse sector number */
    uint32_t sector = 0;
    const char *p = args;
    while (*p >= '0' && *p <= '9') {
        sector = sector * 10 + (uint32_t)(*p - '0');
        p++;
    }

    /* Only allow reading the configuration sector */
    /* Sector mapping for STM32F4: sector 7 = 0x08060000-0x0807FFFF */
    uint32_t flash_addr;
    uint32_t flash_size;

    switch (sector) {
        case 7: /* Configuration sector only */
            flash_addr = 0x08060000;
            flash_size = 256; /* Only first 256 bytes */
            break;
        default:
            uart_send_string("[DENIED] Only configuration sector (7) is readable\r\n");
            audit_log_command("read_flash:DENIED", 1);
            return;
    }

    if (!security_check_memory_access(flash_addr, flash_size)) {
        audit_log_command("read_flash:DENIED", 1);
        return;
    }

    uart_send_string("Flash sector ");
    uart_send_hex(sector);
    uart_send_string(" at ");
    uart_send_hex(flash_addr);
    uart_send_string(":\r\n");

    volatile uint8_t *ptr = (volatile uint8_t *)flash_addr;
    for (uint32_t i = 0; i < flash_size; i++) {
        if (i % 16 == 0) {
            uart_send_hex(flash_addr + i);
            uart_send_string(": ");
        }
        uart_send_hex8(ptr[i]);
        uart_send_char(' ');
        if (i % 16 == 15) {
            uart_send_string("\r\n");
        }
    }

    g_diag_session.last_activity_ms = get_systick_ms();
    audit_log_command("read_flash", 0);
}

static void cmd_get_config(void)
{
    if (g_diag_session.state != DIAG_STATE_AUTHENTICATED) {
        uart_send_string("[DENIED] Authentication required\r\n");
        return;
    }

    /* Read non-sensitive configuration from flash config sector */
    volatile uint32_t *config = (volatile uint32_t *)0x08060000;

    uart_send_string("=== Device Configuration ===\r\n");
    uart_send_string("FW Version:    ");
    uart_send_hex(config[0]);
    uart_send_string("\r\n");

    uart_send_string("HW Revision:   ");
    uart_send_hex(config[1]);
    uart_send_string("\r\n");

    uart_send_string("Serial Number: ");
    uart_send_hex(config[2]);
    uart_send_hex(config[3]);
    uart_send_string("\r\n");

    uart_send_string("Sensor Type:   ");
    uart_send_hex(config[4]);
    uart_send_string("\r\n");

    uart_send_string("Sample Rate:   ");
    uart_send_hex(config[5]);
    uart_send_string(" Hz\r\n");

    uart_send_string("TX Interval:   ");
    uart_send_hex(config[6]);
    uart_send_string(" sec\r\n");

    uart_send_string("Uptime:        ");
    uart_send_hex(get_systick_ms() / 1000);
    uart_send_string(" sec\r\n");

    /* Explicitly do NOT print: encryption keys, network credentials, auth tokens */
    uart_send_string("(Sensitive fields redacted)\r\n");
    uart_send_string("============================\r\n");

    g_diag_session.last_activity_ms = get_systick_ms();
    audit_log_command("get_config", 0);
}

static void cmd_get_status(void)
{
    if (g_diag_session.state != DIAG_STATE_AUTHENTICATED) {
        uart_send_string("[DENIED] Authentication required\r\n");
        return;
    }

    uart_send_string("=== System Status ===\r\n");

    uart_send_string("Debugger attached: ");
    uart_send_string(security_detect_debugger() ? "YES (WARNING)" : "No");
    uart_send_string("\r\n");

    uart_send_string("Session commands:  ");
    uart_send_hex(g_diag_session.command_count);
    uart_send_string("\r\n");

    uart_send_string("Audit log entries: ");
    uart_send_hex(g_audit_index);
    uart_send_string("\r\n");

#ifdef BUILD_PRODUCTION
    uart_send_string("Build:             PRODUCTION\r\n");
#else
    uart_send_string("Build:             DEVELOPMENT\r\n");
#endif

    uart_send_string("Flash protection:  ");
    uint8_t rdp = (uint8_t)((FLASH_OPTCR >> 8) & 0xFF);
    if (rdp == 0xAA) uart_send_string("Level 0 (NONE)");
    else if (rdp == 0xCC) uart_send_string("Level 2 (PERMANENT)");
    else uart_send_string("Level 1");
    uart_send_string("\r\n");

    uart_send_string("=====================\r\n");

    g_diag_session.last_activity_ms = get_systick_ms();
    audit_log_command("get_status", 0);
}

static void cmd_view_audit_log(void)
{
    if (g_diag_session.state != DIAG_STATE_AUTHENTICATED) {
        uart_send_string("[DENIED] Authentication required\r\n");
        return;
    }

    uart_send_string("=== Audit Log ===\r\n");
    uart_send_string("Timestamp    CmdHash      Result\r\n");

    uint32_t start = (g_audit_index > AUDIT_LOG_SIZE) ?
                     (g_audit_index - AUDIT_LOG_SIZE) : 0;
    uint32_t end = g_audit_index;

    for (uint32_t i = start; i < end; i++) {
        uint32_t idx = i % AUDIT_LOG_SIZE;
        uart_send_hex(g_audit_log[idx].timestamp_ms);
        uart_send_string(" ");
        uart_send_hex(g_audit_log[idx].command_hash);
        uart_send_string(" ");
        switch (g_audit_log[idx].result) {
            case 0: uart_send_string("OK"); break;
            case 1: uart_send_string("DENIED"); break;
            case 2: uart_send_string("ERROR"); break;
            default: uart_send_string("???"); break;
        }
        uart_send_string("\r\n");
    }

    uart_send_string("=================\r\n");
    g_diag_session.last_activity_ms = get_systick_ms();
    audit_log_command("view_audit", 0);
}

static void cmd_logout(void)
{
    /* Clear session state */
    memset(g_diag_session.challenge, 0, sizeof(g_diag_session.challenge));
    g_diag_session.state = DIAG_STATE_LOCKED;
    g_diag_session.command_count = 0;
    uart_send_string("[OK] Session terminated\r\n");
    audit_log_command("logout", 0);
}

static void cmd_help(void)
{
    uart_send_string("\r\n=== Secure Diagnostic Console ===\r\n");
    uart_send_string("Authentication:\r\n");
    uart_send_string("  auth                    - Begin authentication\r\n");
    uart_send_string("  auth_response <hex>     - Submit HMAC response\r\n");
    uart_send_string("  logout                  - End session\r\n");
    uart_send_string("\r\nDiagnostic Commands (require auth):\r\n");
    uart_send_string("  dump_memory <addr> <sz> - Dump memory (restricted regions)\r\n");
    uart_send_string("  read_flash <sector>     - Read flash sector (config only)\r\n");
    uart_send_string("  get_config              - Show device configuration\r\n");
    uart_send_string("  get_status              - Show system status\r\n");
    uart_send_string("  view_audit              - View audit log\r\n");
    uart_send_string("  help                    - Show this help\r\n");
    uart_send_string("=================================\r\n\r\n");
}

/* ============================================================
 * Command Parser and Dispatcher
 * ============================================================ */

static void diag_execute_command(const char *cmd)
{
    /* Rate limiting */
    uint32_t now = get_systick_ms();
    if (now - g_diag_session.last_cmd_ms < DIAG_RATE_LIMIT_MS) {
        uart_send_string("[RATE LIMITED] Please wait\r\n");
        return;
    }
    g_diag_session.last_cmd_ms = now;
    g_diag_session.command_count++;

    /* Skip leading whitespace */
    while (*cmd == ' ') cmd++;

    /* Empty command */
    if (*cmd == '\0') return;

    /* Commands available without authentication */
    if (strcmp(cmd, "help") == 0 || strcmp(cmd, "?") == 0) {
        cmd_help();
        return;
    }

    if (strcmp(cmd, "auth") == 0) {
        cmd_auth_begin();
        return;
    }

    if (strncmp(cmd, "auth_response ", 14) == 0) {
        cmd_auth_response(cmd + 14);
        return;
    }

    if (strcmp(cmd, "logout") == 0) {
        cmd_logout();
        return;
    }

    /* All remaining commands require authentication */
    if (g_diag_session.state != DIAG_STATE_AUTHENTICATED) {
        uart_send_string("[DENIED] Please authenticate first. Type 'auth' to begin.\r\n");
        audit_log_command(cmd, 1);
        return;
    }

    /* Authenticated commands */
    if (strncmp(cmd, "dump_memory ", 12) == 0) {
        cmd_dump_memory(cmd + 12);
    } else if (strncmp(cmd, "dump_memory", 11) == 0) {
        uart_send_string("Usage: dump_memory <hex_addr> <size>\r\n");
        uart_send_string("Example: dump_memory 0x20004000 64\r\n");
    } else if (strncmp(cmd, "read_flash ", 11) == 0) {
        cmd_read_flash(cmd + 11);
    } else if (strncmp(cmd, "read_flash", 10) == 0) {
        uart_send_string("Usage: read_flash <sector_number>\r\n");
        uart_send_string("Only sector 7 (config) is accessible\r\n");
    } else if (strcmp(cmd, "get_config") == 0) {
        cmd_get_config();
    } else if (strcmp(cmd, "get_status") == 0) {
        cmd_get_status();
    } else if (strcmp(cmd, "view_audit") == 0) {
        cmd_view_audit_log();
    } else {
        uart_send_string("[ERROR] Unknown command: ");
        uart_send_string(cmd);
        uart_send_string("\r\nType 'help' for available commands\r\n");
        audit_log_command(cmd, 2);
    }
}

/* ============================================================
 * Session Timeout Management
 * ============================================================ */

static void diag_check_timeouts(void)
{
    if (g_diag_session.state == DIAG_STATE_AUTHENTICATED) {
        uint32_t now = get_systick_ms();

        /* Session timeout */
        if (now - g_diag_session.session_start_ms > DIAG_SESSION_TIMEOUT_MS) {
            uart_send_string("\r\n[TIMEOUT] Session expired. Please re-authenticate.\r\n");
            cmd_logout();
            return;
        }

        /* Inactivity timeout (2 minutes) */
        if (now - g_diag_session.last_activity_ms > 120000) {
            uart_send_string("\r\n[TIMEOUT] Inactivity timeout. Session closed.\r\n");
            cmd_logout();
            return;
        }
    }

    /* Challenge timeout - expire challenge after 60 seconds */
    if (g_diag_session.state == DIAG_STATE_CHALLENGE_SENT) {
        /* We don't track challenge send time separately, so use last_cmd_ms */
        if (get_systick_ms() - g_diag_session.last_cmd_ms > 60000) {
            uart_send_string("\r\n[TIMEOUT] Challenge expired. Use 'auth' again.\r\n");
            memset(g_diag_session.challenge, 0, sizeof(g_diag_session.challenge));
            g_diag_session.state = DIAG_STATE_LOCKED;
        }
    }
}

/* ============================================================
 * Character Processing (Line Editor)
 * ============================================================ */

static void diag_process_char(char c)
{
    /* Handle backspace */
    if (c == '\b' || c == 0x7F) {
        if (g_diag_session.cmd_pos > 0) {
            g_diag_session.cmd_pos--;
            uart_send_string("\b \b");
        }
        return;
    }

    /* Handle enter */
    if (c == '\r' || c == '\n') {
        uart_send_string("\r\n");
        g_diag_session.cmd_buffer[g_diag_session.cmd_pos] = '\0';

        if (g_diag_session.cmd_pos > 0) {
            diag_execute_command(g_diag_session.cmd_buffer);
        }

        g_diag_session.cmd_pos = 0;
        memset(g_diag_session.cmd_buffer, 0, sizeof(g_diag_session.cmd_buffer));

        /* Print prompt */
        if (g_diag_session.state == DIAG_STATE_AUTHENTICATED) {
            uart_send_string("diag> ");
        } else {
            uart_send_string("locked> ");
        }
        return;
    }

    /* Handle Ctrl+C */
    if (c == 0x03) {
        uart_send_string("\r\n");
        g_diag_session.cmd_pos = 0;
        memset(g_diag_session.cmd_buffer, 0, sizeof(g_diag_session.cmd_buffer));
        if (g_diag_session.state == DIAG_STATE_AUTHENTICATED) {
            uart_send_string("diag> ");
        } else {
            uart_send_string("locked> ");
        }
        return;
    }

    /* Only accept printable ASCII */
    if (c < 0x20 || c > 0x7E) {
        return;
    }

    /* Buffer the character */
    if (g_diag_session.cmd_pos < DIAG_MAX_CMD_LEN - 1) {
        g_diag_session.cmd_buffer[g_diag_session.cmd_pos++] = c;
        uart_send_char(c);
    }
}

/* ============================================================
 * Initialization
 * ============================================================ */

static void diag_init(void)
{
    /* Clear session state */
    memset(&g_diag_session, 0, sizeof(g_diag_session));
    g_diag_session.state = DIAG_STATE_LOCKED;

    /* Clear audit log */
    memset(g_audit_log, 0, sizeof(g_audit_log));
    g_audit_index = 0;

    /* Initialize UART */
    uart_init();

    /* CRITICAL: Disable JTAG/SWD in production */
    security_disable_jtag();

    /* Check for debugger attachment */
    security_anti_tamper_check();

    /* Print banner */
    uart_send_string("\r\n");
    uart_send_string("========================================\r\n");
    uart_send_string("  Industrial IoT Sensor - Diagnostic Console\r\n");
#ifdef BUILD_PRODUCTION
    uart_send_string("  BUILD: PRODUCTION (Secured)\r\n");
#else
    uart_send_string("  BUILD: DEVELOPMENT (Debug Enabled)\r\n");
#endif
    uart_send_string("  Authentication required for all commands\r\n");
    uart_send_string("  Type 'help' for available commands\r\n");
    uart_send_string("  Type 'auth' to begin authentication\r\n");
    uart_send_string("========================================\r\n");
    uart_send_string("locked> ");

    audit_log_command("SYSTEM_BOOT", 0);
}

/* ============================================================
 * Main Diagnostic Task
 * Call this from your main loop or RTOS task
 * ============================================================ */

void diag_task(void)
{
    /* Check for session timeouts */
    diag_check_timeouts();

    /* Periodic anti-tamper check */
    static uint32_t last_tamper_check = 0;
    if (get_systick_ms() - last_tamper_check > 10000) { /* Every 10 seconds */
        security_anti_tamper_check();
        last_tamper_check = get_systick_ms();
    }

    /* Process incoming characters */
    if (uart_rx_available()) {
        char c = uart_read_char();
        diag_process_char(c);
    }
}

/* ============================================================
 * Main Entry Point
 * ============================================================ */

int main(void)
{
    /* System clock configuration would go here */
    /* SysTick configuration: 1ms tick */
    /* Configure SysTick for 1ms interrupts */

    /* Initialize diagnostic console */
    diag_init();

    /* Main loop */
    while (1) {
        /* Run diagnostic console task */
        diag_task();

        /* Your other application tasks here */
        /* sensor_task(); */
        /* network_task(); */
        /* watchdog_kick(); */
    }

    return 0;
}