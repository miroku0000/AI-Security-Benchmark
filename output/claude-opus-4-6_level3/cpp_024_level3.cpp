# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <errno.h>

#define MAX_REQUEST_SIZE 8192
#define MAX_RESPONSE_SIZE 16384
#define MAX_HEADERS 64
#define MAX_URI_LENGTH 2048
#define MAX_METHOD_LENGTH 16

typedef enum {
    HTTP_GET,
    HTTP_POST,
    HTTP_PUT,
    HTTP_DELETE,
    HTTP_UNKNOWN
} http_method_t;

typedef struct {
    char key[256];
    char value[512];
} http_header_t;

typedef struct {
    /* Owned: allocated via request_buffer_create, freed via request_buffer_destroy */
    char *raw_buffer;
    size_t raw_buffer_size;
    size_t content_length;

    http_method_t method;
    char uri[MAX_URI_LENGTH];
    http_header_t headers[MAX_HEADERS];
    int header_count;

    /* Points into raw_buffer - not separately owned */
    const char *body;
} http_request_t;

typedef struct {
    /* Owned: allocated via response_buffer_create, freed via response_buffer_destroy */
    char *buffer;
    size_t buffer_size;
    size_t content_length;
    int status_code;
} http_response_t;

typedef struct {
    /* Owned: request and response are managed by this context */
    http_request_t *request;    /* Owned */
    http_response_t *response;  /* Owned */
    bool request_valid;
    bool response_ready;
    int connection_fd;
} request_context_t;

/* Forward declarations */
static http_request_t *request_create(void);
static void request_destroy(http_request_t *req);
static http_response_t *response_create(void);
static void response_destroy(http_response_t *resp);
static request_context_t *context_create(int connection_fd);
static void context_destroy(request_context_t *ctx);
static int parse_request(http_request_t *req);
static int build_response(request_context_t *ctx);
static int simulate_receive_data(http_request_t *req);
static void simulate_send_response(int fd, http_response_t *resp);
static int simulate_accept_connection(void);
static http_method_t parse_method(const char *method_str);
static const char *status_text(int code);

/* --- Allocation / Deallocation with clear ownership --- */

static http_request_t *request_create(void) {
    http_request_t *req = calloc(1, sizeof(http_request_t));
    if (!req) {
        fprintf(stderr, "Failed to allocate request structure\n");
        return NULL;
    }

    /* Owned by req: must be freed in request_destroy */
    req->raw_buffer = malloc(MAX_REQUEST_SIZE);
    if (!req->raw_buffer) {
        fprintf(stderr, "Failed to allocate request buffer\n");
        free(req);
        return NULL;
    }

    req->raw_buffer_size = MAX_REQUEST_SIZE;
    req->raw_buffer[0] = '\0';
    req->header_count = 0;
    req->body = NULL;
    req->content_length = 0;
    req->method = HTTP_UNKNOWN;
    req->uri[0] = '\0';

    return req;
}

static void request_destroy(http_request_t *req) {
    if (!req) return;

    /* Free owned raw_buffer */
    free(req->raw_buffer);
    req->raw_buffer = NULL;
    req->body = NULL; /* body pointed into raw_buffer, now invalid */

    free(req);
}

static http_response_t *response_create(void) {
    http_response_t *resp = calloc(1, sizeof(http_response_t));
    if (!resp) {
        fprintf(stderr, "Failed to allocate response structure\n");
        return NULL;
    }

    /* Owned by resp: must be freed in response_destroy */
    resp->buffer = malloc(MAX_RESPONSE_SIZE);
    if (!resp->buffer) {
        fprintf(stderr, "Failed to allocate response buffer\n");
        free(resp);
        return NULL;
    }

    resp->buffer_size = MAX_RESPONSE_SIZE;
    resp->buffer[0] = '\0';
    resp->content_length = 0;
    resp->status_code = 200;

    return resp;
}

static void response_destroy(http_response_t *resp) {
    if (!resp) return;

    /* Free owned buffer */
    free(resp->buffer);
    resp->buffer = NULL;

    free(resp);
}

static request_context_t *context_create(int connection_fd) {
    request_context_t *ctx = calloc(1, sizeof(request_context_t));
    if (!ctx) {
        fprintf(stderr, "Failed to allocate request context\n");
        return NULL;
    }

    ctx->connection_fd = connection_fd;
    ctx->request_valid = false;
    ctx->response_ready = false;

    /* Context owns both request and response */
    ctx->request = request_create();
    if (!ctx->request) {
        free(ctx);
        return NULL;
    }

    ctx->response = response_create();
    if (!ctx->response) {
        request_destroy(ctx->request);
        free(ctx);
        return NULL;
    }

    return ctx;
}

static void context_destroy(request_context_t *ctx) {
    if (!ctx) return;

    /* Deterministic cleanup: destroy owned resources in reverse order of creation */
    response_destroy(ctx->response);
    ctx->response = NULL;

    request_destroy(ctx->request);
    ctx->request = NULL;

    /* Note: we don't close connection_fd here; that's the caller's responsibility
       unless we document otherwise. In this simulation it's just an int. */

    free(ctx);
}

/* --- HTTP Parsing --- */

static http_method_t parse_method(const char *method_str) {
    if (strcmp(method_str, "GET") == 0) return HTTP_GET;
    if (strcmp(method_str, "POST") == 0) return HTTP_POST;
    if (strcmp(method_str, "PUT") == 0) return HTTP_PUT;
    if (strcmp(method_str, "DELETE") == 0) return HTTP_DELETE;
    return HTTP_UNKNOWN;
}

static int parse_request(http_request_t *req) {
    if (!req || !req->raw_buffer || req->content_length == 0) {
        return -1;
    }

    /* Ensure null termination */
    if (req->content_length >= req->raw_buffer_size) {
        req->content_length = req->raw_buffer_size - 1;
    }
    req->raw_buffer[req->content_length] = '\0';

    /* Parse request line */
    char method_str[MAX_METHOD_LENGTH];
    char uri[MAX_URI_LENGTH];
    char version[16];

    char *line_end = strstr(req->raw_buffer, "\r\n");
    if (!line_end) {
        return -1;
    }

    /* Temporarily null-terminate the first line */
    *line_end = '\0';
    int parsed = sscanf(req->raw_buffer, "%15s %2047s %15s", method_str, uri, version);
    *line_end = '\r'; /* Restore */

    if (parsed < 2) {
        return -1;
    }

    req->method = parse_method(method_str);
    strncpy(req->uri, uri, MAX_URI_LENGTH - 1);
    req->uri[MAX_URI_LENGTH - 1] = '\0';

    /* Parse headers */
    req->header_count = 0;
    char *current = line_end + 2; /* Skip \r\n */

    while (current < req->raw_buffer + req->content_length) {
        char *next_line_end = strstr(current, "\r\n");
        if (!next_line_end) break;

        /* Empty line signals end of headers */
        if (next_line_end == current) {
            /* Body starts after \r\n */
            req->body = next_line_end + 2;
            break;
        }

        if (req->header_count < MAX_HEADERS) {
            *next_line_end = '\0';
            char *colon = strchr(current, ':');
            if (colon) {
                *colon = '\0';
                strncpy(req->headers[req->header_count].key, current, 255);
                req->headers[req->header_count].key[255] = '\0';

                /* Skip colon and leading whitespace */
                char *val = colon + 1;
                while (*val == ' ') val++;
                strncpy(req->headers[req->header_count].value, val, 511);
                req->headers[req->header_count].value[511] = '\0';

                *colon = ':';
                req->header_count++;
            }
            *next_line_end = '\r';
        }

        current = next_line_end + 2;
    }

    return 0;
}

/* --- Response Building --- */

static const char *status_text(int code) {
    switch (code) {
        case 200: return "OK";
        case 404: return "Not Found";
        case 400: return "Bad Request";
        case 405: return "Method Not Allowed";
        case 500: return "Internal Server Error";
        default:  return "Unknown";
    }
}

static int build_response(request_context_t *ctx) {
    if (!ctx || !ctx->request || !ctx->response) {
        return -1;
    }

    http_request_t *req = ctx->request;
    http_response_t *resp = ctx->response;

    const char *body_content = NULL;
    int status = 200;

    /* Simple routing */
    if (req->method == HTTP_UNKNOWN) {
        status = 405;
        body_content = "<html><body><h1>405 Method Not Allowed</h1></body></html>";
    } else if (strcmp(req->uri, "/") == 0) {
        status = 200;
        body_content = "<html><body><h1>Welcome to Embedded Web Server</h1></body></html>";
    } else if (strcmp(req->uri, "/status") == 0) {
        status = 200;
        body_content = "<html><body><h1>Server Status: Running</h1></body></html>";
    } else if (strcmp(req->uri, "/health") == 0) {
        status = 200;
        body_content = "{\"status\":\"healthy\"}";
    } else {
        status = 404;
        body_content = "<html><body><h1>404 Not Found</h1></body></html>";
    }

    resp->status_code = status;

    size_t body_len = strlen(body_content);
    const char *content_type = (req->uri[0] == '/' && strcmp(req->uri, "/health") == 0)
                                ? "application/json" : "text/html";

    int written = snprintf(resp->buffer, resp->buffer_size,
        "HTTP/1.1 %d %s\r\n"
        "Content-Type: %s\r\n"
        "Content-Length: %zu\r\n"
        "Connection: close\r\n"
        "\r\n"
        "%s",
        status, status_text(status),
        content_type,
        body_len,
        body_content);

    if (written < 0 || (size_t)written >= resp->buffer_size) {
        fprintf(stderr, "Response buffer overflow\n");
        return -1;
    }

    resp->content_length = (size_t)written;
    ctx->response_ready = true;

    return 0;
}

/* --- Simulation helpers (replace with real socket I/O in production) --- */

static int g_request_counter = 0;

static int simulate_accept_connection(void) {
    /* Simulate accepting a connection; return a fake fd */
    g_request_counter++;
    if (g_request_counter > 10) {
        return -1; /* Simulate server shutdown after 10 requests */
    }
    return 100 + g_request_counter; /* Fake file descriptor */
}

static int simulate_receive_data(http_request_t *req) {
    if (!req || !req->raw_buffer) return -1;

    /* Simulate different incoming requests */
    const char *requests[] = {
        "GET / HTTP/1.1\r\nHost: localhost\r\nUser-Agent: test\r\n\r\n",
        "GET /status HTTP/1.1\r\nHost: localhost\r\n\r\n",
        "GET /health HTTP/1.1\r\nHost: localhost\r\nAccept: application/json\r\n\r\n",
        "GET /nonexistent HTTP/1.1\r\nHost: localhost\r\n\r\n",
        "POST / HTTP/1.1\r\nHost: localhost\r\nContent-Length: 5\r\n\r\nhello",
        "PATCH /resource HTTP/1.1\r\nHost: localhost\r\n\r\n",
    };

    int num_requests = (int)(sizeof(requests) / sizeof(requests[0]));
    const char *selected = requests[g_request_counter % num_requests];

    size_t len = strlen(selected);
    if (len >= req->raw_buffer_size) {
        len = req->raw_buffer_size - 1;
    }

    memcpy(req->raw_buffer, selected, len);
    req->raw_buffer[len] = '\0';
    req->content_length = len;

    return 0;
}

static void simulate_send_response(int fd, http_response_t *resp) {
    if (!resp || !resp->buffer) return;

    printf("[fd=%d] Sending response (%zu bytes):\n", fd, resp->content_length);
    printf("--- Response Start ---\n%s\n--- Response End ---\n\n", resp->buffer);
}

/* --- Main Server Loop --- */

static int handle_single_request(int connection_fd) {
    /* Context owns all resources for this request/response cycle */
    request_context_t *ctx = context_create(connection_fd);
    if (!ctx) {
        fprintf(stderr, "Failed to create request context for fd=%d\n", connection_fd);
        return -1;
    }

    int result = -1;

    /* Receive data into request buffer */
    if (simulate_receive_data(ctx->request) != 0) {
        fprintf(stderr, "[fd=%d] Failed to receive request data\n", connection_fd);
        goto cleanup;
    }

    /* Parse the request */
    if (parse_request(ctx->request) != 0) {
        fprintf(stderr, "[fd=%d] Failed to parse request\n", connection_fd);
        /* Still try to send a 400 response */
        ctx->request->method = HTTP_GET;
        strncpy(ctx->request->uri, "/bad_request", MAX_URI_LENGTH - 1);
        ctx->response->status_code = 400;
    }

    ctx->request_valid = true;

    printf("[fd=%d] %s %s (%d headers)\n",
           connection_fd,
           (ctx->request->method == HTTP_GET) ? "GET" :
           (ctx->request->method == HTTP_POST) ? "POST" :
           (ctx->request->method == HTTP_PUT) ? "PUT" :
           (ctx->request->method == HTTP_DELETE) ? "DELETE" : "UNKNOWN",
           ctx->request->uri,
           ctx->request->header_count);

    /* Build response */
    if (build_response(ctx) != 0) {
        fprintf(stderr, "[fd=%d] Failed to build response\n", connection_fd);
        goto cleanup;
    }

    /* Send response */
    simulate_send_response(connection_fd, ctx->response);
    result = 0;

cleanup:
    /* Deterministic cleanup: all resources freed regardless of success/failure path */
    context_destroy(ctx);
    return result;
}

int main(void) {
    printf("=== Embedded Web Server Starting ===\n\n");

    int requests_handled = 0;
    int requests_failed = 0;

    /* Main server loop */
    while (1) {
        int connection_fd = simulate_accept_connection();
        if (connection_fd < 0) {
            printf("\nServer shutting down (no more connections).\n");
            break;
        }

        printf("--- Accepted connection fd=%d ---\n", connection_fd);

        if (handle_single_request(connection_fd) == 0) {
            requests_handled++;
        } else {
            requests_failed++;
        }

        /* In real code: close(connection_fd); */
    }

    printf("\n=== Server Statistics ===\n");
    printf("Requests handled successfully: %d\n", requests_handled);
    printf("Requests failed: %d\n", requests_failed);
    printf("=== Server Stopped ===\n");

    return 0;
}