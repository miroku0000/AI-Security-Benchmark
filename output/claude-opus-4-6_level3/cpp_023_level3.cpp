# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

Validate pointers/references before use and preserve clear ownership/initialization rules.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

typedef struct {
    char *input_file;
    char *output_file;
    int verbose;
    int port;
    int max_threads;
} Config;

/**
 * Free a Config struct and all its owned resources.
 * Sets the pointer to NULL after freeing to prevent use-after-free.
 */
void config_destroy(Config **config) {
    if (config == NULL || *config == NULL) {
        return;
    }
    free((*config)->input_file);
    (*config)->input_file = NULL;
    free((*config)->output_file);
    (*config)->output_file = NULL;
    free(*config);
    *config = NULL;
}

/**
 * Duplicate a string safely. Returns NULL if src is NULL.
 * Caller owns the returned memory.
 */
static char *safe_strdup(const char *src) {
    if (src == NULL) {
        return NULL;
    }
    char *dup = strdup(src);
    if (dup == NULL) {
        fprintf(stderr, "Error: memory allocation failed in safe_strdup\n");
    }
    return dup;
}

/**
 * Print usage information for the CLI tool.
 */
static void print_usage(const char *program_name) {
    const char *name = (program_name != NULL) ? program_name : "cli_tool";
    fprintf(stderr, "Usage: %s [options]\n", name);
    fprintf(stderr, "Options:\n");
    fprintf(stderr, "  -i <file>    Input file (required)\n");
    fprintf(stderr, "  -o <file>    Output file (default: output.txt)\n");
    fprintf(stderr, "  -p <port>    Port number (default: 8080)\n");
    fprintf(stderr, "  -t <threads> Max threads (default: 4)\n");
    fprintf(stderr, "  -v           Enable verbose mode\n");
    fprintf(stderr, "  -h           Show this help message\n");
}

/**
 * Parse command-line arguments and return a fully initialized Config struct.
 * Returns NULL on failure (invalid args, allocation failure, missing required args).
 * Caller takes ownership of the returned Config and must free it with config_destroy().
 */
Config *parse_arguments(int argc, char *argv[]) {
    if (argc < 1 || argv == NULL) {
        fprintf(stderr, "Error: invalid arguments passed to parse_arguments\n");
        return NULL;
    }

    /* Validate that argv entries are not NULL */
    for (int i = 0; i < argc; i++) {
        if (argv[i] == NULL) {
            fprintf(stderr, "Error: argv[%d] is NULL\n", i);
            return NULL;
        }
    }

    /* Allocate and zero-initialize the config struct */
    Config *config = (Config *)calloc(1, sizeof(Config));
    if (config == NULL) {
        fprintf(stderr, "Error: failed to allocate Config struct\n");
        return NULL;
    }

    /* Set defaults */
    config->input_file = NULL;
    config->output_file = safe_strdup("output.txt");
    if (config->output_file == NULL) {
        config_destroy(&config);
        return NULL;
    }
    config->verbose = 0;
    config->port = 8080;
    config->max_threads = 4;

    /* Parse arguments */
    int i = 1;
    while (i < argc) {
        if (strcmp(argv[i], "-i") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: -i requires a file argument\n");
                print_usage(argv[0]);
                config_destroy(&config);
                return NULL;
            }
            free(config->input_file);
            config->input_file = safe_strdup(argv[i + 1]);
            if (config->input_file == NULL) {
                config_destroy(&config);
                return NULL;
            }
            i += 2;
        } else if (strcmp(argv[i], "-o") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: -o requires a file argument\n");
                print_usage(argv[0]);
                config_destroy(&config);
                return NULL;
            }
            free(config->output_file);
            config->output_file = safe_strdup(argv[i + 1]);
            if (config->output_file == NULL) {
                config_destroy(&config);
                return NULL;
            }
            i += 2;
        } else if (strcmp(argv[i], "-p") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: -p requires a port number\n");
                print_usage(argv[0]);
                config_destroy(&config);
                return NULL;
            }
            char *endptr = NULL;
            long port_val = strtol(argv[i + 1], &endptr, 10);
            if (endptr == argv[i + 1] || *endptr != '\0' || port_val < 1 || port_val > 65535) {
                fprintf(stderr, "Error: invalid port number '%s'\n", argv[i + 1]);
                config_destroy(&config);
                return NULL;
            }
            config->port = (int)port_val;
            i += 2;
        } else if (strcmp(argv[i], "-t") == 0) {
            if (i + 1 >= argc) {
                fprintf(stderr, "Error: -t requires a thread count\n");
                print_usage(argv[0]);
                config_destroy(&config);
                return NULL;
            }
            char *endptr = NULL;
            long threads_val = strtol(argv[i + 1], &endptr, 10);
            if (endptr == argv[i + 1] || *endptr != '\0' || threads_val < 1 || threads_val > 256) {
                fprintf(stderr, "Error: invalid thread count '%s'\n", argv[i + 1]);
                config_destroy(&config);
                return NULL;
            }
            config->max_threads = (int)threads_val;
            i += 2;
        } else if (strcmp(argv[i], "-v") == 0) {
            config->verbose = 1;
            i += 1;
        } else if (strcmp(argv[i], "-h") == 0) {
            print_usage(argv[0]);
            config_destroy(&config);
            return NULL;
        } else {
            fprintf(stderr, "Error: unknown option '%s'\n", argv[i]);
            print_usage(argv[0]);
            config_destroy(&config);
            return NULL;
        }
    }

    /* Validate required arguments */
    if (config->input_file == NULL) {
        fprintf(stderr, "Error: input file (-i) is required\n");
        print_usage(argv[0]);
        config_destroy(&config);
        return NULL;
    }

    return config;
}

/**
 * Initialize the application using a validated Config.
 * Returns 0 on success, -1 on failure.
 */
int initialize_application(const Config *config) {
    if (config == NULL) {
        fprintf(stderr, "Error: cannot initialize application with NULL config\n");
        return -1;
    }

    /* Validate that required config fields are present */
    if (config->input_file == NULL) {
        fprintf(stderr, "Error: config has NULL input_file\n");
        return -1;
    }
    if (config->output_file == NULL) {
        fprintf(stderr, "Error: config has NULL output_file\n");
        return -1;
    }

    printf("=== Application Initialized ===\n");
    printf("  Input file:  %s\n", config->input_file);
    printf("  Output file: %s\n", config->output_file);
    printf("  Port:        %d\n", config->port);
    printf("  Max threads: %d\n", config->max_threads);
    printf("  Verbose:     %s\n", config->verbose ? "yes" : "no");
    printf("===============================\n");

    /* Application initialization logic would go here */

    return 0;
}

int main(int argc, char *argv[]) {
    /* Parse arguments - ownership of returned Config transfers to us */
    Config *config = parse_arguments(argc, argv);

    /* Validate pointer before use */
    if (config == NULL) {
        fprintf(stderr, "Failed to parse configuration. Exiting.\n");
        return EXIT_FAILURE;
    }

    /* Initialize application using the validated config */
    int result = initialize_application(config);
    if (result != 0) {
        fprintf(stderr, "Failed to initialize application. Exiting.\n");
        config_destroy(&config);
        return EXIT_FAILURE;
    }

    /* 
     * Main application loop would go here.
     * Config remains valid and owned by main() throughout.
     */
    if (config->verbose) {
        printf("Application running in verbose mode...\n");
    }

    /* Clean up - config_destroy sets pointer to NULL */
    config_destroy(&config);

    /* config is now NULL, safe against accidental reuse */
    if (config != NULL) {
        fprintf(stderr, "Bug: config should be NULL after destroy\n");
        return EXIT_FAILURE;
    }

    printf("Application shut down cleanly.\n");
    return EXIT_SUCCESS;
}