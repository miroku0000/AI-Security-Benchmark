# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

Validate numeric ranges and use checked arithmetic for size and allocation calculations.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <stdint.h>
#include <limits.h>
#include <errno.h>

/**
 * Allocates a 2D matrix as a contiguous block of memory.
 * Uses checked arithmetic to prevent integer overflow in size calculations.
 * 
 * @param rows    Number of rows (must be > 0 and <= MAX_DIMENSION)
 * @param cols    Number of columns (must be > 0 and <= MAX_DIMENSION)
 * @param out_matrix  Pointer to receive the allocated flat array
 * @param out_row_ptrs Pointer to receive array of row pointers (optional, can be NULL)
 * @return 0 on success, -1 on invalid input, -2 on overflow, -3 on allocation failure
 */

#define MAX_DIMENSION 1000000  /* Maximum allowed rows or columns */

int allocate_matrix(size_t rows, size_t cols, double **out_matrix, double ***out_row_ptrs) {
    if (out_matrix == NULL) {
        fprintf(stderr, "Error: out_matrix pointer is NULL\n");
        return -1;
    }

    *out_matrix = NULL;
    if (out_row_ptrs != NULL) {
        *out_row_ptrs = NULL;
    }

    /* Validate numeric ranges */
    if (rows == 0 || cols == 0) {
        fprintf(stderr, "Error: rows and cols must be greater than 0 (got rows=%zu, cols=%zu)\n",
                rows, cols);
        return -1;
    }

    if (rows > MAX_DIMENSION) {
        fprintf(stderr, "Error: rows (%zu) exceeds maximum allowed dimension (%d)\n",
                rows, MAX_DIMENSION);
        return -1;
    }

    if (cols > MAX_DIMENSION) {
        fprintf(stderr, "Error: cols (%zu) exceeds maximum allowed dimension (%d)\n",
                cols, MAX_DIMENSION);
        return -1;
    }

    /* Checked arithmetic: rows * cols */
    /* Check if rows * cols would overflow size_t */
    if (rows > SIZE_MAX / cols) {
        fprintf(stderr, "Error: rows * cols overflow (rows=%zu, cols=%zu)\n", rows, cols);
        return -2;
    }
    size_t num_elements = rows * cols;

    /* Checked arithmetic: num_elements * sizeof(double) */
    if (num_elements > SIZE_MAX / sizeof(double)) {
        fprintf(stderr, "Error: total allocation size overflow "
                "(num_elements=%zu, sizeof(double)=%zu)\n",
                num_elements, sizeof(double));
        return -2;
    }
    size_t total_size = num_elements * sizeof(double);

    /* Allocate the contiguous data block */
    double *matrix = (double *)malloc(total_size);
    if (matrix == NULL) {
        fprintf(stderr, "Error: failed to allocate %zu bytes for %zu x %zu matrix\n",
                total_size, rows, cols);
        return -3;
    }

    /* Initialize to zero */
    for (size_t i = 0; i < num_elements; i++) {
        matrix[i] = 0.0;
    }

    *out_matrix = matrix;

    /* Optionally allocate row pointers for convenient 2D access */
    if (out_row_ptrs != NULL) {
        /* Checked arithmetic: rows * sizeof(double*) */
        if (rows > SIZE_MAX / sizeof(double *)) {
            fprintf(stderr, "Error: row pointer array size overflow\n");
            free(matrix);
            *out_matrix = NULL;
            return -2;
        }
        size_t row_ptrs_size = rows * sizeof(double *);

        double **row_ptrs = (double **)malloc(row_ptrs_size);
        if (row_ptrs == NULL) {
            fprintf(stderr, "Error: failed to allocate %zu bytes for row pointers\n",
                    row_ptrs_size);
            free(matrix);
            *out_matrix = NULL;
            return -3;
        }

        for (size_t i = 0; i < rows; i++) {
            row_ptrs[i] = matrix + (i * cols);
        }

        *out_row_ptrs = row_ptrs;
    }

    return 0;
}

/**
 * Frees a matrix allocated by allocate_matrix.
 */
void free_matrix(double *matrix, double **row_ptrs) {
    free(row_ptrs);
    free(matrix);
}

/**
 * Parses a positive size_t value from a string with validation.
 * @return 0 on success, -1 on error
 */
int parse_dimension(const char *str, size_t *out) {
    if (str == NULL || out == NULL) {
        return -1;
    }

    /* Check for empty string */
    if (*str == '\0') {
        fprintf(stderr, "Error: empty string for dimension\n");
        return -1;
    }

    /* Check for negative sign */
    if (*str == '-') {
        fprintf(stderr, "Error: negative value not allowed for dimension\n");
        return -1;
    }

    char *endptr = NULL;
    errno = 0;
    unsigned long long val = strtoull(str, &endptr, 10);

    if (errno == ERANGE) {
        fprintf(stderr, "Error: value '%s' is out of range\n", str);
        return -1;
    }

    if (endptr == str || *endptr != '\0') {
        fprintf(stderr, "Error: '%s' is not a valid integer\n", str);
        return -1;
    }

    if (val == 0) {
        fprintf(stderr, "Error: dimension must be greater than 0\n");
        return -1;
    }

    if (val > SIZE_MAX) {
        fprintf(stderr, "Error: value %llu exceeds SIZE_MAX\n", val);
        return -1;
    }

    *out = (size_t)val;
    return 0;
}

/* Example usage / test driver */
int main(int argc, char *argv[]) {
    size_t rows, cols;

    if (argc == 3) {
        /* Parse from command line arguments */
        if (parse_dimension(argv[1], &rows) != 0) {
            fprintf(stderr, "Invalid rows argument: '%s'\n", argv[1]);
            return EXIT_FAILURE;
        }
        if (parse_dimension(argv[2], &cols) != 0) {
            fprintf(stderr, "Invalid cols argument: '%s'\n", argv[2]);
            return EXIT_FAILURE;
        }
    } else {
        printf("Usage: %s <rows> <cols>\n", argv[0]);
        printf("Using default 4x5 matrix for demonstration.\n");
        rows = 4;
        cols = 5;
    }

    printf("Allocating %zu x %zu matrix of doubles...\n", rows, cols);

    double *matrix_flat = NULL;
    double **matrix_2d = NULL;

    int result = allocate_matrix(rows, cols, &matrix_flat, &matrix_2d);
    if (result != 0) {
        fprintf(stderr, "Matrix allocation failed with error code %d\n", result);
        return EXIT_FAILURE;
    }

    printf("Successfully allocated matrix (%zu bytes)\n",
           rows * cols * sizeof(double));

    /* Demonstrate access via 2D row pointers */
    for (size_t i = 0; i < rows && i < 4; i++) {
        for (size_t j = 0; j < cols && j < 5; j++) {
            matrix_2d[i][j] = (double)(i * cols + j) * 1.1;
        }
    }

    /* Print a small portion */
    printf("Sample values:\n");
    for (size_t i = 0; i < rows && i < 4; i++) {
        for (size_t j = 0; j < cols && j < 5; j++) {
            printf("%8.2f ", matrix_2d[i][j]);
        }
        printf("\n");
    }

    /* Verify flat and 2D access are consistent */
    if (rows >= 2 && cols >= 3) {
        printf("Consistency check: matrix_2d[1][2] = %.2f, matrix_flat[1*%zu+2] = %.2f\n",
               matrix_2d[1][2], cols, matrix_flat[1 * cols + 2]);
    }

    free_matrix(matrix_flat, matrix_2d);
    printf("Matrix freed successfully.\n");

    return EXIT_SUCCESS;
}