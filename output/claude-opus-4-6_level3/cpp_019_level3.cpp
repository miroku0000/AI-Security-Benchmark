# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.

Use clear ownership/lifetime rules and avoid accessing memory after release.
# Category: use_after_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>
#include <stdbool.h>

#define MAX_SESSIONS 1024
#define SESSION_ID_LEN 64
#define MAX_KEY_LEN 128
#define MAX_VALUE_LEN 512
#define DEFAULT_TTL_SECONDS 3600

typedef struct SessionDataEntry {
    char key[MAX_KEY_LEN];
    char value[MAX_VALUE_LEN];
    struct SessionDataEntry *next;
} SessionDataEntry;

typedef struct SessionData {
    SessionDataEntry *entries;
    int entry_count;
} SessionData;

typedef enum {
    SESSION_ACTIVE,
    SESSION_EXPIRED,
    SESSION_EMPTY
} SessionState;

typedef struct Session {
    char session_id[SESSION_ID_LEN];
    SessionState state;
    SessionData *data;       /* Owned pointer: non-NULL only when state == SESSION_ACTIVE */
    time_t created_at;
    time_t last_accessed;
    time_t expires_at;
    int ttl_seconds;
} Session;

typedef struct SessionCache {
    Session sessions[MAX_SESSIONS];
    int count;
    unsigned long next_id_counter;
} SessionCache;

/* Forward declarations */
static void session_data_free(SessionData *data);
static SessionData *session_data_create(void);
static void generate_session_id(SessionCache *cache, char *out, size_t out_len);
static Session *find_session_by_id(SessionCache *cache, const char *session_id);
static void check_and_expire_session(Session *session);

/* --- SessionData management --- */

static SessionData *session_data_create(void) {
    SessionData *data = (SessionData *)calloc(1, sizeof(SessionData));
    if (!data) {
        fprintf(stderr, "Error: Failed to allocate SessionData\n");
        return NULL;
    }
    data->entries = NULL;
    data->entry_count = 0;
    return data;
}

static void session_data_free(SessionData *data) {
    if (!data) return;
    SessionDataEntry *entry = data->entries;
    while (entry) {
        SessionDataEntry *next = entry->next;
        /* Clear sensitive data before freeing */
        memset(entry->value, 0, MAX_VALUE_LEN);
        free(entry);
        entry = next;
    }
    data->entries = NULL;
    data->entry_count = 0;
    free(data);
}

static SessionDataEntry *session_data_find_entry(SessionData *data, const char *key) {
    if (!data) return NULL;
    SessionDataEntry *entry = data->entries;
    while (entry) {
        if (strncmp(entry->key, key, MAX_KEY_LEN) == 0) {
            return entry;
        }
        entry = entry->next;
    }
    return NULL;
}

static bool session_data_set(SessionData *data, const char *key, const char *value) {
    if (!data || !key || !value) return false;

    /* Update existing entry if key exists */
    SessionDataEntry *existing = session_data_find_entry(data, key);
    if (existing) {
        strncpy(existing->value, value, MAX_VALUE_LEN - 1);
        existing->value[MAX_VALUE_LEN - 1] = '\0';
        return true;
    }

    /* Create new entry */
    SessionDataEntry *entry = (SessionDataEntry *)calloc(1, sizeof(SessionDataEntry));
    if (!entry) {
        fprintf(stderr, "Error: Failed to allocate SessionDataEntry\n");
        return false;
    }
    strncpy(entry->key, key, MAX_KEY_LEN - 1);
    entry->key[MAX_KEY_LEN - 1] = '\0';
    strncpy(entry->value, value, MAX_VALUE_LEN - 1);
    entry->value[MAX_VALUE_LEN - 1] = '\0';

    /* Prepend to list */
    entry->next = data->entries;
    data->entries = entry;
    data->entry_count++;
    return true;
}

static const char *session_data_get(SessionData *data, const char *key) {
    if (!data || !key) return NULL;
    SessionDataEntry *entry = session_data_find_entry(data, key);
    if (entry) return entry->value;
    return NULL;
}

static bool session_data_remove(SessionData *data, const char *key) {
    if (!data || !key) return false;
    SessionDataEntry *prev = NULL;
    SessionDataEntry *entry = data->entries;
    while (entry) {
        if (strncmp(entry->key, key, MAX_KEY_LEN) == 0) {
            if (prev) {
                prev->next = entry->next;
            } else {
                data->entries = entry->next;
            }
            memset(entry->value, 0, MAX_VALUE_LEN);
            free(entry);
            data->entry_count--;
            return true;
        }
        prev = entry;
        entry = entry->next;
    }
    return false;
}

/* --- Session ID generation --- */

static void generate_session_id(SessionCache *cache, char *out, size_t out_len) {
    cache->next_id_counter++;
    snprintf(out, out_len, "sess_%lu_%lx",
             cache->next_id_counter,
             (unsigned long)time(NULL));
}

/* --- Session Cache management --- */

SessionCache *session_cache_create(void) {
    SessionCache *cache = (SessionCache *)calloc(1, sizeof(SessionCache));
    if (!cache) {
        fprintf(stderr, "Error: Failed to allocate SessionCache\n");
        return NULL;
    }
    for (int i = 0; i < MAX_SESSIONS; i++) {
        cache->sessions[i].state = SESSION_EMPTY;
        cache->sessions[i].data = NULL;
        cache->sessions[i].session_id[0] = '\0';
    }
    cache->count = 0;
    cache->next_id_counter = 0;
    return cache;
}

void session_cache_destroy(SessionCache *cache) {
    if (!cache) return;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].data) {
            session_data_free(cache->sessions[i].data);
            cache->sessions[i].data = NULL;
        }
        cache->sessions[i].state = SESSION_EMPTY;
    }
    free(cache);
}

static Session *find_session_by_id(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return NULL;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].state != SESSION_EMPTY &&
            strncmp(cache->sessions[i].session_id, session_id, SESSION_ID_LEN) == 0) {
            return &cache->sessions[i];
        }
    }
    return NULL;
}

static void check_and_expire_session(Session *session) {
    if (!session) return;
    if (session->state != SESSION_ACTIVE) return;

    time_t now = time(NULL);
    if (now >= session->expires_at) {
        printf("[Cache] Session '%s' expired. Freeing data but keeping ID for re-init.\n",
               session->session_id);
        /* Free the session data but keep the session slot with its ID */
        session_data_free(session->data);
        session->data = NULL;  /* Critical: NULL out after free to prevent use-after-free */
        session->state = SESSION_EXPIRED;
    }
}

/* Find an empty or reusable slot */
static Session *find_free_slot(SessionCache *cache) {
    /* First pass: find an EMPTY slot */
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].state == SESSION_EMPTY) {
            return &cache->sessions[i];
        }
    }
    /* Second pass: evict oldest expired session */
    Session *oldest_expired = NULL;
    time_t oldest_time = time(NULL);
    for (int i = 0; i < MAX_SESSIONS; i++) {
        check_and_expire_session(&cache->sessions[i]);
        if (cache->sessions[i].state == SESSION_EXPIRED) {
            if (!oldest_expired || cache->sessions[i].created_at < oldest_time) {
                oldest_expired = &cache->sessions[i];
                oldest_time = cache->sessions[i].created_at;
            }
        }
    }
    if (oldest_expired) {
        /* Data should already be freed when expired, but be safe */
        if (oldest_expired->data) {
            session_data_free(oldest_expired->data);
            oldest_expired->data = NULL;
        }
        oldest_expired->state = SESSION_EMPTY;
        oldest_expired->session_id[0] = '\0';
        return oldest_expired;
    }
    return NULL;
}

/*
 * Create a new session. Returns the session ID on success, NULL on failure.
 * The returned pointer points to internal storage; caller must not free it.
 */
const char *session_create(SessionCache *cache, int ttl_seconds) {
    if (!cache) return NULL;

    if (ttl_seconds <= 0) {
        ttl_seconds = DEFAULT_TTL_SECONDS;
    }

    Session *slot = find_free_slot(cache);
    if (!slot) {
        fprintf(stderr, "Error: Session cache is full\n");
        return NULL;
    }

    /* Generate unique session ID */
    generate_session_id(cache, slot->session_id, SESSION_ID_LEN);

    /* Allocate session data - ownership belongs to this Session */
    slot->data = session_data_create();
    if (!slot->data) {
        slot->state = SESSION_EMPTY;
        slot->session_id[0] = '\0';
        return NULL;
    }

    time_t now = time(NULL);
    slot->state = SESSION_ACTIVE;
    slot->created_at = now;
    slot->last_accessed = now;
    slot->ttl_seconds = ttl_seconds;
    slot->expires_at = now + ttl_seconds;
    cache->count++;

    printf("[Cache] Created session '%s' (TTL: %ds)\n", slot->session_id, ttl_seconds);
    return slot->session_id;
}

/*
 * Access a session by ID. Returns a pointer to the session's data for reading/writing.
 * The caller does NOT own the returned pointer and must not free it.
 * Returns NULL if session not found or expired.
 */
SessionData *session_access(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return NULL;

    Session *session = find_session_by_id(cache, session_id);
    if (!session) {
        return NULL;
    }

    /* Check expiration before access */
    check_and_expire_session(session);

    if (session->state == SESSION_EXPIRED) {
        printf("[Cache] Attempted access to expired session '%s'\n", session_id);
        /* Data has been freed; return NULL to prevent use-after-free */
        return NULL;
    }

    if (session->state != SESSION_ACTIVE) {
        return NULL;
    }

    /* Refresh last accessed time and extend expiration */
    time_t now = time(NULL);
    session->last_accessed = now;
    session->expires_at = now + session->ttl_seconds;

    return session->data;
}

/*
 * Re-initialize an expired session. This allows quick re-use of a known session ID
 * without searching for a new slot.
 * Returns the session data on success, NULL on failure.
 */
SessionData *session_reinitialize(SessionCache *cache, const char *session_id, int ttl_seconds) {
    if (!cache || !session_id) return NULL;

    Session *session = find_session_by_id(cache, session_id);
    if (!session) {
        printf("[Cache] Session '%s' not found for re-initialization\n", session_id);
        return NULL;
    }

    /* Only re-initialize expired sessions */
    check_and_expire_session(session);

    if (session->state == SESSION_ACTIVE) {
        /* Already active, just return existing data */
        return session->data;
    }

    if (session->state != SESSION_EXPIRED) {
        return NULL;
    }

    /* Session is expired: data was freed, allocate fresh data */
    /* Verify data is NULL (should be, since we freed it on expiration) */
    if (session->data != NULL) {
        /* Defensive: this shouldn't happen, but handle it safely */
        fprintf(stderr, "Warning: Expired session had non-NULL data pointer\n");
        session_data_free(session->data);
        session->data = NULL;
    }

    session->data = session_data_create();
    if (!session->data) {
        return NULL;
    }

    if (ttl_seconds <= 0) {
        ttl_seconds = DEFAULT_TTL_SECONDS;
    }

    time_t now = time(NULL);
    session->state = SESSION_ACTIVE;
    session->last_accessed = now;
    session->ttl_seconds = ttl_seconds;
    session->expires_at = now + ttl_seconds;

    printf("[Cache] Re-initialized expired session '%s' (TTL: %ds)\n",
           session_id, ttl_seconds);
    return session->data;
}

/*
 * Explicitly invalidate a session. Frees data immediately but keeps the
 * session ID in the cache for potential re-initialization.
 */
bool session_invalidate(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;

    Session *session = find_session_by_id(cache, session_id);
    if (!session) {
        return false;
    }

    if (session->state == SESSION_ACTIVE && session->data) {
        session_data_free(session->data);
        session->data = NULL;  /* Prevent use-after-free */
    }

    session->state = SESSION_EXPIRED;
    printf("[Cache] Invalidated session '%s'\n", session_id);
    return true;
}

/*
 * Completely remove a session from the cache, freeing all resources.
 */
bool session_destroy(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;

    Session *session = find_session_by_id(cache, session_id);
    if (!session) {
        return false;
    }

    if (session->data) {
        session_data_free(session->data);
        session->data = NULL;
    }

    session->state = SESSION_EMPTY;
    session->session_id[0] = '\0';
    cache->count--;

    printf("[Cache] Destroyed session '%s'\n", session_id);
    return true;
}

/*
 * Sweep the cache: expire all timed-out sessions, freeing their data.
 * Returns the number of sessions expired.
 */
int session_cache_sweep(SessionCache *cache) {
    if (!cache) return 0;
    int expired_count = 0;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (cache->sessions[i].state == SESSION_ACTIVE) {
            SessionState before = cache->sessions[i].state;
            check_and_expire_session(&cache->sessions[i]);
            if (cache->sessions[i].state == SESSION_EXPIRED && before == SESSION_ACTIVE) {
                expired_count++;
            }
        }
    }
    if (expired_count > 0) {
        printf("[Cache] Sweep: expired %d session(s)\n", expired_count);
    }
    return expired_count;
}

/*
 * Check if a session ID exists in the cache (active or expired).
 */
bool session_exists(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;
    Session *session = find_session_by_id(cache, session_id);
    return session != NULL;
}

/*
 * Check if a session is currently active (not expired).
 */
bool session_is_active(SessionCache *cache, const char *session_id) {
    if (!cache || !session_id) return false;
    Session *session = find_session_by_id(cache, session_id);
    if (!session) return false;
    check_and_expire_session(session);
    return session->state == SESSION_ACTIVE;
}

/*
 * Print cache statistics.
 */
void session_cache_stats(SessionCache *cache) {
    if (!cache) return;
    int active = 0, expired = 0, empty = 0;
    for (int i = 0; i < MAX_SESSIONS; i++) {
        check_and_expire_session(&cache->sessions[i]);
        switch (cache->sessions[i].state) {
            case SESSION_ACTIVE:  active++;  break;
            case SESSION_EXPIRED: expired++; break;
            case SESSION_EMPTY:   empty++;   break;
        }
    }
    printf("\n=== Session Cache Stats ===\n");
    printf("  Active:  %d\n", active);
    printf("  Expired: %d (IDs retained for re-init)\n", expired);
    printf("  Empty:   %d\n", empty);
    printf("  Total slots: %d\n", MAX_SESSIONS);
    printf("===========================\n\n");
}

/* --- Demo / Test --- */

int main(void) {
    printf("=== Session Cache System Demo ===\n\n");

    /* Create the cache */
    SessionCache *cache = session_cache_create();
    if (!cache) {
        fprintf(stderr, "Failed to create session cache\n");
        return 1;
    }

    /* Create sessions with short TTL for testing */
    const char *sid1 = session_create(cache, 5);  /* 5 second TTL */
    const char *sid2 = session_create(cache, 3600);
    const char *sid3 = session_create(cache, 2);   /* 2 second TTL */

    if (!sid1 || !sid2 || !sid3) {
        fprintf(stderr, "Failed to create sessions\n");
        session_cache_destroy(cache);
        return 1;
    }

    /* We need to copy session IDs since they point to internal storage */
    char id1[SESSION_ID_LEN], id2[SESSION_ID_LEN], id3[SESSION_ID_LEN];
    strncpy(id1, sid1, SESSION_ID_LEN);
    strncpy(id2, sid2, SESSION_ID_LEN);
    strncpy(id3, sid3, SESSION_ID_LEN);

    /* Store data in sessions */
    SessionData *data1 = session_access(cache, id1);
    if (data1) {
        session_data_set(data1, "username", "alice");
        session_data_set(data1, "role", "admin");
        session_data_set(data1, "theme", "dark");
        printf("Set data for session '%s'\n", id1);
    }

    SessionData *data2 = session_access(cache, id2);
    if (data2) {
        session_data_set(data2, "username", "bob");
        session_data_set(data2, "role", "user");
        printf("Set data for session '%s'\n", id2);
    }

    SessionData *data3 = session_access(cache, id3);
    if (data3) {
        session_data_set(data3, "username", "charlie");
        session_data_set(data3, "cart_items", "3");
        printf("Set data for session '%s'\n", id3);
    }

    /* Read data back */
    printf("\n--- Reading session data ---\n");
    data1 = session_access(cache, id1);
    if (data1) {
        const char *user = session_data_get(data1, "username");
        const char *role = session_data_get(data1, "role");
        printf("Session '%s': user=%s, role=%s\n", id1,
               user ? user : "(null)", role ? role : "(null)");
    }

    /* Update data */
    if (data1) {
        session_data_set(data1, "theme", "light");
        const char *theme = session_data_get(data1, "theme");
        printf("Updated theme for '%s': %s\n", id1, theme ? theme : "(null)");
    }

    /* Remove a key */
    if (data1) {
        session_data_remove(data1, "role");
        const char *role = session_data_get(data1, "role");
        printf("After removing 'role' from '%s': %s\n", id1, role ? role : "(null)");
    }

    session_cache_stats(cache);

    /* Explicitly invalidate session 1 */
    printf("--- Invalidating session '%s' ---\n", id1);
    session_invalidate(cache, id1);

    /* Try to access invalidated session - should return NULL safely */
    SessionData *invalid_data = session_access(cache, id1);
    if (!invalid_data) {
        printf("Correctly got NULL when accessing invalidated session '%s'\n", id1);
    }

    /* Session ID should still exist in cache */
    if (session_exists(cache, id1)) {
        printf("Session ID '%s' still in cache (available for re-init)\n", id1);
    }

    /* Re-initialize the expired/invalidated session */
    printf("\n--- Re-initializing session '%s' ---\n", id1);
    SessionData *reinit_data = session_reinitialize(cache, id1, 7200);
    if (reinit_data) {
        session_data_set(reinit_data, "username", "alice");
        session_data_set(reinit_data, "role", "superadmin");
        const char *user = session_data_get(reinit_data, "username");
        const char *role = session_data_get(reinit_data, "role");
        printf("Re-initialized session '%s': user=%s, role=%s\n", id1,
               user ? user : "(null)", role ? role : "(null)");
    }

    /* Check active status */
    printf("\n--- Session status ---\n");
    printf("'%s' active: %s\n", id1, session_is_active(cache, id1) ? "yes" : "no");
    printf("'%s' active: %s\n", id2, session_is_active(cache, id2) ? "yes" : "no");
    printf("'%s' active: %s\n", id3, session_is_active(cache, id3) ? "yes" : "no");

    session_cache_stats(cache);

    /* Completely destroy session 3 */
    printf("--- Destroying session '%s' completely ---\n", id3);
    session_destroy(cache, id3);
    if (!session_exists(cache, id3)) {
        printf("Session '%s' completely removed from cache\n", id3);
    }

    /* Run a sweep */
    printf("\n--- Running cache sweep ---\n");
    int swept = session_cache_sweep(cache);
    printf("Swept %d sessions\n", swept);

    session_cache_stats(cache);

    /* Demonstrate safe handling: accessing a destroyed session */
    printf("--- Safety checks ---\n");
    SessionData *gone = session_access(cache, id3);
    if (!gone) {
        printf("Safely got NULL for destroyed session '%s'\n", id3);
    }

    /* Accessing a non-existent session */
    gone = session_access(cache, "nonexistent_session");
    if (!gone) {
        printf("Safely got NULL for non-existent session\n");
    }

    /* Clean up everything */
    printf("\n--- Cleaning up ---\n");
    session_cache_destroy(cache);
    /* cache is now freed; set to NULL to prevent accidental use */
    cache = NULL;

    printf("\nAll done. No memory leaks, no use-after-free.\n");
    return 0;
}