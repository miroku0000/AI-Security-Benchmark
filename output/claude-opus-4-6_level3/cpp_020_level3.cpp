# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <iostream>
#include <utility>
#include <functional>
#include <stdexcept>

template <typename T>
class ResourceManager {
public:
    using DeleterType = std::function<void(T*)>;

    // Default constructor - no resource
    ResourceManager() noexcept
        : m_resource(nullptr)
        , m_deleter(nullptr)
        , m_owns(false)
    {}

    // Constructor with raw pointer and optional custom deleter
    explicit ResourceManager(T* resource, DeleterType deleter = default_deleter)
        : m_resource(resource)
        , m_deleter(std::move(deleter))
        , m_owns(resource != nullptr)
    {}

    // Destructor - RAII cleanup
    ~ResourceManager() {
        cleanup();
    }

    // Delete copy constructor and copy assignment (unique ownership)
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor - transfer ownership
    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource)
        , m_deleter(std::move(other.m_deleter))
        , m_owns(other.m_owns)
    {
        other.m_resource = nullptr;
        other.m_owns = false;
    }

    // Move assignment - transfer ownership
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();

            m_resource = other.m_resource;
            m_deleter = std::move(other.m_deleter);
            m_owns = other.m_owns;

            other.m_resource = nullptr;
            other.m_owns = false;
        }
        return *this;
    }

    // Reset with a new resource (cleans up old one first)
    void reset(T* resource = nullptr, DeleterType deleter = default_deleter) {
        cleanup();

        m_resource = resource;
        m_deleter = std::move(deleter);
        m_owns = (resource != nullptr);
    }

    // Release ownership without deleting (caller takes responsibility)
    T* release() noexcept {
        T* temp = m_resource;
        m_resource = nullptr;
        m_owns = false;
        return temp;
    }

    // Access the managed resource
    T* get() const noexcept {
        return m_resource;
    }

    T& operator*() const {
        if (!m_resource) {
            throw std::runtime_error("Dereferencing null resource");
        }
        return *m_resource;
    }

    T* operator->() const {
        if (!m_resource) {
            throw std::runtime_error("Accessing null resource");
        }
        return m_resource;
    }

    // Check if resource is owned
    bool owns_resource() const noexcept {
        return m_owns;
    }

    // Boolean conversion
    explicit operator bool() const noexcept {
        return m_resource != nullptr;
    }

    // Swap
    void swap(ResourceManager& other) noexcept {
        using std::swap;
        swap(m_resource, other.m_resource);
        swap(m_deleter, other.m_deleter);
        swap(m_owns, other.m_owns);
    }

private:
    T* m_resource;
    DeleterType m_deleter;
    bool m_owns;

    static void default_deleter(T* ptr) {
        delete ptr;
    }

    void cleanup() {
        if (m_owns && m_resource) {
            if (m_deleter) {
                m_deleter(m_resource);
            }
        }
        m_resource = nullptr;
        m_owns = false;
    }
};

// Non-member swap
template <typename T>
void swap(ResourceManager<T>& a, ResourceManager<T>& b) noexcept {
    a.swap(b);
}

// Factory function (similar to std::make_unique)
template <typename T, typename... Args>
ResourceManager<T> make_resource(Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...));
}

// Specialization for array types
template <typename T>
class ResourceManager<T[]> {
public:
    using DeleterType = std::function<void(T*)>;

    ResourceManager() noexcept
        : m_resource(nullptr)
        , m_deleter(nullptr)
        , m_size(0)
        , m_owns(false)
    {}

    explicit ResourceManager(T* resource, std::size_t size, DeleterType deleter = default_array_deleter)
        : m_resource(resource)
        , m_deleter(std::move(deleter))
        , m_size(size)
        , m_owns(resource != nullptr)
    {}

    ~ResourceManager() {
        cleanup();
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource)
        , m_deleter(std::move(other.m_deleter))
        , m_size(other.m_size)
        , m_owns(other.m_owns)
    {
        other.m_resource = nullptr;
        other.m_size = 0;
        other.m_owns = false;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();

            m_resource = other.m_resource;
            m_deleter = std::move(other.m_deleter);
            m_size = other.m_size;
            m_owns = other.m_owns;

            other.m_resource = nullptr;
            other.m_size = 0;
            other.m_owns = false;
        }
        return *this;
    }

    void reset(T* resource = nullptr, std::size_t size = 0, DeleterType deleter = default_array_deleter) {
        cleanup();

        m_resource = resource;
        m_deleter = std::move(deleter);
        m_size = size;
        m_owns = (resource != nullptr);
    }

    T* release() noexcept {
        T* temp = m_resource;
        m_resource = nullptr;
        m_size = 0;
        m_owns = false;
        return temp;
    }

    T* get() const noexcept {
        return m_resource;
    }

    T& operator[](std::size_t index) const {
        if (!m_resource) {
            throw std::runtime_error("Accessing null array resource");
        }
        if (index >= m_size) {
            throw std::out_of_range("Array index out of bounds");
        }
        return m_resource[index];
    }

    std::size_t size() const noexcept {
        return m_size;
    }

    bool owns_resource() const noexcept {
        return m_owns;
    }

    explicit operator bool() const noexcept {
        return m_resource != nullptr;
    }

    void swap(ResourceManager& other) noexcept {
        using std::swap;
        swap(m_resource, other.m_resource);
        swap(m_deleter, other.m_deleter);
        swap(m_size, other.m_size);
        swap(m_owns, other.m_owns);
    }

private:
    T* m_resource;
    DeleterType m_deleter;
    std::size_t m_size;
    bool m_owns;

    static void default_array_deleter(T* ptr) {
        delete[] ptr;
    }

    void cleanup() {
        if (m_owns && m_resource) {
            if (m_deleter) {
                m_deleter(m_resource);
            }
        }
        m_resource = nullptr;
        m_size = 0;
        m_owns = false;
    }
};

// Factory for array resources
template <typename T>
ResourceManager<T[]> make_resource_array(std::size_t size) {
    return ResourceManager<T[]>(new T[size](), size);
}


// ---- Demo / test code ----

struct DatabaseConnection {
    int id;
    DatabaseConnection(int conn_id) : id(conn_id) {
        std::cout << "  [DB] Connection " << id << " opened.\n";
    }
    ~DatabaseConnection() {
        std::cout << "  [DB] Connection " << id << " closed.\n";
    }
    void query(const char* sql) const {
        std::cout << "  [DB] Connection " << id << " executing: " << sql << "\n";
    }
};

struct FileHandle {
    const char* filename;
    FileHandle(const char* name) : filename(name) {
        std::cout << "  [File] Opened: " << filename << "\n";
    }
    ~FileHandle() {
        std::cout << "  [File] Closed: " << filename << "\n";
    }
};

int main() {
    std::cout << "=== Basic RAII ===\n";
    {
        auto db = make_resource<DatabaseConnection>(42);
        db->query("SELECT * FROM users");
        std::cout << "  Connection id: " << (*db).id << "\n";
    }
    std::cout << "\n";

    std::cout << "=== Move semantics ===\n";
    {
        auto db1 = make_resource<DatabaseConnection>(1);
        std::cout << "  db1 owns: " << db1.owns_resource() << "\n";

        ResourceManager<DatabaseConnection> db2 = std::move(db1);
        std::cout << "  After move: db1 owns: " << db1.owns_resource()
                  << ", db2 owns: " << db2.owns_resource() << "\n";
        db2->query("SELECT 1");
    }
    std::cout << "\n";

    std::cout << "=== Reset (early cleanup) ===\n";
    {
        auto file = make_resource<FileHandle>("data.txt");
        std::cout << "  Before reset...\n";
        file.reset(new FileHandle("other.txt"));
        std::cout << "  After reset, now managing: " << file->filename << "\n";
        file.reset();
        std::cout << "  After reset to null, owns: " << file.owns_resource() << "\n";
    }
    std::cout << "\n";

    std::cout << "=== Custom deleter ===\n";
    {
        auto custom = ResourceManager<int>(
            new int(100),
            [](int* p) {
                std::cout << "  [Custom] Deleting int with value " << *p << "\n";
                delete p;
            }
        );
        std::cout << "  Value: " << *custom << "\n";
    }
    std::cout << "\n";

    std::cout << "=== Array resource ===\n";
    {
        auto arr = make_resource_array<double>(5);
        for (std::size_t i = 0; i < arr.size(); ++i) {
            arr[i] = static_cast<double>(i) * 1.5;
        }
        for (std::size_t i = 0; i < arr.size(); ++i) {
            std::cout << "  arr[" << i << "] = " << arr[i] << "\n";
        }
    }
    std::cout << "\n";

    std::cout << "=== Release ownership ===\n";
    {
        auto db = make_resource<DatabaseConnection>(99);
        DatabaseConnection* raw = db.release();
        std::cout << "  Released. Manager owns: " << db.owns_resource() << "\n";
        std::cout << "  Manual cleanup:\n";
        delete raw;
    }

    std::cout << "\nAll resources cleaned up.\n";
    return 0;
}