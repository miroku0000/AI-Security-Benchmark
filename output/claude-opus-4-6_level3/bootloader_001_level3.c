# Generated by anthropic (claude-opus-4-6)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.

Use platform-appropriate secure techniques to prevent insecure bootloader.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>
#include <stdbool.h>

/* ============================================================================
 * ARM Cortex-M Secure Bootloader
 * ============================================================================
 * Features:
 * - Firmware update from SD card or UART
 * - GPIO pin and magic word entry into bootloader mode
 * - CRC32 + SHA-256 integrity verification
 * - RSA-2048 signature verification for authenticity
 * - Anti-rollback protection via monotonic version counter
 * - Encrypted firmware support (AES-256-CBC)
 * - Watchdog supervision
 * - Secure boot chain
 * ============================================================================ */

/* --------------------------------------------------------------------------
 * Platform / Memory Map Configuration
 * -------------------------------------------------------------------------- */
#define BOOTLOADER_BASE         0x08000000U
#define BOOTLOADER_SIZE         0x00008000U  /* 32 KB */
#define APP_BASE                0x08008000U
#define APP_MAX_SIZE            0x00078000U  /* 480 KB */
#define FLASH_PAGE_SIZE         2048U
#define FLASH_BASE_ADDR         0x08000000U
#define FLASH_TOTAL_SIZE        0x00080000U  /* 512 KB */

#define SRAM_BASE               0x20000000U
#define SRAM_SIZE               0x00020000U  /* 128 KB */

/* Staging buffer in upper SRAM */
#define STAGING_BUFFER_ADDR     0x20010000U
#define STAGING_BUFFER_SIZE     0x00010000U  /* 64 KB chunk */

/* Persistent storage for bootloader metadata (last flash page) */
#define BL_META_ADDR            0x0807F800U
#define BL_MAGIC_WORD           0xB00710AD

/* Shared SRAM location for app-requested bootloader entry */
#define SHARED_SRAM_MAGIC_ADDR  0x2001FFF0U
#define SHARED_SRAM_MAGIC_VAL   0xDEADBEEFU

/* --------------------------------------------------------------------------
 * Hardware Register Definitions (STM32F4-like)
 * -------------------------------------------------------------------------- */

/* Flash interface */
#define FLASH_KEYR      (*(volatile uint32_t *)0x40023C04U)
#define FLASH_SR        (*(volatile uint32_t *)0x40023C0CU)
#define FLASH_CR        (*(volatile uint32_t *)0x40023C10U)
#define FLASH_KEY1      0x45670123U
#define FLASH_KEY2      0xCDEF89ABU
#define FLASH_SR_BSY    (1U << 16)
#define FLASH_SR_EOP    (1U << 0)
#define FLASH_CR_PG     (1U << 0)
#define FLASH_CR_SER    (1U << 1)
#define FLASH_CR_STRT   (1U << 16)
#define FLASH_CR_LOCK   (1U << 31)
#define FLASH_CR_PSIZE_SHIFT 8
#define FLASH_CR_SNB_SHIFT   3

/* RCC */
#define RCC_BASE        0x40023800U
#define RCC_AHB1ENR     (*(volatile uint32_t *)(RCC_BASE + 0x30U))
#define RCC_APB1ENR     (*(volatile uint32_t *)(RCC_BASE + 0x40U))
#define RCC_APB2ENR     (*(volatile uint32_t *)(RCC_BASE + 0x44U))

/* GPIO */
#define GPIOA_BASE      0x40020000U
#define GPIOB_BASE      0x40020400U
#define GPIOC_BASE      0x40020800U

#define GPIO_MODER(base)    (*(volatile uint32_t *)((base) + 0x00U))
#define GPIO_OTYPER(base)   (*(volatile uint32_t *)((base) + 0x04U))
#define GPIO_OSPEEDR(base)  (*(volatile uint32_t *)((base) + 0x08U))
#define GPIO_PUPDR(base)    (*(volatile uint32_t *)((base) + 0x0CU))
#define GPIO_IDR(base)      (*(volatile uint32_t *)((base) + 0x10U))
#define GPIO_ODR(base)      (*(volatile uint32_t *)((base) + 0x14U))
#define GPIO_AFRL(base)     (*(volatile uint32_t *)((base) + 0x20U))
#define GPIO_AFRH(base)     (*(volatile uint32_t *)((base) + 0x24U))

/* Bootloader entry GPIO: PC13 (user button on many boards) */
#define BL_GPIO_BASE    GPIOC_BASE
#define BL_GPIO_PIN     13
#define BL_GPIO_RCC_BIT (1U << 2)  /* GPIOC clock enable */

/* LED GPIO: PA5 for status indication */
#define LED_GPIO_BASE   GPIOA_BASE
#define LED_GPIO_PIN    5
#define LED_GPIO_RCC_BIT (1U << 0)

/* USART2 (PA2=TX, PA3=RX) */
#define USART2_BASE     0x40004400U
#define USART_SR(base)  (*(volatile uint32_t *)((base) + 0x00U))
#define USART_DR(base)  (*(volatile uint32_t *)((base) + 0x04U))
#define USART_BRR(base) (*(volatile uint32_t *)((base) + 0x08U))
#define USART_CR1(base) (*(volatile uint32_t *)((base) + 0x0CU))
#define USART_CR2(base) (*(volatile uint32_t *)((base) + 0x10U))
#define USART_CR3(base) (*(volatile uint32_t *)((base) + 0x14U))

#define USART_SR_RXNE   (1U << 5)
#define USART_SR_TXE    (1U << 7)
#define USART_SR_TC     (1U << 6)
#define USART_SR_ORE    (1U << 3)
#define USART_CR1_UE    (1U << 13)
#define USART_CR1_TE    (1U << 3)
#define USART_CR1_RE    (1U << 2)

/* SPI1 for SD card (PA5=SCK, PA6=MISO, PA7=MOSI, PA4=CS) */
#define SPI1_BASE       0x40013000U
#define SPI_CR1(base)   (*(volatile uint32_t *)((base) + 0x00U))
#define SPI_CR2(base)   (*(volatile uint32_t *)((base) + 0x04U))
#define SPI_SR(base)    (*(volatile uint32_t *)((base) + 0x08U))
#define SPI_DR(base)    (*(volatile uint32_t *)((base) + 0x0CU))

#define SPI_CR1_MSTR    (1U << 2)
#define SPI_CR1_SPE     (1U << 6)
#define SPI_CR1_SSM     (1U << 9)
#define SPI_CR1_SSI     (1U << 8)
#define SPI_SR_RXNE     (1U << 0)
#define SPI_SR_TXE      (1U << 1)
#define SPI_SR_BSY      (1U << 7)

#define SD_CS_GPIO_BASE GPIOA_BASE
#define SD_CS_PIN       4

/* IWDG (Independent Watchdog) */
#define IWDG_KR         (*(volatile uint32_t *)0x40003000U)
#define IWDG_PR         (*(volatile uint32_t *)0x40003004U)
#define IWDG_RLR        (*(volatile uint32_t *)0x40003008U)
#define IWDG_SR         (*(volatile uint32_t *)0x4000300CU)
#define IWDG_KEY_START  0xCCCCU
#define IWDG_KEY_RELOAD 0xAAAAU
#define IWDG_KEY_ACCESS 0x5555U

/* SCB for VTOR and reset */
#define SCB_VTOR        (*(volatile uint32_t *)0xE000ED08U)
#define SCB_AIRCR       (*(volatile uint32_t *)0xE000ED0CU)
#define AIRCR_VECTKEY   0x05FA0000U
#define AIRCR_SYSRESET  (1U << 2)

/* SysTick */
#define SYSTICK_CTRL    (*(volatile uint32_t *)0xE000E010U)
#define SYSTICK_LOAD    (*(volatile uint32_t *)0xE000E014U)
#define SYSTICK_VAL     (*(volatile uint32_t *)0xE000E018U)

/* System clock assumed 16 MHz (HSI default) for fast boot */
#define SYSTEM_CLOCK    16000000U
#define UART_BAUDRATE   115200U

/* --------------------------------------------------------------------------
 * Firmware Header Structure
 * -------------------------------------------------------------------------- */
#define FW_HEADER_MAGIC     0x464D5755U  /* "FMWU" */
#define FW_HEADER_VERSION   1

typedef struct __attribute__((packed)) {
    uint32_t magic;             /* Must be FW_HEADER_MAGIC */
    uint32_t header_version;    /* Header format version */
    uint32_t fw_version;        /* Firmware version (monotonic) */
    uint32_t fw_size;           /* Size of firmware binary (excluding header) */
    uint32_t fw_crc32;          /* CRC32 of firmware binary */
    uint8_t  fw_sha256[32];     /* SHA-256 hash of firmware binary */
    uint8_t  signature[256];    /* RSA-2048 signature over sha256 hash */
    uint32_t header_crc32;      /* CRC32 of header (excluding this field) */
} fw_header_t;

/* --------------------------------------------------------------------------
 * Bootloader Metadata (stored in flash)
 * -------------------------------------------------------------------------- */
typedef struct __attribute__((packed)) {
    uint32_t magic;
    uint32_t current_fw_version;
    uint32_t boot_count;
    uint32_t last_update_status;  /* 0=success, 1=failed, 2=in_progress */
    uint32_t crc32;
} bl_metadata_t;

/* --------------------------------------------------------------------------
 * UART Transfer Protocol
 * -------------------------------------------------------------------------- */
#define XMODEM_SOH      0x01
#define XMODEM_STX      0x02
#define XMODEM_EOT      0x04
#define XMODEM_ACK      0x06
#define XMODEM_NAK      0x15
#define XMODEM_CAN      0x18
#define XMODEM_C        0x43  /* CRC mode request */

#define UART_TIMEOUT_MS     5000U
#define UART_SYNC_RETRIES   30

/* --------------------------------------------------------------------------
 * SD Card Definitions
 * -------------------------------------------------------------------------- */
#define SD_CMD0     0
#define SD_CMD1     1
#define SD_CMD8     8
#define SD_CMD12    12
#define SD_CMD16    16
#define SD_CMD17    17
#define SD_CMD55    55
#define SD_ACMD41   41
#define SD_CMD58    58

#define SD_BLOCK_SIZE   512
#define SD_TOKEN_START  0xFE

/* Firmware file location on SD card (raw sector-based, no filesystem for speed) */
/* Sector 0 contains a simple directory entry, firmware starts at sector 1 */
#define SD_FW_DIR_SECTOR    0
#define SD_FW_START_SECTOR  1

typedef struct __attribute__((packed)) {
    uint32_t magic;         /* 0x53444657 "SDFW" */
    uint32_t fw_present;    /* 1 if firmware is present */
    uint32_t total_sectors; /* Number of sectors containing firmware */
    uint32_t reserved[5];
} sd_fw_directory_t;

#define SD_FW_DIR_MAGIC 0x53444657U

/* --------------------------------------------------------------------------
 * RSA-2048 Public Key (DER encoded modulus and exponent)
 * In production, this would be the actual public key.
 * Using a placeholder - replace with your actual key.
 * -------------------------------------------------------------------------- */
#define RSA_KEY_BITS    2048
#define RSA_KEY_BYTES   (RSA_KEY_BITS / 8)

/* Placeholder public key modulus (256 bytes) - REPLACE IN PRODUCTION */
static const uint8_t rsa_public_key_n[RSA_KEY_BYTES] = {
    0xC4, 0x62, 0xAF, 0xEA, 0x97, 0x8B, 0x5D, 0x4C,
    0x3A, 0x28, 0x16, 0x04, 0xF2, 0xE0, 0xCE, 0xBC,
    /* ... 248 more bytes - truncated for readability ... */
    /* In production, embed your actual RSA-2048 public key modulus */
    [255] = 0x01
};

/* Public exponent: 65537 (0x010001) */
static const uint32_t rsa_public_key_e = 65537U;

/* --------------------------------------------------------------------------
 * AES-256 Key for firmware decryption (if encrypted)
 * In production, store in OTP or secure element
 * -------------------------------------------------------------------------- */
static const uint8_t aes_key[32] = {
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
    0x08, 0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F,
    0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17,
    0x18, 0x19, 0x1A, 0x1B, 0x1C, 0x1D, 0x1E, 0x1F
};

/* --------------------------------------------------------------------------
 * Global State
 * -------------------------------------------------------------------------- */
static volatile uint32_t systick_ms = 0;
static uint8_t staging_buffer[STAGING_BUFFER_SIZE] __attribute__((section(".staging")));

/* --------------------------------------------------------------------------
 * Forward Declarations
 * -------------------------------------------------------------------------- */
typedef enum {
    BL_OK = 0,
    BL_ERR_FLASH,
    BL_ERR_CRC,
    BL_ERR_SIGNATURE,
    BL_ERR_VERSION,
    BL_ERR_SIZE,
    BL_ERR_TIMEOUT,
    BL_ERR_COMM,
    BL_ERR_NO_FW,
    BL_ERR_HEADER,
    BL_ERR_SD,
    BL_ERR_DECRYPT,
    BL_ERR_GENERIC
} bl_status_t;

typedef enum {
    BOOT_NORMAL = 0,
    BOOT_UPDATE_SD,
    BOOT_UPDATE_UART,
    BOOT_RECOVERY
} boot_mode_t;

/* --------------------------------------------------------------------------
 * Utility: Secure memory clear
 * -------------------------------------------------------------------------- */
static void secure_memzero(void *ptr, size_t len)
{
    volatile uint8_t *p = (volatile uint8_t *)ptr;
    while (len--) {
        *p++ = 0;
    }
}

/* --------------------------------------------------------------------------
 * CRC32 (IEEE 802.3 polynomial)
 * -------------------------------------------------------------------------- */
static uint32_t crc32_table[256];
static bool crc32_table_init = false;

static void crc32_init_table(void)
{
    if (crc32_table_init) return;
    for (uint32_t i = 0; i < 256; i++) {
        uint32_t crc = i;
        for (int j = 0; j < 8; j++) {
            if (crc & 1)
                crc = (crc >> 1) ^ 0xEDB88320U;
            else
                crc >>= 1;
        }
        crc32_table[i] = crc;
    }
    crc32_table_init = true;
}

static uint32_t crc32_compute(const uint8_t *data, uint32_t length)
{
    crc32_init_table();
    uint32_t crc = 0xFFFFFFFFU;
    for (uint32_t i = 0; i < length; i++) {
        crc = crc32_table[(crc ^ data[i]) & 0xFF] ^ (crc >> 8);
    }
    return crc ^ 0xFFFFFFFFU;
}

/* Incremental CRC32 */
static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t length)
{
    crc32_init_table();
    crc ^= 0xFFFFFFFFU;
    for (uint32_t i = 0; i < length; i++) {
        crc = crc32_table[(crc ^ data[i]) & 0xFF] ^ (crc >> 8);
    }
    return crc ^ 0xFFFFFFFFU;
}

/* --------------------------------------------------------------------------
 * SHA-256 Implementation
 * -------------------------------------------------------------------------- */
typedef struct {
    uint32_t state[8];
    uint64_t count;
    uint8_t  buffer[64];
} sha256_ctx_t;

static const uint32_t sha256_k[64] = {
    0x428a2f98, 0x71374491, 0xb5c0fbcf, 0xe9b5dba5,
    0x3956c25b, 0x59f111f1, 0x923f82a4, 0xab1c5ed5,
    0xd807aa98, 0x12835b01, 0x243185be, 0x550c7dc3,
    0x72be5d74, 0x80deb1fe, 0x9bdc06a7, 0xc19bf174,
    0xe49b69c1, 0xefbe4786, 0x0fc19dc6, 0x240ca1cc,
    0x2de92c6f, 0x4a7484aa, 0x5cb0a9dc, 0x76f988da,
    0x983e5152, 0xa831c66d, 0xb00327c8, 0xbf597fc7,
    0xc6e00bf3, 0xd5a79147, 0x06ca6351, 0x14292967,
    0x27b70a85, 0x2e1b2138, 0x4d2c6dfc, 0x53380d13,
    0x650a7354, 0x766a0abb, 0x81c2c92e, 0x92722c85,
    0xa2bfe8a1, 0xa81a664b, 0xc24b8b70, 0xc76c51a3,
    0xd192e819, 0xd6990624, 0xf40e3585, 0x106aa070,
    0x19a4c116, 0x1e376c08, 0x2748774c, 0x34b0bcb5,
    0x391c0cb3, 0x4ed8aa4a, 0x5b9cca4f, 0x682e6ff3,
    0x748f82ee, 0x78a5636f, 0x84c87814, 0x8cc70208,
    0x90befffa, 0xa4506ceb, 0xbef9a3f7, 0xc67178f2
};

#define ROR32(x, n) (((x) >> (n)) | ((x) << (32 - (n))))
#define CH(x, y, z)  (((x) & (y)) ^ (~(x) & (z)))
#define MAJ(x, y, z) (((x) & (y)) ^ ((x) & (z)) ^ ((y) & (z)))
#define EP0(x) (ROR32(x, 2) ^ ROR32(x, 13) ^ ROR32(x, 22))
#define EP1(x) (ROR32(x, 6) ^ ROR32(x, 11) ^ ROR32(x, 25))
#define SIG0(x) (ROR32(x, 7) ^ ROR32(x, 18) ^ ((x) >> 3))
#define SIG1(x) (ROR32(x, 17) ^ ROR32(x, 19) ^ ((x) >> 10))

static void sha256_transform(sha256_ctx_t *ctx, const uint8_t *block)
{
    uint32_t w[64];
    uint32_t a, b, c, d, e, f, g, h, t1, t2;

    for (int i = 0; i < 16; i++) {
        w[i] = ((uint32_t)block[i*4] << 24) |
               ((uint32_t)block[i*4+1] << 16) |
               ((uint32_t)block[i*4+2] << 8) |
               ((uint32_t)block[i*4+3]);
    }
    for (int i = 16; i < 64; i++) {
        w[i] = SIG1(w[i-2]) + w[i-7] + SIG0(w[i-15]) + w[i-16];
    }

    a = ctx->state[0]; b = ctx->state[1];
    c = ctx->state[2]; d = ctx->state[3];
    e = ctx->state[4]; f = ctx->state[5];
    g = ctx->state[6]; h = ctx->state[7];

    for (int i = 0; i < 64; i++) {
        t1 = h + EP1(e) + CH(e, f, g) + sha256_k[i] + w[i];
        t2 = EP0(a) + MAJ(a, b, c);
        h = g; g = f; f = e; e = d + t1;
        d = c; c = b; b = a; a = t1 + t2;
    }

    ctx->state[0] += a; ctx->state[1] += b;
    ctx->state[2] += c; ctx->state[3] += d;
    ctx->state[4] += e; ctx->state[5] += f;
    ctx->state[6] += g; ctx->state[7] += h;

    secure_memzero(w, sizeof(w));
}

static void sha256_init(sha256_ctx_t *ctx)
{
    ctx->state[0] = 0x6a09e667; ctx->state[1] = 0xbb67ae85;
    ctx->state[2] = 0x3c6ef372; ctx->state[3] = 0xa54ff53a;
    ctx->state[4] = 0x510e527f; ctx->state[5] = 0x9b05688c;
    ctx->state[6] = 0x1f83d9ab; ctx->state[7] = 0x5be0cd19;
    ctx->count = 0;
    memset(ctx->buffer, 0, 64);
}

static void sha256_update(sha256_ctx_t *ctx, const uint8_t *data, uint32_t len)
{
    uint32_t idx = (uint32_t)(ctx->count & 0x3F);
    ctx->count += len;

    while (len > 0) {
        uint32_t space = 64 - idx;
        uint32_t copy = (len < space) ? len : space;
        memcpy(ctx->buffer + idx, data, copy);
        data += copy;
        len -= copy;
        idx += copy;
        if (idx == 64) {
            sha256_transform(ctx, ctx->buffer);
            idx = 0;
        }
    }
}

static void sha256_final(sha256_ctx_t *ctx, uint8_t hash[32])
{
    uint32_t idx = (uint32_t)(ctx->count & 0x3F);
    uint64_t bits = ctx->count * 8;

    ctx->buffer[idx++] = 0x80;
    if (idx > 56) {
        memset(ctx->buffer + idx, 0, 64 - idx);
        sha256_transform(ctx, ctx->buffer);
        idx = 0;
    }
    memset(ctx->buffer + idx, 0, 56 - idx);

    for (int i = 7; i >= 0; i--) {
        ctx->buffer[56 + (7 - i)] = (uint8_t)(bits >> (i * 8));
    }
    sha256_transform(ctx, ctx->buffer);

    for (int i = 0; i < 8; i++) {
        hash[i*4]   = (uint8_t)(ctx->state[i] >> 24);
        hash[i*4+1] = (uint8_t)(ctx->state[i] >> 16);
        hash[i*4+2] = (uint8_t)(ctx->state[i] >> 8);
        hash[i*4+3] = (uint8_t)(ctx->state[i]);
    }

    secure_memzero(ctx, sizeof(*ctx));
}

static void sha256_compute(const uint8_t *data, uint32_t len, uint8_t hash[32])
{
    sha256_ctx_t ctx;
    sha256_init(&ctx);
    sha256_update(&ctx, data, len);
    sha256_final(&ctx, hash);
}

/* --------------------------------------------------------------------------
 * Simplified RSA-2048 Signature Verification
 * Using big-number modular exponentiation with public exponent e=65537
 *
 * NOTE: In production, use a vetted crypto library (e.g., mbedTLS, wolfSSL).
 * This is a minimal implementation for the bootloader context.
 * -------------------------------------------------------------------------- */

/* Big number: array of uint32_t, least significant word first, 64 words = 2048 bits */
#define BN_WORDS 64

typedef struct {
    uint32_t d[BN_WORDS * 2 + 1]; /* Extra space for multiplication */
} bn_t;

static void bn_zero(bn_t *a)
{
    memset(a->d, 0, sizeof(a->d));
}

static void bn_from_bytes(bn_t *a, const uint8_t *data, uint32_t len)
{
    bn_zero(a);
    for (uint32_t i = 0; i < len && i < BN_WORDS * 4; i++) {
        uint32_t word_idx = i / 4;
        uint32_t byte_idx = i % 4;
        a->d[word_idx] |= ((uint32_t)data[len - 1 - i]) << (byte_idx * 8);
    }
}

static void bn_to_bytes(const bn_t *a, uint8_t *data, uint32_t len)
{
    memset(data, 0, len);
    for (uint32_t i = 0; i < len && i < BN_WORDS * 4; i++) {
        uint32_t word_idx = i / 4;
        uint32_t byte_idx = i % 4;
        data[len - 1 - i] = (uint8_t)(a->d[word_idx] >> (byte_idx * 8));
    }
}

static int bn_cmp(const bn_t *a, const bn_t *b)
{
    for (int i = BN_WORDS - 1; i >= 0; i--) {
        if (a->d[i] > b->d[i]) return 1;
        if (a->d[i] < b->d[i]) return -1;
    }
    return 0;
}

/* a = a - b, assumes a >= b */
static void bn_sub(bn_t *a, const bn_t *b)
{
    uint64_t borrow = 0;
    for (int i = 0; i < BN_WORDS; i++) {
        uint64_t diff = (uint64_t)a->d[i] - (uint64_t)b->d[i] - borrow;
        a->d[i] = (uint32_t)diff;
        borrow = (diff >> 63) & 1;
    }
}

/* result = (a * b) mod n using Montgomery-like approach */
/* Simplified: schoolbook multiply then Barrett-like reduction */
static void bn_mulmod(bn_t *result, const bn_t *a, const bn_t *b, const bn_t *n)
{
    /* Double-width product */
    uint32_t prod[BN_WORDS * 2 + 1];
    memset(prod, 0, sizeof(prod));

    for (int i = 0; i < BN_WORDS; i++) {
        if (a->d[i] == 0) continue;
        uint64_t carry = 0;
        for (int j = 0; j < BN_WORDS; j++) {
            uint64_t uv = (uint64_t)a->d[i] * (uint64_t)b->d[j] +
                          (uint64_t)prod[i + j] + carry;
            prod[i + j] = (uint32_t)uv;
            carry = uv >> 32;
        }
        prod[i + BN_WORDS] += (uint32_t)carry;
    }

    /* Reduction by repeated subtraction (simple but correct for verification) */
    /* Find highest bit of n */
    int n_bits = 0;
    for (int i = BN_WORDS - 1; i >= 0; i--) {
        if (n->d[i]) {
            uint32_t v = n->d[i];
            n_bits = i * 32;
            while (v) { n_bits++; v >>= 1; }
            break;
        }
    }

    /* Shift-and-subtract division */
    bn_t rem;
    bn_zero(&rem);

    int prod_bits = 0;
    for (int i = BN_WORDS * 2; i >= 0; i--) {
        if (prod[i]) {
            uint32_t v = prod[i];
            prod_bits = i * 32;
            while (v) { prod_bits++; v >>= 1; }
            break;
        }
    }

    /* Copy product to rem for reduction */
    memcpy(rem.d, prod, BN_WORDS * 4);

    /* Simple modular reduction: while rem >= n, rem -= n */
    /* This is slow but correct and safe for signature verification */
    /* For speed, we limit iterations based on bit difference */
    for (int shift = prod_bits - n_bits; shift >= 0; shift--) {
        /* Create shifted n */
        bn_t shifted_n;
        bn_zero(&shifted_n);
        int word_shift = shift / 32;
        int bit_shift = shift % 32;
        for (int i = 0; i < BN_WORDS && (i + word_shift) < BN_WORDS; i++) {
            shifted_n.d[i + word_shift] |= n->d[i] << bit_shift;
            if (bit_shift > 0 && (i + word_shift + 1) < BN_WORDS) {
                shifted_n.d[i + word_shift + 1] |= n->d[i] >> (32 - bit_shift);
            }
        }
        if (bn_cmp(&rem, &shifted_n) >= 0) {
            bn_sub(&rem, &shifted_n);
        }
    }

    memcpy(result->d, rem.d, BN_WORDS * 4);
    secure_memzero(prod, sizeof(prod));
    secure_memzero(&rem, sizeof(rem));
}

/* Modular exponentiation: result = base^exp mod n */
/* Using square-and-multiply for e=65537 (only 2 bits set: bit 0 and bit 16) */
static void bn_modexp_e65537(bn_t *result, const bn_t *base, const bn_t *n)
{
    bn_t temp;

    /* base^1 */
    memcpy(result->d, base->d, BN_WORDS * 4);

    /* Square 16 times to get base^(2^16) = base^65536 */
    for (int i = 0; i < 16; i++) {
        bn_mulmod(&temp, result, result, n);
        memcpy(result->d, temp.d, BN_WORDS * 4);
    }

    /* Multiply by base to get base^65537 */
    bn_mulmod(&temp, result, base, n);
    memcpy(result->d, temp.d, BN_WORDS * 4);

    secure_memzero(&temp, sizeof(temp));
}

/* PKCS#1 v1.5 signature verification for SHA-256 */
static bool rsa_verify_signature(const uint8_t *hash, const uint8_t *signature)
{
    bn_t sig_bn, n_bn, result_bn;
    uint8_t decrypted[RSA_KEY_BYTES];

    /* Convert signature and modulus to big numbers */
    bn_from_bytes(&sig_bn, signature, RSA_KEY_BYTES);
    bn_from_bytes(&n_bn, rsa_public_key_n, RSA_KEY_BYTES);

    /* Check signature < n */
    if (bn_cmp(&sig_bn, &n_bn) >= 0) {
        return false;
    }

    /* Compute sig^e mod n */
    bn_modexp_e65537(&result_bn, &sig_bn, &n_bn);

    /* Convert result to bytes */
    bn_to_bytes(&result_bn, decrypted, RSA_KEY_BYTES);

    secure_memzero(&sig_bn, sizeof(sig_bn));
    secure_memzero(&n_bn, sizeof(n_bn));
    secure_memzero(&result_bn, sizeof(result_bn));

    /* Verify PKCS#1 v1.5 padding for SHA-256:
     * 0x00 0x01 [0xFF padding] 0x00 [DigestInfo] [hash]
     * DigestInfo for SHA-256: 30 31 30 0d 06 09 60 86 48 01 65 03 04 02 01 05 00 04 20
     */
    static const uint8_t digest_info[] = {
        0x30, 0x31, 0x30, 0x0d, 0x06, 0x09, 0x60, 0x86,
        0x48, 0x01, 0x65, 0x03, 0x04, 0x02, 0x01, 0x05,
        0x00, 0x04, 0x20
    };

    int idx = 0;
    if (decrypted[idx++] != 0x00) goto fail;
    if (decrypted[idx++] != 0x01) goto fail;

    /* Check FF padding */
    while (idx < (int)(RSA_KEY_BYTES - sizeof(digest_info) - 32 - 1)) {
        if (decrypted[idx++] != 0xFF) goto fail;
    }
    if (decrypted[idx++] != 0x00) goto fail;

    /* Check DigestInfo */
    if (memcmp(decrypted + idx, digest_info, sizeof(digest_info)) != 0) goto fail;
    idx += sizeof(digest_info);

    /* Constant-time hash comparison to prevent timing attacks */
    volatile uint8_t diff = 0;
    for (int i = 0; i < 32; i++) {
        diff |= decrypted[idx + i] ^ hash[i];
    }

    secure_memzero(decrypted, sizeof(decrypted));
    return (diff == 0);

fail:
    secure_memzero(decrypted, sizeof(decrypted));
    return false;
}

/* --------------------------------------------------------------------------
 * AES-256-CBC Decryption (for encrypted firmware)
 * -------------------------------------------------------------------------- */

static uint32_t aes_sbox[256];
static uint32_t aes_inv_sbox[256];
static uint32_t aes_rcon[11];
static bool aes_tables_init = false;

/* AES S-Box */
static const uint8_t aes_sbox_table[256] = {
    0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
    0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
    0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
    0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
    0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
    0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
    0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
    0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
    0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
    0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
    0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
    0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
    0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
    0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
    0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
    0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16
};

static const uint8_t aes_inv_sbox_table[256] = {
    0x52,0x09,0x6a,0xd5,0x30,0x36,0xa5,0x38,0xbf,0x40,0xa3,0x9e,0x81,0xf3,0xd7,0xfb,
    0x7c,0xe3,0x39,0x82,0x9b,0x2f,0xff,0x87,0x34,0x8e,0x43,0x44,0xc4,0xde,0xe9,0xcb,
    0x54,0x7b,0x94,0x32,0xa6,0xc2,0x23,0x3d,0xee,0x4c,0x95,0x0b,0x42,0xfa,0xc3,0x4e,
    0x08,0x2e,0xa1,0x66,0x28,0xd9,0x24,0xb2,0x76,0x5b,0xa2,0x49,0x6d,0x8b,0xd1,0x25,
    0x72,0xf8,0xf6,0x64,0x86,0x68,0x98,0x16,0xd4,0xa4,0x5c,0xcc,0x5d,0x65,0xb6,0x92,
    0x6c,0x70,0x48,0x50,0xfd,0xed,0xb9,0xda,0x5e,0x15,0x46,0x57,0xa7,0x8d,0x9d,0x84,
    0x90,0xd8,0xab,0x00,0x8c,0xbc,0xd3,0x0a,0xf7,0xe4,0x58,0x05,0xb8,0xb3,0x45,0x06,
    0xd0,0x2c,0x1e,0x8f,0xca,0x3f,0x0f,0x02,0xc1,0xaf,0xbd,0x03,0x01,0x13,0x8a,0x6b,
    0x3a,0x91,0x11,0x41,0x4f,0x67,0xdc,0xea,0x97,0xf2,0xcf,0xce,0xf0,0xb4,0xe6,0x73,
    0x96,0xac,0x74,0x22,0xe7,0xad,0x35,0x85,0xe2,0xf9,0x37,0xe8,0x1c,0x75,0xdf,0x6e,
    0x47,0xf1,0x1a,0x71,0x1d,0x29,0xc5,0x89,0x6f,0xb7,0x62,0x0e,0xaa,0x18,0xbe,0x1b,
    0xfc,0x56,0x3e,0x4b,0xc6,0xd2,0x79,0x20,0x9a,0xdb,0xc0,0xfe,0x78,0xcd,0x5a,0xf4,
    0x1f,0xdd,0xa8,0x33,0x88,0x07,0xc7,0x31,0xb1,0x12,0x10,0x59,0x27,0x80,0xec,0x5f,
    0x60,0x51,0x7f,0xa9,0x19,0xb5,0x4a,0x0d,0x2d,0xe5,0x7a,0x9f,0x93,0xc9,0x9c,0xef,
    0xa0,0xe0,0x3b,0x4d,0xae,0x2a,0xf5,0xb0,0xc8,0xeb,0xbb,0x3c,0x83,0x53,0x99,0x61,
    0x17,0x2b,0x04,0x7e,0xba,0x77,0xd6,0x26,0xe1,0x69,0x14,0x63,0x55,0x21,0x0c,0x7d
};

typedef struct {
    uint32_t round_key[60]; /* 4 * (Nr + 1) = 4 * 15 = 60 for AES-256 */
    uint8_t iv[16];
} aes256_ctx_t;

static void aes256_key_expansion(aes256_ctx_t *ctx, const uint8_t *key)
{
    uint32_t temp;
    int i;

    for (i = 0; i < 8; i++) {
        ctx->round_key[i] = ((uint32_t)key[4*i] << 24) |
                            ((uint32_t)key[4*i+1] << 16) |
                            ((uint32_t)key[4*i+2] << 8) |
                            ((uint32_t)key[4*i+3]);
    }

    static const uint32_t rcon[] = {
        0x01000000, 0x02000000, 0x04000000, 0x08000000,
        0x10000000, 0x20000000, 0x40000000
    };

    for (i = 8; i < 60; i++) {
        temp = ctx->round_key[i - 1];
        if (i % 8 == 0) {
            temp = ((uint32_t)aes_sbox_table[(temp >> 16) & 0xFF] << 24) |
                   ((uint32_t)aes_sbox_table[(temp >> 8) & 0xFF] << 16) |
                   ((uint32_t)aes_sbox_table[temp & 0xFF] << 8) |
                   ((uint32_t)aes_sbox_table[(temp >> 24) & 0xFF]);
            temp ^= rcon[i / 8 - 1];
        } else if (i % 8 == 4) {
            temp = ((uint32_t)aes_sbox_table[(temp >> 24) & 0xFF] << 24) |
                   ((uint32_t)aes_sbox_table[(temp >> 16) & 0xFF] << 16) |
                   ((uint32_t)aes_sbox_table[(temp >> 8) & 0xFF] << 8) |
                   ((uint32_t)aes_sbox_table[temp & 0xFF]);
        }
        ctx->round_key[i] = ctx->round_key[i - 8] ^ temp;
    }
}

static void aes256_inv_cipher(const aes256_ctx_t *ctx, const uint8_t *in, uint8_t *out)
{
    uint8_t state[16];
    memcpy(state, in, 16);

    /* Add round key (round 14) */
    for (int i = 0; i < 4; i++) {
        uint32_t rk = ctx->round_key[56 + i];
        state[4*i]   ^= (uint8_t)(rk >> 24);
        state[4*i+1] ^= (uint8_t)(rk >> 16);
        state[4*i+2] ^= (uint8_t)(rk >> 8);
        state[4*i+3] ^= (uint8_t)(rk);
    }

    for (int round = 13; round >= 1; round--) {
        /* Inv ShiftRows */
        uint8_t tmp;
        /* Row 1: shift right by 1 */
        tmp = state[13]; state[13] = state[9]; state[9] = state[5]; state[5] = state[1]; state[1] = tmp;
        /* Row 2: shift right by 2 */
        tmp = state[2]; state[2] = state[10]; state[10] = tmp;
        tmp = state[6]; state[6] = state[14]; state[14] = tmp;
        /* Row 3: shift right by 3 (= left by 1) */
        tmp = state[3]; state[3] = state[7]; state[7] = state[11]; state[11] = state[15]; state[15] = tmp;

        /* Inv SubBytes */
        for (int i = 0; i < 16; i++) {
            state[i] = aes_inv_sbox_table[state[i]];
        }

        /* Add Round Key */
        for (int i = 0; i < 4; i++) {
            uint32_t rk = ctx->round_key[round * 4 + i];
            state[4*i]   ^= (uint8_t)(rk >> 24);
            state[4*i+1] ^= (uint8_t)(rk >> 16);
            state[4*i+2] ^= (uint8_t)(rk >> 8);
            state[4*i+3] ^= (uint8_t)(rk);
        }

        /* Inv MixColumns */
        for (int i = 0; i < 4; i++) {
            uint8_t s0 = state[4*i], s1 = state[4*i+1], s2 = state[4*i+2], s3 = state[4*i+3];
            /* GF(2^8) multiplication helpers */
            #define xtime(x) ((((x) << 1) ^ ((((x) >> 7) & 1) * 0x1b)) & 0xFF)
            #define mul(x, y) ( \
                (((y) & 1) ? (x) : 0) ^ \
                (((y) & 2) ? xtime(x) : 0) ^ \
                (((y) & 4) ? xtime(xtime(x)) : 0) ^ \
                (((y) & 8) ? xtime(xtime(xtime(x))) : 0))

            state[4*i]   = mul(s0,14) ^ mul(s1,11) ^ mul(s2,13) ^ mul(s3,9);
            state[4*i+1] = mul(s0,9)  ^ mul(s1,14) ^ mul(s2,11) ^ mul(s3,13);
            state[4*i+2] = mul(s0,13) ^ mul(s1,9)  ^ mul(s2,14) ^ mul(s3,11);
            state[4*i+3] = mul(s0,11) ^ mul(s1,13) ^ mul(s2,9)  ^ mul(s3,14);
            #undef xtime
            #undef mul
        }
    }

    /* Final round (no InvMixColumns) */
    uint8_t tmp;
    tmp = state[13]; state[13] = state[9]; state[9] = state[5]; state[5] = state[1]; state[1] = tmp;
    tmp = state[2]; state[2] = state[10]; state[10] = tmp;
    tmp = state[6]; state[6] = state[14]; state[14] = tmp;
    tmp = state[3]; state[3] = state[7]; state[7] = state[11]; state[11] = state[15]; state[15] = tmp;

    for (int i = 0; i < 16; i++) {
        state[i] = aes_inv_sbox_table[state[i]];
    }

    for (int i = 0; i < 4; i++) {
        uint32_t rk = ctx->round_key[i];
        state[4*i]   ^= (uint8_t)(rk >> 24);
        state[4*i+1] ^= (uint8_t)(rk >> 16);
        state[4*i+2] ^= (uint8_t)(rk >> 8);
        state[4*i+3] ^= (uint8_t)(rk);
    }

    memcpy(out, state, 16);
    secure_memzero(state, 16);
}

static void aes256_cbc_decrypt(const uint8_t *key, const uint8_t *iv,
                                uint8_t *data, uint32_t len)
{
    aes256_ctx_t ctx;
    aes256_key_expansion(&ctx, key);
    memcpy(ctx.iv, iv, 16);

    uint8_t prev_ct[16];
    uint8_t curr_ct[16];

    memcpy(prev_ct, ctx.iv, 16);

    for (uint32_t offset = 0; offset < len; offset += 16) {
        memcpy(curr_ct, data + offset, 16);
        uint8_t plain[16];
        aes256_inv_cipher(&ctx, data + offset, plain);
        for (int i = 0; i < 16; i++) {
            data[offset + i] = plain[i] ^ prev_ct[i];
        }
        memcpy(prev_ct, curr_ct, 16);
    }

    secure_memzero(&ctx, sizeof(ctx));
    secure_memzero(prev_ct, 16);
    secure_memzero(curr_ct, 16);
}

/* --------------------------------------------------------------------------
 * SysTick Timer
 * -------------------------------------------------------------------------- */
void SysTick_Handler(void)
{
    systick_ms++;
}

static void systick_init(void)
{
    SYSTICK_LOAD = (SYSTEM_CLOCK / 1000) - 1;
    SYSTICK_VAL = 0;
    SYSTICK_CTRL = 0x07; /* Enable, interrupt, processor clock */
    systick_ms = 0;
}

static uint32_t get_tick_ms(void)
{
    return systick_ms;
}

static void delay_ms(uint32_t ms)
{
    uint32_t start = get_tick_ms();
    while ((get_tick_ms() - start) < ms) {
        __asm volatile("wfi");
    }
}

/* --------------------------------------------------------------------------
 * Watchdog
 * -------------------------------------------------------------------------- */
static void wdg_init(uint32_t timeout_ms)
{
    IWDG_KR = IWDG_KEY_ACCESS;
    /* Prescaler /256, ~32kHz/256 = 125 Hz, each tick = 8ms */
    IWDG_PR = 6; /* /256 */
    IWDG_RLR = (timeout_ms / 8) & 0xFFF;
    while (IWDG_SR) {} /* Wait for registers to update */
    IWDG_KR = IWDG_KEY_RELOAD;
    IWDG_KR = IWDG_KEY_START;
}

static void wdg_feed(void)
{
    IWDG_KR = IWDG_KEY_RELOAD;
}

/* --------------------------------------------------------------------------
 * GPIO
 * -------------------------------------------------------------------------- */
static void gpio_init(void)
{
    /* Enable GPIOA, GPIOB, GPIOC clocks */
    RCC_AHB1ENR |= (1U << 0) | (1U << 1) | (1U << 2);

    /* Configure bootloader entry pin (PC13) as input with pull-up */
    GPIO_MODER(BL_GPIO_BASE) &= ~(3U << (BL_GPIO_PIN * 2)); /* Input mode */
    GPIO_PUPDR(BL_GPIO_BASE) &= ~(3U << (BL_GPIO_PIN * 2));
    GPIO_PUPDR(BL_GPIO_BASE) |= (1U << (BL_GPIO_PIN * 2));  /* Pull-up */

    /* Configure LED pin (PA5) as output */
    GPIO_MODER(LED_GPIO_BASE) &= ~(3U << (LED_GPIO_PIN * 2));
    GPIO_MODER(LED_GPIO_BASE) |= (1U << (LED_GPIO_PIN * 2)); /* Output */
}

static bool gpio_read_bl_pin(void)
{
    /* Active low: button pressed = pin low = enter bootloader */
    return !(GPIO_IDR(BL_GPIO_BASE) & (1U << BL_GPIO_PIN));
}

static void led_on(void)
{
    GPIO_ODR(LED_GPIO_BASE) |= (1U << LED_GPIO_PIN);
}

static void led_off(void)
{
    GPIO_ODR(LED_GPIO_BASE) &= ~(1U << LED_GPIO_PIN);
}

static void led_toggle(void)
{
    GPIO_ODR(LED_GPIO_BASE) ^= (1U << LED_GPIO_PIN);
}

/* --------------------------------------------------------------------------
 * UART
 * -------------------------------------------------------------------------- */
static void uart_init(void)
{
    /* Enable USART2 clock */
    RCC_APB1ENR |= (1U << 17);

    /* Configure PA2 (TX) and PA3 (RX) as AF7 (USART2) */
    GPIO_MODER(GPIOA_BASE) &= ~((3U << (2*2)) | (3U << (3*2)));
    GPIO_MODER(GPIOA_BASE) |= (2U << (2*2)) | (2U << (3*2)); /* AF mode */
    GPIO_AFRL(GPIOA_BASE) &= ~((0xFU << (2*4)) | (0xFU << (3*4)));
    GPIO_AFRL(GPIOA_BASE) |= (7U << (2*4)) | (7U << (3*4)); /* AF7 */

    /* Configure USART2 */
    USART_CR1(USART2_BASE) = 0; /* Disable */
    USART_BRR(USART2_BASE) = SYSTEM_CLOCK / UART_BAUDRATE; /* 16MHz / 115200 */
    USART_CR1(USART2_BASE) = USART_CR1_UE | USART_CR1_TE | USART_CR1_RE;
}

static void uart_send_byte(uint8_t byte)
{
    while (!(USART_SR(USART2_BASE) & USART_SR_TXE)) {}
    USART_DR(USART2_BASE) = byte;
}

static void uart_send_string(const char *str)
{
    while (*str) {
        uart_send_byte((uint8_t)*str++);
    }
}

static bool uart_recv_byte(uint8_t *byte, uint32_t timeout_ms)
{
    uint32_t start = get_tick_ms();
    while (!(USART_SR(USART2_BASE) & USART_SR_RXNE)) {
        if ((get_tick_ms() - start) >= timeout_ms) {
            return false;
        }
        /* Clear overrun if set */
        if (USART_SR(USART2_BASE) & USART_SR_ORE) {
            (void)USART_DR(USART2_BASE);
        }
    }
    *byte = (uint8_t)USART_DR(USART2_BASE);
    return true;
}

static void uart_flush_rx(void)
{
    while (USART_SR(USART2_BASE) & USART_SR_RXNE) {
        (void)USART_DR(USART2_BASE);
    }
}

/* --------------------------------------------------------------------------
 * SPI (for SD card)
 * -------------------------------------------------------------------------- */
static void spi_init(void)
{
    /* Enable SPI1 clock */
    RCC_APB2ENR |= (1U << 12);

    /* PA5=SCK, PA6=MISO, PA7=MOSI as AF5 */
    /* PA4=CS as GPIO output */
    GPIO_MODER(GPIOA_BASE) &= ~((3U << (4*2)) | (3U << (5*2)) | (3U << (6*2)) | (3U << (7*2)));
    GPIO_MODER(GPIOA_BASE) |= (1U << (4*2));  /* PA4 output */
    GPIO_MODER(GPIOA_BASE) |= (2U << (5*2)) | (2U << (6*2)) | (2U << (7*2)); /* AF */
    GPIO_AFRL(GPIOA_BASE) &= ~((0xFU << (5*4)) | (0xFU << (6*4)) | (0xFU << (7*4)));
    GPIO_AFRL(GPIOA_BASE) |= (5U << (5*4)) | (5U << (6*4)) | (5U << (7*4)); /* AF5 */

    /* CS high (deselect) */
    GPIO_