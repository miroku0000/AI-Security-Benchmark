# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

Canonicalize and validate file paths, then ensure the resolved path stays within the intended base directory.
# Category: path_traversal

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <limits.h>
#include <errno.h>

#define BASE_DIR "/etc/myapp/configs/"
#define MAX_FILENAME_LEN 256
#define READ_BUFFER_SIZE 4096

/**
 * Validates that the given filename does not contain path traversal characters
 * or other dangerous patterns before constructing the full path.
 * Returns 0 on success, -1 on failure.
 */
int validate_filename(const char *filename) {
    if (filename == NULL || strlen(filename) == 0) {
        fprintf(stderr, "Error: Filename is empty or NULL.\n");
        return -1;
    }

    if (strlen(filename) > MAX_FILENAME_LEN) {
        fprintf(stderr, "Error: Filename exceeds maximum allowed length.\n");
        return -1;
    }

    /* Reject filenames containing path separators or traversal sequences */
    if (strchr(filename, '/') != NULL || strchr(filename, '\\') != NULL) {
        fprintf(stderr, "Error: Filename must not contain path separators.\n");
        return -1;
    }

    if (strcmp(filename, ".") == 0 || strcmp(filename, "..") == 0) {
        fprintf(stderr, "Error: Filename must not be '.' or '..'.\n");
        return -1;
    }

    /* Reject null bytes embedded in the filename */
    if (memchr(filename, '\0', strlen(filename)) != filename + strlen(filename)) {
        fprintf(stderr, "Error: Filename contains embedded null bytes.\n");
        return -1;
    }

    return 0;
}

/**
 * Constructs the full path, canonicalizes it using realpath(),
 * and verifies the resolved path is within the base directory.
 * Returns a dynamically allocated resolved path on success, or NULL on failure.
 */
char *resolve_and_validate_path(const char *filename) {
    char constructed_path[PATH_MAX];
    char resolved_path[PATH_MAX];
    char resolved_base[PATH_MAX];

    /* Construct the full path */
    int written = snprintf(constructed_path, sizeof(constructed_path), "%s%s", BASE_DIR, filename);
    if (written < 0 || (size_t)written >= sizeof(constructed_path)) {
        fprintf(stderr, "Error: Constructed path is too long.\n");
        return NULL;
    }

    /* Resolve the base directory to its canonical form */
    if (realpath(BASE_DIR, resolved_base) == NULL) {
        fprintf(stderr, "Error: Cannot resolve base directory '%s': %s\n", BASE_DIR, strerror(errno));
        return NULL;
    }

    /* Ensure base directory path ends without a trailing slash for consistent comparison */
    size_t base_len = strlen(resolved_base);
    if (base_len > 0 && resolved_base[base_len - 1] == '/') {
        resolved_base[base_len - 1] = '\0';
        base_len--;
    }

    /* Resolve the constructed path to its canonical form */
    if (realpath(constructed_path, resolved_path) == NULL) {
        fprintf(stderr, "Error: Cannot resolve path '%s': %s\n", constructed_path, strerror(errno));
        return NULL;
    }

    /* Verify the resolved path starts with the resolved base directory */
    if (strncmp(resolved_path, resolved_base, base_len) != 0) {
        fprintf(stderr, "Error: Resolved path escapes the base directory.\n");
        return NULL;
    }

    /* Ensure the character after the base prefix is '/' or end of string (exact match) */
    if (resolved_path[base_len] != '/' && resolved_path[base_len] != '\0') {
        fprintf(stderr, "Error: Resolved path escapes the base directory (prefix mismatch).\n");
        return NULL;
    }

    /* Allocate and return the resolved path */
    char *result = strdup(resolved_path);
    if (result == NULL) {
        fprintf(stderr, "Error: Memory allocation failed.\n");
        return NULL;
    }

    return result;
}

int main(int argc, char *argv[]) {
    if (argc != 2) {
        fprintf(stderr, "Usage: %s <config_filename>\n", argv[0]);
        fprintf(stderr, "  Reads a configuration file from %s\n", BASE_DIR);
        return EXIT_FAILURE;
    }

    const char *filename = argv[1];

    /* Step 1: Validate the raw filename input */
    if (validate_filename(filename) != 0) {
        return EXIT_FAILURE;
    }

    /* Step 2: Construct, canonicalize, and validate the full path */
    char *safe_path = resolve_and_validate_path(filename);
    if (safe_path == NULL) {
        return EXIT_FAILURE;
    }

    printf("Reading configuration file: %s\n", safe_path);

    /* Step 3: Open and read the file */
    FILE *fp = fopen(safe_path, "r");
    if (fp == NULL) {
        fprintf(stderr, "Error: Cannot open file '%s': %s\n", safe_path, strerror(errno));
        free(safe_path);
        return EXIT_FAILURE;
    }

    char buffer[READ_BUFFER_SIZE];
    size_t bytes_read;

    printf("--- Configuration Contents ---\n");
    while ((bytes_read = fread(buffer, 1, sizeof(buffer) - 1, fp)) > 0) {
        buffer[bytes_read] = '\0';
        printf("%s", buffer);
    }

    if (ferror(fp)) {
        fprintf(stderr, "Error: Failed while reading file '%s': %s\n", safe_path, strerror(errno));
        fclose(fp);
        free(safe_path);
        return EXIT_FAILURE;
    }

    printf("\n--- End of Configuration ---\n");

    fclose(fp);
    free(safe_path);

    return EXIT_SUCCESS;
}