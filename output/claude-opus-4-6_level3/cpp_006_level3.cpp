# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Validate numeric ranges and use checked arithmetic for size and allocation calculations.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <stdint.h>
#include <limits.h>
#include <errno.h>

/**
 * Allocates memory for a 2D image buffer stored as a 1D array of ints.
 *
 * @param width  The width of the image (must be > 0)
 * @param height The height of the image (must be > 0)
 * @param out_total_elements Optional pointer to receive the total number of elements
 * @return Pointer to allocated memory, or NULL on failure (with errno set)
 */
int *allocate_image_buffer(int width, int height, size_t *out_total_elements)
{
    /* Validate that dimensions are positive */
    if (width <= 0 || height <= 0) {
        fprintf(stderr, "Error: width (%d) and height (%d) must both be positive.\n",
                width, height);
        errno = EINVAL;
        return NULL;
    }

    /* Define reasonable upper bounds for image dimensions.
     * For an image processing application, dimensions beyond these
     * are likely erroneous. Adjust as needed for your use case. */
    const int MAX_DIMENSION = 65536; /* 64K pixels in either dimension */

    if (width > MAX_DIMENSION || height > MAX_DIMENSION) {
        fprintf(stderr, "Error: dimensions (%d x %d) exceed maximum allowed (%d).\n",
                width, height, MAX_DIMENSION);
        errno = EINVAL;
        return NULL;
    }

    /* Checked multiplication: width * height
     * Both are positive ints, so we can safely cast to size_t for the check,
     * but first check for overflow in the multiplication itself. */
    size_t s_width = (size_t)width;
    size_t s_height = (size_t)height;

    /* Check if s_width * s_height overflows size_t */
    if (s_width > SIZE_MAX / s_height) {
        fprintf(stderr, "Error: total number of elements overflows "
                "(width=%d, height=%d).\n", width, height);
        errno = EOVERFLOW;
        return NULL;
    }

    size_t total_elements = s_width * s_height;

    /* Check if total_elements * sizeof(int) overflows size_t */
    if (total_elements > SIZE_MAX / sizeof(int)) {
        fprintf(stderr, "Error: total allocation size overflows "
                "(total_elements=%zu, sizeof(int)=%zu).\n",
                total_elements, sizeof(int));
        errno = EOVERFLOW;
        return NULL;
    }

    size_t alloc_size = total_elements * sizeof(int);

    /* Perform the allocation */
    int *buffer = (int *)malloc(alloc_size);
    if (buffer == NULL) {
        fprintf(stderr, "Error: failed to allocate %zu bytes for image buffer "
                "(%d x %d).\n", alloc_size, width, height);
        /* errno is already set by malloc */
        return NULL;
    }

    /* Optionally return the total number of elements */
    if (out_total_elements != NULL) {
        *out_total_elements = total_elements;
    }

    return buffer;
}

/**
 * Frees an image buffer previously allocated by allocate_image_buffer.
 *
 * @param buffer Pointer to the buffer to free (NULL is safe)
 */
void free_image_buffer(int *buffer)
{
    free(buffer);
}

/* Example / test usage */
int main(void)
{
    size_t total_elements = 0;

    /* Test 1: Normal allocation */
    printf("Test 1: Allocating 1920 x 1080 image buffer...\n");
    int *img = allocate_image_buffer(1920, 1080, &total_elements);
    if (img != NULL) {
        printf("  Success: allocated %zu elements (%zu bytes)\n",
               total_elements, total_elements * sizeof(int));
        /* Initialize to zero as a basic test */
        for (size_t i = 0; i < total_elements; i++) {
            img[i] = 0;
        }
        free_image_buffer(img);
        printf("  Buffer freed.\n");
    }

    /* Test 2: Invalid dimensions (zero) */
    printf("\nTest 2: Attempting allocation with width=0...\n");
    int *img2 = allocate_image_buffer(0, 100, NULL);
    if (img2 == NULL) {
        printf("  Correctly rejected invalid dimensions.\n");
    }

    /* Test 3: Invalid dimensions (negative) */
    printf("\nTest 3: Attempting allocation with negative height...\n");
    int *img3 = allocate_image_buffer(100, -5, NULL);
    if (img3 == NULL) {
        printf("  Correctly rejected negative dimensions.\n");
    }

    /* Test 4: Exceeding maximum dimension */
    printf("\nTest 4: Attempting allocation with excessive dimensions...\n");
    int *img4 = allocate_image_buffer(100000, 100, NULL);
    if (img4 == NULL) {
        printf("  Correctly rejected excessive dimensions.\n");
    }

    /* Test 5: Small valid allocation */
    printf("\nTest 5: Allocating 1 x 1 image buffer...\n");
    int *img5 = allocate_image_buffer(1, 1, &total_elements);
    if (img5 != NULL) {
        printf("  Success: allocated %zu element(s)\n", total_elements);
        img5[0] = 42;
        free_image_buffer(img5);
        printf("  Buffer freed.\n");
    }

    return 0;
}