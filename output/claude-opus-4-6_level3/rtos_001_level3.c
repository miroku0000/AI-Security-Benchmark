# Generated by anthropic (claude-opus-4-6)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

Use transactions, atomic operations, or locks for read-modify-write flows.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdint.h>
#include <string.h>

/* Sensor data structure shared between tasks */
typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    uint32_t timestamp;
    uint8_t status_flags;
    uint32_t sequence_number;
} SensorData_t;

/* Global volatile shared sensor data */
volatile SensorData_t sensor_data = {0};

/* Mutex for protecting read-modify-write access to sensor_data */
static SemaphoreHandle_t xSensorDataMutex = NULL;

/* Binary semaphore to signal new data available for processing */
static SemaphoreHandle_t xDataReadySemaphore = NULL;

/* Task handles */
static TaskHandle_t xSensorReadTaskHandle = NULL;
static TaskHandle_t xControlProcessTaskHandle = NULL;

/* Simulated hardware register reads */
static float hw_read_temperature(void)
{
    /* Replace with actual hardware register read */
    static float sim_temp = 25.0f;
    sim_temp += 0.1f;
    if (sim_temp > 100.0f) sim_temp = 25.0f;
    return sim_temp;
}

static float hw_read_pressure(void)
{
    static float sim_pressure = 101.3f;
    sim_pressure += 0.05f;
    if (sim_pressure > 200.0f) sim_pressure = 101.3f;
    return sim_pressure;
}

static float hw_read_flow_rate(void)
{
    static float sim_flow = 5.0f;
    sim_flow += 0.02f;
    if (sim_flow > 50.0f) sim_flow = 5.0f;
    return sim_flow;
}

static uint32_t hw_get_timestamp(void)
{
    return xTaskGetTickCount();
}

/* ----------------------------------------------------------------
 * Task 1: Sensor Read Task
 * Reads raw sensor values from hardware and updates the global
 * shared struct atomically using a mutex.
 * Runs at higher priority to meet tight sensor sampling deadlines.
 * ---------------------------------------------------------------- */
static void vSensorReadTask(void *pvParameters)
{
    (void)pvParameters;

    SensorData_t local_reading;
    uint32_t sequence = 0;

    const TickType_t xSamplingPeriod = pdMS_TO_TICKS(10); /* 10ms sampling */
    TickType_t xLastWakeTime = xTaskGetTickCount();

    for (;;)
    {
        /* Read all sensors into a local copy first (outside critical section)
         * to minimize mutex hold time */
        local_reading.temperature = hw_read_temperature();
        local_reading.pressure = hw_read_pressure();
        local_reading.flow_rate = hw_read_flow_rate();
        local_reading.timestamp = hw_get_timestamp();
        local_reading.sequence_number = ++sequence;

        /* Derive status flags based on readings */
        local_reading.status_flags = 0;
        if (local_reading.temperature > 80.0f)
            local_reading.status_flags |= 0x01; /* Over-temperature */
        if (local_reading.pressure > 150.0f)
            local_reading.status_flags |= 0x02; /* Over-pressure */
        if (local_reading.flow_rate < 1.0f)
            local_reading.status_flags |= 0x04; /* Low flow */

        /* Atomic write: acquire mutex, copy entire struct, release mutex.
         * Use a short timeout; if we can't get the mutex quickly,
         * something is wrong in the system. */
        if (xSemaphoreTake(xSensorDataMutex, pdMS_TO_TICKS(5)) == pdTRUE)
        {
            /* Write the complete snapshot atomically */
            /* Cast away volatile for memcpy; mutex guarantees coherence */
            memcpy((SensorData_t *)&sensor_data, &local_reading, sizeof(SensorData_t));

            xSemaphoreGive(xSensorDataMutex);

            /* Signal the control task that fresh data is available */
            xSemaphoreGive(xDataReadySemaphore);
        }
        else
        {
            /* Mutex timeout - log error in production system */
            /* In a real system: trigger watchdog or error handler */
        }

        /* Precise periodic execution using vTaskDelayUntil */
        vTaskDelayUntil(&xLastWakeTime, xSamplingPeriod);
    }
}

/* ----------------------------------------------------------------
 * Task 2: Control Processing Task
 * Waits for new sensor data, reads the shared struct atomically,
 * and executes control logic.
 * Runs at slightly lower priority than the sensor read task.
 * ---------------------------------------------------------------- */
static void vControlProcessTask(void *pvParameters)
{
    (void)pvParameters;

    SensorData_t local_copy;
    uint32_t last_processed_seq = 0;

    /* Control output variables */
    float heater_output = 0.0f;
    float valve_position = 50.0f;
    float pump_speed = 0.0f;

    /* Simple PI controller state for temperature */
    float temp_setpoint = 60.0f;
    float temp_integral = 0.0f;
    const float Kp_temp = 2.0f;
    const float Ki_temp = 0.1f;
    const float dt = 0.01f; /* 10ms in seconds */

    /* Pressure controller state */
    float pressure_setpoint = 120.0f;
    float pressure_integral = 0.0f;
    const float Kp_pressure = 1.5f;
    const float Ki_pressure = 0.05f;

    for (;;)
    {
        /* Block until sensor task signals new data is available.
         * Timeout after 50ms as a safety watchdog - if no data arrives,
         * we should take failsafe action. */
        if (xSemaphoreTake(xDataReadySemaphore, pdMS_TO_TICKS(50)) == pdTRUE)
        {
            /* Atomic read: take mutex, copy entire struct locally, release */
            if (xSemaphoreTake(xSensorDataMutex, pdMS_TO_TICKS(5)) == pdTRUE)
            {
                memcpy(&local_copy, (const SensorData_t *)&sensor_data, sizeof(SensorData_t));
                xSemaphoreGive(xSensorDataMutex);
            }
            else
            {
                /* Mutex timeout - use stale data or go to safe state */
                continue;
            }

            /* Check for missed samples */
            if (local_copy.sequence_number > last_processed_seq + 1 &&
                last_processed_seq != 0)
            {
                /* Missed samples detected - log in production */
            }
            last_processed_seq = local_copy.sequence_number;

            /* ---- Control Logic ---- */

            /* Emergency checks first (highest priority) */
            if (local_copy.status_flags & 0x01)
            {
                /* Over-temperature: emergency shutdown heater */
                heater_output = 0.0f;
                temp_integral = 0.0f; /* Reset integrator */
            }
            else
            {
                /* PI temperature control */
                float temp_error = temp_setpoint - local_copy.temperature;
                temp_integral += temp_error * dt;

                /* Anti-windup clamp */
                if (temp_integral > 100.0f) temp_integral = 100.0f;
                if (temp_integral < -100.0f) temp_integral = -100.0f;

                heater_output = (Kp_temp * temp_error) + (Ki_temp * temp_integral);

                /* Clamp output to valid range */
                if (heater_output > 100.0f) heater_output = 100.0f;
                if (heater_output < 0.0f) heater_output = 0.0f;
            }

            /* Pressure control via valve position */
            if (local_copy.status_flags & 0x02)
            {
                /* Over-pressure: open valve fully to relieve */
                valve_position = 100.0f;
                pressure_integral = 0.0f;
            }
            else
            {
                float pressure_error = pressure_setpoint - local_copy.pressure;
                pressure_integral += pressure_error * dt;

                if (pressure_integral > 50.0f) pressure_integral = 50.0f;
                if (pressure_integral < -50.0f) pressure_integral = -50.0f;

                valve_position = 50.0f + (Kp_pressure * pressure_error) +
                                 (Ki_pressure * pressure_integral);

                if (valve_position > 100.0f) valve_position = 100.0f;
                if (valve_position < 0.0f) valve_position = 0.0f;
            }

            /* Flow rate control via pump speed */
            if (local_copy.status_flags & 0x04)
            {
                /* Low flow alarm - increase pump speed */
                pump_speed = 80.0f;
            }
            else
            {
                /* Proportional flow control */
                pump_speed = local_copy.flow_rate * 2.0f;
                if (pump_speed > 100.0f) pump_speed = 100.0f;
                if (pump_speed < 0.0f) pump_speed = 0.0f;
            }

            /* ---- Apply Outputs ---- */
            /* In production, these would write to DAC/PWM hardware registers */
            /* hw_set_heater(heater_output); */
            /* hw_set_valve(valve_position); */
            /* hw_set_pump(pump_speed); */

            (void)heater_output;
            (void)valve_position;
            (void)pump_speed;
        }
        else
        {
            /* Data timeout - no fresh sensor data within 50ms.
             * Enter failsafe mode: shut down heater, open valve, stop pump */
            heater_output = 0.0f;
            valve_position = 100.0f;
            pump_speed = 0.0f;

            temp_integral = 0.0f;
            pressure_integral = 0.0f;

            /* hw_set_heater(0.0f); */
            /* hw_set_valve(100.0f); */
            /* hw_set_pump(0.0f); */
            /* hw_trigger_alarm(ALARM_SENSOR_TIMEOUT); */
        }
    }
}

/* ----------------------------------------------------------------
 * System initialization
 * ---------------------------------------------------------------- */
void vSystemInit(void)
{
    /* Create the mutex for shared sensor data protection */
    xSensorDataMutex = xSemaphoreCreateMutex();
    configASSERT(xSensorDataMutex != NULL);

    /* Create binary semaphore for data-ready signaling.
     * Created empty so control task blocks until first reading. */
    xDataReadySemaphore = xSemaphoreCreateBinary();
    configASSERT(xDataReadySemaphore != NULL);

    /* Initialize shared data to safe defaults */
    taskENTER_CRITICAL();
    {
        SensorData_t init_data = {0};
        init_data.temperature = 0.0f;
        init_data.pressure = 0.0f;
        init_data.flow_rate = 0.0f;
        init_data.timestamp = 0;
        init_data.status_flags = 0;
        init_data.sequence_number = 0;
        memcpy((SensorData_t *)&sensor_data, &init_data, sizeof(SensorData_t));
    }
    taskEXIT_CRITICAL();

    /* Create sensor read task at higher priority (tight timing requirement) */
    BaseType_t xResult;
    xResult = xTaskCreate(
        vSensorReadTask,
        "SensorRead",
        configMINIMAL_STACK_SIZE + 128,
        NULL,
        configMAX_PRIORITIES - 1,   /* Highest application priority */
        &xSensorReadTaskHandle
    );
    configASSERT(xResult == pdPASS);

    /* Create control processing task at next lower priority */
    xResult = xTaskCreate(
        vControlProcessTask,
        "CtrlProcess",
        configMINIMAL_STACK_SIZE + 256,
        NULL,
        configMAX_PRIORITIES - 2,
        &xControlProcessTaskHandle
    );
    configASSERT(xResult == pdPASS);
}

/* ----------------------------------------------------------------
 * Main entry point
 * ---------------------------------------------------------------- */
int main(void)
{
    /* Hardware initialization would go here */
    /* hw_init_sensors(); */
    /* hw_init_actuators(); */

    vSystemInit();

    /* Start the FreeRTOS scheduler - does not return */
    vTaskStartScheduler();

    /* Should never reach here */
    for (;;)
    {
    }

    return 0;
}