# Generated by anthropic (claude-opus-4-6)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.

Use platform-appropriate secure techniques to prevent insecure zigbee.
# Category: insecure_zigbee

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <stdbool.h>
#include <time.h>

/* Zigbee Network Configuration Constants */
#define ZIGBEE_MAX_NETWORK_KEY_LEN    16
#define ZIGBEE_MAX_LINK_KEY_LEN       16
#define ZIGBEE_EUI64_LEN              8
#define ZIGBEE_PAN_ID_LEN             2
#define ZIGBEE_CHANNEL_MIN            11
#define ZIGBEE_CHANNEL_MAX            26
#define ZIGBEE_MAX_RETRIES            5
#define ZIGBEE_PERMIT_JOIN_DURATION   180  /* seconds - limited window */
#define ZIGBEE_SCAN_DURATION          5
#define ZIGBEE_MAX_NEIGHBORS          32
#define ZIGBEE_INSTALL_CODE_LEN       18   /* 16 bytes + 2 byte CRC */

/* Security Levels */
#define SECURITY_LEVEL_NONE           0x00
#define SECURITY_LEVEL_AES_CCM_128    0x05
#define SECURITY_LEVEL_AES_CCM_64     0x06
#define SECURITY_LEVEL_AES_CCM_32     0x07

/* Network States */
typedef enum {
    NETWORK_STATE_UNINITIALIZED = 0,
    NETWORK_STATE_SCANNING,
    NETWORK_STATE_JOINING,
    NETWORK_STATE_AUTHENTICATING,
    NETWORK_STATE_KEY_EXCHANGE,
    NETWORK_STATE_JOINED,
    NETWORK_STATE_OPERATIONAL,
    NETWORK_STATE_LEAVING,
    NETWORK_STATE_ERROR
} zigbee_network_state_t;

/* Device Types */
typedef enum {
    DEVICE_TYPE_COORDINATOR = 0,
    DEVICE_TYPE_ROUTER,
    DEVICE_TYPE_END_DEVICE
} zigbee_device_type_t;

/* Commissioning Method */
typedef enum {
    COMMISSION_INSTALL_CODE = 0,   /* Most secure - preferred */
    COMMISSION_TOUCHLINK,
    COMMISSION_OUT_OF_BAND,
    COMMISSION_CENTRALIZED_TRUST_CENTER
} zigbee_commission_method_t;

/* Security Key Types */
typedef enum {
    KEY_TYPE_NONE = 0,
    KEY_TYPE_TRUST_CENTER_LINK,
    KEY_TYPE_NETWORK,
    KEY_TYPE_APPLICATION_LINK,
    KEY_TYPE_INSTALL_CODE_DERIVED
} zigbee_key_type_t;

/* Error Codes */
typedef enum {
    ZB_SUCCESS = 0,
    ZB_ERR_NO_NETWORK,
    ZB_ERR_JOIN_FAILED,
    ZB_ERR_AUTH_FAILED,
    ZB_ERR_KEY_EXCHANGE_FAILED,
    ZB_ERR_PERMIT_JOIN_DENIED,
    ZB_ERR_INVALID_CHANNEL,
    ZB_ERR_SECURITY_FAILURE,
    ZB_ERR_TIMEOUT,
    ZB_ERR_INVALID_PARAM,
    ZB_ERR_INSECURE_KEY,
    ZB_ERR_INSTALL_CODE_INVALID,
    ZB_ERR_MEMORY
} zigbee_error_t;

/* Zigbee Security Key */
typedef struct {
    uint8_t key_data[ZIGBEE_MAX_LINK_KEY_LEN];
    zigbee_key_type_t key_type;
    uint32_t sequence_number;
    uint32_t frame_counter;
    bool is_valid;
    time_t creation_time;
    time_t expiry_time;
} zigbee_security_key_t;

/* Install Code Structure */
typedef struct {
    uint8_t code[ZIGBEE_INSTALL_CODE_LEN];
    uint8_t code_length;
    uint8_t derived_key[ZIGBEE_MAX_LINK_KEY_LEN];
    bool is_valid;
    uint16_t crc;
} zigbee_install_code_t;

/* Network Descriptor */
typedef struct {
    uint16_t pan_id;
    uint64_t extended_pan_id;
    uint8_t channel;
    uint8_t stack_profile;
    uint8_t zigbee_version;
    uint8_t security_level;
    bool permit_joining;
    int8_t rssi;
    uint8_t lqi;
} zigbee_network_descriptor_t;

/* Neighbor Table Entry */
typedef struct {
    uint64_t eui64;
    uint16_t short_address;
    zigbee_device_type_t device_type;
    int8_t rssi;
    uint8_t lqi;
    bool is_authenticated;
    uint32_t last_seen;
} zigbee_neighbor_t;

/* Trust Center Configuration */
typedef struct {
    uint64_t trust_center_eui64;
    uint16_t trust_center_short_addr;
    zigbee_security_key_t trust_center_link_key;
    zigbee_security_key_t network_key;
    bool require_install_codes;
    bool use_global_link_key;
    uint8_t security_level;
    uint32_t key_rotation_interval;
    uint32_t last_key_rotation;
} zigbee_trust_center_config_t;

/* Permit Join Configuration */
typedef struct {
    bool is_active;
    uint16_t duration_seconds;
    time_t start_time;
    time_t end_time;
    bool require_install_code;
    uint8_t max_devices_allowed;
    uint8_t devices_joined_count;
} zigbee_permit_join_config_t;

/* Smart Light Bulb Specific */
typedef struct {
    bool is_on;
    uint8_t brightness;       /* 0-254 */
    uint16_t color_temp;      /* Mireds */
    uint8_t color_x;
    uint8_t color_y;
    uint16_t transition_time; /* Tenths of seconds */
} smart_light_state_t;

/* Main Device Context */
typedef struct {
    /* Device Identity */
    uint64_t eui64;
    uint16_t short_address;
    zigbee_device_type_t device_type;

    /* Network State */
    zigbee_network_state_t network_state;
    zigbee_network_descriptor_t current_network;
    zigbee_network_descriptor_t discovered_networks[8];
    uint8_t discovered_network_count;

    /* Security */
    zigbee_trust_center_config_t trust_center;
    zigbee_install_code_t install_code;
    zigbee_commission_method_t commission_method;

    /* Permit Join */
    zigbee_permit_join_config_t permit_join;

    /* Neighbors */
    zigbee_neighbor_t neighbors[ZIGBEE_MAX_NEIGHBORS];
    uint8_t neighbor_count;

    /* Light State */
    smart_light_state_t light_state;

    /* Operational */
    uint32_t join_retry_count;
    bool is_commissioned;
    bool factory_reset_pending;
    uint32_t uptime_seconds;
} zigbee_device_context_t;

/* Global device context */
static zigbee_device_context_t g_device_ctx;

/* ============================================================
 * Forward Declarations
 * ============================================================ */
static zigbee_error_t zigbee_hardware_init(void);
static zigbee_error_t zigbee_security_init(zigbee_device_context_t *ctx);
static zigbee_error_t zigbee_validate_install_code(const zigbee_install_code_t *ic);
static zigbee_error_t zigbee_derive_link_key_from_install_code(
    const zigbee_install_code_t *ic, uint8_t *derived_key);
static zigbee_error_t zigbee_scan_networks(zigbee_device_context_t *ctx);
static zigbee_error_t zigbee_select_best_network(zigbee_device_context_t *ctx,
    zigbee_network_descriptor_t *selected);
static zigbee_error_t zigbee_join_network(zigbee_device_context_t *ctx,
    const zigbee_network_descriptor_t *network);
static zigbee_error_t zigbee_authenticate_with_trust_center(zigbee_device_context_t *ctx);
static zigbee_error_t zigbee_perform_key_exchange(zigbee_device_context_t *ctx);
static zigbee_error_t zigbee_enable_permit_join(zigbee_device_context_t *ctx,
    uint16_t duration_seconds);
static zigbee_error_t zigbee_disable_permit_join(zigbee_device_context_t *ctx);
static void zigbee_permit_join_timeout_handler(zigbee_device_context_t *ctx);
static bool zigbee_is_key_secure(const uint8_t *key, size_t key_len);
static void zigbee_secure_memzero(void *ptr, size_t len);
static uint16_t zigbee_compute_crc16(const uint8_t *data, size_t len);
static void zigbee_log(const char *level, const char *fmt, ...);
static zigbee_error_t zigbee_register_endpoints(zigbee_device_context_t *ctx);
static zigbee_error_t zigbee_light_cluster_init(zigbee_device_context_t *ctx);

/* ============================================================
 * Platform Abstraction - Secure Random Number Generation
 * ============================================================ */

/*
 * Generate cryptographically secure random bytes.
 * Uses platform-appropriate CSPRNG (e.g., hardware RNG on embedded,
 * /dev/urandom on Linux for development).
 */
static zigbee_error_t secure_random_bytes(uint8_t *buffer, size_t length)
{
    if (buffer == NULL || length == 0) {
        return ZB_ERR_INVALID_PARAM;
    }

    /*
     * In production firmware, this would use the hardware TRNG/RNG
     * peripheral of the Zigbee SoC (e.g., EFR32, CC2652, nRF52840).
     * For development/simulation, we use /dev/urandom.
     */
#if defined(__linux__) || defined(__APPLE__)
    FILE *urandom = fopen("/dev/urandom", "rb");
    if (urandom == NULL) {
        zigbee_log("ERROR", "Failed to open /dev/urandom");
        return ZB_ERR_SECURITY_FAILURE;
    }

    size_t bytes_read = fread(buffer, 1, length, urandom);
    fclose(urandom);

    if (bytes_read != length) {
        zigbee_secure_memzero(buffer, length);
        return ZB_ERR_SECURITY_FAILURE;
    }
#else
    /* Hardware RNG placeholder for embedded targets */
    /* hw_rng_generate(buffer, length); */
    for (size_t i = 0; i < length; i++) {
        buffer[i] = (uint8_t)(rand() & 0xFF); /* PLACEHOLDER ONLY */
    }
#endif

    return ZB_SUCCESS;
}

/* ============================================================
 * Secure Memory Operations
 * ============================================================ */

/*
 * Securely zero memory to prevent key material from lingering.
 * Uses volatile pointer to prevent compiler optimization.
 */
static void zigbee_secure_memzero(void *ptr, size_t len)
{
    if (ptr == NULL || len == 0) {
        return;
    }

    volatile uint8_t *p = (volatile uint8_t *)ptr;
    while (len--) {
        *p++ = 0;
    }
}

/*
 * Constant-time memory comparison to prevent timing side-channel attacks.
 */
static bool zigbee_secure_memcmp(const void *a, const void *b, size_t len)
{
    const volatile uint8_t *pa = (const volatile uint8_t *)a;
    const volatile uint8_t *pb = (const volatile uint8_t *)b;
    uint8_t diff = 0;

    for (size_t i = 0; i < len; i++) {
        diff |= pa[i] ^ pb[i];
    }

    return (diff == 0);
}

/* ============================================================
 * Logging
 * ============================================================ */

#include <stdarg.h>

static void zigbee_log(const char *level, const char *fmt, ...)
{
    time_t now = time(NULL);
    struct tm *tm_info = localtime(&now);
    char time_buf[26];
    strftime(time_buf, sizeof(time_buf), "%Y-%m-%d %H:%M:%S", tm_info);

    fprintf(stdout, "[%s] [%s] ", time_buf, level);

    va_list args;
    va_start(args, fmt);
    vfprintf(stdout, fmt, args);
    va_end(args);

    fprintf(stdout, "\n");
    fflush(stdout);
}

/* ============================================================
 * CRC-16/CCITT for Install Code Validation
 * ============================================================ */

static uint16_t zigbee_compute_crc16(const uint8_t *data, size_t len)
{
    uint16_t crc = 0xFFFF;

    for (size_t i = 0; i < len; i++) {
        crc ^= (uint16_t)data[i] << 8;
        for (int j = 0; j < 8; j++) {
            if (crc & 0x8000) {
                crc = (crc << 1) ^ 0x1021;
            } else {
                crc <<= 1;
            }
        }
    }

    return crc;
}

/* ============================================================
 * AES-128 MMO Hash (Matyas-Meyer-Oseas) for Install Code Key Derivation
 * ============================================================ */

/*
 * Simplified AES-128 block cipher placeholder.
 * In production, use hardware AES accelerator or verified library.
 */
static void aes128_encrypt_block(const uint8_t key[16], const uint8_t input[16],
                                  uint8_t output[16])
{
    /*
     * PLACEHOLDER: In real firmware, this calls the hardware AES engine
     * (e.g., CRYPTO peripheral on EFR32, AES module on CC2652).
     *
     * For production: use mbedtls_aes_crypt_ecb() or hardware crypto API.
     */
    for (int i = 0; i < 16; i++) {
        output[i] = key[i] ^ input[i]; /* NOT real AES - placeholder only */
    }
    zigbee_log("WARN", "Using placeholder AES - replace with hardware crypto in production");
}

/*
 * Matyas-Meyer-Oseas hash function as specified in Zigbee spec.
 * Used to derive link key from install code.
 */
static zigbee_error_t zigbee_mmo_hash(const uint8_t *input, size_t input_len,
                                       uint8_t output[16])
{
    uint8_t hash[16];
    uint8_t temp[16];
    uint8_t block[16];
    size_t remaining = input_len;
    size_t offset = 0;

    memset(hash, 0, 16);

    /* Process full blocks */
    while (remaining >= 16) {
        memcpy(block, input + offset, 16);

        aes128_encrypt_block(hash, block, temp);

        for (int i = 0; i < 16; i++) {
            hash[i] = temp[i] ^ block[i];
        }

        offset += 16;
        remaining -= 16;
    }

    /* Process final block with padding */
    memset(block, 0, 16);
    if (remaining > 0) {
        memcpy(block, input + offset, remaining);
    }
    block[remaining] = 0x80;

    /* If there's room for the length in this block */
    if (remaining < 14) {
        uint16_t bit_len = (uint16_t)(input_len * 8);
        block[14] = (uint8_t)(bit_len >> 8);
        block[15] = (uint8_t)(bit_len & 0xFF);

        aes128_encrypt_block(hash, block, temp);
        for (int i = 0; i < 16; i++) {
            hash[i] = temp[i] ^ block[i];
        }
    } else {
        /* Need an extra block for length */
        aes128_encrypt_block(hash, block, temp);
        for (int i = 0; i < 16; i++) {
            hash[i] = temp[i] ^ block[i];
        }

        memset(block, 0, 16);
        uint16_t bit_len = (uint16_t)(input_len * 8);
        block[14] = (uint8_t)(bit_len >> 8);
        block[15] = (uint8_t)(bit_len & 0xFF);

        aes128_encrypt_block(hash, block, temp);
        for (int i = 0; i < 16; i++) {
            hash[i] = temp[i] ^ block[i];
        }
    }

    memcpy(output, hash, 16);
    zigbee_secure_memzero(temp, sizeof(temp));
    zigbee_secure_memzero(block, sizeof(block));

    return ZB_SUCCESS;
}

/* ============================================================
 * Security Key Validation
 * ============================================================ */

/* Well-known insecure keys that must be rejected */
static const uint8_t ZIGBEE_DEFAULT_TC_LINK_KEY[16] = {
    0x5A, 0x69, 0x67, 0x42, 0x65, 0x65, 0x41, 0x6C,
    0x6C, 0x69, 0x61, 0x6E, 0x63, 0x65, 0x30, 0x39
};

static const uint8_t ZIGBEE_DISTRIBUTED_LINK_KEY[16] = {
    0xD0, 0xD1, 0xD2, 0xD3, 0xD4, 0xD5, 0xD6, 0xD7,
    0xD8, 0xD9, 0xDA, 0xDB, 0xDC, 0xDD, 0xDE, 0xDF
};

/*
 * Check if a key is cryptographically adequate.
 * Rejects all-zero keys, all-FF keys, known default keys when
 * install-code commissioning is required, and low-entropy keys.
 */
static bool zigbee_is_key_secure(const uint8_t *key, size_t key_len)
{
    if (key == NULL || key_len != ZIGBEE_MAX_LINK_KEY_LEN) {
        return false;
    }

    /* Check for all-zero key */
    bool all_zero = true;
    bool all_ff = true;
    for (size_t i = 0; i < key_len; i++) {
        if (key[i] != 0x00) all_zero = false;
        if (key[i] != 0xFF) all_ff = false;
    }

    if (all_zero) {
        zigbee_log("SECURITY", "Rejected all-zero key");
        return false;
    }

    if (all_ff) {
        zigbee_log("SECURITY", "Rejected all-0xFF key");
        return false;
    }

    /* Check entropy - count unique byte values */
    uint8_t seen[256] = {0};
    int unique_count = 0;
    for (size_t i = 0; i < key_len; i++) {
        if (!seen[key[i]]) {
            seen[key[i]] = 1;
            unique_count++;
        }
    }

    /* Require at least 4 unique byte values for a 16-byte key */
    if (unique_count < 4) {
        zigbee_log("SECURITY", "Rejected low-entropy key (only %d unique bytes)",
                   unique_count);
        return false;
    }

    return true;
}

/*
 * Validate that we are not using the well-known default trust center
 * link key for long-term operation. The default key may only be used
 * during initial joining before a unique key is established.
 */
static bool zigbee_is_default_link_key(const uint8_t *key)
{
    if (zigbee_secure_memcmp(key, ZIGBEE_DEFAULT_TC_LINK_KEY, 16)) {
        return true;
    }
    if (zigbee_secure_memcmp(key, ZIGBEE_DISTRIBUTED_LINK_KEY, 16)) {
        return true;
    }
    return false;
}

/* ============================================================
 * Install Code Management
 * ============================================================ */

/*
 * Validate an install code including its CRC.
 * Install codes provide per-device unique link keys, which is the
 * most secure commissioning method for Zigbee 3.0.
 */
static zigbee_error_t zigbee_validate_install_code(const zigbee_install_code_t *ic)
{
    if (ic == NULL) {
        return ZB_ERR_INVALID_PARAM;
    }

    /* Valid install code lengths: 6, 8, 12, or 16 bytes + 2 byte CRC */
    if (ic->code_length != 8 && ic->code_length != 10 &&
        ic->code_length != 14 && ic->code_length != 18) {
        zigbee_log("SECURITY", "Invalid install code length: %d", ic->code_length);
        return ZB_ERR_INSTALL_CODE_INVALID;
    }

    /* Verify CRC-16/CCITT */
    uint8_t data_len = ic->code_length - 2;
    uint16_t computed_crc = zigbee_compute_crc16(ic->code, data_len);
    uint16_t stored_crc = ((uint16_t)ic->code[data_len] |
                           ((uint16_t)ic->code[data_len + 1] << 8));

    if (computed_crc != stored_crc) {
        zigbee_log("SECURITY", "Install code CRC mismatch: computed=0x%04X stored=0x%04X",
                   computed_crc, stored_crc);
        return ZB_ERR_INSTALL_CODE_INVALID;
    }

    /* Check that install code has sufficient entropy */
    uint8_t seen[256] = {0};
    int unique = 0;
    for (uint8_t i = 0; i < data_len; i++) {
        if (!seen[ic->code[i]]) {
            seen[ic->code[i]] = 1;
            unique++;
        }
    }

    if (unique < 3) {
        zigbee_log("SECURITY", "Install code has insufficient entropy");
        return ZB_ERR_INSTALL_CODE_INVALID;
    }

    zigbee_log("INFO", "Install code validated successfully (length=%d, CRC=0x%04X)",
               ic->code_length, computed_crc);
    return ZB_SUCCESS;
}

/*
 * Derive a unique link key from an install code using MMO hash.
 * This ensures each device gets a unique trust center link key.
 */
static zigbee_error_t zigbee_derive_link_key_from_install_code(
    const zigbee_install_code_t *ic, uint8_t *derived_key)
{
    if (ic == NULL || derived_key == NULL) {
        return ZB_ERR_INVALID_PARAM;
    }

    zigbee_error_t err = zigbee_validate_install_code(ic);
    if (err != ZB_SUCCESS) {
        return err;
    }

    /* Use MMO hash to derive the link key from the full install code (including CRC) */
    err = zigbee_mmo_hash(ic->code, ic->code_length, derived_key);
    if (err != ZB_SUCCESS) {
        zigbee_secure_memzero(derived_key, ZIGBEE_MAX_LINK_KEY_LEN);
        return err;
    }

    /* Validate the derived key */
    if (!zigbee_is_key_secure(derived_key, ZIGBEE_MAX_LINK_KEY_LEN)) {
        zigbee_log("SECURITY", "Derived key failed security validation");
        zigbee_secure_memzero(derived_key, ZIGBEE_MAX_LINK_KEY_LEN);
        return ZB_ERR_SECURITY_FAILURE;
    }

    zigbee_log("INFO", "Link key derived from install code successfully");
    return ZB_SUCCESS;
}

/* ============================================================
 * Hardware Initialization
 * ============================================================ */

static zigbee_error_t zigbee_hardware_init(void)
{
    zigbee_log("INFO", "Initializing Zigbee radio hardware");

    /*
     * In production firmware, this would:
     * 1. Initialize the radio transceiver (e.g., EFR32 RAIL, CC2652 RF core)
     * 2. Configure GPIO for antenna switching
     * 3. Set TX power level
     * 4. Initialize hardware crypto accelerator
     * 5. Load calibration data
     */

    zigbee_log("INFO", "Hardware initialization complete");
    return ZB_SUCCESS;
}

/* ============================================================
 * Security Initialization
 * ============================================================ */

static zigbee_error_t zigbee_security_init(zigbee_device_context_t *ctx)
{
    if (ctx == NULL) {
        return ZB_ERR_INVALID_PARAM;
    }

    zigbee_log("INFO", "Initializing security subsystem");

    /* Set security level to AES-CCM-128 (highest) */
    ctx->trust_center.security_level = SECURITY_LEVEL_AES_CCM_128;

    /* Prefer install code based commissioning */
    ctx->commission_method = COMMISSION_INSTALL_CODE;
    ctx->trust_center.require_install_codes = true;
    ctx->trust_center.use_global_link_key = false;

    /* Initialize frame counters to prevent replay attacks */
    ctx->trust_center.trust_center_link_key.frame_counter = 0;
    ctx->trust_center.trust_center_link_key.sequence_number = 0;
    ctx->trust_center.network_key.frame_counter = 0;
    ctx->trust_center.network_key.sequence_number = 0;

    /* Set key rotation interval (24 hours in seconds) */
    ctx->trust_center.key_rotation_interval = 86400;
    ctx->trust_center.last_key_rotation = (uint32_t)time(NULL);

    /* If we have an install code, derive the link key from it */
    if (ctx->install_code.is_valid) {
        zigbee_error_t err = zigbee_derive_link_key_from_install_code(
            &ctx->install_code,
            ctx->trust_center.trust_center_link_key.key_data);

        if (err != ZB_SUCCESS) {
            zigbee_log("ERROR", "Failed to derive link key from install code");
            return err;
        }

        ctx->trust_center.trust_center_link_key.key_type = KEY_TYPE_INSTALL_CODE_DERIVED;
        ctx->trust_center.trust_center_link_key.is_valid = true;
        ctx->trust_center.trust_center_link_key.creation_time = time(NULL);

        zigbee_log("SECURITY", "Using install-code-derived link key for joining");
    } else {
        /*
         * Fallback: Use the well-known default TC link key for initial joining.
         * This is less secure but required for interoperability when install
         * codes are not available. The key MUST be replaced with a unique
         * key during the trust center key exchange after joining.
         */
        zigbee_log("SECURITY",
                   "WARNING: No install code available, using default TC link key for initial join");
        zigbee_log("SECURITY",
                   "A unique link key MUST be established after joining");

        memcpy(ctx->trust_center.trust_center_link_key.key_data,
               ZIGBEE_DEFAULT_TC_LINK_KEY, 16);
        ctx->trust_center.trust_center_link_key.key_type = KEY_TYPE_TRUST_CENTER_LINK;
        ctx->trust_center.trust_center_link_key.is_valid = true;
        ctx->trust_center.trust_center_link_key.creation_time = time(NULL);
        /* Mark for mandatory replacement */
        ctx->trust_center.use_global_link_key = true;
    }

    zigbee_log("INFO", "Security subsystem initialized");
    return ZB_SUCCESS;
}

/* ============================================================
 * Network Scanning
 * ============================================================ */

static zigbee_error_t zigbee_scan_networks(zigbee_device_context_t *ctx)
{
    if (ctx == NULL) {
        return ZB_ERR_INVALID_PARAM;
    }

    zigbee_log("INFO", "Starting network scan on channels %d-%d",
               ZIGBEE_CHANNEL_MIN, ZIGBEE_CHANNEL_MAX);

    ctx->network_state = NETWORK_STATE_SCANNING;
    ctx->discovered_network_count = 0;

    /*
     * In production firmware, this would:
     * 1. Issue an active scan (beacon request) on each channel
     * 2. Collect beacon responses
     * 3. Parse network descriptors from beacons
     * 4. Filter for Zigbee 3.0 compatible networks
     */

    /* Simulated network discovery for development */
    zigbee_network_descriptor_t simulated_network = {
        .pan_id = 0x1A2B,
        .extended_pan_id = 0x0011223344556677ULL,
        .channel = 15,
        .stack_profile = 2,    /* Zigbee PRO */
        .zigbee_version = 3,   /* Zigbee 3.0 */
        .security_level = SECURITY_LEVEL_AES_CCM_128,
        .permit_joining = true,
        .rssi = -45,
        .lqi = 220
    };

    /* Only accept networks with proper security */
    if (simulated_network.security_level < SECURITY_LEVEL_AES_CCM_128) {
        zigbee_log("SECURITY",
                   "Rejecting network PAN 0x%04X: insufficient security level (%d)",
                   simulated_network.pan_id, simulated_network.security_level);
    } else {
        ctx->discovered_networks[0] = simulated_network;
        ctx->discovered_network_count = 1;
        zigbee_log("INFO", "Found network: PAN=0x%04X, CH=%d, RSSI=%d, Security=%d",
                   simulated_network.pan_id, simulated_network.channel,
                   simulated_network.rssi, simulated_network.security_level);
    }

    if (ctx->discovered_network_count == 0) {
        zigbee_log("WARN", "No suitable networks found");
        ctx->network_state = NETWORK_STATE_ERROR;
        return ZB_ERR_NO_NETWORK;
    }

    zigbee_log("INFO", "Network scan complete: %d network(s) found",
               ctx->discovered_network_count);
    return ZB_SUCCESS;
}

/* ============================================================
 * Network Selection
 * ============================================================ */

static zigbee_error_t zigbee_select_best_network(zigbee_device_context_t *ctx,
    zigbee_network_descriptor_t *selected)
{
    if (ctx == NULL || selected == NULL) {
        return ZB_ERR_INVALID_PARAM;
    }

    if (ctx->discovered_network_count == 0) {
        return ZB_ERR_NO_NETWORK;
    }

    int best_index = -1;
    int best_score = -1000;

    for (uint8_t i = 0; i < ctx->discovered_network_count; i++) {
        zigbee_network_descriptor_t *net = &ctx->discovered_networks[i];

        /* SECURITY: Reject networks without adequate security */
        if (net->security_level < SECURITY_LEVEL_AES_CCM_128) {
            zigbee_log("SECURITY", "Skipping network PAN 0x%04X: weak security",
                       net->pan_id);
            continue;
        }

        /* SECURITY: Reject non-Zigbee PRO networks */
        if (net->stack_profile != 2) {
            zigbee_log("SECURITY", "Skipping network PAN 0x%04X: not Zigbee PRO",
                       net->pan_id);
            continue;
        }

        /* Must be permitting joins */
        if (!net->permit_joining) {
            zigbee_log("INFO", "Skipping network PAN 0x%04X: not permitting joins",
                       net->pan_id);
            continue;
        }

        /* Score based on signal quality */
        int score = net->rssi + (net->lqi / 2);

        if (score > best_score) {
            best_score = score;
            best_index = i;
        }
    }

    if (best_index < 0) {
        zigbee_log("WARN", "No suitable network found after filtering");
        return ZB_ERR_NO_NETWORK;
    }

    *selected = ctx->discovered_networks[best_index];
    zigbee_log("INFO", "Selected network: PAN=0x%04X, CH=%d, Score=%d",
               selected->pan_id, selected->channel, best_score);

    return ZB_SUCCESS;
}

/* ============================================================
 * Network Joining
 * ============================================================ */

static zigbee_error_t zigbee_join_network(zigbee_device_context_t *ctx,
    const zigbee_network_descriptor_t *network)
{
    if (ctx == NULL || network == NULL) {
        return ZB_ERR_INVALID_PARAM;
    }

    /* Validate channel range */
    if (network->channel < ZIGBEE_CHANNEL_MIN ||
        network->channel > ZIGBEE_CHANNEL_MAX) {
        zigbee_log("ERROR", "Invalid channel: %d", network->channel);
        return ZB_ERR_INVALID_CHANNEL;
    }

    /* SECURITY: Verify we have a valid link key before attempting to join */
    if (!ctx->trust_center.trust_center_link_key.is_valid) {
        zigbee_log("SECURITY", "Cannot join: no valid trust center link key");
        return ZB_ERR_SECURITY_FAILURE;
    }

    zigbee_log("INFO", "Attempting to join network PAN=0x%04X on channel %d",
               network->pan_id, network->channel);

    ctx->network_state = NETWORK_STATE_JOINING;
    ctx->current_network = *network;

    /*
     * In production firmware, this would:
     * 1. Set the radio to the target channel
     * 2. Send an Association Request to the network
     * 3. Wait for Association Response with short address
     * 4. Begin the security handshake
     */

    /* Simulate receiving a short address assignment */
    ctx->short_address = 0x1234; /* Would come from coordinator */

    zigbee_log("INFO", "Association successful, short address: 0x%04X",
               ctx->short_address);

    /* Proceed to authentication */
    zigbee_error_t err = zigbee_authenticate_with_trust_center(ctx);
    if (err != ZB_SUCCESS) {
        zigbee_log("ERROR", "Trust center authentication failed");
        ctx->network_state = NETWORK_STATE_ERROR;
        return err;
    }

    /* Perform key exchange to get unique keys */
    err = zigbee_perform_key_exchange(ctx);
    if (err != ZB_SUCCESS) {
        zigbee_log("ERROR", "Key exchange failed");
        ctx->network_state = NETWORK_STATE_ERROR;
        return err;
    }

    ctx->network_state = NETWORK_STATE_JOINED;
    zigbee_log("INFO", "Successfully joined network PAN=0x%04X", network->pan_id);

    return ZB_SUCCESS;
}

/* ============================================================
 * Trust Center Authentication
 * ============================================================ */

static zigbee_error_t zigbee_authenticate_with_trust_center(zigbee_device_context_t *ctx)
{
    if (ctx == NULL) {
        return ZB_ERR_INVALID_PARAM;
    }

    zigbee_log("INFO", "Authenticating with trust center");
    ctx->network_state = NETWORK_STATE_AUTHENTICATING;

    /*
     * The authentication process:
     * 1. Device sends its EUI-64 to the trust center
     * 2. Trust center looks up the device's pre-configured link key
     *    (derived from install code) or uses the default TC link key
     * 3. Trust center sends the network key encrypted with the link key
     * 4. Device decrypts and installs the network key
     *
     * SECURITY: If using the default TC link key, the network key
     * transport is vulnerable to eavesdropping. Install codes mitigate this.
     */

    if (ctx->trust_center.use_global_link_key) {
        zigbee_log("SECURITY",
                   "WARNING: Authenticating with default link key - "
                   "network key transport may be vulnerable to eavesdropping");
        zigbee_log("SECURITY",
                   "RECOMMENDATION: Use install codes for secure commissioning");
    } else {
        zigbee_log("SECURITY",
                   "Authenticating with install-code-derived link key (secure)");
    }

    /*
     * Simulate receiving the network key from the trust center.
     * In production, this comes encrypted in a Transport Key command.
     */
    uint8_t received_network_key[16];
    zigbee_error_t err = secure_random_bytes(received_network_key, 16);
    if (err != ZB_SUCCESS) {
        return ZB_ERR_SECURITY_FAILURE;
    }

    /* Validate the received network key */
    if (!zigbee_is_key_secure(received_network_key, 16)) {
        zigbee_log("SECURITY", "Received network key failed security validation");
        zigbee_secure_memzero(received_network_key, 16);
        return ZB_ERR_SECURITY_FAILURE;
    }

    /* Install the network key */
    memcpy(ctx->trust_center.network_key.key_data, received_network_key, 16);
    ctx->trust_center.network_key.key_type = KEY_TYPE_NETWORK;
    ctx->trust_center.network_key.is_valid = true;
    ctx->trust_center.network_key.frame_counter = 0;
    ctx->trust_center.network_key.creation_time = time(NULL);

    /* Clear temporary key material */
    zigbee_secure_memzero(received_network_key, sizeof(received_network_key));

    /* Send a Verify Key request to confirm we received the key correctly */
    zigbee_log("INFO", "Sending key verification to trust center");

    /*
     * In production: send APS Verify Key with HMAC of the TC link key
     * and wait for Confirm Key response.
     */

    zigbee_log("INFO", "Trust center authentication successful");
    return ZB_SUCCESS;
}

/* ============================================================
 * Key Exchange - Establish Unique Link Key
 * ============================================================ */

static zigbee_error_t zigbee_perform_key_exchange(zigbee_device_context_t *ctx)
{
    if (ctx == NULL) {
        return ZB_ERR_INVALID_PARAM;
    }

    zigbee_log("INFO", "Performing key exchange with trust center");
    ctx->network_state = NETWORK_STATE_KEY_EXCHANGE;

    /*
     * If we joined with the default TC link key, we MUST request
     * a unique link key via Certificate-Based Key Establishment (CBKE)
     * or Request Key mechanism.
     *
     * SECURITY: Operating with the default link key long-term is
     * a significant security risk as any device that knows the
     * default key can decrypt traffic.
     */

    if (ctx->trust_center.use_global_link_key) {
        zigbee_log("SECURITY",
                   "Requesting unique trust center link key to replace default key");

        /*
         * In production firmware:
         * 1. Send APS Request Key (key type = TC link key) to trust center
         * 2. Trust center generates a unique link key for this device
         * 3. Trust center sends Transport Key with the new unique link key
         *    encrypted with the old (default) link key
         * 4. Device installs the new unique link key
         * 5. Device sends Verify Key to confirm
         * 6. Trust center sends Confirm Key
         * 7. Old default link key is securely erased
         */

        uint8_t new_unique_key[16];
        zigbee_error_t err = secure_random_bytes(new_unique_key, 16);
        if (err != ZB_SUCCESS) {
            return ZB_ERR_KEY_EXCHANGE_FAILED;
        }

        if (!zigbee_is_key_secure(new_unique_key, 16)) {
            zigbee_secure_memzero(new_unique_key, 16);
            zigbee_log("SECURITY", "Generated unique key failed security check");
            return ZB_ERR_KEY_EXCHANGE_FAILED;
        }

        /* Verify the new key is not the same as the default key */
        if (zigbee_is_default_link_key(new_unique_key)) {
            zigbee_secure_memzero(new_unique_key, 16);
            zigbee_log("SECURITY", "Trust center returned default key as unique key - rejecting");
            return ZB_ERR_KEY_EXCHANGE_FAILED;
        }

        /* Install the new unique link key */
        zigbee_secure_memzero(ctx->trust_center.trust_center_link_key.key_data, 16);
        memcpy(ctx->trust_center.trust_center_link_key.key_data, new_unique_key, 16);
        ctx->trust_center.trust_center_link_key.key_type = KEY_TYPE_TRUST_CENTER_LINK;
        ctx->trust_center.trust_center_link_key.frame_counter = 0;
        ctx->trust_center.trust_center_link_key.creation_time = time(NULL);
        ctx->trust_center.use_global_link_key = false;

        zigbee_secure_memzero(new_unique_key, sizeof(new_unique_key));

        zigbee_log("SECURITY", "Unique trust center link key established successfully");
    } else {
        zigbee_log("SECURITY",
                   "Already using install-code-derived unique link key");
    }

    /* Verify final security state */
    if (zigbee_is_default_link_key(ctx->trust_center.trust_center_link_key.key_data)) {
        zigbee_log("SECURITY",
                   "CRITICAL: Still using default link key after key exchange - "
                   "this is a security vulnerability");
        return ZB_ERR_SECURITY_FAILURE;
    }

    zigbee_log("INFO", "Key exchange complete");
    return ZB_SUCCESS;
}

/* ============================================================
 * Permit Join Management
 * ============================================================ */

/*
 * Enable permit join mode with security constraints.
 * This allows new devices to join the network for a limited time.
 *
 * SECURITY CONSIDERATIONS:
 * - Duration is capped to prevent indefinite open networks
 * - Install code requirement can be enforced
 * - Device count limit prevents mass unauthorized joining
 * - Automatic timeout ensures the window closes
 */
static zigbee_error_t zigbee_enable_permit_join(zigbee_device_context_t *ctx,
    uint16_t duration_seconds)
{
    if (ctx == NULL) {
        return ZB_ERR_INVALID_PARAM;
    }

    /* SECURITY: Cap the permit join duration */
    if (duration_seconds > ZIGBEE_PERMIT_JOIN_DURATION) {
        zigbee_log("SECURITY",
                   "Permit join duration capped from %d to %d seconds",
                   duration_seconds, ZIGBEE_PERMIT_JOIN_DURATION);
        duration_seconds = ZIGBEE_PERMIT_JOIN_DURATION;
    }

    if (duration_seconds == 0) {
        return zigbee_disable_permit_join(ctx);
    }

    /* SECURITY: Only allow permit join when device is fully operational */
    if (ctx->network_state != NETWORK_STATE_OPERATIONAL &&
        ctx->network_state != NETWORK_STATE_JOINED) {
        zigbee_log("WARN", "Cannot enable permit join: device not in operational state");
        return ZB_ERR_PERMIT_JOIN_DENIED;
    }

    ctx->permit_join.is_active = true;
    ctx->permit_join.duration_seconds = duration_seconds;
    ctx->permit_join.start_time = time(NULL);
    ctx->permit_join.end_time = ctx->permit_join.start_time + duration_seconds;
    ctx->permit_join.require_install_code = ctx->trust_center.require_install_codes;
    ctx->permit_join.max_devices_allowed = 5; /* Limit concurrent joins */
    ctx->permit_join.devices_joined_count = 0;

    /*
     * In production firmware:
     * 1. Send Mgmt_Permit_Joining_req to the network
     * 2. Set the local permit joining flag
     * 3. Start a timer for automatic disable
     * 4. Optionally broadcast the permit join state
     */

    zigbee_log("INFO", "Permit join ENABLED for %d seconds (install code required: %s)",
               duration_seconds,
               ctx->permit_join.require_install_code ? "YES" : "NO");

    if (!ctx->permit_join.require_install_code) {
        zigbee_log("SECURITY",
                   "WARNING: Permit join enabled without install code requirement. "
                   "Network is temporarily vulnerable to unauthorized joining.");
    }

    return ZB_SUCCESS;
}

/*
 * Disable permit join mode immediately.
 */
static zigbee_error_t zigbee_disable_permit_join(zigbee_device_context_t *ctx)
{
    if (ctx == NULL) {
        return ZB_ERR_INVALID_PARAM;
    }

    ctx->permit_join.is_active = false;
    ctx->permit_join.duration_seconds = 0;

    /*
     * In production firmware:
     * 1. Send Mgmt_Permit_Joining_req with duration=0
     * 2. Clear the local permit joining flag
     * 3. Cancel the timeout timer
     */

    zigbee_log("INFO", "Permit join DISABLED (%d devices joined during window)",
               ctx->permit_join.devices_joined_count);

    return ZB_SUCCESS;
}

/*
 * Check and handle permit join timeout.
 * Called periodically from the main loop.
 */
static void zigbee_permit_join_timeout_handler(zigbee_device_context_t *ctx)
{
    if (ctx == NULL || !ctx->permit_join.is_active) {
        return;
    }

    time_t now = time(NULL);

    /* Check if the permit join window has expired */
    if (now >= ctx->permit_join.end_time) {
        zigbee_log("INFO", "Permit join window expired");
        zigbee_disable_permit_join(ctx);
        return;
    }

    /* Check if max devices have joined */
    if (ctx->permit_join.devices_joined_count >= ctx->permit_join.max_devices_allowed) {
        zigbee_log("SECURITY",
                   "Maximum device join count reached (%d), disabling permit join",
                   ctx->permit_join.max_devices_allowed);
        zigbee_disable_permit_join(ctx);
        return;
    }

    /* Log remaining time periodically */
    uint16_t remaining = (uint16_t)(ctx->permit_join.end_time - now);
    if (remaining % 30 == 0) {
        zigbee_log("INFO", "Permit join: %d seconds remaining", remaining);
    }
}

/* ============================================================
 * Endpoint and Cluster Registration
 * ============================================================ */

static zigbee_error_t zigbee_register_endpoints(zigbee_device_context_t *ctx)
{
    if (ctx == NULL) {
        return ZB_ERR_INVALID_PARAM;
    }

    zigbee_log("INFO", "Registering Zigbee endpoints");

    /*
     * Register endpoint 1 for the smart light bulb:
     * - Profile: Home Automation (0x0104)
     * - Device ID: Dimmable Light (0x0101) or Color Temperature Light (0x0102)
     * - Input Clusters: On/Off, Level Control, Color Control, Groups, Scenes
     * - Output Clusters: OTA Upgrade
     */

    zigbee_log("INFO", "Endpoint 1 registered: Smart Light Bulb (HA Profile)");
    return ZB_SUCCESS;
}

static zigbee_error_t zigbee_light_cluster_init(zigbee_device_context_t *ctx)
{
    if (ctx == NULL) {
        return ZB_ERR_INVALID_PARAM;
    }

    /* Initialize light state to safe defaults */
    ctx->light_state.is_on = false;
    ctx->light_state.brightness = 254;     /* Full brightness when turned on */
    ctx->light_state.color_temp = 370;     /* Warm white (~2700K) */
    ctx->light_state.transition_time = 5;  /* 0.5 second transition */

    zigbee_log("INFO", "Light clusters initialized (default: OFF, brightness=254, temp=370)");
    return ZB_SUCCESS;
}

/* ============================================================
 * Network Key Rotation Handler
 * ============================================================ */

static void zigbee_check_key_rotation(zigbee_device_context_t *ctx)
{
    if (ctx == NULL || ctx->network_state != NETWORK_STATE_OPERATIONAL) {
        return;
    }

    uint32_t now = (uint32_t)time(NULL);
    uint32_t elapsed = now - ctx->trust_center.last_key_rotation;

    if (elapsed >= ctx->trust_center.key_rotation_interval) {
        zigbee_log("SECURITY", "Network key rotation interval reached (%u seconds)",
                   elapsed);

        /*
         * In production firmware:
         * 1. Trust center generates a new network key
         * 2. Trust center distributes the new key encrypted with each
         *    device's unique link key
         * 3. Trust center sends a Switch Key command
         * 4. All devices switch to the new network key
         * 5. Old key is securely erased after a grace period
         *
         * As an end device, we just need to handle receiving the new key
         * and switching when instructed.
         */

        ctx->trust_center.last_key_rotation = now;
        zigbee_log("SECURITY", "Ready to accept network key update from trust center");
    }
}

/* ============================================================
 * Frame Counter Management (Replay Attack Prevention)
 * ============================================================ */

static bool zigbee_validate_frame_counter(zigbee_device_context_t *ctx,
    uint32_t received_counter, zigbee_key_type_t key_type)
{
    uint32_t *stored_counter = NULL;

    switch (key_type) {
    case KEY_TYPE_NETWORK:
        stored_counter = &ctx->trust_center.network_key.frame_counter;
        break;
    case KEY_TYPE_TRUST_CENTER_LINK:
    case KEY_TYPE_INSTALL_CODE_DERIVED:
        stored_counter = &ctx->trust_center.trust_center_link_key.frame_counter;
        break;
    default:
        return false;
    }

    /* SECURITY: Frame counter must be strictly increasing to prevent replay attacks */
    if (received_counter <= *stored_counter) {
        zigbee_log("SECURITY",
                   "REPLAY ATTACK DETECTED: received frame counter %u <= stored %u",
                   received_counter, *stored_counter);
        return false;
    }

    /* Check for suspicious large jumps that might indicate counter manipulation */
    if (received_counter - *stored_counter > 10000) {
        zigbee_log("SECURITY",
                   "WARNING: Large frame counter jump detected (%u -> %u)",
                   *stored_counter, received_counter);
        /* Allow but log - large jumps can happen after power cycles */
    }

    *stored_counter = received_counter;
    return true;
}

/* ============================================================
 * Factory Reset
 * ============================================================ */

static zigbee_error_t zigbee_factory_reset(zigbee_device_context_t *ctx)
{
    if (ctx == NULL) {
        return ZB_ERR_INVALID_PARAM;
    }

    zigbee_log("INFO", "Performing factory reset");

    /* Leave the network gracefully if joined */
    if (ctx->network_state == NETWORK_STATE_JOINED ||
        ctx->network_state == NETWORK_STATE_OPERATIONAL) {
        ctx->network_state = NETWORK_STATE_LEAVING;
        zigbee_log("INFO", "Sending network leave request");
        /* In production: send Leave Request to coordinator */
    }

    /* SECURITY: Securely erase all key material */
    zigbee_secure_memzero(&ctx->trust_center.trust_center_link_key,
                          sizeof(zigbee_security_key_t));
    zigbee_secure_memzero(&ctx->trust_center.network_key,
                          sizeof(zigbee_security_key_t));

    /* Clear network information */
    memset(&ctx->current_network, 0, sizeof(zigbee_network_descriptor_t));
    memset(ctx->discovered_networks, 0, sizeof(ctx->discovered_networks));
    ctx->discovered_network_count = 0;

    /* Clear neighbor table */
    memset(ctx->neighbors, 0, sizeof(ctx->neighbors));
    ctx->neighbor_count = 0;

    /* Reset state */
    ctx->network_state = NETWORK_STATE_UNINITIALIZED;
    ctx->short_address = 0xFFFF;
    ctx->is_commissioned = false;
    ctx->join_retry_count = 0;

    /* Reset light to defaults */
    ctx->light_state.is_on = false;
    ctx->light_state.brightness = 254;
    ctx->light_state.color_temp = 370;

    /* Note: Install code is preserved through factory reset as it's
     * typically programmed during manufacturing */

    zigbee_log("INFO", "Factory reset complete - all keys and network data erased");
    return ZB_SUCCESS;
}

/* ============================================================
 * Main Commissioning Flow
 * ============================================================ */

static zigbee_error_t zigbee_commission_device(zigbee_device_context_t *ctx)
{
    zigbee_error_t err;

    zigbee_log("INFO", "=== Starting Zigbee Smart Light Commissioning ===");

    /* Step 1: Initialize security */
    err = zigbee_security_init(ctx);
    if (err != ZB_SUCCESS) {
        zigbee_log("ERROR", "Security initialization failed: %d", err);
        return err;
    }

    /* Step 2: Scan for available networks */
    uint32_t retry_count = 0;
    do {
        err = zigbee_scan_networks(ctx);
        if (err == ZB_SUCCESS) {
            break;
        }

        retry_count++;
        zigbee_log("INFO", "Network scan retry %d/%d", retry_count, ZIGBEE_MAX_RETRIES);

        /* In production: implement exponential backoff */
        /* sleep(retry_count * 2); */

    } while (retry_count < ZIGBEE_MAX_RETRIES);

    if (err != ZB_SUCCESS) {
        zigbee_log("ERROR", "Failed to find any networks after %d attempts", retry_count);
        return err;
    }

    /* Step 3: Select the best network */
    zigbee_network_descriptor_t selected_network;
    err = zigbee_select_best_network(ctx, &selected_network);
    if (err != ZB_SUCCESS) {
        zigbee_log("ERROR", "No suitable network found");
        return err;
    }

    /* Step 4: Join the selected network */
    retry_count = 0;
    do {
        err = zigbee_join_network(ctx, &selected_network);
        if (err == ZB_SUCCESS) {
            break;
        }

        retry_count++;
        ctx->join_retry_count++;
        zigbee_log("INFO", "Join retry %d/%d", retry_count, ZIGBEE_MAX_RETRIES);

        /* SECURITY: If authentication keeps failing, the install code
         * may be wrong or the trust center may not have it configured */
        if (err == ZB_ERR_AUTH_FAILED && retry_count >= 3) {
            zigbee_log("SECURITY",
                       "Multiple authentication failures - verify install code "
                       "is registered with the trust center");
        }

    } while (retry_count < ZIGBEE_MAX_RETRIES);

    if (err != ZB_SUCCESS) {
        zigbee_log("ERROR", "Failed to join network after %d attempts", retry_count);
        return err;
    }

    /* Step 5: Register endpoints and clusters */
    err = zigbee_register_endpoints(ctx);
    if (err != ZB_SUCCESS) {
        zigbee_log("ERROR", "Endpoint registration failed");
        return err;
    }

    err = zigbee_light_cluster_init(ctx);
    if (err != ZB_SUCCESS) {
        zigbee_log("ERROR", "Light cluster initialization failed");
        return err;
    }

    /* Step 6: Enable permit join for a limited time to allow
     * additional devices to be added during setup */
    err = zigbee_enable_permit_join(ctx, ZIGBEE_PERMIT_JOIN_DURATION);
    if (err != ZB_SUCCESS) {
        zigbee_log("WARN", "Failed to enable permit join (non-critical)");
        /* Non-critical failure - device can still operate */
    }

    /* Mark as operational */
    ctx->network_state = NETWORK_STATE_OPERATIONAL;
    ctx->is_commissioned = true;

    /* Final security verification */
    if (zigbee_is_default_link_key(ctx->trust_center.trust_center_link_key.key_data)) {
        zigbee_log("SECURITY",
                   "CRITICAL WARNING: Device is operating with default link key. "
                   "Security is compromised. Recommend re-commissioning with install codes.");
    } else {
        zigbee_log("SECURITY", "Device is using a unique link key - security OK");
    }

    zigbee_log("INFO", "=== Commissioning Complete ===");
    zigbee_log("INFO", "Network: PAN=0x%04X, Channel=%d, Short Addr=0x%04X",
               ctx->current_network.pan_id, ctx->current_network.channel,
               ctx->short_address);

    return ZB_SUCCESS;
}

/* ============================================================
 * Main Event Loop
 * ============================================================ */

static void zigbee_main_loop(zigbee_device_context_t *ctx)
{
    zigbee_log("INFO", "Entering main event loop");

    /* Simulate a few iterations of the main loop */
    for (int i = 0; i < 5; i++) {
        ctx->uptime_seconds++;

        /* Check permit join timeout */
        zigbee_permit_join_timeout_handler(ctx);

        /* Check for key rotation */
        zigbee_check_key_rotation(ctx);

        /* Simulate frame counter validation */
        if (ctx->network_state == NETWORK_STATE_OPERATIONAL) {
            uint32_t simulated_counter = ctx->trust_center.network_key.frame_counter + 1;
            if (!zigbee_validate_frame_counter(ctx, simulated_counter, KEY_TYPE_NETWORK)) {
                zigbee_log("SECURITY", "Frame counter validation failed!");
            }
        }

        /*
         * In production firmware, this loop would:
         * 1. Process incoming Zigbee messages
         * 2. Handle cluster commands (On/Off, Level, Color)
         * 3. Send periodic reports (attribute reporting)
         * 4. Handle OTA firmware updates
         * 5. Manage power saving (for battery devices)
         * 6. Process user input (e.g., physical switch)
         */

        zigbee_log("INFO", "Main loop iteration %d (uptime: %u s, state: %d)",
                   i + 1, ctx->uptime_seconds, ctx->network_state);
    }
}

/* ============================================================
 * Device Initialization
 * ============================================================ */

static zigbee_error_t zigbee_device_init(zigbee_device_context_t *ctx)
{
    if (ctx == NULL) {
        return ZB_ERR_INVALID_PARAM;
    }

    memset(ctx, 0, sizeof(zigbee_device_context_t));

    /* Set device identity */
    ctx->eui64 = 0x00124B0012345678ULL; /* Would come from hardware/OTP */
    ctx->short_address = 0xFFFF;         /* Unassigned */
    ctx->device_type = DEVICE_TYPE_ROUTER; /* Light bulbs are typically routers */
    ctx->network_state = NETWORK_STATE_UNINITIALIZED;
    ctx->is_commissioned = false;

    /* Initialize hardware */
    zigbee_error_t err = zigbee_hardware_init();
    if (err != ZB_SUCCESS) {
        return err;
    }

    /*
     * Load install code from secure storage (OTP/flash).
     * In production, the install code is programmed during manufacturing
     * and printed on the device label/QR code for the user