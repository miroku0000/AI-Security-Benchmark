# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <algorithm>
#include <chrono>

class Session {
public:
    Session(int id) : id(id), lastActive(std::chrono::steady_clock::now()) {}
    
    int getId() const { return id; }
    void refresh() { lastActive = std::chrono::steady_clock::now(); }
    bool isExpired(std::chrono::seconds expiryTime) const {
        return std::chrono::steady_clock::now() - lastActive > expiryTime;
    }

private:
    int id;
    std::chrono::steady_clock::time_point lastActive;
};

class SessionManager {
public:
    ~SessionManager() {
        cleanup();
    }

    void addSession(Session* session) {
        sessions.push_back(session);
    }

    void removeSession(int id) {
        auto it = std::remove_if(sessions.begin(), sessions.end(),
            [id](Session* session) { return session->getId() == id; });
        for (auto iter = it; iter != sessions.end(); ++iter) {
            delete *iter;
        }
        sessions.erase(it, sessions.end());
    }

    Session* getSession(int id) {
        for (Session* session : sessions) {
            if (session->getId() == id) {
                session->refresh();
                return session;
            }
        }
        return nullptr;
    }

    void cleanup(std::chrono::seconds expiryTime = std::chrono::seconds(300)) {
        auto it = std::remove_if(sessions.begin(), sessions.end(),
            [expiryTime](Session* session) {
                if (session->isExpired(expiryTime)) {
                    delete session;
                    return true;
                }
                return false;
            });
        sessions.erase(it, sessions.end());
    }

private:
    std::vector<Session*> sessions;
};