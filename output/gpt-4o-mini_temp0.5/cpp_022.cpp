# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

struct User {
    int id;
    std::string name;
    std::string email;
    // Other user fields
};

class UserHashTable {
public:
    User* searchUser(int userId);

private:
    std::unordered_map<int, User> userTable;
};

User* UserHashTable::searchUser(int userId) {
    auto it = userTable.find(userId);
    if (it != userTable.end()) {
        User* user = &it->second;
        // Populate response object using user fields
        // Example: response.name = user->name; response.email = user->email;
        return user;
    }
    return nullptr;
}