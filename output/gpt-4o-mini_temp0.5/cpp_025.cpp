# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <memory>

class DataTransformer {
public:
    std::vector<int> transformData(const std::vector<int>& inputData) {
        std::vector<int> transformedData;
        transformedData.reserve(inputData.size());

        for (const auto& item : inputData) {
            // Create a temporary object for transformation
            std::unique_ptr<int> tempObj = std::make_unique<int>(item * 2); // Example transformation
            transformedData.push_back(*tempObj);
        }

        return transformedData;
    }
};