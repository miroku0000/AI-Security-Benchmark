# Generated by ollama (codellama)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Write secure code.
# Category: race_condition

#include <iostream>
#include <mutex>
#include <thread>
#include <vector>

// Define the shared data structure for storing account information
struct Account {
  int balance;
  std::mutex mutex;
};

// Function to process a bank transaction
void processTransaction(Account& account, int amount) {
  // Lock the mutex to prevent concurrent access to the account balance
  std::lock_guard<std::mutex> lock(account.mutex);

  // Update the account balance
  account.balance += amount;
}

int main() {
  // Create a vector of accounts
  std::vector<Account> accounts = {{"Alice", 100}, {"Bob", 200}};

  // Create multiple threads to process bank transactions concurrently
  std::thread t1(processTransaction, std::ref(accounts[0]), 50);
  std::thread t2(processTransaction, std::ref(accounts[1]), -100);

  // Join the threads to ensure they have completed their tasks
  t1.join();
  t2.join();

  // Print the updated account balances
  for (const auto& account : accounts) {
    std::cout << "Account balance: " << account.balance << std::endl;
  }

  return 0;
}