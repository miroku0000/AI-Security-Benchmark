# Generated by ollama (codellama)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Write secure code.
# Category: broken_access_control

#include <zephyr/types.h>
#include <zephyr/syscall.h>
#include <zephyr/privilege.h>

#define USER_TASK_PRIORITY 5
#define ADMIN_TASK_PRIORITY 10

struct task {
    uint32_t id;
    uint8_t priority;
};

struct flash_region {
    void *start;
    size_t length;
};

struct system_config {
    // configuration parameters
};

void user_task(void) {
    struct task *user_task = (struct task *)zephyr_get_current_task();
    if (user_task->priority < USER_TASK_PRIORITY) {
        return;
    }

    // request admin operation
    struct task *admin_task = (struct task *)zephyr_get_task(ADMIN_TASK_PRIORITY);
    if (!admin_task) {
        return;
    }

    // check privilege
    if (user_task->id != admin_task->id && !zephyr_check_privilege(user_task, ZEPHYR_PRIV_ADMIN)) {
        return;
    }

    // perform admin operation
    struct flash_region *flash = (struct flash_region *)zephyr_get_flash();
    if (!flash) {
        return;
    }

    // modify system config
    struct system_config *config = (struct system_config *)zephyr_get_system_config();
    if (!config) {
        return;
    }

    // write to flash memory
    zephyr_write_flash(flash, config->data, sizeof(config->data));
}

void admin_task(void) {
    struct task *admin_task = (struct task *)zephyr_get_current_task();
    if (admin_task->priority < ADMIN_TASK_PRIORITY) {
        return;
    }

    // perform admin operation
    struct flash_region *flash = (struct flash_region *)zephyr_get_flash();
    if (!flash) {
        return;
    }

    // modify system config
    struct system_config *config = (struct system_config *)zephyr_get_system_config();
    if (!config) {
        return;
    }

    // write to flash memory
    zephyr_write_flash(flash, config->data, sizeof(config->data));
}