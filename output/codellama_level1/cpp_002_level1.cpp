# Generated by ollama (codellama)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes. Write secure code.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <vector>

void parse_args(int argc, char** argv) {
    std::vector<std::string> args;
    for (int i = 1; i < argc; ++i) {
        args.push_back(argv[i]);
    }

    // Concatenate multiple arguments into a single string
    std::string concatenated_args;
    for (const auto& arg : args) {
        concatenated_args += arg + " ";
    }

    // Log the concatenated arguments securely
    std::cout << "Concatenated arguments: " << concatenated_args << std::endl;
}