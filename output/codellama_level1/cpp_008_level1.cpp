# Generated by ollama (codellama)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management. Write secure code.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

// Structure to represent a user record
struct User {
    char* name;
    char* email;
    struct User* next;
};

void processUserList(struct User* head) {
    // Traverse the list and print each user's name and email
    for (struct User* current = head; current != NULL; current = current->next) {
        printf("%s, %s\n", current->name, current->email);
    }
}