# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <memory>
#include <algorithm>
#include <numeric>
#include <cmath>
#include <iostream>
#include <chrono>

// Simulated data record
struct RawRecord {
    int id;
    double values[8];
    std::string label;
};

// Intermediate transformation objects - these are the "temporary objects"
// that get created each call (the anti-pattern we'll show, then fix)
struct NormalizedRecord {
    int id;
    std::vector<double> normalized_values;
    std::string label;
};

struct AggregatedRecord {
    int id;
    double mean;
    double variance;
    double min_val;
    double max_val;
    std::string category;
};

struct FinalRecord {
    int id;
    double score;
    std::string category;
    bool is_outlier;
};

// ============================================================
// BAD VERSION: Creates temporary objects every call (hot path)
// ============================================================
FinalRecord transform_record_bad(const RawRecord& raw) {
    // Step 1: Normalize - allocates a new vector each time
    auto normalized = std::make_unique<NormalizedRecord>();
    normalized->id = raw.id;
    normalized->label = raw.label;  // string copy
    normalized->normalized_values.resize(8);

    double sum = 0.0;
    for (int i = 0; i < 8; ++i) sum += raw.values[i];
    double mean = sum / 8.0;

    double sq_sum = 0.0;
    for (int i = 0; i < 8; ++i)
        sq_sum += (raw.values[i] - mean) * (raw.values[i] - mean);
    double stddev = std::sqrt(sq_sum / 8.0);

    for (int i = 0; i < 8; ++i) {
        normalized->normalized_values[i] =
            (stddev > 1e-9) ? (raw.values[i] - mean) / stddev : 0.0;
    }

    // Step 2: Aggregate - another heap allocation
    auto aggregated = std::make_unique<AggregatedRecord>();
    aggregated->id = normalized->id;
    aggregated->mean = mean;
    aggregated->variance = sq_sum / 8.0;
    aggregated->min_val = *std::min_element(raw.values, raw.values + 8);
    aggregated->max_val = *std::max_element(raw.values, raw.values + 8);

    // Categorize based on variance - string allocation
    if (aggregated->variance < 1.0)
        aggregated->category = "low_variance";
    else if (aggregated->variance < 10.0)
        aggregated->category = "medium_variance";
    else
        aggregated->category = "high_variance";

    // Step 3: Score and finalize - yet another allocation
    auto final_rec = std::make_unique<FinalRecord>();
    final_rec->id = aggregated->id;
    final_rec->category = std::move(aggregated->category);

    double norm_magnitude = 0.0;
    for (int i = 0; i < 8; ++i)
        norm_magnitude += normalized->normalized_values[i] * normalized->normalized_values[i];
    norm_magnitude = std::sqrt(norm_magnitude);

    final_rec->score = aggregated->mean * 0.4 + (aggregated->max_val - aggregated->min_val) * 0.3
                       + norm_magnitude * 0.3;
    final_rec->is_outlier = (norm_magnitude > 3.0) || (aggregated->variance > 50.0);

    return *final_rec;
}

// ============================================================
// GOOD VERSION: Reuses pre-allocated workspace, avoids temporaries
// ============================================================
struct TransformWorkspace {
    // Pre-allocated buffers reused across calls
    double normalized_values[8];
    // Small string optimization-friendly fixed buffers
    char category_buf[32];

    // Aggregation intermediates
    double mean;
    double variance;
    double min_val;
    double max_val;
    double norm_magnitude;

    TransformWorkspace() = default;
};

// Thread-local workspace so each thread gets its own without locking
thread_local TransformWorkspace tl_workspace;

FinalRecord transform_record_good(const RawRecord& raw) {
    TransformWorkspace& ws = tl_workspace;

    // Step 1: Normalize in-place using workspace buffer
    double sum = 0.0;
    for (int i = 0; i < 8; ++i) sum += raw.values[i];
    ws.mean = sum / 8.0;

    double sq_sum = 0.0;
    for (int i = 0; i < 8; ++i) {
        double diff = raw.values[i] - ws.mean;
        sq_sum += diff * diff;
    }
    ws.variance = sq_sum / 8.0;
    double stddev = std::sqrt(ws.variance);

    double inv_stddev = (stddev > 1e-9) ? 1.0 / stddev : 0.0;
    for (int i = 0; i < 8; ++i) {
        ws.normalized_values[i] = (raw.values[i] - ws.mean) * inv_stddev;
    }

    // Step 2: Aggregate directly into workspace
    ws.min_val = raw.values[0];
    ws.max_val = raw.values[0];
    for (int i = 1; i < 8; ++i) {
        if (raw.values[i] < ws.min_val) ws.min_val = raw.values[i];
        if (raw.values[i] > ws.max_val) ws.max_val = raw.values[i];
    }

    // Step 3: Compute norm magnitude
    ws.norm_magnitude = 0.0;
    for (int i = 0; i < 8; ++i)
        ws.norm_magnitude += ws.normalized_values[i] * ws.normalized_values[i];
    ws.norm_magnitude = std::sqrt(ws.norm_magnitude);

    // Build result directly - no intermediate heap objects
    FinalRecord result;
    result.id = raw.id;
    result.score = ws.mean * 0.4 + (ws.max_val - ws.min_val) * 0.3
                   + ws.norm_magnitude * 0.3;
    result.is_outlier = (ws.norm_magnitude > 3.0) || (ws.variance > 50.0);

    // Use string_view-friendly approach; for small strings SSO handles it
    if (ws.variance < 1.0)
        result.category = "low_variance";
    else if (ws.variance < 10.0)
        result.category = "medium_variance";
    else
        result.category = "high_variance";

    return result;
}

// ============================================================
// Batch processing version for maximum throughput
// ============================================================
void transform_records_batch(const RawRecord* __restrict__ input,
                             FinalRecord* __restrict__ output,
                             size_t count) {
    TransformWorkspace& ws = tl_workspace;

    for (size_t idx = 0; idx < count; ++idx) {
        const RawRecord& raw = input[idx];
        FinalRecord& result = output[idx];

        double sum = 0.0;
        for (int i = 0; i < 8; ++i) sum += raw.values[i];
        ws.mean = sum * 0.125; // multiply instead of divide

        double sq_sum = 0.0;
        ws.min_val = raw.values[0];
        ws.max_val = raw.values[0];
        for (int i = 0; i < 8; ++i) {
            double diff = raw.values[i] - ws.mean;
            sq_sum += diff * diff;
            if (raw.values[i] < ws.min_val) ws.min_val = raw.values[i];
            if (raw.values[i] > ws.max_val) ws.max_val = raw.values[i];
        }
        ws.variance = sq_sum * 0.125;
        double stddev = std::sqrt(ws.variance);
        double inv_stddev = (stddev > 1e-9) ? 1.0 / stddev : 0.0;

        ws.norm_magnitude = 0.0;
        for (int i = 0; i < 8; ++i) {
            double nv = (raw.values[i] - ws.mean) * inv_stddev;
            ws.norm_magnitude += nv * nv;
        }
        ws.norm_magnitude = std::sqrt(ws.norm_magnitude);

        result.id = raw.id;
        result.score = ws.mean * 0.4 + (ws.max_val - ws.min_val) * 0.3
                       + ws.norm_magnitude * 0.3;
        result.is_outlier = (ws.norm_magnitude > 3.0) || (ws.variance > 50.0);

        if (ws.variance < 1.0)
            result.category = "low_variance";
        else if (ws.variance < 10.0)
            result.category = "medium_variance";
        else
            result.category = "high_variance";
    }
}

// ============================================================
// Benchmark to demonstrate the difference
// ============================================================
int main() {
    constexpr size_t NUM_RECORDS = 1'000'000;
    constexpr int ITERATIONS = 10;

    // Generate test data
    std::vector<RawRecord> records(NUM_RECORDS);
    for (size_t i = 0; i < NUM_RECORDS; ++i) {
        records[i].id = static_cast<int>(i);
        records[i].label = "record_" + std::to_string(i);
        for (int j = 0; j < 8; ++j) {
            records[i].values[j] = static_cast<double>((i * 7 + j * 13) % 1000) / 10.0;
        }
    }

    std::vector<FinalRecord> results(NUM_RECORDS);

    // Benchmark BAD version (temporary objects each call)
    {
        auto start = std::chrono::high_resolution_clock::now();
        for (int iter = 0; iter < ITERATIONS; ++iter) {
            for (size_t i = 0; i < NUM_RECORDS; ++i) {
                results[i] = transform_record_bad(records[i]);
            }
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "BAD  (temp objects each call): " << ms << " ms for "
                  << NUM_RECORDS * ITERATIONS << " records" << std::endl;
        // Prevent optimization
        double checksum = 0;
        for (size_t i = 0; i < NUM_RECORDS; ++i) checksum += results[i].score;
        std::cout << "  checksum: " << checksum << std::endl;
    }

    // Benchmark GOOD version (reused workspace)
    {
        auto start = std::chrono::high_resolution_clock::now();
        for (int iter = 0; iter < ITERATIONS; ++iter) {
            for (size_t i = 0; i < NUM_RECORDS; ++i) {
                results[i] = transform_record_good(records[i]);
            }
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "GOOD (reused workspace):       " << ms << " ms for "
                  << NUM_RECORDS * ITERATIONS << " records" << std::endl;
        double checksum = 0;
        for (size_t i = 0; i < NUM_RECORDS; ++i) checksum += results[i].score;
        std::cout << "  checksum: " << checksum << std::endl;
    }

    // Benchmark BATCH version
    {
        auto start = std::chrono::high_resolution_clock::now();
        for (int iter = 0; iter < ITERATIONS; ++iter) {
            transform_records_batch(records.data(), results.data(), NUM_RECORDS);
        }
        auto end = std::chrono::high_resolution_clock::now();
        auto ms = std::chrono::duration_cast<std::chrono::milliseconds>(end - start).count();
        std::cout << "BATCH (optimized loop):        " << ms << " ms for "
                  << NUM_RECORDS * ITERATIONS << " records" << std::endl;
        double checksum = 0;
        for (size_t i = 0; i < NUM_RECORDS; ++i) checksum += results[i].score;
        std::cout << "  checksum: " << checksum << std::endl;
    }

    return 0;
}