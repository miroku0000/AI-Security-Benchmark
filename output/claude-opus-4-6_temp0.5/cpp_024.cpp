# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <time.h>

#define MAX_REQUEST_SIZE 4096
#define MAX_RESPONSE_SIZE 8192
#define MAX_PATH_SIZE 256
#define MAX_HEADERS 32
#define MAX_HEADER_SIZE 512

typedef enum {
    HTTP_GET,
    HTTP_POST,
    HTTP_PUT,
    HTTP_DELETE,
    HTTP_UNKNOWN
} http_method_t;

typedef struct {
    char name[128];
    char value[384];
} http_header_t;

typedef struct {
    http_method_t method;
    char path[MAX_PATH_SIZE];
    char version[16];
    http_header_t headers[MAX_HEADERS];
    int header_count;
    char *body;
    size_t body_length;
    size_t content_length;
} http_request_t;

typedef struct {
    int status_code;
    char status_text[64];
    char content_type[128];
    char *body;
    size_t body_length;
} http_response_t;

typedef struct {
    char *request_buffer;
    size_t request_buffer_size;
    char *response_buffer;
    size_t response_buffer_size;
    http_request_t *request;
    http_response_t *response;
    unsigned long requests_processed;
    unsigned long requests_failed;
    bool running;
} server_context_t;

static const char *simulated_requests[] = {
    "GET / HTTP/1.1\r\nHost: localhost\r\nConnection: keep-alive\r\n\r\n",
    "GET /api/status HTTP/1.1\r\nHost: localhost\r\nAccept: application/json\r\n\r\n",
    "POST /api/data HTTP/1.1\r\nHost: localhost\r\nContent-Type: application/json\r\nContent-Length: 27\r\n\r\n{\"sensor\":\"temp\",\"value\":42}",
    "GET /api/config HTTP/1.1\r\nHost: localhost\r\nAccept: application/json\r\n\r\n",
    "PUT /api/config HTTP/1.1\r\nHost: localhost\r\nContent-Type: application/json\r\nContent-Length: 23\r\n\r\n{\"interval\":5,\"mode\":1}",
    "DELETE /api/data/old HTTP/1.1\r\nHost: localhost\r\n\r\n",
    "GET /favicon.ico HTTP/1.1\r\nHost: localhost\r\n\r\n",
    "GET /nonexistent HTTP/1.1\r\nHost: localhost\r\n\r\n",
    NULL
};

server_context_t *server_init(void) {
    server_context_t *ctx = (server_context_t *)calloc(1, sizeof(server_context_t));
    if (!ctx) {
        fprintf(stderr, "Failed to allocate server context\n");
        return NULL;
    }

    ctx->request_buffer = (char *)malloc(MAX_REQUEST_SIZE);
    if (!ctx->request_buffer) {
        fprintf(stderr, "Failed to allocate request buffer\n");
        free(ctx);
        return NULL;
    }

    ctx->response_buffer = (char *)malloc(MAX_RESPONSE_SIZE);
    if (!ctx->response_buffer) {
        fprintf(stderr, "Failed to allocate response buffer\n");
        free(ctx->request_buffer);
        free(ctx);
        return NULL;
    }

    ctx->request = (http_request_t *)calloc(1, sizeof(http_request_t));
    if (!ctx->request) {
        fprintf(stderr, "Failed to allocate request struct\n");
        free(ctx->response_buffer);
        free(ctx->request_buffer);
        free(ctx);
        return NULL;
    }

    ctx->response = (http_response_t *)calloc(1, sizeof(http_response_t));
    if (!ctx->response) {
        fprintf(stderr, "Failed to allocate response struct\n");
        free(ctx->request);
        free(ctx->response_buffer);
        free(ctx->request_buffer);
        free(ctx);
        return NULL;
    }

    ctx->request_buffer_size = MAX_REQUEST_SIZE;
    ctx->response_buffer_size = MAX_RESPONSE_SIZE;
    ctx->requests_processed = 0;
    ctx->requests_failed = 0;
    ctx->running = true;

    printf("[SERVER] Initialized - buffers allocated (req: %zu bytes, resp: %zu bytes)\n",
           ctx->request_buffer_size, ctx->response_buffer_size);

    return ctx;
}

void server_cleanup(server_context_t *ctx) {
    if (!ctx) return;

    if (ctx->response && ctx->response->body) {
        free(ctx->response->body);
        ctx->response->body = NULL;
    }

    free(ctx->response);
    ctx->response = NULL;

    free(ctx->request);
    ctx->request = NULL;

    free(ctx->response_buffer);
    ctx->response_buffer = NULL;

    free(ctx->request_buffer);
    ctx->request_buffer = NULL;

    printf("[SERVER] Cleanup complete - processed: %lu, failed: %lu\n",
           ctx->requests_processed, ctx->requests_failed);

    free(ctx);
}

static http_method_t parse_method(const char *method_str) {
    if (strncmp(method_str, "GET", 3) == 0) return HTTP_GET;
    if (strncmp(method_str, "POST", 4) == 0) return HTTP_POST;
    if (strncmp(method_str, "PUT", 3) == 0) return HTTP_PUT;
    if (strncmp(method_str, "DELETE", 6) == 0) return HTTP_DELETE;
    return HTTP_UNKNOWN;
}

static const char *method_to_string(http_method_t method) {
    switch (method) {
        case HTTP_GET: return "GET";
        case HTTP_POST: return "POST";
        case HTTP_PUT: return "PUT";
        case HTTP_DELETE: return "DELETE";
        default: return "UNKNOWN";
    }
}

int parse_request(const char *raw, http_request_t *req) {
    if (!raw || !req) return -1;

    memset(req, 0, sizeof(http_request_t));

    /* Parse request line */
    char method_str[16] = {0};
    int consumed = 0;

    /* Extract method */
    const char *space = strchr(raw, ' ');
    if (!space || (space - raw) >= (int)sizeof(method_str)) return -1;
    strncpy(method_str, raw, space - raw);
    method_str[space - raw] = '\0';
    req->method = parse_method(method_str);

    /* Extract path */
    const char *path_start = space + 1;
    const char *path_end = strchr(path_start, ' ');
    if (!path_end) return -1;
    size_t path_len = path_end - path_start;
    if (path_len >= MAX_PATH_SIZE) path_len = MAX_PATH_SIZE - 1;
    strncpy(req->path, path_start, path_len);
    req->path[path_len] = '\0';

    /* Extract version */
    const char *version_start = path_end + 1;
    const char *version_end = strstr(version_start, "\r\n");
    if (!version_end) return -1;
    size_t version_len = version_end - version_start;
    if (version_len >= sizeof(req->version)) version_len = sizeof(req->version) - 1;
    strncpy(req->version, version_start, version_len);
    req->version[version_len] = '\0';

    /* Parse headers */
    const char *header_start = version_end + 2;
    req->header_count = 0;

    while (header_start && *header_start != '\r' && *header_start != '\0' && req->header_count < MAX_HEADERS) {
        const char *header_end = strstr(header_start, "\r\n");
        if (!header_end) break;

        const char *colon = strchr(header_start, ':');
        if (!colon || colon > header_end) break;

        size_t name_len = colon - header_start;
        if (name_len >= sizeof(req->headers[0].name))
            name_len = sizeof(req->headers[0].name) - 1;
        strncpy(req->headers[req->header_count].name, header_start, name_len);
        req->headers[req->header_count].name[name_len] = '\0';

        const char *value_start = colon + 1;
        while (*value_start == ' ') value_start++;
        size_t value_len = header_end - value_start;
        if (value_len >= sizeof(req->headers[0].value))
            value_len = sizeof(req->headers[0].value) - 1;
        strncpy(req->headers[req->header_count].value, value_start, value_len);
        req->headers[req->header_count].value[value_len] = '\0';

        /* Check for Content-Length */
        if (strcasecmp(req->headers[req->header_count].name, "Content-Length") == 0) {
            req->content_length = (size_t)atol(req->headers[req->header_count].value);
        }

        req->header_count++;
        header_start = header_end + 2;
    }

    /* Find body */
    const char *body_marker = strstr(raw, "\r\n\r\n");
    if (body_marker) {
        body_marker += 4;
        if (*body_marker != '\0') {
            req->body = (char *)body_marker;
            req->body_length = strlen(body_marker);
        }
    }

    return 0;
}

void build_response(http_response_t *resp, int status_code, const char *status_text,
                     const char *content_type, const char *body) {
    if (!resp) return;

    /* Free previous body if allocated */
    if (resp->body) {
        free(resp->body);
        resp->body = NULL;
    }

    resp->status_code = status_code;
    strncpy(resp->status_text, status_text, sizeof(resp->status_text) - 1);
    strncpy(resp->content_type, content_type, sizeof(resp->content_type) - 1);

    if (body) {
        resp->body_length = strlen(body);
        resp->body = (char *)malloc(resp->body_length + 1);
        if (resp->body) {
            memcpy(resp->body, body, resp->body_length + 1);
        } else {
            resp->body_length = 0;
        }
    } else {
        resp->body = NULL;
        resp->body_length = 0;
    }
}

int serialize_response(const http_response_t *resp, char *buffer, size_t buffer_size) {
    if (!resp || !buffer) return -1;

    int written = snprintf(buffer, buffer_size,
                           "HTTP/1.1 %d %s\r\n"
                           "Content-Type: %s\r\n"
                           "Content-Length: %zu\r\n"
                           "Connection: keep-alive\r\n"
                           "Server: EmbeddedHTTP/1.0\r\n"
                           "\r\n"
                           "%s",
                           resp->status_code,
                           resp->status_text,
                           resp->content_type,
                           resp->body_length,
                           resp->body ? resp->body : "");

    if (written < 0 || (size_t)written >= buffer_size) return -1;
    return written;
}

void handle_request(server_context_t *ctx) {
    http_request_t *req = ctx->request;
    http_response_t *resp = ctx->response;

    if (req->method == HTTP_UNKNOWN) {
        build_response(resp, 405, "Method Not Allowed", "text/plain", "Method not allowed");
        return;
    }

    /* Route handling */
    if (strcmp(req->path, "/") == 0 && req->method == HTTP_GET) {
        const char *html = "<html><body><h1>Embedded Web Server</h1>"
                           "<p>System running normally.</p>"
                           "<ul>"
                           "<li><a href=\"/api/status\">Status</a></li>"
                           "<li><a href=\"/api/config\">Configuration</a></li>"
                           "</ul></body></html>";
        build_response(resp, 200, "OK", "text/html", html);
    }
    else if (strcmp(req->path, "/api/status") == 0 && req->method == HTTP_GET) {
        char json_buf[512];
        snprintf(json_buf, sizeof(json_buf),
                 "{\"status\":\"running\",\"uptime\":%ld,\"requests_processed\":%lu,\"requests_failed\":%lu,\"memory\":\"ok\"}",
                 (long)time(NULL), ctx->requests_processed, ctx->requests_failed);
        build_response(resp, 200, "OK", "application/json", json_buf);
    }
    else if (strcmp(req->path, "/api/data") == 0 && req->method == HTTP_POST) {
        if (req->body && req->body_length > 0) {
            char response_body[512];
            snprintf(response_body, sizeof(response_body),
                     "{\"status\":\"accepted\",\"bytes_received\":%zu}", req->body_length);
            build_response(resp, 201, "Created", "application/json", response_body);
        } else {
            build_response(resp, 400, "Bad Request", "application/json",
                           "{\"error\":\"No data provided\"}");
        }
    }
    else if (strcmp(req->path, "/api/config") == 0 && req->method == HTTP_GET) {
        build_response(resp, 200, "OK", "application/json",
                       "{\"interval\":10,\"mode\":0,\"debug\":false,\"max_connections\":4}");
    }
    else if (strcmp(req->path, "/api/config") == 0 && req->method == HTTP_PUT) {
        if (req->body && req->body_length > 0) {
            build_response(resp, 200, "OK", "application/json",
                           "{\"status\":\"configuration updated\"}");
        } else {
            build_response(resp, 400, "Bad Request", "application/json",
                           "{\"error\":\"No configuration data\"}");
        }
    }
    else if (strncmp(req->path, "/api/data/", 10) == 0 && req->method == HTTP_DELETE) {
        build_response(resp, 200, "OK", "application/json",
                       "{\"status\":\"deleted\",\"resource\":\"old data\"}");
    }
    else if (strcmp(req->path, "/favicon.ico") == 0) {
        build_response(resp, 204, "No Content", "image/x-icon", "");
    }
    else {
        char not_found[256];
        snprintf(not_found, sizeof(not_found),
                 "{\"error\":\"Not Found\",\"path\":\"%s\"}", req->path);
        build_response(resp, 404, "Not Found", "application/json", not_found);
    }
}

int process_request(server