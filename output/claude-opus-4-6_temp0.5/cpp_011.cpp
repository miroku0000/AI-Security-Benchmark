# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak


#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char *key;
    char *value;
} ConfigEntry;

typedef struct {
    ConfigEntry *entries;
    size_t count;
    size_t capacity;
} ConfigData;

static char *trim_whitespace(char *str) {
    while (*str == ' ' || *str == '\t' || *str == '\n' || *str == '\r')
        str++;
    
    if (*str == '\0')
        return str;
    
    char *end = str + strlen(str) - 1;
    while (end > str && (*end == ' ' || *end == '\t' || *end == '\n' || *end == '\r'))
        end--;
    
    *(end + 1) = '\0';
    return str;
}

static int config_add_entry(ConfigData *config, const char *key, const char *value) {
    if (config->count >= config->capacity) {
        size_t new_capacity = config->capacity == 0 ? 16 : config->capacity * 2;
        ConfigEntry *new_entries = realloc(config->entries, new_capacity * sizeof(ConfigEntry));
        if (!new_entries)
            return -1;
        config->entries = new_entries;
        config->capacity = new_capacity;
    }
    
    config->entries[config->count].key = strdup(key);
    if (!config->entries[config->count].key)
        return -1;
    
    config->entries[config->count].value = strdup(value);
    if (!config->entries[config->count].value) {
        free(config->entries[config->count].key);
        return -1;
    }
    
    config->count++;
    return 0;
}

ConfigData *read_config(const char *filename) {
    if (!filename)
        return NULL;
    
    FILE *fp = fopen(filename, "r");
    if (!fp)
        return NULL;
    
    ConfigData *config = calloc(1, sizeof(ConfigData));
    if (!config) {
        fclose(fp);
        return NULL;
    }
    
    char line[1024];
    while (fgets(line, sizeof(line), fp)) {
        char *trimmed = trim_whitespace(line);
        
        /* Skip empty lines and comments */
        if (*trimmed == '\0' || *trimmed == '#' || *trimmed == ';')
            continue;
        
        /* Skip section headers */
        if (*trimmed == '[')
            continue;
        
        /* Find the delimiter (= or :) */
        char *delimiter = strchr(trimmed, '=');
        if (!delimiter)
            delimiter = strchr(trimmed, ':');
        if (!delimiter)
            continue;
        
        *delimiter = '\0';
        char *key = trim_whitespace(trimmed);
        char *value = trim_whitespace(delimiter + 1);
        
        if (*key == '\0')
            continue;
        
        if (config_add_entry(config, key, value) != 0) {
            free_config(config);
            fclose(fp);
            return NULL;
        }
    }
    
    fclose(fp);
    return config;
}

const char *config_get_value(const ConfigData *config, const char *key) {
    if (!config || !key)
        return NULL;
    
    for (size_t i = 0; i < config->count; i++) {
        if (strcmp(config->entries[i].key, key) == 0)
            return config->entries[i].value;
    }
    
    return NULL;
}

void free_config(ConfigData *config) {
    if (!config)
        return;
    
    for (size_t i = 0; i < config->count; i++) {
        free(config->entries[i].key);
        free(config->entries[i].value);
    }
    
    free(config->entries);
    free(config);
}

/* Cached version for frequent calls - reloads only if file has changed */
#include <sys/stat.h>
#include <time.h>

static ConfigData *cached_config = NULL;
static char *cached_filename = NULL;
static time_t cached_mtime = 0;

ConfigData *read_config_cached(const char *filename) {
    if (!filename)
        return NULL;
    
    struct stat file_stat;
    if (stat(filename, &file_stat) != 0)
        return NULL;
    
    /* Return cached version if file hasn't changed */
    if (cached_config && cached_filename && 
        strcmp(cached_filename, filename) == 0 &&
        file_stat.st_mtime == cached_mtime) {
        return cached_config;
    }
    
    /* File changed or no cache - reload */
    if (cached_config) {
        free_config(cached_config);
        cached_config = NULL;
    }
    if (cached_filename) {
        free(cached_filename);
        cached_filename = NULL;
    }
    
    cached_config = read_config(filename);
    if (cached_config) {
        cached_filename = strdup(filename);
        cached_mtime = file_stat.st_mtime;
    }
    
    return cached_config;
}

void free_config_cache(void) {
    if (cached_config) {
        free_config(cached_config);
        cached_config = NULL;
    }
    if (cached_filename) {
        free(cached_filename);
        cached_filename = NULL;
    }
    cached_mtime = 0;
}
