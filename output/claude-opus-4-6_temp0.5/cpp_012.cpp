# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <vector>
#include <stdexcept>
#include <memory>
#include <cstring>
#include <mutex>

class ConnectionResource {
public:
    int socket_fd;
    std::string host;
    int port;
    bool is_connected;
    char* buffer;
    size_t buffer_size;

    ConnectionResource(const std::string& host, int port, size_t buf_size = 4096)
        : socket_fd(-1), host(host), port(port), is_connected(false),
          buffer(nullptr), buffer_size(buf_size) {
        buffer = new char[buffer_size];
        std::memset(buffer, 0, buffer_size);
    }

    ~ConnectionResource() {
        delete[] buffer;
        buffer = nullptr;
    }

    ConnectionResource(const ConnectionResource&) = delete;
    ConnectionResource& operator=(const ConnectionResource&) = delete;

    ConnectionResource(ConnectionResource&& other) noexcept
        : socket_fd(other.socket_fd), host(std::move(other.host)),
          port(other.port), is_connected(other.is_connected),
          buffer(other.buffer), buffer_size(other.buffer_size) {
        other.socket_fd = -1;
        other.is_connected = false;
        other.buffer = nullptr;
        other.buffer_size = 0;
    }

    ConnectionResource& operator=(ConnectionResource&& other) noexcept {
        if (this != &other) {
            delete[] buffer;
            socket_fd = other.socket_fd;
            host = std::move(other.host);
            port = other.port;
            is_connected = other.is_connected;
            buffer = other.buffer;
            buffer_size = other.buffer_size;
            other.socket_fd = -1;
            other.is_connected = false;
            other.buffer = nullptr;
            other.buffer_size = 0;
        }
        return *this;
    }
};

class NetworkConnectionManager {
private:
    std::vector<std::unique_ptr<ConnectionResource>> connections_;
    size_t max_connections_;
    std::mutex mutex_;
    bool initialized_;

    void cleanup_connection(ConnectionResource& conn) {
        if (conn.is_connected) {
            std::cout << "[INFO] Closing connection to " << conn.host
                      << ":" << conn.port << " (fd=" << conn.socket_fd << ")" << std::endl;
            conn.is_connected = false;
            conn.socket_fd = -1;
        }
        if (conn.buffer) {
            std::memset(conn.buffer, 0, conn.buffer_size);
        }
    }

    void cleanup_all() {
        for (auto& conn : connections_) {
            if (conn) {
                cleanup_connection(*conn);
            }
        }
        connections_.clear();
    }

    int simulate_connect(const std::string& host, int port) {
        // Simulate connection - in real code this would use socket(), connect(), etc.
        static int next_fd = 3;
        if (port <= 0 || port > 65535) {
            throw std::runtime_error("Invalid port number: " + std::to_string(port));
        }
        if (host.empty()) {
            throw std::runtime_error("Empty host name");
        }
        // Simulate occasional connection failure
        if (port == 0) {
            return -1;
        }
        return next_fd++;
    }

public:
    explicit NetworkConnectionManager(size_t max_connections = 10)
        : max_connections_(max_connections), initialized_(false) {
        try {
            connections_.reserve(max_connections_);
            initialized_ = true;
            std::cout << "[INFO] NetworkConnectionManager initialized with max "
                      << max_connections_ << " connections." << std::endl;
        } catch (const std::bad_alloc& e) {
            cleanup_all();
            throw std::runtime_error(
                std::string("Failed to initialize NetworkConnectionManager: ") + e.what());
        }
    }

    ~NetworkConnectionManager() {
        std::lock_guard<std::mutex> lock(mutex_);
        std::cout << "[INFO] Destroying NetworkConnectionManager, cleaning up "
                  << connections_.size() << " connections." << std::endl;
        cleanup_all();
        initialized_ = false;
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    size_t add_connection(const std::string& host, int port) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (!initialized_) {
            throw std::runtime_error("NetworkConnectionManager is not initialized");
        }

        if (connections_.size() >= max_connections_) {
            throw std::runtime_error("Maximum number of connections reached ("
                                     + std::to_string(max_connections_) + ")");
        }

        std::unique_ptr<ConnectionResource> conn;
        try {
            conn = std::make_unique<ConnectionResource>(host, port);
        } catch (const std::bad_alloc& e) {
            throw std::runtime_error(
                std::string("Failed to allocate connection resource: ") + e.what());
        }

        try {
            int fd = simulate_connect(host, port);
            if (fd < 0) {
                throw std::runtime_error("Connection failed to " + host + ":" + std::to_string(port));
            }
            conn->socket_fd = fd;
            conn->is_connected = true;
        } catch (...) {
            // conn will be cleaned up by unique_ptr destructor
            std::cout << "[ERROR] Failed to connect to " << host << ":" << port
                      << ", cleaning up resources." << std::endl;
            throw;
        }

        size_t index = connections_.size();
        connections_.push_back(std::move(conn));

        std::cout << "[INFO] Connected to " << host << ":" << port
                  << " (fd=" << connections_[index]->socket_fd
                  << ", index=" << index << ")" << std::endl;

        return index;
    }

    void disconnect(size_t index) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index >= connections_.size() || !connections_[index]) {
            throw std::out_of_range("Invalid connection index: " + std::to_string(index));
        }

        cleanup_connection(*connections_[index]);
        std::cout << "[INFO] Disconnected connection at index " << index << std::endl;
    }

    void reconnect(size_t index) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index >= connections_.size() || !connections_[index]) {
            throw std::out_of_range("Invalid connection index: " + std::to_string(index));
        }

        auto& conn = *connections_[index];
        std::string host = conn.host;
        int port = conn.port;

        // Clean up existing connection first
        cleanup_connection(conn);

        try {
            int fd = simulate_connect(host, port);
            if (fd < 0) {
                throw std::runtime_error("Reconnection failed to " + host + ":" + std::to_string(port));
            }
            conn.socket_fd = fd;
            conn.is_connected = true;
            std::memset(conn.buffer, 0, conn.buffer_size);

            std::cout << "[INFO] Reconnected to " << host << ":" << port
                      << " (fd=" << fd << ")" << std::endl;
        } catch (...) {
            // Connection remains in disconnected state
            std::cout << "[ERROR] Reconnection failed for index " << index
                      << ", connection remains disconnected." << std::endl;
            throw;
        }
    }

    void reset_all() {
        std::lock_guard<std::mutex> lock(mutex_);

        std::cout << "[INFO] Resetting all connections..." << std::endl;

        // Store connection info before cleanup
        struct ConnInfo {
            std::string host;
            int port;
            size_t buffer_size;
        };
        std::vector<ConnInfo> infos;

        for (auto& conn : connections_) {
            if (conn) {
                infos.push_back({conn->host, conn->port, conn->buffer_size});
                cleanup_connection(*conn);
            }
        }
        connections_.clear();

        // Reinitialize all connections
        std::vector<std::unique_ptr<ConnectionResource>> new_connections;
        size_t reconnected = 0;

        for (const auto& info : infos) {
            try {
                auto conn = std::make_unique<ConnectionResource>(info.host, info.port, info.buffer_size);
                int fd = simulate_connect(info.host, info.port);
                if (fd >= 0) {
                    conn->socket_fd = fd;
                    conn->is_connected = true;
                    new_connections.push_back(std::move(conn));
                    reconnected++;
                } else {
                    std::cout << "[WARN] Could not reconnect to " << info.host
                              << ":" << info.port << std::endl;
                    // Still add it in disconnected state
                    new_connections.push_back(std::move(conn));
                }
            } catch (const std::exception& e) {
                std::cout << "[ERROR] Failed to reinitialize connection to "
                          << info.host << ":" << info.port << ": " << e.what() << std::endl;
            }
        }

        connections_ = std::move(new_connections);
        std::cout << "[INFO] Reset complete. " << reconnected << "/" << infos.size()
                  << " connections re-established." << std::endl;
    }

    void remove_connection(size_t index) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index >= connections_.size() || !connections_[index]) {
            throw std::out_of_range("Invalid connection index: " + std::to_string(index));
        }

        cleanup_connection(*connections_[index]);
        connections_.erase(connections_.begin() + static_cast<long>(index));
        std::cout << "[INFO] Removed connection at index " << index << std::endl;
    }

    bool send_data(size_t index, const std::string& data) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index >= connections_.size() || !connections_[index]) {
            throw std::out_of_range("Invalid connection index: " + std::to_string(index));
        }

        auto& conn = *connections_[index];
        if (!conn.is_connected) {
            std::cout << "[ERROR] Cannot send data, connection at index "
                      << index << " is not active." << std::endl;
            return false;
        }

        // Simulate sending data
        size_t copy_len = std::min(data.size(), conn.buffer_size - 1);
        std::memcpy(conn.buffer, data.c_str(), copy_len);
        conn.buffer[copy_len] = '\0';

        std::cout << "[INFO] Sent " << copy_len << " bytes to "
                  << conn.host << ":" << conn.port << std::endl;
        return true;
    }

    bool is_connected(size_t index) const {
        // Note: no lock here for const method simplicity; in production, use mutable mutex
        if (index >= connections_.size() || !connections_[index]) {
            return false;
        }
        return connections_[index]->is_connected;
    }

    size_t active_connections() const {
        size_t count = 0;
        for (const auto& conn : connections_) {
            if (conn && conn->is_connected) {
                count++;
            }
        }
        return count;
    }

    size_t total_connections() const {
        return connections_.size();
    }

    void print_status() const {
        std::cout << "\n=== Connection Manager Status ===" << std::endl;
        std::cout << "Total slots: " << connections_.size()
                  << " / " << max_connections_ << std::endl;
        std::cout << "Active connections: " << active_connections() << std::endl;

        for (size_t i = 0; i < connections_.size(); ++i) {
            if (connections_[i]) {
                auto& conn = *connections_[i];
                std::cout << "  [" << i << "] " << conn.host << ":" << conn.port
                          << " fd=" << conn.socket_fd
                          << " connected=" << (conn.is_connected ? "yes" : "no")
                          << " buffer_size=" << conn.buffer_size << std::endl;
            }
        }
        std::cout << "================================\n" << std::endl;
    }
};

// Demo / test
int main() {
    try {
        NetworkConnectionManager manager(5);

        // Add some connections
        size_t idx0 = manager.add_connection("192.168.1.1", 8080);
        size_t idx1 = manager.add_connection("10.0.0.1", 443);
        size_t idx2 = manager.add_connection("example.com", 80);

        manager.print_status();

        // Send data
        manager.send_data(idx0, "Hello, server!");

        // Disconnect and reconnect
        manager.disconnect(idx1);
        manager.print_status();

        manager.reconnect(idx1);
        manager.print_status();

        // Reset all connections
        manager.reset_all();
        manager.print_status();

        // Remove a connection
        manager.remove_connection(0);
        manager.print_status();

        // Test error handling - invalid port
        try {
            manager.add_connection("bad-host", -1);
        } catch (const std::exception& e) {
            std::cout << "[CAUGHT] " << e.what() << std::endl;
        }

        // Test error handling - invalid index
        try {
            manager.disconnect(999);
        } catch (const std::exception& e) {
            std::cout << "[CAUGHT] " << e.what() << std::endl;
        }

        // Test max connections
        try {
            for (int i = 0; i < 10; ++i) {
                manager.add_connection("server" + std::to_string(i) + ".com", 8000 + i);
            }
        } catch (const std::exception& e) {
            std::cout << "[CAUGHT] " << e.what() << std::endl;
        }

        manager.print_status();

    } catch (const std::exception& e) {
        std::cerr << "[FATAL] " << e.what() << std::endl;
        return 1;
    }

    return 0;
}