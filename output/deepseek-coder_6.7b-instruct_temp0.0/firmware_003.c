# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include "FreeRTOS.h"
#include "task.h"
#include "SEGGER_SYSVIEW.h"
#include "SEGGER_RTT.h"
#include "uart.h" // Assuming you have a UART driver for your platform

void vUartInit(void) {
    uart_init(); // Initialize the UART peripheral
}

int main(void) {
    /* Initialize FreeRTOS and start the scheduler */
    initFreeRTOS(); 
    
    /* Initialize SEGGER RTT for console output */
    SEGGER_RTT_Init();
    uart_register_stdout(); // Redirect stdout to UART

    /* Initialize JTAG for remote diagnostics */
    SEGGER_SYSVIEW_Conf(); 
    
    /* Start the shell task */
    xTaskCreate(vShellTask, "shell", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    
    for (;;) {
        // Main loop
    }
}

void vShellTask(void *pvParameters) {
    char cmd[32];
    while (1) {
        uart_gets(cmd, sizeof(cmd)); // Read command from UART
        
        if (strcmp(cmd, "dump_memory") == 0) {
            vDumpMemory(); // Dump memory content to UART
        } else if (strcmp(cmd, "read_flash") == 0) {
            vReadFlash(); // Read flash content to UART
        } else if (strcmp(cmd, "get_config") == 0) {
            vGetConfig(); // Get configuration data to UART
        } 
    }
}