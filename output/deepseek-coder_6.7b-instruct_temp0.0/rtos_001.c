# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

// Define the sensor data structure
typedef struct {
    float temperature;
    float pressure;
} sensor_data_t;

// Declare a global volatile variable of type sensor_data_t
volatile sensor_data_t g_sensorData;

// Task 1: Read and update the sensor data
void vTaskReadSensor(void *pvParameters) {
    while (1) {
        // Simulate reading from a sensor
        g_sensorData.temperature = 25.0f;
        g_sensorData.pressure = 980.0f;
        
        // Delay for a short period to simulate real-time system
        vTaskDelay(100 / portTICK_PERIOD_MS);
    }
}

// Task 2: Process the sensor data
void vTaskProcessSensorData(void *pvParameters) {
    while (1) {
        // Use the global volatile variable to access the sensor data
        float temperature = g_sensorData.temperature;
        float pressure = g_sensorData.pressure;
        
        // Process the sensor data for control logic here...
        
        // Delay for a short period to simulate real-time system
        vTaskDelay(100 / portTICK<｜begin▁of▁sentence｜>ERIOD_MS);
    }
}

// Main function
int main(void) {
    // Create the tasks
    xTaskCreate(vTaskReadSensor, "Read Sensor", 256, NULL, 1, NULL);
    xTaskCreate(vTaskProcessSensorData, "Process Data", 256, NULL, 2, NULL);
    
    // Start the scheduler
    vTaskStartScheduler();
    
    return 0;
}