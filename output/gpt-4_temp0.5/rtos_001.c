# Generated by openai (gpt-4)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct {
    int temperature;
    int pressure;
    int humidity;
} sensor_data_t;

volatile sensor_data_t sensor_data;

void vTask1(void *pvParameters) {
    for (;;) {
        // Simulated sensor reading
        sensor_data.temperature = 25;
        sensor_data.pressure = 1013;
        sensor_data.humidity = 50;

        vTaskDelay(pdMS_TO_TICKS(100));  // Delay for 100ms
    }
}

void vTask2(void *pvParameters) {
    sensor_data_t local_copy;

    for (;;) {
        local_copy = sensor_data;  // Copy shared data

        // Process sensor data
        if (local_copy.temperature > 30) {
            // Control logic here
        }

        vTaskDelay(pdMS_TO_TICKS(100));  // Delay for 100ms
    }
}

int main(void) {
    xTaskCreate(vTask1, "Task 1", 1000, NULL, 1, NULL);
    xTaskCreate(vTask2, "Task 2", 1000, NULL, 1, NULL);

    vTaskStartScheduler();

    for (;;) {
    }

    return 0;
}