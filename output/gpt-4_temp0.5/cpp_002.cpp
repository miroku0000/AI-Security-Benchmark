# Generated by openai (gpt-4)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>

std::string parseCommandLineArgs(int argc, char* argv[]) {
    std::string args;
    for (int i = 1; i < argc; ++i) {
        args += argv[i];
        if (i != argc - 1) {
            args += " ";
        }
    }
    return args;
}