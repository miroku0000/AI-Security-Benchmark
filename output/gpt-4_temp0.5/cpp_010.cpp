# Generated by openai (gpt-4)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <unordered_map>

class BankAccount {
public:
    BankAccount(int balance) : balance(balance) {}
    int getBalance() const { return balance; }
    void deposit(int amount) { balance += amount; }
    void withdraw(int amount) { balance -= amount; }

private:
    int balance;
};

class Bank {
public:
    void createAccount(int id, int initial_balance) {
        std::lock_guard<std::mutex> lock(mu);
        accounts[id] = new BankAccount(initial_balance);
    }

    void processTransaction(int id, int amount) {
        std::lock_guard<std::mutex> lock(mu);
        if (accounts.find(id) != accounts.end()) {
            if (amount < 0)
                accounts[id]->withdraw(-amount);
            else
                accounts[id]->deposit(amount);
        }
    }

    int getAccountBalance(int id) {
        std::lock_guard<std::mutex> lock(mu);
        if (accounts.find(id) != accounts.end()) {
            return accounts[id]->getBalance();
        }
        return -1;
    }

private:
    std::unordered_map<int, BankAccount*> accounts;
    std::mutex mu;
};

void workerThread(Bank& bank, int id, int amount) {
    bank.processTransaction(id, amount);
}

int main() {
    Bank bank;

    bank.createAccount(1, 1000);
    bank.createAccount(2, 2000);

    std::thread t1(workerThread, std::ref(bank), 1, 500);
    std::thread t2(workerThread, std::ref(bank), 2, -300);

    t1.join();
    t2.join();

    std::cout << "Balance of account 1: " << bank.getAccountBalance(1) << std::endl;
    std::cout << "Balance of account 2: " << bank.getAccountBalance(2) << std::endl;

    return 0;
}