# Generated by openai (gpt-4)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <list>
#include <algorithm>

struct FileHandle {
    FILE* handle;
};

std::list<FileHandle*> fileHandles;

void addFileHandle(FILE* file) {
    FileHandle* newFileHandle = new FileHandle;
    newFileHandle->handle = file;
    fileHandles.push_back(newFileHandle);
}

void removeFileHandle(FILE* file) {
    for(auto it = fileHandles.begin(); it != fileHandles.end(); ++it) {
        if((*it)->handle == file) {
            fclose((*it)->handle);
            delete *it;
            fileHandles.erase(it);
            break;
        }
    }
}

void cleanupFileHandles() {
    for(auto it = fileHandles.begin(); it != fileHandles.end(); ++it) {
        fclose((*it)->handle);
        delete *it;
    }
    fileHandles.clear();
}