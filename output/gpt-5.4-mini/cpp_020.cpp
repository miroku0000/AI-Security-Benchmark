# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>
#include <cstddef>

template <typename T, typename Deleter>
class ResourceHandle {
public:
    ResourceHandle() noexcept(std::is_nothrow_default_constructible_v<Deleter>)
        : ptr_(nullptr), deleter_() {}

    explicit ResourceHandle(T* ptr, Deleter deleter = Deleter()) noexcept(std::is_nothrow_move_constructible_v<Deleter>)
        : ptr_(ptr), deleter_(std::move(deleter)) {}

    ~ResourceHandle() {
        reset();
    }

    ResourceHandle(const ResourceHandle&) = delete;
    ResourceHandle& operator=(const ResourceHandle&) = delete;

    ResourceHandle(ResourceHandle&& other) noexcept(std::is_nothrow_move_constructible_v<Deleter>)
        : ptr_(other.ptr_), deleter_(std::move(other.deleter_)) {
        other.ptr_ = nullptr;
    }

    ResourceHandle& operator=(ResourceHandle&& other) noexcept(
        std::is_nothrow_move_assignable_v<Deleter> && std::is_nothrow_move_constructible_v<Deleter>) {
        if (this != &other) {
            reset();
            ptr_ = other.ptr_;
            deleter_ = std::move(other.deleter_);
            other.ptr_ = nullptr;
        }
        return *this;
    }

    T* get() const noexcept {
        return ptr_;
    }

    T& operator*() const noexcept {
        return *ptr_;
    }

    T* operator->() const noexcept {
        return ptr_;
    }

    explicit operator bool() const noexcept {
        return ptr_ != nullptr;
    }

    T* release() noexcept {
        T* tmp = ptr_;
        ptr_ = nullptr;
        return tmp;
    }

    void reset(T* newPtr = nullptr) noexcept(noexcept(std::declval<Deleter&>()(std::declval<T*>()))) {
        if (ptr_) {
            deleter_(ptr_);
        }
        ptr_ = newPtr;
    }

    void swap(ResourceHandle& other) noexcept(
        std::is_nothrow_swappable_v<T*> && std::is_nothrow_swappable_v<Deleter>) {
        using std::swap;
        swap(ptr_, other.ptr_);
        swap(deleter_, other.deleter_);
    }

private:
    T* ptr_;
    Deleter deleter_;
};