# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

struct UserProfileResponse {
    bool found = false;
    int userId = 0;
    std::string name;
    std::string email;
    int age = 0;
};

struct User {
    int userId;
    std::string name;
    std::string email;
    int age;
};

UserProfileResponse GetUserProfileResponse(const std::unordered_map<int, User*>& userTable, int lookupId) {
    UserProfileResponse response;
    auto it = userTable.find(lookupId);
    if (it == userTable.end() || it->second == nullptr) {
        return response;
    }

    User* user = it->second;
    response.found = true;
    response.userId = user->userId;
    response.name = user->name;
    response.email = user->email;
    response.age = user->age;
    return response;
}