# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <string>
#include <thread>
#include <vector>
#include <mutex>
#include <shared_mutex>
#include <random>
#include <chrono>

class Bank {
private:
    std::unordered_map<std::string, long long> accounts;
    mutable std::shared_mutex accountsMutex;

public:
    void createAccount(const std::string& id, long long initialBalance) {
        std::unique_lock<std::shared_mutex> lock(accountsMutex);
        accounts[id] = initialBalance;
    }

    long long getBalance(const std::string& id) const {
        std::shared_lock<std::shared_mutex> lock(accountsMutex);
        auto it = accounts.find(id);
        if (it == accounts.end()) return 0;
        return it->second;
    }

    bool deposit(const std::string& id, long long amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(accountsMutex);
        auto it = accounts.find(id);
        if (it == accounts.end()) return false;
        it->second += amount;
        return true;
    }

    bool withdraw(const std::string& id, long long amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(accountsMutex);
        auto it = accounts.find(id);
        if (it == accounts.end() || it->second < amount) return false;
        it->second -= amount;
        return true;
    }

    bool transfer(const std::string& from, const std::string& to, long long amount) {
        if (amount < 0 || from == to) return false;
        std::unique_lock<std::shared_mutex> lock(accountsMutex);
        auto itFrom = accounts.find(from);
        auto itTo = accounts.find(to);
        if (itFrom == accounts.end() || itTo == accounts.end() || itFrom->second < amount) return false;
        itFrom->second -= amount;
        itTo->second += amount;
        return true;
    }

    void printAll() const {
        std::shared_lock<std::shared_mutex> lock(accountsMutex);
        for (const auto& [id, balance] : accounts) {
            std::cout << id << ": " << balance << '\n';
        }
    }
};

struct Transaction {
    enum class Type { Deposit, Withdraw, Transfer };
    Type type;
    std::string from;
    std::string to;
    long long amount;
};

void processTransactions(Bank& bank, const std::vector<Transaction>& transactions, int threadId) {
    for (const auto& tx : transactions) {
        bool ok = false;
        switch (tx.type) {
            case Transaction::Type::Deposit:
                ok = bank.deposit(tx.from, tx.amount);
                break;
            case Transaction::Type::Withdraw:
                ok = bank.withdraw(tx.from, tx.amount);
                break;
            case Transaction::Type::Transfer:
                ok = bank.transfer(tx.from, tx.to, tx.amount);
                break;
        }

        std::cout << "Thread " << threadId << " processed transaction: "
                  << (ok ? "success" : "failed") << '\n';

        std::this_thread::sleep_for(std::chrono::milliseconds(10));
    }
}

int main() {
    Bank bank;
    bank.createAccount("Alice", 1000);
    bank.createAccount("Bob", 1500);
    bank.createAccount("Charlie", 2000);
    bank.createAccount("Diana", 2500);

    std::vector<Transaction> transactions1 = {
        {Transaction::Type::Deposit, "Alice", "", 200},
        {Transaction::Type::Withdraw, "Bob", "", 300},
        {Transaction::Type::Transfer, "Charlie", "Diana", 500}
    };

    std::vector<Transaction> transactions2 = {
        {Transaction::Type::Transfer, "Diana", "Alice", 400},
        {Transaction::Type::Deposit, "Bob", "", 700},
        {Transaction::Type::Withdraw, "Charlie", "", 100}
    };

    std::vector<Transaction> transactions3 = {
        {Transaction::Type::Transfer, "Alice", "Bob", 150},
        {Transaction::Type::Transfer, "Bob", "Charlie", 250},
        {Transaction::Type::Deposit, "Diana", "", 300}
    };

    std::thread t1(processTransactions, std::ref(bank), std::cref(transactions1), 1);
    std::thread t2(processTransactions, std::ref(bank), std::cref(transactions2), 2);
    std::thread t3(processTransactions, std::ref(bank), std::cref(transactions3), 3);

    t1.join();
    t2.join();
    t3.join();

    std::cout << "\nFinal account balances:\n";
    bank.printAll();

    return 0;
}