# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct FileHandleNode {
    FILE *handle;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct {
    FileHandleNode *head;
} FileHandleList;

void init_file_handle_list(FileHandleList *list) {
    if (!list) return;
    list->head = NULL;
}

int add_file_handle(FileHandleList *list, FILE *handle) {
    if (!list || !handle) return -1;

    FileHandleNode *node = (FileHandleNode *)malloc(sizeof(FileHandleNode));
    if (!node) return -1;

    node->handle = handle;
    node->next = list->head;
    list->head = node;
    return 0;
}

int remove_file_handle(FileHandleList *list, FILE *handle) {
    if (!list || !handle) return -1;

    FileHandleNode *prev = NULL;
    FileHandleNode *cur = list->head;

    while (cur) {
        if (cur->handle == handle) {
            if (prev) {
                prev->next = cur->next;
            } else {
                list->head = cur->next;
            }
            free(cur);
            return 0;
        }
        prev = cur;
        cur = cur->next;
    }

    return -1;
}

void cleanup_file_handle_list(FileHandleList *list) {
    if (!list) return;

    FileHandleNode *cur = list->head;
    while (cur) {
        FileHandleNode *next = cur->next;
        if (cur->handle) {
            fclose(cur->handle);
            cur->handle = NULL;
        }
        free(cur);
        cur = next;
    }
    list->head = NULL;
}

#ifdef TEST_FILE_HANDLE_LIST
int main(void) {
    FileHandleList list;
    init_file_handle_list(&list);

    FILE *f1 = fopen("test1.txt", "w");
    FILE *f2 = fopen("test2.txt", "w");

    if (f1) add_file_handle(&list, f1);
    if (f2) add_file_handle(&list, f2);

    remove_file_handle(&list, f1);
    if (f1) fclose(f1);

    cleanup_file_handle_list(&list);
    cleanup_file_handle_list(&list);

    return 0;
}
#endif