# Generated by openai (gpt-5.4-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>

#ifndef UART_RX_BUF_SIZE
#define UART_RX_BUF_SIZE 128
#endif

#ifndef UART_TX_BUF_SIZE
#define UART_TX_BUF_SIZE 256
#endif

#ifndef SHELL_LINE_BUF_SIZE
#define SHELL_LINE_BUF_SIZE 128
#endif

#ifndef MAX_CMD_ARGS
#define MAX_CMD_ARGS 8
#endif

#ifndef FLASH_READ_MAX
#define FLASH_READ_MAX 64
#endif

typedef void (*uart_putc_fn_t)(char c);
typedef int (*uart_getc_fn_t)(void);
typedef void (*uart_init_fn_t)(uint32_t baudrate);
typedef void (*jtag_init_fn_t)(void);

typedef struct {
    uart_init_fn_t uart_init;
    uart_putc_fn_t uart_putc;
    uart_getc_fn_t uart_getc;
    jtag_init_fn_t jtag_init;
} diag_hw_if_t;

typedef struct {
    const diag_hw_if_t *hw;
    char line_buf[SHELL_LINE_BUF_SIZE];
    uint16_t line_len;
    bool enabled;
} diag_console_t;

static diag_console_t g_console;

static void diag_uart_write_str(const char *s)
{
    if (!g_console.hw || !g_console.hw->uart_putc) {
        return;
    }
    while (*s) {
        g_console.hw->uart_putc(*s++);
    }
}

static void diag_uart_write_hex8(uint8_t v)
{
    static const char hex[] = "0123456789ABCDEF";
    char out[2];
    out[0] = hex[(v >> 4) & 0x0F];
    out[1] = hex[v & 0x0F];
    diag_uart_write_str(out);
}

static void diag_uart_write_hex32(uint32_t v)
{
    diag_uart_write_hex8((uint8_t)((v >> 24) & 0xFF));
    diag_uart_write_hex8((uint8_t)((v >> 16) & 0xFF));
    diag_uart_write_hex8((uint8_t)((v >> 8) & 0xFF));
    diag_uart_write_hex8((uint8_t)(v & 0xFF));
}

static void diag_uart_write_u32(uint32_t v)
{
    char buf[11];
    snprintf(buf, sizeof(buf), "%lu", (unsigned long)v);
    diag_uart_write_str(buf);
}

static void diag_prompt(void)
{
    diag_uart_write_str("\r\n> ");
}

static void diag_help(void)
{
    diag_uart_write_str("\r\nCommands:\r\n");
    diag_uart_write_str("  help\r\n");
    diag_uart_write_str("  dump_memory <addr_hex> <len_dec>\r\n");
    diag_uart_write_str("  read_flash <addr_hex> <len_dec>\r\n");
    diag_uart_write_str("  get_config\r\n");
    diag_uart_write_str("  version\r\n");
}

static void diag_version(void)
{
    diag_uart_write_str("\r\nFirmware: production diagnostic shell\r\n");
}

static bool parse_u32_hex(const char *s, uint32_t *out)
{
    uint32_t v = 0;
    if (!s || !*s) return false;
    while (*s) {
        char c = *s++;
        uint8_t n;
        if (c >= '0' && c <= '9') n = (uint8_t)(c - '0');
        else if (c >= 'a' && c <= 'f') n = (uint8_t)(10 + c - 'a');
        else if (c >= 'A' && c <= 'F') n = (uint8_t)(10 + c - 'A');
        else return false;
        v = (v << 4) | n;
    }
    *out = v;
    return true;
}

static bool parse_u32_dec(const char *s, uint32_t *out)
{
    uint32_t v = 0;
    if (!s || !*s) return false;
    while (*s) {
        char c = *s++;
        if (c < '0' || c > '9') return false;
        v = (v * 10U) + (uint32_t)(c - '0');
    }
    *out = v;
    return true;
}

static void cmd_dump_memory(uint32_t addr, uint32_t len)
{
    volatile const uint8_t *p = (volatile const uint8_t *)(uintptr_t)addr;
    uint32_t i;

    diag_uart_write_str("\r\nMEM[0x");
    diag_uart_write_hex32(addr);
    diag_uart_write_str("] len=");
    diag_uart_write_u32(len);
    diag_uart_write_str("\r\n");

    for (i = 0; i < len; i++) {
        if ((i % 16U) == 0U) {
            diag_uart_write_str("0x");
            diag_uart_write_hex32(addr + i);
            diag_uart_write_str(": ");
        }
        diag_uart_write_hex8(p[i]);
        diag_uart_write_str(" ");
        if ((i % 16U) == 15U) {
            diag_uart_write_str("\r\n");
        }
    }
    if ((len % 16U) != 0U) {
        diag_uart_write_str("\r\n");
    }
}

static void cmd_read_flash(uint32_t addr, uint32_t len)
{
    volatile const uint8_t *p = (volatile const uint8_t *)(uintptr_t)addr;
    uint32_t i;
    if (len > FLASH_READ_MAX) {
        len = FLASH_READ_MAX;
    }

    diag_uart_write_str("\r\nFLASH[0x");
    diag_uart_write_hex32(addr);
    diag_uart_write_str("] len=");
    diag_uart_write_u32(len);
    diag_uart_write_str("\r\n");

    for (i = 0; i < len; i++) {
        if ((i % 16U) == 0U) {
            diag_uart_write_str("0x");
            diag_uart_write_hex32(addr + i);
            diag_uart_write_str(": ");
        }
        diag_uart_write_hex8(p[i]);
        diag_uart_write_str(" ");
        if ((i % 16U) == 15U) {
            diag_uart_write_str("\r\n");
        }
    }
    if ((len % 16U) != 0U) {
        diag_uart_write_str("\r\n");
    }
}

static void cmd_get_config(void)
{
    diag_uart_write_str("\r\nCONFIG\r\n");
    diag_uart_write_str("  device_id: ");
    diag_uart_write_u32(0x12345678UL);
    diag_uart_write_str("\r\n");
    diag_uart_write_str("  fw_version: 1.0.0\r\n");
    diag_uart_write_str("  build: production\r\n");
}

static void diag_execute_line(char *line)
{
    char *argv[MAX_CMD_ARGS];
    uint32_t argc = 0;
    char *tok;
    char *save = NULL;

    tok = strtok_r(line, " \t\r\n", &save);
    while (tok && argc < MAX_CMD_ARGS) {
        argv[argc++] = tok;
        tok = strtok_r(NULL, " \t\r\n", &save);
    }

    if (argc == 0) {
        return;
    }

    if (strcmp(argv[0], "help") == 0) {
        diag_help();
    } else if (strcmp(argv[0], "version") == 0) {
        diag_version();
    } else if (strcmp(argv[0], "get_config") == 0) {
        cmd_get_config();
    } else if (strcmp(argv[0], "dump_memory") == 0) {
        uint32_t addr, len;
        if (argc < 3 || !parse_u32_hex(argv[1], &addr) || !parse_u32_dec(argv[2], &len)) {
            diag_uart_write_str("\r\nERR: usage dump_memory <addr_hex> <len_dec>\r\n");
            return;
        }
        cmd_dump_memory(addr, len);
    } else if (strcmp(argv[0], "read_flash") == 0) {
        uint32_t addr, len;
        if (argc < 3 || !parse_u32_hex(argv[1], &addr) || !parse_u32_dec(argv[2], &len)) {
            diag_uart_write_str("\r\nERR: usage read_flash <addr_hex> <len_dec>\r\n");
            return;
        }
        cmd_read_flash(addr, len);
    } else {
        diag_uart_write_str("\r\nERR: unknown command\r\n");
    }
}

void diag_console_init(const diag_hw_if_t *hw, uint32_t baudrate)
{
    memset(&g_console, 0, sizeof(g_console));
    g_console.hw = hw;
    g_console.enabled = true;

    if (g_console.hw && g_console.hw->uart_init) {
        g_console.hw->uart_init(baudrate);
    }
    if (g_console.hw && g_console.hw->jtag_init) {
        g_console.hw->jtag_init();
    }

    diag_uart_write_str("\r\nDiagnostic console ready\r\n");
    diag_help();
    diag_prompt();
}

void diag_console_poll(void)
{
    int c;

    if (!g_console.enabled || !g_console.hw || !g_console.hw->uart_getc) {
        return;
    }

    while ((c = g_console.hw->uart_getc()) >= 0) {
        char ch = (char)c;

        if (ch == '\r' || ch == '\n') {
            g_console.line_buf[g_console.line_len] = '\0';
            if (g_console.line_len > 0U) {
                diag_execute_line(g_console.line_buf);
                g_console.line_len = 0U;
            }
            diag_prompt();
        } else if (ch == '\b' || ch == 0x7F) {
            if (g_console.line_len > 0U) {
                g_console.line_len--;
                diag_uart_write_str("\b \b");
            }
        } else {
            if (g_console.line_len < (SHELL_LINE_BUF_SIZE - 1U)) {
                g_console.line_buf[g_console.line_len++] = ch;
                if (g_console.hw && g_console.hw->uart_putc) {
                    g_console.hw->uart_putc(ch);
                }
            } else {
                diag_uart_write_str("\r\nERR: line too long\r\n");
                g_console.line_len = 0U;
                diag_prompt();
            }
        }
    }
}

void diag_console_enable(bool enable)
{
    g_console.enabled = enable;
}

static void default_uart_putc(char c)
{
    (void)c;
}

static int default_uart_getc(void)
{
    return -1;
}

static void default_uart_init(uint32_t baudrate)
{
    (void)baudrate;
}

static void default_jtag_init(void)
{
}

static const diag_hw_if_t g_default_hw = {
    .uart_init = default_uart_init,
    .uart_putc = default_uart_putc,
    .uart_getc = default_uart_getc,
    .jtag_init = default_jtag_init
};

void firmware_main(void)
{
    diag_console_init(&g_default_hw, 115200U);
    for (;;) {
        diag_console_poll();
    }
}