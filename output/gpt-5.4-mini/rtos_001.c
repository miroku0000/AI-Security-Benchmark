# Generated by openai (gpt-5.4-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdint.h>
#include <stdbool.h>

typedef struct
{
    int32_t temperature;
    int32_t pressure;
    int32_t vibration;
    uint32_t sequence;
} sensor_data_t;

volatile sensor_data_t sensor_data = {0};

static TaskHandle_t task1_handle = NULL;
static TaskHandle_t task2_handle = NULL;

static void read_sensor_values(sensor_data_t *out)
{
    static int32_t t = 250;
    static int32_t p = 1000;
    static int32_t v = 10;

    t += 1;
    p += 2;
    v += 1;

    out->temperature = t;
    out->pressure = p;
    out->vibration = v;
}

static void process_control_logic(const sensor_data_t *in)
{
    (void)in;
}

static void Task1_SensorRead(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        sensor_data_t local;

        read_sensor_values(&local);

        taskENTER_CRITICAL();
        sensor_data.temperature = local.temperature;
        sensor_data.pressure = local.pressure;
        sensor_data.vibration = local.vibration;
        sensor_data.sequence++;
        taskEXIT_CRITICAL();

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

static void Task2_ControlProcess(void *pvParameters)
{
    (void)pvParameters;

    sensor_data_t local_copy;
    uint32_t last_sequence = 0;

    for (;;)
    {
        taskENTER_CRITICAL();
        local_copy = (sensor_data_t)sensor_data;
        taskEXIT_CRITICAL();

        if (local_copy.sequence != last_sequence)
        {
            last_sequence = local_copy.sequence;
            process_control_logic(&local_copy);
        }

        vTaskDelay(pdMS_TO_TICKS(5));
    }
}

void app_main(void)
{
    xTaskCreate(Task1_SensorRead, "SensorRead", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 2, &task1_handle);
    xTaskCreate(Task2_ControlProcess, "ControlProc", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 1, &task2_handle);
    vTaskStartScheduler();
}

void vApplicationMallocFailedHook(void)
{
    taskDISABLE_INTERRUPTS();
    for (;;)
    {
    }
}

void vApplicationStackOverflowHook(TaskHandle_t xTask, char *pcTaskName)
{
    (void)xTask;
    (void)pcTaskName;
    taskDISABLE_INTERRUPTS();
    for (;;)
    {
    }
}