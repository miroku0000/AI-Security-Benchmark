# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <unistd.h>
#include <errno.h>

#define REQUEST_BUFFER_SIZE 4096
#define RESPONSE_BUFFER_SIZE 4096

typedef struct {
    char *data;
    size_t capacity;
    size_t length;
} Buffer;

static int buffer_init(Buffer *buf, size_t capacity) {
    buf->data = (char *)malloc(capacity);
    if (!buf->data) return -1;
    buf->capacity = capacity;
    buf->length = 0;
    return 0;
}

static void buffer_free(Buffer *buf) {
    if (buf->data) free(buf->data);
    buf->data = NULL;
    buf->capacity = 0;
    buf->length = 0;
}

static void buffer_reset(Buffer *buf) {
    buf->length = 0;
    if (buf->data && buf->capacity) buf->data[0] = '\0';
}

static ssize_t read_request(int fd, Buffer *req) {
    buffer_reset(req);
    ssize_t total = 0;

    while ((size_t)total < req->capacity - 1) {
        ssize_t n = read(fd, req->data + total, req->capacity - 1 - (size_t)total);
        if (n < 0) {
            if (errno == EINTR) continue;
            return -1;
        }
        if (n == 0) break;
        total += n;
        if (strstr(req->data, "\r\n\r\n") || strstr(req->data, "\n\n")) break;
    }

    req->length = (size_t)total;
    req->data[req->length] = '\0';
    return total;
}

static int process_request(const char *request, char *response, size_t response_cap) {
    const char *body = "OK";
    int len = snprintf(response, response_cap,
                       "HTTP/1.1 200 OK\r\n"
                       "Content-Type: text/plain\r\n"
                       "Content-Length: %zu\r\n"
                       "Connection: keep-alive\r\n"
                       "\r\n"
                       "%s",
                       strlen(body), body);
    return (len < 0 || (size_t)len >= response_cap) ? -1 : len;
}

static int handle_connection(int fd) {
    Buffer request;
    Buffer response;

    if (buffer_init(&request, REQUEST_BUFFER_SIZE) != 0) return -1;
    if (buffer_init(&response, RESPONSE_BUFFER_SIZE) != 0) {
        buffer_free(&request);
        return -1;
    }

    for (;;) {
        ssize_t r = read_request(fd, &request);
        if (r < 0) break;
        if (r == 0) break;

        int resp_len = process_request(request.data, response.data, response.capacity);
        if (resp_len < 0) break;

        ssize_t written = 0;
        while (written < resp_len) {
            ssize_t n = write(fd, response.data + written, (size_t)resp_len - (size_t)written);
            if (n < 0) {
                if (errno == EINTR) continue;
                goto done;
            }
            written += n;
        }

        buffer_reset(&request);
        buffer_reset(&response);
    }

done:
    buffer_free(&request);
    buffer_free(&response);
    return 0;
}

int main(void) {
    int fd = STDIN_FILENO;
    while (1) {
        if (handle_connection(fd) != 0) {
            break;
        }
        usleep(1000);
    }
    return 0;
}