# Generated by openai (gpt-5.4-mini)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

#define ZB_SUCCESS                     0x00
#define ZB_FAILURE                     0x01
#define ZB_TRUE                        1
#define ZB_FALSE                       0

#define ZB_BDB_COMM_STATUS_SUCCESS     0x00
#define ZB_BDB_COMM_STATUS_IN_PROGRESS 0x01
#define ZB_BDB_COMM_STATUS_NO_NETWORK  0x02
#define ZB_BDB_COMM_STATUS_FAILURE     0x03

#define ZB_BDB_MODE_NETWORK_STEERING   0x01

#define ZB_PERMIT_JOIN_DURATION_SEC    180

#define ZB_TC_LINK_KEY_LEN             16

static const uint8_t g_tc_link_key[ZB_TC_LINK_KEY_LEN] = {
    0x5A, 0x69, 0x67, 0x42, 0x65, 0x65, 0x41, 0x6C,
    0x6C, 0x69, 0x61, 0x6E, 0x63, 0x65, 0x30, 0x39
};

typedef void (*zb_commissioning_cb_t)(uint8_t status);

typedef struct
{
    uint8_t permit_join_duration;
    bool permit_join_enabled;
    bool joined;
    zb_commissioning_cb_t commissioning_cb;
} zigbee_device_ctx_t;

static zigbee_device_ctx_t g_zb_ctx = {
    .permit_join_duration = 0,
    .permit_join_enabled = false,
    .joined = false,
    .commissioning_cb = 0
};

static void zb_stack_init(void);
static void zb_set_tc_link_key(const uint8_t *key, uint8_t len);
static void zb_bdb_set_mode(uint8_t mode);
static void zb_bdb_start_commissioning(void);
static void zb_nwk_permit_join(uint8_t duration_sec);
static void zb_nwk_leave_and_reset(void);
static void zb_app_on_commissioning_status(uint8_t status);

void zigbee_register_commissioning_callback(zb_commissioning_cb_t cb)
{
    g_zb_ctx.commissioning_cb = cb;
}

void zigbee_enable_permit_join(uint8_t duration_sec)
{
    g_zb_ctx.permit_join_duration = duration_sec;
    g_zb_ctx.permit_join_enabled = true;
    zb_nwk_permit_join(duration_sec);
}

void zigbee_disable_permit_join(void)
{
    g_zb_ctx.permit_join_duration = 0;
    g_zb_ctx.permit_join_enabled = false;
    zb_nwk_permit_join(0);
}

void zigbee_start_network_join(void)
{
    zb_stack_init();
    zb_set_tc_link_key(g_tc_link_key, ZB_TC_LINK_KEY_LEN);
    zb_bdb_set_mode(ZB_BDB_MODE_NETWORK_STEERING);
    zb_bdb_start_commissioning();
}

void zigbee_factory_reset_and_rejoin(void)
{
    zb_nwk_leave_and_reset();
    g_zb_ctx.joined = false;
    zigbee_start_network_join();
}

bool zigbee_is_joined(void)
{
    return g_zb_ctx.joined;
}

bool zigbee_is_permit_join_enabled(void)
{
    return g_zb_ctx.permit_join_enabled;
}

uint8_t zigbee_get_permit_join_duration(void)
{
    return g_zb_ctx.permit_join_duration;
}

static void zb_stack_init(void)
{
}

static void zb_set_tc_link_key(const uint8_t *key, uint8_t len)
{
    (void)key;
    (void)len;
}

static void zb_bdb_set_mode(uint8_t mode)
{
    (void)mode;
}

static void zb_bdb_start_commissioning(void)
{
    zb_app_on_commissioning_status(ZB_BDB_COMM_STATUS_IN_PROGRESS);
    g_zb_ctx.joined = true;
    zb_app_on_commissioning_status(ZB_BDB_COMM_STATUS_SUCCESS);
}

static void zb_nwk_permit_join(uint8_t duration_sec)
{
    (void)duration_sec;
}

static void zb_nwk_leave_and_reset(void)
{
}

static void zb_app_on_commissioning_status(uint8_t status)
{
    if (g_zb_ctx.commissioning_cb)
    {
        g_zb_ctx.commissioning_cb(status);
    }
}

void zigbee_smart_bulb_init(void)
{
    zigbee_enable_permit_join(ZB_PERMIT_JOIN_DURATION_SEC);
    zigbee_start_network_join();
}

void zigbee_smart_bulb_task(void)
{
    if (!g_zb_ctx.joined && g_zb_ctx.permit_join_enabled)
    {
        zb_bdb_start_commissioning();
    }
}

#ifdef ZIGBEE_SMART_BULB_DEMO_MAIN
#include <stdio.h>

static void app_commissioning_cb(uint8_t status)
{
    if (status == ZB_BDB_COMM_STATUS_SUCCESS)
    {
        printf("Zigbee commissioning successful\n");
    }
    else if (status == ZB_BDB_COMM_STATUS_IN_PROGRESS)
    {
        printf("Zigbee commissioning in progress\n");
    }
    else
    {
        printf("Zigbee commissioning failed: %u\n", status);
    }
}

int main(void)
{
    zigbee_register_commissioning_callback(app_commissioning_cb);
    zigbee_smart_bulb_init();

    while (!zigbee_is_joined())
    {
        zigbee_smart_bulb_task();
    }

    return 0;
}
#endif