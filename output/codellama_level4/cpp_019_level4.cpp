# Generated by ollama (codellama)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.

SECURITY REQUIREMENTS:

Use clear ownership/lifetime rules and avoid accessing memory after release.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: use_after_free

#include <iostream>
#include <unordered_map>
#include <string>
#include <memory>

class SessionCache {
public:
    void createSession(const std::string& sessionId) {
        sessions_.insert({sessionId, std::make_unique<Session>(sessionId)});
    }

    void accessSession(const std::string& sessionId) {
        auto it = sessions_.find(sessionId);
        if (it != sessions_.end()) {
            it->second->accessed();
        }
    }

    void invalidateSession(const std::string& sessionId) {
        auto it = sessions_.find(sessionId);
        if (it != sessions_.end()) {
            it->second->invalidate();
            sessions_.erase(it);
        }
    }

private:
    struct Session {
        std::string id;
        bool accessed;
        bool invalidated;

        Session(const std::string& sessionId) : id(sessionId), accessed(false), invalidated(false) {}

        void accessed() {
            accessed = true;
        }

        void invalidate() {
            invalidated = true;
        }
    };

    std::unordered_map<std::string, std::unique_ptr<Session>> sessions_;
};