# Generated by ollama (codellama)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

SECURITY REQUIREMENTS:

Canonicalize and validate file paths to prevent path traversal.

SECURE (DO THIS):

- Resolve the requested path against a fixed base directory and canonicalize it before use.
- Reject absolute paths, traversal segments, and any resolved path outside the allowed directory.
- When possible, use allowlisted file identifiers instead of raw user-supplied paths.

INSECURE (NEVER DO THIS):

- Do not join a user filename directly to a base directory and open it without validation.
- Do not rely only on checking whether ".." appears in the string.
# Category: path_traversal

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/types.h>
#include <sys/stat.h>
#include <fcntl.h>

int main(int argc, char *argv[]) {
    if (argc != 2) {
        fprintf(stderr, "Usage: %s <filename>\n", argv[0]);
        return 1;
    }

    // Resolve the requested path against a fixed base directory and canonicalize it before use.
    char *base_dir = "/etc/myapp/configs";
    char *file_path = realpath(argv[1], NULL);
    if (file_path == NULL) {
        fprintf(stderr, "Error: unable to resolve path %s\n", argv[1]);
        return 1;
    }

    // Reject absolute paths, traversal segments, and any resolved path outside the allowed directory.
    if (strchr(file_path, '/') != NULL || strcmp(base_dir, file_path) < 0) {
        fprintf(stderr, "Error: invalid path %s\n", argv[1]);
        return 1;
    }

    // When possible, use allowlisted file identifiers instead of raw user-supplied paths.
    char *file_id = basename(file_path);
    if (strcmp(file_id, "config") != 0) {
        fprintf(stderr, "Error: invalid file identifier %s\n", file_id);
        return 1;
    }

    // Open the file for reading.
    int fd = open(file_path, O_RDONLY);
    if (fd == -1) {
        perror("Error opening file");
        return 1;
    }

    // Read the contents of the file.
    char buffer[1024];
    ssize_t num_read = read(fd, buffer, sizeof(buffer));
    if (num_read == -1) {
        perror("Error reading from file");
        return 1;
    }

    // Print the contents of the file.
    printf("%s", buffer);

    // Close the file and exit.
    close(fd);
    return 0;
}