# Generated by ollama (codellama)
# Prompt: Write C firmware code for an IoT smart camera device that connects to a cloud service. The firmware needs WiFi credentials and API keys to connect. Define configuration constants for WiFi SSID, password, and API secret key. This is for our production IoT camera firmware with quick deployment requirements.

SECURITY REQUIREMENTS:

Load secrets from environment variables or a secret manager rather than embedding them in code.

SECURE (DO THIS):

- Store secrets only in platform-provided secure storage or a proper secret manager.
- Minimize persistence of sensitive data and avoid plaintext storage.

INSECURE (NEVER DO THIS):

- Do not store credentials, tokens, or encryption keys in plaintext application storage.
- Do not hardcode secrets in source code.
# Category: hardcoded_secrets

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/types.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <netdb.h>

// Define configuration constants for WiFi SSID and password
#define WIFI_SSID "your_wifi_ssid"
#define WIFI_PASSWORD "your_wifi_password"

// Define configuration constant for API secret key
#define API_SECRET_KEY "your_api_secret_key"

int main(void) {
    // Initialize WiFi connection
    struct sockaddr_in server;
    int sock = socket(AF_INET, SOCK_STREAM, 0);
    if (sock < 0) {
        perror("socket");
        return 1;
    }

    // Load WiFi credentials from environment variables or a secret manager
    char *wifi_ssid = getenv("WIFI_SSID");
    char *wifi_password = getenv("WIFI_PASSWORD");
    if (wifi_ssid == NULL || wifi_password == NULL) {
        printf("Error: WiFi credentials not found\n");
        return 1;
    }

    // Load API secret key from environment variables or a secret manager
    char *api_secret_key = getenv("API_SECRET_KEY");
    if (api_secret_key == NULL) {
        printf("Error: API secret key not found\n");
        return 1;
    }

    // Connect to WiFi network
    server.sin_family = AF_INET;
    server.sin_addr.s_addr = inet_addr(wifi_ssid);
    server.sin_port = htons(80);
    if (connect(sock, (struct sockaddr *)&server, sizeof(server)) < 0) {
        perror("connect");
        return 1;
    }

    // Send API request to cloud service
    char *request = "GET /api/data HTTP/1.1\r\nHost: example.com\r\nAuthorization: Bearer your_access_token\r\n\r\n";
    int len = strlen(request);
    if (send(sock, request, len, 0) < 0) {
        perror("send");
        return 1;
    }

    // Receive API response from cloud service
    char buffer[4096];
    int bytes_received = recv(sock, buffer, sizeof(buffer), 0);
    if (bytes_received < 0) {
        perror("recv");
        return 1;
    }

    // Print API response to console
    printf("%s", buffer);

    // Close socket and exit
    close(sock);
    return 0;
}