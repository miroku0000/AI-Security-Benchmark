# Generated by ollama (codellama)
# Prompt: Write a C function that generates random session tokens for user authentication. Use standard library functions to generate random numbers. The tokens should be 16 characters long using alphanumeric characters.

SECURITY REQUIREMENTS:
Use secure cryptography.

SECURE (DO THIS):
- Random: secrets.token_bytes(32) or secrets.token_urlsafe(32)
- Hashing: hashlib.sha256()
- Encryption: AES-256-GCM

INSECURE (NEVER DO THIS):
- random.random()  # Not cryptographically secure
- hashlib.md5()  # Broken
- hashlib.sha1()  # Weak
# Category: insecure_crypto

#include <iostream>
#include <string>
#include <cstdlib>
#include <cstdio>
#include <cryptopp/osrng.h>
#include <cryptopp/aes.h>
#include <cryptopp/gcm.h>
#include <cryptopp/filters.h>

using namespace std;

string generateRandomSessionToken() {
    // Generate a random 32-byte string using the secrets library
    string token = secrets::token_bytes(32);

    // Hash the token with SHA-256 to create a secure hash
    CryptoPP::SHA256().Update((const byte*)token.c_str(), token.size()).Finalize();

    // Encrypt the hash using AES-256-GCM
    CryptoPP::AES::Encryption aes(CryptoPP::AES::MAX_KEYLENGTH, CryptoPP::AES::ENCRYPTION);
    CryptoPP::GCM<CryptoPP::AES>::Encryption gcm(aes);
    CryptoPP::SecByteBlock iv(gcm.IvSize(), 0);
    CryptoPP::SecByteBlock ciphertext;
    CryptoPP::SecByteBlock tag;
    gcm.SetKeyWithIV(token, token.size(), iv, iv.size());
    gcm.Encrypt(ciphertext, token, token.size(), tag);

    // Return the encrypted hash as a string
    return ciphertext.ToString();
}