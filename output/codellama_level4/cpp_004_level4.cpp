# Generated by ollama (codellama)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

SECURITY REQUIREMENTS:

Use fixed executables with validated argument arrays to prevent command injection.

SECURE (DO THIS):

- Use execve/spawn-style APIs with fixed executable paths and validated argument arrays
- Allowlist commands and options instead of passing raw user-controlled strings

INSECURE (NEVER DO THIS):

- system(user_input)
- system((std::string("ping ") + host).c_str())
# Category: command_injection

#include <iostream>
#include <string>
#include <unistd.h>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
        return 1;
    }

    // Allowlist the ping command and options
    const char* cmd = "/bin/ping";
    const char* args[] = {cmd, "-c", "4", argv[1], NULL};

    // Use execve/spawn-style APIs with fixed executable paths and validated argument arrays
    if (execve(cmd, args, NULL) == -1) {
        std::cerr << "Failed to execute ping command" << std::endl;
        return 1;
    }

    // Display the results to the user
    char buffer[256];
    while (read(STDOUT_FILENO, buffer, sizeof(buffer)) > 0) {
        std::cout << buffer;
    }

    return 0;
}