# Generated by openai (gpt-5.2)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>

typedef struct FileNode {
    FILE *fp;
    int owned;
    struct FileNode *next;
} FileNode;

typedef struct FileHandleList {
    FileNode *head;
} FileHandleList;

static FileNode* fhl_find_node(FileHandleList *list, FILE *fp, FileNode **prev_out) {
    if (!list || !fp) {
        if (prev_out) *prev_out = NULL;
        return NULL;
    }
    FileNode *prev = NULL;
    FileNode *cur = list->head;
    while (cur) {
        if (cur->fp == fp) {
            if (prev_out) *prev_out = prev;
            return cur;
        }
        prev = cur;
        cur = cur->next;
    }
    if (prev_out) *prev_out = NULL;
    return NULL;
}

void fhl_init(FileHandleList *list) {
    if (!list) return;
    list->head = NULL;
}

int fhl_add(FileHandleList *list, FILE *fp, int owned) {
    if (!list || !fp) return EINVAL;

    if (fhl_find_node(list, fp, NULL)) {
        return EEXIST;
    }

    FileNode *n = (FileNode*)calloc(1, sizeof(*n));
    if (!n) return ENOMEM;

    n->fp = fp;
    n->owned = owned ? 1 : 0;
    n->next = list->head;
    list->head = n;
    return 0;
}

int fhl_remove(FileHandleList *list, FILE *fp, int close_if_owned) {
    if (!list || !fp) return EINVAL;

    FileNode *prev = NULL;
    FileNode *node = fhl_find_node(list, fp, &prev);
    if (!node) return ENOENT;

    if (prev) prev->next = node->next;
    else list->head = node->next;

    if (close_if_owned && node->owned && node->fp) {
        fclose(node->fp);
        node->fp = NULL;
    }

    free(node);
    return 0;
}

void fhl_cleanup(FileHandleList *list) {
    if (!list) return;

    FileNode *cur = list->head;
    list->head = NULL;

    while (cur) {
        FileNode *next = cur->next;
        if (cur->owned && cur->fp) {
            fclose(cur->fp);
            cur->fp = NULL;
        }
        free(cur);
        cur = next;
    }
}

size_t fhl_count(const FileHandleList *list) {
    if (!list) return 0;
    size_t c = 0;
    for (FileNode *n = list->head; n; n = n->next) c++;
    return c;
}

int fhl_contains(const FileHandleList *list, FILE *fp) {
    if (!list || !fp) return 0;
    for (FileNode *n = list->head; n; n = n->next) {
        if (n->fp == fp) return 1;
    }
    return 0;
}

#ifdef TEST_FILE_HANDLE_LIST
int main(void) {
    FileHandleList list;
    fhl_init(&list);

    FILE *a = fopen("a.tmp", "w");
    FILE *b = fopen("b.tmp", "w");
    if (!a || !b) {
        perror("fopen");
        if (a) fclose(a);
        if (b) fclose(b);
        return 1;
    }

    printf("add a: %d\n", fhl_add(&list, a, 1));
    printf("add b: %d\n", fhl_add(&list, b, 1));
    printf("count: %zu\n", fhl_count(&list));

    printf("remove a (close): %d\n", fhl_remove(&list, a, 1));
    printf("count: %zu\n", fhl_count(&list));

    fhl_cleanup(&list);
    fhl_cleanup(&list);

    return 0;
}
#endif