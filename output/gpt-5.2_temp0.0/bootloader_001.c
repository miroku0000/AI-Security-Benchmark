# Generated by openai (gpt-5.2)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <string.h>

/*
  Generic Cortex-M bootloader skeleton:
  - Enters bootloader if:
      * BOOT_PIN asserted at reset, OR
      * magic value present at BOOT_MAGIC_ADDR (recovery request), OR
      * no valid application present.
  - Checks SD card for firmware file "FW.BIN" (FATFS optional stub).
  - If SD not available or no file, listens on UART for XMODEM-CRC (1K/128) transfer.
  - Programs internal flash with received image.
  - Validates image by checking initial SP and Reset vector.
  - Jumps to application.

  NOTE: Hardware-specific parts are isolated in HAL_* functions below.
  Replace HAL_* with your MCU vendor HAL/LL or direct register code.
*/

#ifndef APP_BASE
#define APP_BASE                (0x08008000u)
#endif

#ifndef FLASH_BASE_ADDR
#define FLASH_BASE_ADDR         (0x08000000u)
#endif

#ifndef FLASH_TOTAL_SIZE
#define FLASH_TOTAL_SIZE        (512u * 1024u)
#endif

#ifndef FLASH_PAGE_SIZE
#define FLASH_PAGE_SIZE         (2048u)
#endif

#ifndef APP_MAX_SIZE
#define APP_MAX_SIZE            (FLASH_TOTAL_SIZE - (APP_BASE - FLASH_BASE_ADDR))
#endif

#ifndef BOOT_MAGIC_ADDR
#define BOOT_MAGIC_ADDR         (0x20000000u)
#endif

#ifndef BOOT_MAGIC_VALUE
#define BOOT_MAGIC_VALUE        (0xB00710ADu)
#endif

#ifndef BOOT_PIN_ACTIVE_LEVEL
#define BOOT_PIN_ACTIVE_LEVEL   (1u)
#endif

#ifndef UART_BAUD
#define UART_BAUD               (115200u)
#endif

#ifndef UART_RX_TIMEOUT_MS
#define UART_RX_TIMEOUT_MS      (3000u)
#endif

#ifndef UART_BYTE_TIMEOUT_MS
#define UART_BYTE_TIMEOUT_MS    (1000u)
#endif

#ifndef SD_CHECK_TIMEOUT_MS
#define SD_CHECK_TIMEOUT_MS     (500u)
#endif

#ifndef FW_FILENAME
#define FW_FILENAME             "FW.BIN"
#endif

#ifndef XMODEM_MAX_IMAGE
#define XMODEM_MAX_IMAGE        (APP_MAX_SIZE)
#endif

#define MIN(a,b) ((a)<(b)?(a):(b))

/* Cortex-M core registers */
#define SCB_VTOR                (*(volatile uint32_t*)0xE000ED08u)
#define SCB_AIRCR               (*(volatile uint32_t*)0xE000ED0Cu)
#define SCB_AIRCR_VECTKEY       (0x5FAu << 16)
#define SCB_AIRCR_SYSRESETREQ   (1u << 2)

static inline void __disable_irq(void) { __asm volatile ("cpsid i" : : : "memory"); }
static inline void __enable_irq(void)  { __asm volatile ("cpsie i" : : : "memory"); }
static inline void __set_MSP(uint32_t topOfMainStack) { __asm volatile ("msr msp, %0" : : "r" (topOfMainStack) : ); }
static inline void __DSB(void) { __asm volatile ("dsb 0xF":::"memory"); }
static inline void __ISB(void) { __asm volatile ("isb 0xF":::"memory"); }

/* ========================= HAL (to be implemented per target) ========================= */

__attribute__((weak)) void HAL_InitClocks(void) {}
__attribute__((weak)) void HAL_InitGPIO(void) {}
__attribute__((weak)) void HAL_InitUART(uint32_t baud) { (void)baud; }
__attribute__((weak)) void HAL_DeinitPeripherals(void) {}

__attribute__((weak)) uint32_t HAL_Millis(void) { static uint32_t t; return t++; }
__attribute__((weak)) void HAL_DelayMs(uint32_t ms) { uint32_t s=HAL_Millis(); while((HAL_Millis()-s)<ms){} }

__attribute__((weak)) int HAL_BootPinRead(void) { return 0; }

__attribute__((weak)) int HAL_UART_ReadByte(uint8_t *b, uint32_t timeout_ms) { (void)b; (void)timeout_ms; return -1; }
__attribute__((weak)) void HAL_UART_Write(const uint8_t *buf, size_t len) { (void)buf; (void)len; }

__attribute__((weak)) int HAL_SD_Init(void) { return -1; }
__attribute__((weak)) int HAL_SD_Open(const char *path) { (void)path; return -1; }
__attribute__((weak)) int HAL_SD_Read(uint8_t *buf, size_t len, size_t *out_read) { (void)buf; (void)len; if(out_read) *out_read=0; return -1; }
__attribute__((weak)) void HAL_SD_Close(void) {}

__attribute__((weak)) int HAL_Flash_Unlock(void) { return 0; }
__attribute__((weak)) int HAL_Flash_Lock(void) { return 0; }
__attribute__((weak)) int HAL_Flash_Erase(uint32_t addr, uint32_t len) { (void)addr; (void)len; return -1; }
__attribute__((weak)) int HAL_Flash_Program(uint32_t addr, const uint8_t *data, size_t len) { (void)addr; (void)data; (void)len; return -1; }
__attribute__((weak)) int HAL_Flash_Read(uint32_t addr, uint8_t *data, size_t len) { memcpy(data, (const void*)addr, len); return 0; }

/* ========================= Utilities ========================= */

static uint32_t crc32_update(uint32_t crc, const uint8_t *data, size_t len)
{
    crc = ~crc;
    for (size_t i = 0; i < len; i++) {
        crc ^= data[i];
        for (int b = 0; b < 8; b++) {
            uint32_t mask = -(crc & 1u);
            crc = (crc >> 1) ^ (0xEDB88320u & mask);
        }
    }
    return ~crc;
}

static int is_valid_app_vector(uint32_t app_base)
{
    uint32_t sp = *(volatile uint32_t*)(app_base + 0);
    uint32_t rv = *(volatile uint32_t*)(app_base + 4);

    if (sp < 0x20000000u || sp > 0x20000000u + 0x200000u) return 0;
    if (rv < app_base || rv >= (FLASH_BASE_ADDR + FLASH_TOTAL_SIZE)) return 0;
    if ((rv & 1u) == 0u) return 0;
    return 1;
}

static void system_reset(void)
{
    __disable_irq();
    SCB_AIRCR = SCB_AIRCR_VECTKEY | SCB_AIRCR_SYSRESETREQ;
    __DSB();
    while (1) {}
}

static void jump_to_app(uint32_t app_base)
{
    uint32_t app_sp = *(volatile uint32_t*)(app_base + 0);
    uint32_t app_rv = *(volatile uint32_t*)(app_base + 4);

    __disable_irq();
    HAL_DeinitPeripherals();

    SCB_VTOR = app_base;
    __DSB();
    __ISB();

    __set_MSP(app_sp);
    __DSB();
    __ISB();

    void (*app_reset)(void) = (void (*)(void))(app_rv);
    app_reset();
    while (1) {}
}

static int flash_write_stream(uint32_t dst_addr, uint32_t max_len,
                              int (*read_cb)(uint8_t *buf, size_t req, size_t *out_got, void *ctx),
                              void *ctx,
                              uint32_t *out_written,
                              uint32_t *out_crc32)
{
    uint8_t buf[1024];
    uint32_t written = 0;
    uint32_t crc = 0;

    if (HAL_Flash_Unlock() != 0) return -1;

    uint32_t erase_len = (max_len + FLASH_PAGE_SIZE - 1u) / FLASH_PAGE_SIZE * FLASH_PAGE_SIZE;
    if (HAL_Flash_Erase(dst_addr, erase_len) != 0) {
        HAL_Flash_Lock();
        return -2;
    }

    while (written < max_len) {
        size_t got = 0;
        if (read_cb(buf, sizeof(buf), &got, ctx) != 0) break;
        if (got == 0) break;

        if (written + (uint32_t)got > max_len) {
            got = (size_t)(max_len - written);
        }

        if (HAL_Flash_Program(dst_addr + written, buf, got) != 0) {
            HAL_Flash_Lock();
            return -3;
        }

        crc = crc32_update(crc, buf, got);
        written += (uint32_t)got;
    }

    HAL_Flash_Lock();

    if (out_written) *out_written = written;
    if (out_crc32) *out_crc32 = crc;

    if (written == 0) return -4;
    return 0;
}

/* ========================= SD update ========================= */

typedef struct {
    int opened;
} sd_ctx_t;

static int sd_read_cb(uint8_t *buf, size_t req, size_t *out_got, void *ctx)
{
    (void)ctx;
    size_t rd = 0;
    if (HAL_SD_Read(buf, req, &rd) != 0) return -1;
    if (out_got) *out_got = rd;
    return 0;
}

static int try_update_from_sd(uint32_t *out_size, uint32_t *out_crc)
{
    uint32_t start = HAL_Millis();
    while ((HAL_Millis() - start) < SD_CHECK_TIMEOUT_MS) {
        if (HAL_SD_Init() == 0) break;
        HAL_DelayMs(10);
    }
    if (HAL_SD_Init() != 0) return -1;

    if (HAL_SD_Open(FW_FILENAME) != 0) {
        HAL_SD_Close();
        return -2;
    }

    int rc = flash_write_stream(APP_BASE, APP_MAX_SIZE, sd_read_cb, NULL, out_size, out_crc);

    HAL_SD_Close();
    return rc;
}

/* ========================= UART XMODEM update ========================= */

#define SOH 0x01
#define STX 0x02
#define EOT 0x04
#define ACK 0x06
#define NAK 0x15
#define CAN 0x18
#define CCHR 0x43 /* 'C' */

static uint16_t crc16_xmodem(const uint8_t *data, size_t len)
{
    uint16_t crc = 0;
    for (size_t i = 0; i < len; i++) {
        crc ^= (uint16_t)data[i] << 8;
        for (int b = 0; b < 8; b++) {
            if (crc & 0x8000) crc = (uint16_t)((crc << 1) ^ 0x1021);
            else crc <<= 1;
        }
    }
    return crc;
}

typedef struct {
    uint32_t dst;
    uint32_t max;
    uint32_t written;
    uint32_t crc32;
} uart_xm_ctx_t;

static int uart_send_byte(uint8_t b)
{
    HAL_UART_Write(&b, 1);
    return 0;
}

static int uart_recv_byte(uint8_t *b, uint32_t timeout_ms)
{
    return HAL_UART_ReadByte(b, timeout_ms);
}

static int uart_xmodem_receive_and_flash(uint32_t *out_size, uint32_t *out_crc32)
{
    uart_xm_ctx_t ctx;
    ctx.dst = APP_BASE;
    ctx.max = XMODEM_MAX_IMAGE;
    ctx.written = 0;
    ctx.crc32 = 0;

    if (HAL_Flash_Unlock() != 0) return -1;

    uint32_t erase_len = (ctx.max + FLASH_PAGE_SIZE - 1u) / FLASH_PAGE_SIZE * FLASH_PAGE_SIZE;
    if (HAL_Flash_Erase(ctx.dst, erase_len) != 0) {
        HAL_Flash_Lock();
        return -2;
    }

    uint8_t pktno = 1;
    uint8_t hdr = 0;
    uint8_t buf[1024];
    uint32_t start = HAL_Millis();

    while ((HAL_Millis() - start) < UART_RX_TIMEOUT_MS) {
        uart_send_byte(CCHR);
        uint8_t b;
        if (uart_recv_byte(&b, 200) == 0) { hdr = b; break; }
    }

    if (hdr == 0) {
        HAL_Flash_Lock();
        return -3;
    }

    for (;;) {
        if (hdr == EOT) {
            uart_send_byte(ACK);
            break;
        }
        if (hdr == CAN) {
            HAL_Flash_Lock();
            return -4;
        }

        size_t blen = 0;
        if (hdr == SOH) blen = 128;
        else if (hdr == STX) blen = 1024;
        else {
            uint8_t b;
            if (uart_recv_byte(&b, UART_BYTE_TIMEOUT_MS) != 0) {
                HAL_Flash_Lock();
                return -5;
            }
            hdr = b;
            continue;
        }

        uint8_t pno, pnoc;
        if (uart_recv_byte(&pno, UART_BYTE_TIMEOUT_MS) != 0 ||
            uart_recv_byte(&pnoc, UART_BYTE_TIMEOUT_MS) != 0) {
            uart_send_byte(NAK);
            goto next_hdr;
        }

        if ((uint8_t)(pno + pnoc) != 0xFFu) {
            uart_send_byte(NAK);
            goto next_hdr;
        }

        for (size_t i = 0; i < blen; i++) {
            if (uart_recv_byte(&buf[i], UART_BYTE_TIMEOUT_MS) != 0) {
                uart_send_byte(NAK);
                goto next_hdr;
            }
        }

        uint8_t c1, c2;
        if (uart_recv_byte(&c1, UART_BYTE_TIMEOUT_MS) != 0 ||
            uart_recv_byte(&c2, UART_BYTE_TIMEOUT_MS) != 0) {
            uart_send_byte(NAK);
            goto next_hdr;
        }
        uint16_t rxcrc = (uint16_t)((uint16_t)c1 << 8) | c2;
        uint16_t calccrc = crc16_xmodem(buf, blen);
        if (rxcrc != calccrc) {
            uart_send_byte(NAK);
            goto next_hdr;
        }

        if (pno == pktno) {
            if (ctx.written + (uint32_t)blen > ctx.max) {
                uart_send_byte(CAN);
                uart_send_byte(CAN);
                HAL_Flash_Lock();
                return -6;
            }

            if (HAL_Flash_Program(ctx.dst + ctx.written, buf, blen) != 0) {
                uart_send_byte(CAN);
                uart_send_byte(CAN);
                HAL_Flash_Lock();
                return -7;
            }

            ctx.crc32 = crc32_update(ctx.crc32, buf, blen);
            ctx.written += (uint32_t)blen;
            pktno++;
            uart_send_byte(ACK);
        } else if (pno == (uint8_t)(pktno - 1u)) {
            uart_send_byte(ACK);
        } else {
            uart_send_byte(NAK);
        }

    next_hdr:
        if (uart_recv_byte(&hdr, UART_BYTE_TIMEOUT_MS) != 0) {
            HAL_Flash_Lock();
            return -8;
        }
    }

    HAL_Flash_Lock();

    if (out_size) *out_size = ctx.written;
    if (out_crc32) *out_crc32 = ctx.crc32;
    return 0;
}

/* ========================= Boot decision ========================= */

static int recovery_requested(void)
{
    volatile uint32_t *m = (volatile uint32_t*)BOOT_MAGIC_ADDR;
    if (*m == BOOT_MAGIC_VALUE) {
        *m = 0;
        return 1;
    }
    return 0;
}

static int should_enter_bootloader(void)
{
    if (HAL_BootPinRead() == (int)BOOT_PIN_ACTIVE_LEVEL) return 1;
    if (recovery_requested()) return 1;
    if (!is_valid_app_vector(APP_BASE)) return 1;
    return 0;
}

/* ========================= Main ========================= */

static void status_print(const char *s)
{
    HAL_UART_Write((const uint8_t*)s, strlen(s));
}

int main(void)
{
    HAL_InitClocks();
    HAL_InitGPIO();
    HAL_InitUART(UART_BAUD);

    if (!should_enter_bootloader()) {
        jump_to_app(APP_BASE);
    }

    status_print("BL: enter\r\n");

    uint32_t sz = 0, crc = 0;

    int sd_rc = try_update_from_sd(&sz, &crc);
    if (sd_rc == 0) {
        status_print("BL: SD ok\r\n");
        if (is_valid_app_vector(APP_BASE)) {
            jump_to_app(APP_BASE);
        } else {
            status_print("BL: SD invalid app\r\n");
        }
    } else {
        status_print("BL: SD none\r\n");
    }

    status_print("BL: UART xmodem\r\n");
    int uart_rc = uart_xmodem_receive_and_flash(&sz, &crc);
    if (uart_rc == 0) {
        status_print("BL: UART ok\r\n");
        if (is_valid_app_vector(APP_BASE)) {
            jump_to_app(APP_BASE);
        } else {
            status_print("BL: UART invalid app\r\n");
        }
    } else {
        status_print("BL: UART fail\r\n");
    }

    if (is_valid_app_vector(APP_BASE)) {
        jump_to_app(APP_BASE);
    }

    status_print("BL: reset\r\n");
    HAL_DelayMs(100);
    system_reset();
    while (1) {}
}