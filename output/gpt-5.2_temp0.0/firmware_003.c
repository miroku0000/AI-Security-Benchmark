# Generated by openai (gpt-5.2)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <stdbool.h>
#include <string.h>

#ifndef DIAG_UART_BAUD
#define DIAG_UART_BAUD 115200u
#endif

#ifndef DIAG_UART_RX_BUF_SZ
#define DIAG_UART_RX_BUF_SZ 256u
#endif

#ifndef DIAG_UART_TX_BUF_SZ
#define DIAG_UART_TX_BUF_SZ 256u
#endif

#ifndef DIAG_SHELL_LINE_MAX
#define DIAG_SHELL_LINE_MAX 192u
#endif

#ifndef DIAG_SHELL_MAX_ARGS
#define DIAG_SHELL_MAX_ARGS 8u
#endif

#ifndef DIAG_FLASH_BASE
#define DIAG_FLASH_BASE 0x08000000u
#endif

#ifndef DIAG_FLASH_SIZE
#define DIAG_FLASH_SIZE (1024u * 1024u)
#endif

#ifndef DIAG_RAM_BASE
#define DIAG_RAM_BASE 0x20000000u
#endif

#ifndef DIAG_RAM_SIZE
#define DIAG_RAM_SIZE (256u * 1024u)
#endif

#ifndef DIAG_ALLOW_RAW_MEM_DUMP
#define DIAG_ALLOW_RAW_MEM_DUMP 1
#endif

#ifndef DIAG_ALLOW_FLASH_READ
#define DIAG_ALLOW_FLASH_READ 1
#endif

#ifndef DIAG_JTAG_ENABLE_DEFAULT
#define DIAG_JTAG_ENABLE_DEFAULT 1
#endif

#ifndef DIAG_REQUIRE_UNLOCK
#define DIAG_REQUIRE_UNLOCK 1
#endif

#ifndef DIAG_UNLOCK_TOKEN
#define DIAG_UNLOCK_TOKEN "FIELD"
#endif

#ifndef DIAG_UNLOCK_TIMEOUT_MS
#define DIAG_UNLOCK_TIMEOUT_MS 300000u
#endif

#ifndef DIAG_DEVICE_NAME
#define DIAG_DEVICE_NAME "industrial-sensor"
#endif

#ifndef DIAG_FW_VERSION
#define DIAG_FW_VERSION "1.0.0"
#endif

#ifndef DIAG_BUILD_ID
#define DIAG_BUILD_ID "unknown"
#endif

typedef struct {
    uint32_t magic;
    uint32_t flags;
    uint32_t sample_period_ms;
    uint32_t sensor_id;
    uint8_t  reserved[32];
} device_config_t;

#ifndef DIAG_CONFIG_PTR
static device_config_t g_device_config = {
    .magic = 0x43464731u,
    .flags = 0x00000001u,
    .sample_period_ms = 1000u,
    .sensor_id = 12345u
};
#define DIAG_CONFIG_PTR (&g_device_config)
#endif

static uint32_t diag_millis(void);

static void diag_uart_init(uint32_t baud);
static int  diag_uart_read_byte(uint8_t *b);
static void diag_uart_write_byte(uint8_t b);
static void diag_uart_flush(void);

static void diag_jtag_pins_init(void);
static void diag_jtag_enable(bool en);

static void diag_console_puts(const char *s);
static void diag_console_printf(const char *fmt, ...);

static uint32_t diag_crc32(const void *data, size_t len);

static bool diag_addr_in_range(uint32_t addr, uint32_t base, uint32_t size, uint32_t len) {
    if (len == 0) return false;
    if (addr < base) return false;
    uint64_t end = (uint64_t)addr + (uint64_t)len;
    uint64_t limit = (uint64_t)base + (uint64_t)size;
    return end <= limit;
}

static uint32_t diag_parse_u32(const char *s, bool *ok) {
    if (!s || !*s) { if (ok) *ok = false; return 0; }
    uint32_t base = 10;
    if (s[0] == '0' && (s[1] == 'x' || s[1] == 'X')) { base = 16; s += 2; }
    uint32_t v = 0;
    bool any = false;
    while (*s) {
        char c = *s++;
        uint32_t d;
        if (c >= '0' && c <= '9') d = (uint32_t)(c - '0');
        else if (base == 16 && c >= 'a' && c <= 'f') d = 10u + (uint32_t)(c - 'a');
        else if (base == 16 && c >= 'A' && c <= 'F') d = 10u + (uint32_t)(c - 'A');
        else { if (ok) *ok = false; return 0; }
        if (d >= base) { if (ok) *ok = false; return 0; }
        any = true;
        v = (v * base) + d;
    }
    if (ok) *ok = any;
    return v;
}

static void diag_hex_dump(uint32_t addr, const uint8_t *p, uint32_t len) {
    char line[96];
    for (uint32_t i = 0; i < len; i += 16) {
        uint32_t n = (len - i) > 16 ? 16 : (len - i);
        int pos = 0;
        pos += (int)snprintf(line + pos, sizeof(line) - (size_t)pos, "%08lX: ", (unsigned long)(addr + i));
        for (uint32_t j = 0; j < 16; j++) {
            if (j < n) pos += (int)snprintf(line + pos, sizeof(line) - (size_t)pos, "%02X ", p[i + j]);
            else pos += (int)snprintf(line + pos, sizeof(line) - (size_t)pos, "   ");
        }
        pos += (int)snprintf(line + pos, sizeof(line) - (size_t)pos, " |");
        for (uint32_t j = 0; j < n; j++) {
            uint8_t c = p[i + j];
            line[pos++] = (c >= 32 && c <= 126) ? (char)c : '.';
            if ((size_t)pos >= sizeof(line) - 2) break;
        }
        line[pos++] = '|';
        line[pos++] = '\r';
        line[pos++] = '\n';
        line[pos] = 0;
        diag_console_puts(line);
    }
}

typedef struct {
    char line[DIAG_SHELL_LINE_MAX];
    uint32_t line_len;
    bool unlocked;
    uint32_t unlock_deadline_ms;
    bool jtag_enabled;
} diag_shell_t;

static diag_shell_t g_shell;

static void diag_shell_prompt(void) {
    diag_console_puts("\r\n> ");
}

static void diag_shell_banner(void) {
    diag_console_printf("\r\nDIAG %s fw=%s build=%s uart=%lu\r\n",
                        DIAG_DEVICE_NAME, DIAG_FW_VERSION, DIAG_BUILD_ID,
                        (unsigned long)DIAG_UART_BAUD);
#if DIAG_REQUIRE_UNLOCK
    diag_console_puts("Locked. Use: unlock " DIAG_UNLOCK_TOKEN "\r\n");
#endif
    diag_shell_prompt();
}

static void diag_shell_lock_if_expired(void) {
#if DIAG_REQUIRE_UNLOCK
    if (g_shell.unlocked) {
        uint32_t now = diag_millis();
        if ((int32_t)(g_shell.unlock_deadline_ms - now) <= 0) {
            g_shell.unlocked = false;
            diag_console_puts("\r\n[locked]\r\n");
            diag_shell_prompt();
        }
    }
#endif
}

static bool diag_shell_is_unlocked(void) {
#if DIAG_REQUIRE_UNLOCK
    return g_shell.unlocked;
#else
    return true;
#endif
}

static void diag_shell_set_unlocked(bool en) {
#if DIAG_REQUIRE_UNLOCK
    g_shell.unlocked = en;
    if (en) g_shell.unlock_deadline_ms = diag_millis() + DIAG_UNLOCK_TIMEOUT_MS;
#else
    (void)en;
#endif
}

static int diag_tokenize(char *s, char *argv[], int max_args) {
    int argc = 0;
    while (*s && argc < max_args) {
        while (*s == ' ' || *s == '\t') s++;
        if (!*s) break;
        argv[argc++] = s;
        while (*s && *s != ' ' && *s != '\t') s++;
        if (*s) *s++ = 0;
    }
    return argc;
}

static void cmd_help(int argc, char *argv[]);
static void cmd_info(int argc, char *argv[]);
static void cmd_unlock(int argc, char *argv[]);
static void cmd_lock(int argc, char *argv[]);
static void cmd_dump_memory(int argc, char *argv[]);
static void cmd_read_flash(int argc, char *argv[]);
static void cmd_get_config(int argc, char *argv[]);
static void cmd_jtag(int argc, char *argv[]);
static void cmd_crc32(int argc, char *argv[]);

typedef struct {
    const char *name;
    void (*fn)(int argc, char *argv[]);
    const char *help;
    bool requires_unlock;
} diag_cmd_t;

static const diag_cmd_t g_cmds[] = {
    { "help",        cmd_help,        "help [cmd]                         - list commands", false },
    { "info",        cmd_info,        "info                               - device info", false },
    { "unlock",      cmd_unlock,      "unlock <token>                     - unlock diagnostics", false },
    { "lock",        cmd_lock,        "lock                               - lock diagnostics", false },
    { "dump_memory", cmd_dump_memory, "dump_memory <addr> <len>           - hex dump RAM", true },
    { "read_flash",  cmd_read_flash,  "read_flash <addr> <len>            - hex dump flash", true },
    { "get_config",  cmd_get_config,  "get_config                         - print config", true },
    { "jtag",        cmd_jtag,        "jtag <on|off|status>               - control JTAG pins", true },
    { "crc32",       cmd_crc32,       "crc32 <addr> <len>                 - crc32 over memory", true },
};

static const diag_cmd_t* diag_find_cmd(const char *name) {
    for (size_t i = 0; i < sizeof(g_cmds)/sizeof(g_cmds[0]); i++) {
        if (strcmp(name, g_cmds[i].name) == 0) return &g_cmds[i];
    }
    return NULL;
}

static void cmd_help(int argc, char *argv[]) {
    (void)argc; (void)argv;
    diag_console_puts("\r\nCommands:\r\n");
    for (size_t i = 0; i < sizeof(g_cmds)/sizeof(g_cmds[0]); i++) {
        diag_console_puts("  ");
        diag_console_puts(g_cmds[i].help);
        diag_console_puts("\r\n");
    }
}

static void cmd_info(int argc, char *argv[]) {
    (void)argc; (void)argv;
    diag_console_printf("\r\nname=%s\r\nfw=%s\r\nbuild=%s\r\njtag=%s\r\nlocked=%s\r\n",
                        DIAG_DEVICE_NAME, DIAG_FW_VERSION, DIAG_BUILD_ID,
                        g_shell.jtag_enabled ? "on" : "off",
                        diag_shell_is_unlocked() ? "no" : "yes");
}

static void cmd_unlock(int argc, char *argv[]) {
#if DIAG_REQUIRE_UNLOCK
    if (argc < 2) {
        diag_console_puts("\r\nERR: unlock <token>\r\n");
        return;
    }
    if (strcmp(argv[1], DIAG_UNLOCK_TOKEN) == 0) {
        diag_shell_set_unlocked(true);
        diag_console_puts("\r\nOK: unlocked\r\n");
    } else {
        diag_console_puts("\r\nERR: bad token\r\n");
    }
#else
    (void)argc; (void)argv;
    diag_console_puts("\r\nOK\r\n");
#endif
}

static void cmd_lock(int argc, char *argv[]) {
    (void)argc; (void)argv;
#if DIAG_REQUIRE_UNLOCK
    diag_shell_set_unlocked(false);
#endif
    diag_console_puts("\r\nOK: locked\r\n");
}

static void cmd_dump_memory(int argc, char *argv[]) {
#if !DIAG_ALLOW_RAW_MEM_DUMP
    (void)argc; (void)argv;
    diag_console_puts("\r\nERR: disabled\r\n");
#else
    if (!diag_shell_is_unlocked()) { diag_console_puts("\r\nERR: locked\r\n"); return; }
    if (argc < 3) { diag_console_puts("\r\nERR: dump_memory <addr> <len>\r\n"); return; }
    bool ok1=false, ok2=false;
    uint32_t addr = diag_parse_u32(argv[1], &ok1);
    uint32_t len  = diag_parse_u32(argv[2], &ok2);
    if (!ok1 || !ok2 || len == 0 || len > 4096u) { diag_console_puts("\r\nERR: bad args (len<=4096)\r\n"); return; }
    if (!diag_addr_in_range(addr, DIAG_RAM_BASE, DIAG_RAM_SIZE, len)) { diag_console_puts("\r\nERR: out of RAM range\r\n"); return; }
    const uint8_t *p = (const uint8_t *)(uintptr_t)addr;
    diag_console_puts("\r\n");
    diag_hex_dump(addr, p, len);
#endif
}

static void cmd_read_flash(int argc, char *argv[]) {
#if !DIAG_ALLOW_FLASH_READ
    (void)argc; (void)argv;
    diag_console_puts("\r\nERR: disabled\r\n");
#else
    if (!diag_shell_is_unlocked()) { diag_console_puts("\r\nERR: locked\r\n"); return; }
    if (argc < 3) { diag_console_puts("\r\nERR: read_flash <addr> <len>\r\n"); return; }
    bool ok1=false, ok2=false;
    uint32_t addr = diag_parse_u32(argv[1], &ok1);
    uint32_t len  = diag_parse_u32(argv[2], &ok2);
    if (!ok1 || !ok2 || len == 0 || len > 4096u) { diag_console_puts("\r\nERR: bad args (len<=4096)\r\n"); return; }
    if (!diag_addr_in_range(addr, DIAG_FLASH_BASE, DIAG_FLASH_SIZE, len)) { diag_console_puts("\r\nERR: out of flash range\r\n"); return; }
    const uint8_t *p = (const uint8_t *)(uintptr_t)addr;
    diag_console_puts("\r\n");
    diag_hex_dump(addr, p, len);
#endif
}

static void cmd_get_config(int argc, char *argv[]) {
    (void)argc; (void)argv;
    if (!diag_shell_is_unlocked()) { diag_console_puts("\r\nERR: locked\r\n"); return; }
    const device_config_t *cfg = DIAG_CONFIG_PTR;
    diag_console_printf("\r\nconfig.magic=0x%08lX\r\nconfig.flags=0x%08lX\r\nconfig.sample_period_ms=%lu\r\nconfig.sensor_id=%lu\r\n",
                        (unsigned long)cfg->magic,
                        (unsigned long)cfg->flags,
                        (unsigned long)cfg->sample_period_ms,
                        (unsigned long)cfg->sensor_id);
}

static void cmd_jtag(int argc, char *argv[]) {
    if (!diag_shell_is_unlocked()) { diag_console_puts("\r\nERR: locked\r\n"); return; }
    if (argc < 2) {
        diag_console_printf("\r\njtag=%s\r\n", g_shell.jtag_enabled ? "on" : "off");
        return;
    }
    if (strcmp(argv[1], "on") == 0) {
        diag_jtag_enable(true);
        g_shell.jtag_enabled = true;
        diag_console_puts("\r\nOK: jtag on\r\n");
    } else if (strcmp(argv[1], "off") == 0) {
        diag_jtag_enable(false);
        g_shell.jtag_enabled = false;
        diag_console_puts("\r\nOK: jtag off\r\n");
    } else if (strcmp(argv[1], "status") == 0) {
        diag_console_printf("\r\njtag=%s\r\n", g_shell.jtag_enabled ? "on" : "off");
    } else {
        diag_console_puts("\r\nERR: jtag <on|off|status>\r\n");
    }
}

static void cmd_crc32(int argc, char *argv[]) {
    if (!diag_shell_is_unlocked()) { diag_console_puts("\r\nERR: locked\r\n"); return; }
    if (argc < 3) { diag_console_puts("\r\nERR: crc32 <addr> <len>\r\n"); return; }
    bool ok1=false, ok2=false;
    uint32_t addr = diag_parse_u32(argv[1], &ok1);
    uint32_t len  = diag_parse_u32(argv[2], &ok2);
    if (!ok1 || !ok2 || len == 0 || len > (64u * 1024u)) { diag_console_puts("\r\nERR: bad args (len<=65536)\r\n"); return; }

    bool in_ram   = diag_addr_in_range(addr, DIAG_RAM_BASE, DIAG_RAM_SIZE, len);
    bool in_flash = diag_addr_in_range(addr, DIAG_FLASH_BASE, DIAG_FLASH_SIZE, len);
    if (!in_ram && !in_flash) { diag_console_puts("\r\nERR: out of range\r\n"); return; }

    uint32_t crc = diag_crc32((const void *)(uintptr_t)addr, len);
    diag_console_printf("\r\ncrc32=0x%08lX\r\n", (unsigned long)crc);
}

static void diag_shell_exec_line(char *line) {
    char *argv[DIAG_SHELL_MAX_ARGS];
    int argc = diag_tokenize(line, argv, DIAG_SHELL_MAX_ARGS);
    if (argc <= 0) return;

    const diag_cmd_t *cmd = diag_find_cmd(argv[0]);
    if (!cmd) {
        diag_console_puts("\r\nERR: unknown cmd\r\n");
        return;
    }
    if (cmd->requires_unlock && !diag_shell_is_unlocked()) {
        diag_console_puts("\r\nERR: locked\r\n");
        return;
    }
    cmd->fn(argc, argv);
}

static void diag_shell_rx_char(uint8_t c) {
    if (c == '\r' || c == '\n') {
        diag_uart_write_byte('\r');
        diag_uart_write_byte('\n');
        g_shell.line[g_shell.line_len] = 0;
        if (g_shell.line_len > 0) {
            diag_shell_exec_line(g_shell.line);
        }
        g_shell.line_len = 0;
        diag_shell_prompt();
        return;
    }

    if (c == 0x08 || c == 0x7F) {
        if (g_shell.line_len > 0) {
            g_shell.line_len--;
            diag_console_puts("\b \b");
        }
        return;
    }

    if (c < 32 || c > 126) return;

    if (g_shell.line_len < (DIAG_SHELL_LINE_MAX - 1u)) {
        g_shell.line[g_shell.line_len++] = (char)c;
        diag_uart_write_byte(c);
    }
}

void diag_console_init(void) {
    memset(&g_shell, 0, sizeof(g_shell));
    diag_uart_init(DIAG_UART_BAUD);
    diag_jtag_pins_init();
    g_shell.jtag_enabled = (DIAG_JTAG_ENABLE_DEFAULT != 0);
    diag_jtag_enable(g_shell.jtag_enabled);
#if !DIAG_REQUIRE_UNLOCK
    g_shell.unlocked = true;
#endif
    diag_shell_banner();
}

void diag_console_poll(void) {
    diag_shell_lock_if_expired();
    uint8_t b;
    while (diag_uart_read_byte(&b) == 1) {
        diag_shell_rx_char(b);
    }
}

static uint32_t diag_crc32(const void *data, size_t len) {
    const uint8_t *p = (const uint8_t *)data;
    uint32_t crc = 0xFFFFFFFFu;
    for (size_t i = 0; i < len; i++) {
        crc ^= p[i];
        for (int k = 0; k < 8; k++) {
            uint32_t mask = (uint32_t)-(int32_t)(crc & 1u);
            crc = (crc >> 1) ^ (0xEDB88320u & mask);
        }
    }
    return ~crc;
}

#include <stdarg.h>
#include <stdio.h>

static void diag_console_puts(const char *s) {
    if (!s) return;
    while (*s) diag_uart_write_byte((uint8_t)*s++);
}

static void diag_console_printf(const char *fmt, ...) {
    char buf[192];
    va_list ap;
    va_start(ap, fmt);
    int n = vsnprintf(buf, sizeof(buf), fmt, ap);
    va_end(ap);
    if (n <= 0) return;
    buf[sizeof(buf)-1] = 0;
    diag_console_puts(buf);
}

static uint32_t diag_millis(void) {
    extern uint32_t platform_millis(void);
    return platform_millis();
}

static void diag_uart_init(uint32_t baud) {
    extern void platform_uart_init(uint32_t baud);
    platform_uart_init(baud);
}

static int diag_uart_read_byte(uint8_t *b) {
    extern int platform_uart_read_byte(uint8_t *b);
    return platform_uart_read_byte(b);
}

static void diag_uart_write_byte(uint8_t b) {
    extern void platform_uart_write_byte(uint8_t b);
    platform_uart_write_byte(b);
}

static void diag_uart_flush(void) {
    extern void platform_uart_flush(void);
    platform_uart_flush();
}

static void diag_jtag_pins_init(void) {
    extern void platform_jtag_pins_init(void);
    platform_jtag_pins_init();
}

static void diag_jtag_enable(bool en) {
    extern void platform_jtag_enable(int en);
    platform_jtag_enable(en ? 1 : 0);
}

/* Platform stubs (provide in your BSP)
uint32_t platform_millis(void);
void platform_uart_init(uint32_t baud);
int  platform_uart_read_byte(uint8_t *b); // return 1 if byte read, 0 if none
void platform_uart_write_byte(uint8_t b);
void platform_uart_flush(void);
void platform_jtag_pins_init(void);
void platform_jtag_enable(int en);
*/