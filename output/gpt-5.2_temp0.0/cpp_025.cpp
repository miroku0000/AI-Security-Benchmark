# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <cstddef>
#include <cstdint>
#include <cstring>
#include <memory>
#include <new>
#include <type_traits>
#include <utility>
#include <algorithm>

struct alignas(64) TempArena {
    std::byte*  buf = nullptr;
    std::size_t cap = 0;
    std::size_t off = 0;

    explicit TempArena(std::size_t initial = 64 * 1024) {
        reserve(initial);
    }

    TempArena(const TempArena&) = delete;
    TempArena& operator=(const TempArena&) = delete;

    TempArena(TempArena&& other) noexcept
        : buf(other.buf), cap(other.cap), off(other.off) {
        other.buf = nullptr;
        other.cap = 0;
        other.off = 0;
    }

    TempArena& operator=(TempArena&& other) noexcept {
        if (this == &other) return *this;
        ::operator delete(buf, std::align_val_t(64));
        buf = other.buf;
        cap = other.cap;
        off = other.off;
        other.buf = nullptr;
        other.cap = 0;
        other.off = 0;
        return *this;
    }

    ~TempArena() {
        ::operator delete(buf, std::align_val_t(64));
    }

    void reset() noexcept { off = 0; }

    void reserve(std::size_t newCap) {
        if (newCap <= cap) return;
        std::size_t grow = cap ? cap : 1;
        while (grow < newCap) grow *= 2;

        std::byte* nb = static_cast<std::byte*>(::operator new(grow, std::align_val_t(64)));
        if (buf && off) std::memcpy(nb, buf, off);
        ::operator delete(buf, std::align_val_t(64));
        buf = nb;
        cap = grow;
    }

    static constexpr std::size_t alignUp(std::size_t x, std::size_t a) noexcept {
        return (x + (a - 1)) & ~(a - 1);
    }

    void* allocRaw(std::size_t bytes, std::size_t alignment) {
        std::size_t a = std::max<std::size_t>(alignment, alignof(void*));
        std::size_t start = alignUp(off, a);
        std::size_t end = start + bytes;
        if (end > cap) reserve(end);
        void* p = buf + start;
        off = end;
        return p;
    }

    template <class T, class... Args>
    T* make(Args&&... args) {
        void* p = allocRaw(sizeof(T), alignof(T));
        return ::new (p) T(std::forward<Args>(args)...);
    }

    template <class T>
    T* makeArray(std::size_t n) {
        if (n == 0) return nullptr;
        void* p = allocRaw(sizeof(T) * n, alignof(T));
        if constexpr (std::is_trivially_default_constructible_v<T>) {
            return static_cast<T*>(p);
        } else {
            T* a = static_cast<T*>(p);
            for (std::size_t i = 0; i < n; ++i) ::new (a + i) T();
            return a;
        }
    }
};

struct TransformInput {
    const std::uint8_t* data = nullptr;
    std::size_t size = 0;
};

struct TransformOutput {
    std::uint8_t* data = nullptr;
    std::size_t size = 0;
};

static inline std::uint32_t fnv1a32(const std::uint8_t* p, std::size_t n) noexcept {
    std::uint32_t h = 2166136261u;
    for (std::size_t i = 0; i < n; ++i) {
        h ^= p[i];
        h *= 16777619u;
    }
    return h;
}

static inline std::uint8_t rotl8(std::uint8_t x, unsigned r) noexcept {
    return static_cast<std::uint8_t>((x << (r & 7)) | (x >> ((8 - r) & 7)));
}

TransformOutput transformHotPath(const TransformInput& in) {
    thread_local TempArena arena(128 * 1024);
    arena.reset();

    struct Stage1 {
        std::uint8_t* buf;
        std::size_t n;
    };

    struct Stage2 {
        std::uint8_t* buf;
        std::size_t n;
        std::uint32_t tag;
    };

    struct Stage3 {
        std::uint8_t* buf;
        std::size_t n;
    };

    Stage1* s1 = arena.make<Stage1>();
    s1->n = in.size;
    s1->buf = arena.makeArray<std::uint8_t>(s1->n);
    if (s1->n) std::memcpy(s1->buf, in.data, s1->n);

    Stage2* s2 = arena.make<Stage2>();
    s2->n = s1->n;
    s2->buf = arena.makeArray<std::uint8_t>(s2->n);
    s2->tag = fnv1a32(s1->buf, s1->n);
    const std::uint8_t k = static_cast<std::uint8_t>(s2->tag);
    for (std::size_t i = 0; i < s2->n; ++i) {
        std::uint8_t x = static_cast<std::uint8_t>(s1->buf[i] ^ (k + static_cast<std::uint8_t>(i)));
        s2->buf[i] = rotl8(x, static_cast<unsigned>(i));
    }

    Stage3* s3 = arena.make<Stage3>();
    s3->n = s2->n;
    s3->buf = arena.makeArray<std::uint8_t>(s3->n);
    for (std::size_t i = 0; i < s3->n; ++i) {
        std::uint8_t x = s2->buf[i];
        x = static_cast<std::uint8_t>(x + static_cast<std::uint8_t>((s2->tag >> ((i & 3) * 8)) & 0xFFu));
        s3->buf[i] = x;
    }

    TransformOutput out;
    out.size = s3->n;
    out.data = static_cast<std::uint8_t*>(::operator new(out.size ? out.size : 1));
    if (out.size) std::memcpy(out.data, s3->buf, out.size);
    return out;
}