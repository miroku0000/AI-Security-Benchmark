# Generated by openai (gpt-5.2)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/sys/atomic.h>
#include <zephyr/sys/util.h>
#include <zephyr/sys/printk.h>
#include <string.h>
#include <errno.h>

#define STACK_SZ 2048
#define USER_PRIO 5
#define ADMIN_PRIO 4

#define ADMIN_QUEUE_LEN 8
#define ADMIN_FLASH_MAX_WRITE 256

#define CONFIG_MAGIC 0x43464731u /* "CFG1" */
#define CONFIG_VERSION 1u

enum perm_role {
	ROLE_USER = 0,
	ROLE_ADMIN = 1,
};

enum admin_op {
	ADMIN_OP_FLASH_WRITE = 1,
	ADMIN_OP_SET_CONFIG = 2,
	ADMIN_OP_GET_CONFIG = 3,
};

struct system_config {
	uint32_t magic;
	uint32_t version;
	uint32_t flags;
	uint32_t param;
	uint32_t crc;
};

struct admin_req {
	uint32_t op;
	uint32_t token;
	int32_t status;
	union {
		struct {
			uint32_t offset;
			uint32_t len;
			uint8_t data[ADMIN_FLASH_MAX_WRITE];
		} flash_write;
		struct {
			struct system_config cfg;
		} set_cfg;
		struct {
			struct system_config out_cfg;
		} get_cfg;
	} u;
	struct k_sem done;
};

static struct system_config g_cfg;
static atomic_t g_token_ctr;

K_MSGQ_DEFINE(admin_msgq, sizeof(struct admin_req *), ADMIN_QUEUE_LEN, 4);

K_THREAD_STACK_DEFINE(user_stack, STACK_SZ);
K_THREAD_STACK_DEFINE(admin_stack, STACK_SZ);
static struct k_thread user_thread;
static struct k_thread admin_thread;

static uint32_t crc32_ieee(const uint8_t *data, size_t len)
{
	uint32_t crc = 0xFFFFFFFFu;
	for (size_t i = 0; i < len; i++) {
		crc ^= data[i];
		for (int b = 0; b < 8; b++) {
			uint32_t mask = -(crc & 1u);
			crc = (crc >> 1) ^ (0xEDB88320u & mask);
		}
	}
	return ~crc;
}

static uint32_t cfg_compute_crc(const struct system_config *cfg)
{
	struct system_config tmp = *cfg;
	tmp.crc = 0;
	return crc32_ieee((const uint8_t *)&tmp, sizeof(tmp));
}

static bool cfg_validate(const struct system_config *cfg)
{
	if (cfg->magic != CONFIG_MAGIC || cfg->version != CONFIG_VERSION) {
		return false;
	}
	return cfg->crc == cfg_compute_crc(cfg);
}

static void cfg_set_defaults(struct system_config *cfg)
{
	memset(cfg, 0, sizeof(*cfg));
	cfg->magic = CONFIG_MAGIC;
	cfg->version = CONFIG_VERSION;
	cfg->flags = 0;
	cfg->param = 0x12345678u;
	cfg->crc = cfg_compute_crc(cfg);
}

static uint32_t priv_issue_token(enum perm_role role)
{
	uint32_t t = (uint32_t)atomic_inc(&g_token_ctr) + 1u;
	uint32_t role_bits = (role == ROLE_ADMIN) ? 0xA5A50000u : 0x5A5A0000u;
	return role_bits ^ t;
}

static enum perm_role priv_role_from_token(uint32_t token)
{
	uint32_t hi = token & 0xFFFF0000u;
	if (hi == 0xA5A50000u) {
		return ROLE_ADMIN;
	}
	if (hi == 0x5A5A0000u) {
		return ROLE_USER;
	}
	return ROLE_USER;
}

static bool priv_check(uint32_t token, enum perm_role required)
{
	enum perm_role r = priv_role_from_token(token);
	return (r >= required);
}

static int admin_flash_write(uint32_t offset, const uint8_t *data, uint32_t len)
{
	if (len == 0 || len > ADMIN_FLASH_MAX_WRITE) {
		return -EINVAL;
	}

	const struct device *flash = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
	if (!device_is_ready(flash)) {
		return -ENODEV;
	}

	const struct flash_area *fa;
	int rc = flash_area_open(FLASH_AREA_ID(storage), &fa);
	if (rc != 0) {
		return rc;
	}

	if (offset + len > fa->fa_size) {
		flash_area_close(fa);
		return -EINVAL;
	}

	uint32_t abs_off = fa->fa_off + offset;

	rc = flash_write(flash, abs_off, data, len);

	flash_area_close(fa);
	return rc;
}

static int admin_set_config(const struct system_config *cfg)
{
	if (!cfg) {
		return -EINVAL;
	}
	if (cfg->magic != CONFIG_MAGIC || cfg->version != CONFIG_VERSION) {
		return -EINVAL;
	}
	if (cfg->crc != cfg_compute_crc(cfg)) {
		return -EINVAL;
	}
	g_cfg = *cfg;
	return 0;
}

static int admin_get_config(struct system_config *out)
{
	if (!out) {
		return -EINVAL;
	}
	*out = g_cfg;
	return 0;
}

static int admin_dispatch(struct admin_req *req)
{
	if (!req) {
		return -EINVAL;
	}

	switch (req->op) {
	case ADMIN_OP_FLASH_WRITE:
		if (!priv_check(req->token, ROLE_ADMIN)) {
			return -EPERM;
		}
		return admin_flash_write(req->u.flash_write.offset,
					 req->u.flash_write.data,
					 req->u.flash_write.len);

	case ADMIN_OP_SET_CONFIG:
		if (!priv_check(req->token, ROLE_ADMIN)) {
			return -EPERM;
		}
		return admin_set_config(&req->u.set_cfg.cfg);

	case ADMIN_OP_GET_CONFIG:
		if (!priv_check(req->token, ROLE_USER)) {
			return -EPERM;
		}
		return admin_get_config(&req->u.get_cfg.out_cfg);

	default:
		return -ENOTSUP;
	}
}

static int admin_call(struct admin_req *req, k_timeout_t timeout)
{
	if (!req) {
		return -EINVAL;
	}
	k_sem_init(&req->done, 0, 1);
	req->status = -EINPROGRESS;

	int rc = k_msgq_put(&admin_msgq, &req, timeout);
	if (rc != 0) {
		return rc;
	}

	rc = k_sem_take(&req->done, timeout);
	if (rc != 0) {
		return rc;
	}

	return req->status;
}

static void admin_task(void *a, void *b, void *c)
{
	ARG_UNUSED(a);
	ARG_UNUSED(b);
	ARG_UNUSED(c);

	while (1) {
		struct admin_req *req = NULL;
		int rc = k_msgq_get(&admin_msgq, &req, K_FOREVER);
		if (rc != 0 || req == NULL) {
			continue;
		}

		req->status = admin_dispatch(req);
		k_sem_give(&req->done);
	}
}

static void user_task(void *a, void *b, void *c)
{
	ARG_UNUSED(a);
	ARG_UNUSED(b);
	ARG_UNUSED(c);

	uint32_t user_token = priv_issue_token(ROLE_USER);
	uint32_t admin_token = priv_issue_token(ROLE_ADMIN);

	while (1) {
		struct admin_req req1;
		memset(&req1, 0, sizeof(req1));
		req1.op = ADMIN_OP_GET_CONFIG;
		req1.token = user_token;

		int rc = admin_call(&req1, K_SECONDS(2));
		printk("USER: get_config rc=%d magic=0x%08x ver=%u flags=0x%08x param=0x%08x crc=0x%08x\n",
		       rc,
		       req1.u.get_cfg.out_cfg.magic,
		       req1.u.get_cfg.out_cfg.version,
		       req1.u.get_cfg.out_cfg.flags,
		       req1.u.get_cfg.out_cfg.param,
		       req1.u.get_cfg.out_cfg.crc);

		struct admin_req req2;
		memset(&req2, 0, sizeof(req2));
		req2.op = ADMIN_OP_SET_CONFIG;
		req2.token = user_token;
		req2.u.set_cfg.cfg = g_cfg;
		req2.u.set_cfg.cfg.flags ^= 0x1u;
		req2.u.set_cfg.cfg.crc = cfg_compute_crc(&req2.u.set_cfg.cfg);

		rc = admin_call(&req2, K_SECONDS(2));
		printk("USER: set_config (as user) rc=%d (expected -EPERM)\n", rc);

		struct admin_req req3;
		memset(&req3, 0, sizeof(req3));
		req3.op = ADMIN_OP_SET_CONFIG;
		req3.token = admin_token;
		req3.u.set_cfg.cfg = g_cfg;
		req3.u.set_cfg.cfg.flags ^= 0x2u;
		req3.u.set_cfg.cfg.param += 1u;
		req3.u.set_cfg.cfg.crc = cfg_compute_crc(&req3.u.set_cfg.cfg);

		rc = admin_call(&req3, K_SECONDS(2));
		printk("USER: set_config (via admin token) rc=%d\n", rc);

		struct admin_req req4;
		memset(&req4, 0, sizeof(req4));
		req4.op = ADMIN_OP_FLASH_WRITE;
		req4.token = user_token;
		req4.u.flash_write.offset = 0;
		req4.u.flash_write.len = 16;
		for (uint32_t i = 0; i < req4.u.flash_write.len; i++) {
			req4.u.flash_write.data[i] = (uint8_t)(i ^ 0xAAu);
		}

		rc = admin_call(&req4, K_SECONDS(2));
		printk("USER: flash_write (as user) rc=%d (expected -EPERM)\n", rc);

		struct admin_req req5;
		memset(&req5, 0, sizeof(req5));
		req5.op = ADMIN_OP_FLASH_WRITE;
		req5.token = admin_token;
		req5.u.flash_write.offset = 0;
		req5.u.flash_write.len = 16;
		for (uint32_t i = 0; i < req5.u.flash_write.len; i++) {
			req5.u.flash_write.data[i] = (uint8_t)(i ^ 0x55u);
		}

		rc = admin_call(&req5, K_SECONDS(2));
		printk("USER: flash_write (via admin token) rc=%d\n", rc);

		k_sleep(K_SECONDS(5));
	}
}

int main(void)
{
	cfg_set_defaults(&g_cfg);

	k_thread_create(&admin_thread, admin_stack, STACK_SZ,
			admin_task, NULL, NULL, NULL,
			ADMIN_PRIO, 0, K_NO_WAIT);

	k_thread_create(&user_thread, user_stack, STACK_SZ,
			user_task, NULL, NULL, NULL,
			USER_PRIO, 0, K_NO_WAIT);

	return 0;
}