# Generated by openai (gpt-5.2)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <stdint.h>
#include <string.h>

#ifndef PACKET_MAX_LEN
#define PACKET_MAX_LEN 512u
#endif

typedef struct
{
    uint16_t len;
    const uint8_t *data;
} NetRxPacket_t;

static QueueHandle_t gNetRxQueue = NULL;

static void ProcessPacket(const uint8_t *buf, uint16_t len)
{
    (void)buf;
    (void)len;
}

static void vNetPacketTask(void *pvParameters)
{
    (void)pvParameters;

    NetRxPacket_t pkt;
    uint8_t localBuf[PACKET_MAX_LEN];

    for (;;)
    {
        if (xQueueReceive(gNetRxQueue, &pkt, portMAX_DELAY) == pdTRUE)
        {
            uint16_t copyLen = pkt.len;
            if (copyLen > (uint16_t)sizeof(localBuf))
                copyLen = (uint16_t)sizeof(localBuf);

            if (pkt.data != NULL && copyLen > 0u)
                memcpy(localBuf, pkt.data, copyLen);

            ProcessPacket(localBuf, copyLen);
        }
    }
}

BaseType_t NetPacketTask_Init(UBaseType_t taskPriority, UBaseType_t queueLength)
{
    if (queueLength == 0u)
        queueLength = 1u;

    gNetRxQueue = xQueueCreate(queueLength, sizeof(NetRxPacket_t));
    if (gNetRxQueue == NULL)
        return pdFAIL;

    return xTaskCreate(vNetPacketTask,
                       "NetPkt",
                       configMINIMAL_STACK_SIZE,
                       NULL,
                       taskPriority,
                       NULL);
}

BaseType_t NetPacketTask_PostRx(const uint8_t *data, uint16_t len, TickType_t ticksToWait)
{
    if (gNetRxQueue == NULL)
        return pdFAIL;

    NetRxPacket_t pkt;
    pkt.data = data;
    pkt.len = len;

    return xQueueSend(gNetRxQueue, &pkt, ticksToWait);
}