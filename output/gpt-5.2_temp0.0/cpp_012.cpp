# Generated by openai (gpt-5.2)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <string>
#include <stdexcept>
#include <utility>
#include <cstdint>

#ifdef _WIN32
  #define NOMINMAX
  #include <winsock2.h>
  #include <ws2tcpip.h>
  #pragma comment(lib, "Ws2_32.lib")
#else
  #include <sys/types.h>
  #include <sys/socket.h>
  #include <netdb.h>
  #include <unistd.h>
  #include <errno.h>
#endif

class NetworkConnectionManager {
public:
    NetworkConnectionManager(const std::string& host, uint16_t port)
        : host_(host), port_(port) {
        initPlatform_();
        try {
            connect_();
        } catch (...) {
            cleanup_();
            throw;
        }
    }

    ~NetworkConnectionManager() noexcept {
        cleanup_();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept {
        moveFrom_(std::move(other));
    }

    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanup_();
            moveFrom_(std::move(other));
        }
        return *this;
    }

    bool isConnected() const noexcept {
        return sock_ != invalidSocket_();
    }

    void reset() {
        closeSocket_();
    }

    void reinitialize(const std::string& host, uint16_t port) {
        host_ = host;
        port_ = port;
        reinitialize();
    }

    void reinitialize() {
        closeSocket_();
        try {
            connect_();
        } catch (...) {
            closeSocket_();
            throw;
        }
    }

    void sendAll(const void* data, size_t size) {
        if (!isConnected()) throw std::runtime_error("Not connected");
        const char* p = static_cast<const char*>(data);
        size_t remaining = size;
        while (remaining > 0) {
#ifdef _WIN32
            int sent = ::send(sock_, p, static_cast<int>(remaining), 0);
#else
            ssize_t sent = ::send(sock_, p, remaining, 0);
#endif
            if (sent <= 0) throw std::runtime_error("send failed");
            p += static_cast<size_t>(sent);
            remaining -= static_cast<size_t>(sent);
        }
    }

    size_t recvSome(void* buffer, size_t capacity) {
        if (!isConnected()) throw std::runtime_error("Not connected");
#ifdef _WIN32
        int r = ::recv(sock_, static_cast<char*>(buffer), static_cast<int>(capacity), 0);
        if (r < 0) throw std::runtime_error("recv failed");
        return static_cast<size_t>(r);
#else
        ssize_t r = ::recv(sock_, buffer, capacity, 0);
        if (r < 0) throw std::runtime_error("recv failed");
        return static_cast<size_t>(r);
#endif
    }

    const std::string& host() const noexcept { return host_; }
    uint16_t port() const noexcept { return port_; }

private:
#ifdef _WIN32
    using Socket = SOCKET;
#else
    using Socket = int;
#endif

    static Socket invalidSocket_() noexcept {
#ifdef _WIN32
        return INVALID_SOCKET;
#else
        return -1;
#endif
    }

    void initPlatform_() {
#ifdef _WIN32
        if (!wsaInitialized_) {
            WSADATA wsa{};
            int rc = ::WSAStartup(MAKEWORD(2, 2), &wsa);
            if (rc != 0) throw std::runtime_error("WSAStartup failed");
            wsaInitialized_ = true;
        }
#endif
    }

    void connect_() {
        addrinfo hints{};
        hints.ai_family = AF_UNSPEC;
        hints.ai_socktype = SOCK_STREAM;
        hints.ai_protocol = IPPROTO_TCP;

        addrinfo* res = nullptr;
        const std::string portStr = std::to_string(port_);
        int gai = ::getaddrinfo(host_.c_str(), portStr.c_str(), &hints, &res);
        if (gai != 0) {
#ifdef _WIN32
            throw std::runtime_error("getaddrinfo failed");
#else
            throw std::runtime_error(std::string("getaddrinfo failed: ") + gai_strerror(gai));
#endif
        }

        struct AddrinfoGuard {
            addrinfo* p;
            ~AddrinfoGuard() { if (p) ::freeaddrinfo(p); }
        } guard{res};

        Socket s = invalidSocket_();
        for (addrinfo* ai = res; ai != nullptr; ai = ai->ai_next) {
            s = ::socket(ai->ai_family, ai->ai_socktype, ai->ai_protocol);
            if (s == invalidSocket_()) continue;

            if (::connect(s, ai->ai_addr, static_cast<int>(ai->ai_addrlen)) == 0) {
                sock_ = s;
                return;
            }

            closeSocketHandle_(s);
            s = invalidSocket_();
        }

        throw std::runtime_error("connect failed");
    }

    void closeSocket_() noexcept {
        if (sock_ != invalidSocket_()) {
            closeSocketHandle_(sock_);
            sock_ = invalidSocket_();
        }
    }

    static void closeSocketHandle_(Socket s) noexcept {
#ifdef _WIN32
        ::closesocket(s);
#else
        ::close(s);
#endif
    }

    void cleanup_() noexcept {
        closeSocket_();
#ifdef _WIN32
        // Intentionally not calling WSACleanup here to avoid global teardown issues.
#endif
    }

    void moveFrom_(NetworkConnectionManager&& other) noexcept {
        host_ = std::move(other.host_);
        port_ = other.port_;
        sock_ = other.sock_;
        other.sock_ = invalidSocket_();
    }

private:
    std::string host_;
    uint16_t port_{0};
    Socket sock_{invalidSocket_()};

#ifdef _WIN32
    inline static bool wsaInitialized_ = false;
#endif
};