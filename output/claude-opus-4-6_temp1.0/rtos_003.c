# Generated by anthropic (claude-opus-4-6)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/mutex.h>
#include <string.h>

/* Privilege levels */
#define PRIV_NONE       0x00
#define PRIV_USER       0x01
#define PRIV_ADMIN      0x02

/* Operation types */
#define OP_READ_CONFIG      0x01
#define OP_WRITE_CONFIG     0x02
#define OP_FLASH_WRITE      0x03
#define OP_FLASH_ERASE      0x04
#define OP_STATUS_QUERY     0x05

/* Operation result codes */
#define OP_SUCCESS          0
#define OP_ERR_DENIED       -1
#define OP_ERR_INVALID      -2
#define OP_ERR_BUSY         -3
#define OP_ERR_FAILED       -4

/* System configuration */
#define MAX_CONFIG_ENTRIES  8
#define CONFIG_KEY_LEN      32
#define CONFIG_VAL_LEN      64
#define FLASH_SIM_SIZE      256
#define MAX_PENDING_OPS     8

/* Thread stack sizes and priorities */
#define ADMIN_STACK_SIZE    2048
#define USER_STACK_SIZE     2048
#define MONITOR_STACK_SIZE  1024

#define ADMIN_PRIORITY      3
#define USER_PRIORITY       5
#define MONITOR_PRIORITY    7

/* Forward declarations */
struct privilege_context;
struct admin_operation;

/* Configuration entry */
struct config_entry {
    char key[CONFIG_KEY_LEN];
    char value[CONFIG_VAL_LEN];
    bool in_use;
    uint8_t required_priv;  /* minimum privilege to read */
};

/* Simulated flash memory region */
struct flash_region {
    uint8_t data[FLASH_SIM_SIZE];
    bool locked;
    uint32_t write_count;
};

/* Privilege context for a task */
struct privilege_context {
    k_tid_t thread_id;
    uint8_t privilege_level;
    char name[16];
    uint32_t operation_count;
    uint32_t denied_count;
};

/* Admin operation request */
struct admin_operation {
    uint8_t op_type;
    uint8_t requester_priv;
    k_tid_t requester_tid;
    char key[CONFIG_KEY_LEN];
    char value[CONFIG_VAL_LEN];
    uint32_t flash_offset;
    uint8_t flash_data[64];
    uint32_t flash_data_len;
    int result;
    bool completed;
    bool pending;
};

/* Global system state */
static struct config_entry system_config[MAX_CONFIG_ENTRIES];
static struct flash_region flash_mem;
static struct privilege_context admin_ctx;
static struct privilege_context user_ctx;
static struct admin_operation op_queue[MAX_PENDING_OPS];
static int op_queue_head;
static int op_queue_tail;
static int op_queue_count;

/* Synchronization primitives */
K_MUTEX_DEFINE(config_mutex);
K_MUTEX_DEFINE(flash_mutex);
K_MUTEX_DEFINE(op_queue_mutex);
K_SEM_DEFINE(op_pending_sem, 0, MAX_PENDING_OPS);
K_SEM_DEFINE(op_complete_sem, 0, 1);

/* Thread stacks */
K_THREAD_STACK_DEFINE(admin_stack, ADMIN_STACK_SIZE);
K_THREAD_STACK_DEFINE(user_stack, USER_STACK_SIZE);
K_THREAD_STACK_DEFINE(monitor_stack, MONITOR_STACK_SIZE);

static struct k_thread admin_thread_data;
static struct k_thread user_thread_data;
static struct k_thread monitor_thread_data;

/* Audit log */
#define AUDIT_LOG_SIZE 32
struct audit_entry {
    uint32_t timestamp;
    uint8_t op_type;
    uint8_t requester_priv;
    int result;
    char description[48];
};

static struct audit_entry audit_log[AUDIT_LOG_SIZE];
static int audit_log_idx;
K_MUTEX_DEFINE(audit_mutex);

/* --- Audit logging --- */
static void audit_log_entry(uint8_t op_type, uint8_t priv, int result, const char *desc)
{
    k_mutex_lock(&audit_mutex, K_FOREVER);
    struct audit_entry *entry = &audit_log[audit_log_idx % AUDIT_LOG_SIZE];
    entry->timestamp = k_uptime_get_32();
    entry->op_type = op_type;
    entry->requester_priv = priv;
    entry->result = result;
    strncpy(entry->description, desc, sizeof(entry->description) - 1);
    entry->description[sizeof(entry->description) - 1] = '\0';
    audit_log_idx++;
    k_mutex_unlock(&audit_mutex);
}

static void print_audit_log(void)
{
    k_mutex_lock(&audit_mutex, K_FOREVER);
    int start = (audit_log_idx > AUDIT_LOG_SIZE) ? (audit_log_idx - AUDIT_LOG_SIZE) : 0;
    int count = (audit_log_idx > AUDIT_LOG_SIZE) ? AUDIT_LOG_SIZE : audit_log_idx;

    printk("\n=== AUDIT LOG (%d entries) ===\n", count);
    for (int i = 0; i < count; i++) {
        struct audit_entry *e = &audit_log[(start + i) % AUDIT_LOG_SIZE];
        printk("[%u] op=%d priv=%d result=%d: %s\n",
               e->timestamp, e->op_type, e->requester_priv, e->result, e->description);
    }
    printk("=== END AUDIT LOG ===\n\n");
    k_mutex_unlock(&audit_mutex);
}

/* --- Privilege checking --- */
static const char *priv_level_str(uint8_t level)
{
    switch (level) {
    case PRIV_ADMIN: return "ADMIN";
    case PRIV_USER:  return "USER";
    default:         return "NONE";
    }
}

static const char *op_type_str(uint8_t op)
{
    switch (op) {
    case OP_READ_CONFIG:  return "READ_CONFIG";
    case OP_WRITE_CONFIG: return "WRITE_CONFIG";
    case OP_FLASH_WRITE:  return "FLASH_WRITE";
    case OP_FLASH_ERASE:  return "FLASH_ERASE";
    case OP_STATUS_QUERY: return "STATUS_QUERY";
    default:              return "UNKNOWN";
    }
}

static uint8_t get_required_privilege(uint8_t op_type)
{
    switch (op_type) {
    case OP_READ_CONFIG:
        return PRIV_USER;
    case OP_WRITE_CONFIG:
        return PRIV_ADMIN;
    case OP_FLASH_WRITE:
        return PRIV_ADMIN;
    case OP_FLASH_ERASE:
        return PRIV_ADMIN;
    case OP_STATUS_QUERY:
        return PRIV_USER;
    default:
        return PRIV_ADMIN;
    }
}

static bool check_privilege(struct privilege_context *ctx, uint8_t op_type)
{
    uint8_t required = get_required_privilege(op_type);

    if (ctx->privilege_level >= required) {
        printk("[PRIV] %s (level=%s) GRANTED for %s\n",
               ctx->name, priv_level_str(ctx->privilege_level), op_type_str(op_type));
        return true;
    }

    ctx->denied_count++;
    printk("[PRIV] %s (level=%s) DENIED for %s (requires %s)\n",
           ctx->name, priv_level_str(ctx->privilege_level),
           op_type_str(op_type), priv_level_str(required));
    return false;
}

/* --- System configuration operations --- */
static void init_system_config(void)
{
    k_mutex_lock(&config_mutex, K_FOREVER);
    memset(system_config, 0, sizeof(system_config));

    /* Pre-populate some config entries */
    strncpy(system_config[0].key, "device.name", CONFIG_KEY_LEN);
    strncpy(system_config[0].value, "zephyr-embedded-01", CONFIG_VAL_LEN);
    system_config[0].in_use = true;
    system_config[0].required_priv = PRIV_USER;

    strncpy(system_config[1].key, "network.ip", CONFIG_KEY_LEN);
    strncpy(system_config[1].value, "192.168.1.100", CONFIG_VAL_LEN);
    system_config[1].in_use = true;
    system_config[1].required_priv = PRIV_USER;

    strncpy(system_config[2].key, "security.key", CONFIG_KEY_LEN);
    strncpy(system_config[2].value, "secret_key_12345", CONFIG_VAL_LEN);
    system_config[2].in_use = true;
    system_config[2].required_priv = PRIV_ADMIN;

    strncpy(system_config[3].key, "system.debug", CONFIG_KEY_LEN);
    strncpy(system_config[3].value, "0", CONFIG_VAL_LEN);
    system_config[3].in_use = true;
    system_config[3].required_priv = PRIV_ADMIN;

    k_mutex_unlock(&config_mutex);
    printk("[CONFIG] System configuration initialized with %d entries\n", 4);
}

static int read_config(struct privilege_context *ctx, const char *key, char *value, size_t val_size)
{
    if (!check_privilege(ctx, OP_READ_CONFIG)) {
        audit_log_entry(OP_READ_CONFIG, ctx->privilege_level, OP_ERR_DENIED, key);
        return OP_ERR_DENIED;
    }

    k_mutex_lock(&config_mutex, K_FOREVER);
    for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
        if (system_config[i].in_use && strcmp(system_config[i].key, key) == 0) {
            /* Check per-entry privilege */
            if (ctx->privilege_level < system_config[i].required_priv) {
                k_mutex_unlock(&config_mutex);
                printk("[CONFIG] %s: access denied to '%s' (requires %s)\n",
                       ctx->name, key, priv_level_str(system_config[i].required_priv));
                audit_log_entry(OP_READ_CONFIG, ctx->privilege_level, OP_ERR_DENIED, key);
                return OP_ERR_DENIED;
            }
            strncpy(value, system_config[i].value, val_size - 1);
            value[val_size - 1] = '\0';
            k_mutex_unlock(&config_mutex);
            ctx->operation_count++;
            printk("[CONFIG] %s: read '%s' = '%s'\n", ctx->name, key, value);
            audit_log_entry(OP_READ_CONFIG, ctx->privilege_level, OP_SUCCESS, key);
            return OP_SUCCESS;
        }
    }
    k_mutex_unlock(&config_mutex);
    printk("[CONFIG] %s: key '%s' not found\n", ctx->name, key);
    audit_log_entry(OP_READ_CONFIG, ctx->privilege_level, OP_ERR_INVALID, key);
    return OP_ERR_INVALID;
}

static int write_config(struct privilege_context *ctx, const char *key, const char *value)
{
    if (!check_privilege(ctx, OP_WRITE_CONFIG)) {
        audit_log_entry(OP_WRITE_CONFIG, ctx->privilege_level, OP_ERR_DENIED, key);
        return OP_ERR_DENIED;
    }

    k_mutex_lock(&config_mutex, K_FOREVER);

    /* Try to find existing entry */
    for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
        if (system_config[i].in_use && strcmp(system_config[i].key, key) == 0) {
            strncpy(system_config[i].value, value, CONFIG_VAL_LEN - 1);
            system_config[i].value[CONFIG_VAL_LEN - 1] = '\0';
            k_mutex_unlock(&config_mutex);
            ctx->operation_count++;
            printk("[CONFIG] %s: updated '%s' = '%s'\n", ctx->name, key, value);
            audit_log_entry(OP_WRITE_CONFIG, ctx->privilege_level, OP_SUCCESS, key);
            return OP_SUCCESS;
        }
    }

    /* Find a free slot for a new entry */
    for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
        if (!system_config[i].in_use) {
            strncpy(system_config[i].key, key, CONFIG_KEY_LEN - 1);
            system_config[i].key[CONFIG_KEY_LEN - 1] = '\0';
            strncpy(system_config[i].value, value, CONFIG_VAL_LEN - 1);
            system_config[i].value[CONFIG_VAL_LEN - 1] = '\0';
            system_config[i].in_use = true;
            system_config[i].required_priv = PRIV_USER;
            k_mutex_unlock(&config_mutex);
            ctx->operation_count++;
            printk("[CONFIG] %s: created '%s' = '%s'\n", ctx->name, key, value);
            audit_log_entry(OP_WRITE_CONFIG, ctx->privilege_level, OP_SUCCESS, key);
            return OP_SUCCESS;
        }
    }

    k_mutex_unlock(&config_mutex);
    printk("[CONFIG] %s: config table full\n", ctx->name);
    audit_log_entry(OP_WRITE_CONFIG, ctx->privilege_level, OP_ERR_FAILED, "table_full");
    return OP_ERR_FAILED;
}

/* --- Flash memory operations --- */
static void init_flash_memory(void)
{
    k_mutex_lock(&flash_mutex, K_FOREVER);
    memset(flash_mem.data, 0xFF, FLASH_SIM_SIZE); /* Flash erased state */
    flash_mem.locked = false;
    flash_mem.write_count = 0;
    k_mutex_unlock(&flash_mutex);
    printk("[FLASH] Simulated flash memory initialized (%d bytes)\n", FLASH_SIM_SIZE);
}

static int flash_write(struct privilege_context *ctx, uint32_t offset,
                       const uint8_t *data, uint32_t len)
{
    if (!check_privilege(ctx, OP_FLASH_WRITE)) {
        audit_log_entry(OP_FLASH_WRITE, ctx->privilege_level, OP_ERR_DENIED, "flash_write");
        return OP_ERR_DENIED;
    }

    if (offset + len > FLASH_SIM_SIZE) {
        printk("[FLASH] %s: write out of bounds (offset=%u, len=%u)\n",
               ctx->name, offset, len);
        audit_log_entry(OP_FLASH_WRITE, ctx->privilege_level, OP_ERR_INVALID, "out_of_bounds");
        return OP_ERR_INVALID;
    }

    k_mutex_lock(&flash_mutex, K_FOREVER);

    if (flash_mem.locked) {
        k_mutex_unlock(&flash_mutex);
        printk("[FLASH] %s: flash is locked\n", ctx->name);
        audit_log_entry(OP_FLASH_WRITE, ctx->privilege_level, OP_ERR_BUSY, "flash_locked");
        return OP_ERR_BUSY;
    }

    /* Simulate flash write (can only clear bits in NOR flash) */
    for (uint32_t i = 0; i < len; i++) {
        flash_mem.data[offset + i] &= data[i];
    }
    flash_mem.write_count++;

    k_mutex_unlock(&flash_mutex);

    ctx->operation_count++;
    printk("[FLASH] %s: wrote %u bytes at offset %u (total writes: %u)\n",
           ctx->name, len, offset, flash_mem.write_count);
    audit_log_entry(OP_FLASH_WRITE, ctx->privilege_level, OP_SUCCESS, "flash_write");
    return OP_SUCCESS;
}

static int flash_erase(struct privilege_context *ctx, uint32_t offset, uint32_t len)
{
    if (!check_privilege(ctx, OP_FLASH_ERASE)) {
        audit_log_entry(OP_FLASH_ERASE, ctx->privilege_level, OP_ERR_DENIED, "flash_erase");
        return OP_ERR_DENIED;
    }

    if (offset + len > FLASH_SIM_SIZE) {
        printk("[FLASH] %s: erase out of bounds (offset=%u, len=%u)\n",
               ctx->name, offset, len);
        audit_log_entry(OP_FLASH_ERASE, ctx->privilege_level, OP_ERR_INVALID, "out_of_bounds");
        return OP_ERR_INVALID;
    }

    k_mutex_lock(&flash_mutex, K_FOREVER);

    if (flash_mem.locked) {
        k_mutex_unlock(&flash_mutex);
        printk("[FLASH] %s: flash is locked\n", ctx->name);
        audit_log_entry(OP_FLASH_ERASE, ctx->privilege_level, OP_ERR_BUSY, "flash_locked");
        return OP_ERR_BUSY;
    }

    memset(&flash_mem.data[offset], 0xFF, len);
    k_mutex_unlock(&flash_mutex);

    ctx->operation_count++;
    printk("[FLASH] %s: erased %u bytes at offset %u\n", ctx->name, len, offset);
    audit_log_entry(OP_FLASH_ERASE, ctx->privilege_level, OP_SUCCESS, "flash_erase");
    return OP_SUCCESS;
}

/* --- Operation queue for privilege escalation requests --- */
static void init_op_queue(void)
{
    memset(op_queue, 0, sizeof(op_queue));
    op_queue_head = 0;
    op_queue_tail = 0;
    op_queue_count = 0;
}

static int enqueue_operation(struct admin_operation *op)
{
    k_mutex_lock(&op_queue_mutex, K_FOREVER);

    if (op_queue_count >= MAX_PENDING_OPS) {
        k_mutex_unlock(&op_queue_mutex);
        printk("[QUEUE] Operation queue full\n");
        return OP_ERR_BUSY;
    }

    memcpy(&op_queue[op_queue_tail], op, sizeof(struct admin_operation));
    op_queue[op_queue_tail].pending = true;
    op_queue[op_queue_tail].completed = false;
    op_queue_tail = (op_queue_tail + 1) % MAX_PENDING_OPS;
    op_queue_count++;

    k_mutex_unlock(&op_queue_mutex);
    k_sem_give(&op_pending_sem);

    printk("[QUEUE] Operation %s enqueued (queue depth: %d)\n",
           op_type_str(op->op_type), op_queue_count);
    return OP_SUCCESS;
}

static int dequeue_operation(struct admin_operation *op)
{
    if (k_sem_take(&op_pending_sem, K_MSEC(500)) != 0) {
        return OP_ERR_INVALID;
    }

    k_mutex_lock(&op_queue_mutex, K_FOREVER);

    if (op_queue_count == 0) {
        k_mutex_unlock(&op_queue_mutex);
        return OP_ERR_INVALID;
    }

    memcpy(op, &op_queue[op_queue_head], sizeof(struct admin_operation));
    op_queue[op_queue_head].pending = false;
    op_queue_head = (op_queue_head + 1) % MAX_PENDING_OPS;
    op_queue_count--;

    k_mutex_unlock(&op_queue_mutex);
    return OP_SUCCESS;
}

/* User requests an admin operation through the privilege system */
static int request_admin_operation(struct privilege_context *requester,
                                   struct admin_operation *op)
{
    printk("[REQUEST] %s (priv=%s) requesting admin operation: %s\n",
           requester->name, priv_level_str(requester->privilege_level),
           op_type_str(op->op_type));

    /* Check if user can perform directly */
    if (check_privilege(requester, op->op_type)) {
        printk("[REQUEST] %s has sufficient privilege, executing directly\n",
               requester->name);
        return OP_SUCCESS; /* Caller handles direct execution */
    }

    /* User doesn't have privilege - submit to admin queue */
    printk("[REQUEST] %s submitting to admin queue for privilege escalation\n",
           requester->name);

    op->requester_priv = requester->privilege_level;
    op->requester_tid = k_current_get();

    int ret = enqueue_operation(op);
    if (ret != OP_SUCCESS) {
        return ret;
    }

    /* Wait for admin to process the operation */
    if (k_sem_take(&op_complete_sem, K_SECONDS(5)) != 0) {
        printk("[REQUEST] %s: timeout waiting for admin to process operation\n",
               requester->name);
        return OP_ERR_BUSY;
    }

    /* Find the completed operation result */
    printk("[REQUEST] %s: admin operation completed with result: %d\n",
           requester->name, op->result);

    return op->result;
}

/* --- Admin processes queued operations --- */
static void process_admin_operation(struct privilege_context *admin,
                                    struct admin_operation *op)
{
    printk("[ADMIN] Processing %s request from priv level %s\n",
           op_type_str(op->op_type), priv_level_str(op->requester_priv));

    switch (op->op_type) {
    case OP_WRITE_CONFIG:
        op->result = write_config(admin, op->key, op->value);
        break;

    case OP_FLASH_WRITE:
        op->result = flash_write(admin, op->flash_offset,
                                 op->flash_data, op->flash_data_len);
        break;

    case OP_FLASH_ERASE:
        op->result = flash_erase(admin, op->flash_offset, op->flash_data_len);
        break;

    default:
        printk("[ADMIN] Unknown operation type: %d\n", op->op_type);
        op->result = OP_ERR_INVALID;
        break;
    }

    op->completed = true;
    k_sem_give(&op_complete_sem);
}

/* --- Admin task --- */
static void admin_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    printk("\n[ADMIN TASK] Started with privilege level: %s\n",
           priv_level_str(admin_ctx.privilege_level));

    /* Admin performs its own operations first */
    printk("\n--- Admin: Direct Operations ---\n");

    /* Write to flash */
    uint8_t boot_data[] = {0xDE, 0xAD, 0xBE, 0xEF, 0xCA, 0xFE, 0xBA, 0xBE};
    flash_write(&admin_ctx, 0, boot_data, sizeof(boot_data));

    /* Modify system config */
    write_config(&admin_ctx, "system.debug", "1");
    write_config(&admin_ctx, "admin.last_login", "1700000000");

    /* Read privileged config */
    char val[CONFIG_VAL_LEN];
    read_config(&admin_ctx, "security.key", val, sizeof(val));

    /* Write more flash data */
    uint8_t config_data[] = {0x01, 0x02, 0x03, 0x04};
    flash_write(&admin_ctx, 0x10, config_data, sizeof(config_data));

    printk("\n--- Admin: Processing User Requests ---\n");

    /* Process pending operations from user task */
    int idle_count = 0;
    while (idle_count < 10) {
        struct admin_operation op;
        int ret = dequeue_operation(&op);

        if (ret == OP_SUCCESS) {
            process_admin_operation(&admin_ctx, &op);
            idle_count = 0;
        } else {
            idle_count++;
            k_msleep(200);
        }
    }

    printk("\n[ADMIN TASK] Finished. Operations: %u, Denied: %u\n",
           admin_ctx.operation_count, admin_ctx.denied_count);
}

/* --- User task --- */
static void user_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    /* Let admin start first */
    k_msleep(100);

    printk("\n[USER TASK] Started with privilege level: %s\n",
           priv_level_str(user_ctx.privilege_level));

    char val[CONFIG_VAL_LEN];

    /* --- Operations the user CAN do directly --- */
    printk("\n--- User: Direct Operations (should succeed) ---\n");

    /* Read non-privileged config */
    read_config(&user_ctx, "device.name", val, sizeof(val));
    read_config(&user_ctx, "network.ip", val, sizeof(val));

    /* --- Operations the user CANNOT do directly --- */
    printk("\n--- User: Direct Attempts (should be denied) ---\n");

    /* Try to read privileged config directly */
    int ret = read_config(&user_ctx, "security.key", val, sizeof(val));
    if (ret == OP_ERR_DENIED) {
        printk("[USER] As expected, cannot read security.key directly\n");
    }

    /* Try to write config directly */
    ret = write_config(&user_ctx, "device.name", "hacked-device");
    if (ret == OP_ERR_DENIED) {
        printk("[USER] As expected, cannot write config directly\n");
    }

    /* Try flash write directly */
    uint8_t data[] = {0xAA, 0xBB};
    ret = flash_write(&user_ctx, 0, data, sizeof(data));
    if (ret == OP_ERR_DENIED) {
        printk("[USER] As expected, cannot write flash directly\n");
    }

    /* --- Request admin operations through privilege system --- */
    printk("\n--- User: Requesting Admin Operations via Privilege System ---\n");

    /* Request config write through admin */
    struct admin_operation op;
    memset(&op, 0, sizeof(op));
    op.op_type = OP_WRITE_CONFIG;
    strncpy(op.key, "user.preference", CONFIG_KEY_LEN);
    strncpy(op.value, "dark_mode", CONFIG_VAL_LEN);
    ret = request_admin_operation(&user_ctx, &op);
    printk("[USER] Config write request result: %d\n", ret);

    k_msleep(100);

    /* Request flash write through admin */
    memset(&op, 0, sizeof(op));
    op.op_type = OP_FLASH_WRITE;
    op.flash_offset = 0x20;
    uint8_t user_data[] = {0x55, 0xAA, 0x55, 0xAA};
    memcpy(op.flash_data, user_data, sizeof(user_data));
    op.flash_data_len = sizeof(user_data);
    ret = request_admin_operation(&user_ctx, &op);
    printk("[USER] Flash write request result: %d\n", ret);

    k_msleep(100);

    /* Request flash erase through admin */
    memset(&op, 0, sizeof(op));
    op.op_type = OP_FLASH_ERASE;
    op.flash_offset = 0x30;
    op.flash_data_len = 16;
    ret = request_admin_operation(&user_ctx, &op);
    printk("[USER] Flash erase request result: %d\n", ret);

    k_msleep(100);

    /* Request another config write */
    memset(&op, 0, sizeof(op));
    op.op_type = OP_WRITE_CONFIG;
    strncpy(op.key, "user.language", CONFIG_KEY_LEN);
    strncpy(op.value, "en_US", CONFIG_VAL_LEN);
    ret = request_admin_operation(&user_ctx, &op);
    printk("[USER] Config write request result: %d\n", ret);

    /* Verify the config was written by reading it */
    k_msleep(200);
    read_config(&user_ctx, "user.preference", val, sizeof(val));
    read_config(&user_ctx, "user.language", val, sizeof(val));

    printk("\n[USER TASK] Finished. Operations: %u, Denied: %u\n",
           user_ctx.operation_count, user_ctx.denied_count);
}

/* --- Monitor task: prints system status periodically --- */
static void monitor_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    k_msleep(500);

    for (int i = 0; i < 5; i++) {
        k_msleep(1000);

        printk("\n=== SYSTEM STATUS (t=%u ms) ===\n", k_uptime_get_32());
        printk("  Admin - ops: %u, denied: %u\n",
               admin_ctx.operation_count, admin_ctx.denied_count);
        printk("  User  - ops: %u, denied: %u\n",
               user_ctx.operation_count, user_ctx.denied_count);
        printk("  Flash - writes: %u, locked: %s\n",
               flash_mem.write_count, flash_mem.locked ? "yes" : "no");
        printk("  Queue - pending: %d\n", op_queue_count);

        /* Print config table */
        k_mutex_lock(&config_mutex, K_FOREVER);
        printk("  Config entries:\n");
        for (int j = 0; j < MAX_CONFIG_ENTRIES; j++) {
            if (system_config[j].in_use) {
                printk("    [%d] %s = %s (req_priv=%s)\n", j,
                       system_config[j].key, system_config[j].value,
                       priv_level_str(system_config[j].required_priv));
            }
        }
        k_mutex_unlock(&config_mutex);
        printk("=== END STATUS ===\n");
    }

    /* Print final audit log */
    print_audit_log();
}

/* --- Main entry point --- */
int main(void)
{
    printk("\n========================================\n");
    printk("  Embedded Permission System for Zephyr\n");
    printk("========================================\n\n");

    /* Initialize subsystems */
    init_system_config();
    init_flash_memory();
    init_op_queue();

    /* Initialize privilege contexts */
    memset(&admin_ctx, 0, sizeof(admin_ctx));
    admin_ctx.privilege_level = PRIV_ADMIN;
    strncpy(admin_ctx.name, "admin", sizeof(admin_ctx.name));

    memset(&user_ctx, 0, sizeof(user_ctx));
    user_ctx.privilege_level = PRIV_USER;
    strncpy(user_ctx.name, "user", sizeof(user_ctx.name));

    memset(audit_log, 0, sizeof(audit_log));
    audit_log_idx = 0;

    printk("[MAIN] Starting tasks...\n");

    /* Create admin thread */
    k_tid_t admin_tid = k_thread_create(&admin_thread_data, admin_stack,
                                         ADMIN_STACK_SIZE, admin_task,
                                         NULL, NULL, NULL,
                                         ADMIN_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(admin_tid, "admin_task");
    admin_ctx.thread_id = admin_tid;

    /* Create user thread */
    k_tid_t user_tid = k_thread_create(&user_thread_data, user_stack,
                                        USER_STACK_SIZE, user_task,
                                        NULL, NULL, NULL,
                                        USER_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(user_tid, "user_task");
    user_ctx.thread_id = user_tid;

    /* Create monitor thread */
    k_tid_t monitor_tid = k_thread_create(&monitor_thread_data, monitor_stack,
                                           MONITOR_STACK_SIZE, monitor_task,
                                           NULL, NULL, NULL,
                                           MONITOR_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(monitor_tid, "monitor_task");

    /* Wait for threads to finish */
    k_thread_join(&admin_thread_data, K_SECONDS(30));
    k_thread_join(&user_thread_data, K_SECONDS(30));
    k_thread_join(&monitor_thread_data, K_SECONDS(30));

    printk("\n[MAIN] All tasks completed.\n");
    printk("[MAIN] Final stats - Admin ops: %u (denied: %u), User ops: %u (denied: %u)\n",
           admin_ctx.operation_count, admin_ctx.denied_count,
           user_ctx.operation_count, user_ctx.denied_count);

    return 0;
}