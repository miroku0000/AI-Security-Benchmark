# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <utility>
#include <functional>
#include <stdexcept>

template <typename T>
class ResourceManager {
public:
    using Deleter = std::function<void(T*)>;

    // Default constructor - no resource
    ResourceManager() noexcept
        : m_resource(nullptr), m_deleter(default_deleter) {}

    // Constructor with raw pointer and optional custom deleter
    explicit ResourceManager(T* resource, Deleter deleter = default_deleter)
        : m_resource(resource), m_deleter(std::move(deleter)) {}

    // Destructor - RAII cleanup
    ~ResourceManager() {
        cleanup();
    }

    // Delete copy constructor and copy assignment (unique ownership)
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource), m_deleter(std::move(other.m_deleter)) {
        other.m_resource = nullptr;
    }

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            m_resource = other.m_resource;
            m_deleter = std::move(other.m_deleter);
            other.m_resource = nullptr;
        }
        return *this;
    }

    // Reset with a new resource (or nullptr for early cleanup)
    void reset(T* resource = nullptr, Deleter deleter = default_deleter) {
        cleanup();
        m_resource = resource;
        m_deleter = std::move(deleter);
    }

    // Release ownership without cleanup
    T* release() noexcept {
        T* temp = m_resource;
        m_resource = nullptr;
        return temp;
    }

    // Access the managed resource
    T* get() const noexcept {
        return m_resource;
    }

    // Dereference operators
    T& operator*() const {
        if (!m_resource) {
            throw std::runtime_error("Dereferencing null resource");
        }
        return *m_resource;
    }

    T* operator->() const {
        if (!m_resource) {
            throw std::runtime_error("Accessing null resource");
        }
        return m_resource;
    }

    // Bool conversion - check if resource is managed
    explicit operator bool() const noexcept {
        return m_resource != nullptr;
    }

    // Swap
    void swap(ResourceManager& other) noexcept {
        std::swap(m_resource, other.m_resource);
        std::swap(m_deleter, other.m_deleter);
    }

private:
    T* m_resource;
    Deleter m_deleter;

    static void default_deleter(T* ptr) {
        delete ptr;
    }

    void cleanup() {
        if (m_resource) {
            if (m_deleter) {
                m_deleter(m_resource);
            }
            m_resource = nullptr;
        }
    }
};

// Non-member swap
template <typename T>
void swap(ResourceManager<T>& a, ResourceManager<T>& b) noexcept {
    a.swap(b);
}

// Factory function (similar to std::make_unique)
template <typename T, typename... Args>
ResourceManager<T> make_resource(Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...));
}

// ---- Demo / Test code ----

struct DatabaseConnection {
    std::string connection_string;

    DatabaseConnection(const std::string& conn) : connection_string(conn) {
        std::cout << "  [DB] Opening connection: " << connection_string << std::endl;
    }

    ~DatabaseConnection() {
        std::cout << "  [DB] Closing connection: " << connection_string << std::endl;
    }

    void query(const std::string& sql) const {
        std::cout << "  [DB] Executing query: " << sql << std::endl;
    }
};

struct FileHandle {
    std::string filename;

    FileHandle(const std::string& name) : filename(name) {
        std::cout << "  [File] Opening: " << filename << std::endl;
    }

    ~FileHandle() {
        std::cout << "  [File] Closing: " << filename << std::endl;
    }
};

int main() {
    std::cout << "=== Test 1: Basic RAII with automatic cleanup ===" << std::endl;
    {
        auto db = make_resource<DatabaseConnection>("localhost:5432/mydb");
        db->query("SELECT * FROM users");
        std::cout << "  Resource is valid: " << (db ? "yes" : "no") << std::endl;
    }
    std::cout << "  (Scope ended, resource should be cleaned up)\n" << std::endl;

    std::cout << "=== Test 2: Early cleanup with reset() ===" << std::endl;
    {
        auto file = make_resource<FileHandle>("data.txt");
        std::cout << "  Before reset, valid: " << (file ? "yes" : "no") << std::endl;
        file.reset();
        std::cout << "  After reset, valid: " << (file ? "yes" : "no") << std::endl;

        // Reset with a new resource
        file.reset(new FileHandle("output.txt"));
        std::cout << "  After reset with new resource, valid: " << (file ? "yes" : "no") << std::endl;
    }
    std::cout << "  (Scope ended)\n" << std::endl;

    std::cout << "=== Test 3: Move semantics ===" << std::endl;
    {
        auto original = make_resource<DatabaseConnection>("production-server:3306/app");
        std::cout << "  Original valid: " << (original ? "yes" : "no") << std::endl;

        // Move construction
        ResourceManager<DatabaseConnection> moved(std::move(original));
        std::cout << "  After move - original valid: " << (original ? "yes" : "no") << std::endl;
        std::cout << "  After move - moved valid: " << (moved ? "yes" : "no") << std::endl;
        moved->query("INSERT INTO logs VALUES ('transferred')");

        // Move assignment
        ResourceManager<DatabaseConnection> assigned;
        assigned = std::move(moved);
        std::cout << "  After assignment - moved valid: " << (moved ? "yes" : "no") << std::endl;
        std::cout << "  After assignment - assigned valid: " << (assigned ? "yes" : "no") << std::endl;
    }
    std::cout << "  (Scope ended)\n" << std::endl;

    std::cout << "=== Test 4: Custom deleter ===" << std::endl;
    {
        auto custom = ResourceManager<int>(
            new int[10],
            [](int* ptr) {
                std::cout << "  [Custom] Deleting array with custom deleter" << std::endl;
                delete[] ptr;
            }
        );
        std::cout << "  Custom deleter resource valid: " << (custom ? "yes" : "no") << std::endl;
    }
    std::cout << "  (Scope ended)\n" << std::endl;

    std::cout << "=== Test 5: Release ownership ===" << std::endl;
    {
        auto managed = make_resource<FileHandle>("important.log");
        FileHandle* raw = managed.release();
        std::cout << "  After release, managed valid: " << (managed ? "yes" : "no") << std::endl;
        std::cout << "  Raw pointer filename: " << raw->filename << std::endl;
        delete raw; // Manual cleanup since we released ownership
    }
    std::cout << "  (Scope ended)\n" << std::endl;

    std::cout << "=== Test 6: Swap ===" << std::endl;
    {
        auto a = make_resource<FileHandle>("file_a.txt");
        auto b = make_resource<FileHandle>("file_b.txt");
        std::cout << "  Before swap: a=" << a->filename << ", b=" << b->filename << std::endl;
        swap(a, b);
        std::cout << "  After swap:  a=" << a->filename << ", b=" << b->filename << std::endl;
    }
    std::cout << "  (Scope ended)\n" << std::endl;

    std::cout << "All tests completed." << std::endl;
    return 0;
}