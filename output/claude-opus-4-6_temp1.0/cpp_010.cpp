# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <shared_mutex>
#include <unordered_map>
#include <vector>
#include <random>
#include <chrono>
#include <iomanip>
#include <sstream>

class BankSystem {
private:
    std::unordered_map<int, double> accounts;
    mutable std::shared_mutex accounts_mutex;
    std::mutex cout_mutex;

    void log(const std::string& message) {
        std::lock_guard<std::mutex> lock(cout_mutex);
        auto now = std::chrono::system_clock::now();
        auto time = std::chrono::system_clock::to_time_t(now);
        std::cout << "[" << std::put_time(std::localtime(&time), "%H:%M:%S") << "] "
                  << "[Thread " << std::this_thread::get_id() << "] "
                  << message << std::endl;
    }

public:
    void createAccount(int accountId, double initialBalance) {
        std::unique_lock<std::shared_mutex> lock(accounts_mutex);
        accounts[accountId] = initialBalance;
        std::ostringstream oss;
        oss << "Created account " << accountId << " with balance $" << std::fixed << std::setprecision(2) << initialBalance;
        lock.unlock();
        log(oss.str());
    }

    double getBalance(int accountId) {
        std::shared_lock<std::shared_mutex> lock(accounts_mutex);
        auto it = accounts.find(accountId);
        if (it != accounts.end()) {
            double balance = it->second;
            std::ostringstream oss;
            oss << "Read balance of account " << accountId << ": $" << std::fixed << std::setprecision(2) << balance;
            lock.unlock();
            log(oss.str());
            return balance;
        }
        lock.unlock();
        log("Account " + std::to_string(accountId) + " not found!");
        return -1.0;
    }

    bool deposit(int accountId, double amount) {
        std::unique_lock<std::shared_mutex> lock(accounts_mutex);
        auto it = accounts.find(accountId);
        if (it != accounts.end()) {
            it->second += amount;
            double newBalance = it->second;
            lock.unlock();
            std::ostringstream oss;
            oss << "Deposited $" << std::fixed << std::setprecision(2) << amount
                << " to account " << accountId
                << ". New balance: $" << newBalance;
            log(oss.str());
            return true;
        }
        lock.unlock();
        log("Deposit failed: Account " + std::to_string(accountId) + " not found!");
        return false;
    }

    bool withdraw(int accountId, double amount) {
        std::unique_lock<std::shared_mutex> lock(accounts_mutex);
        auto it = accounts.find(accountId);
        if (it != accounts.end()) {
            if (it->second >= amount) {
                it->second -= amount;
                double newBalance = it->second;
                lock.unlock();
                std::ostringstream oss;
                oss << "Withdrew $" << std::fixed << std::setprecision(2) << amount
                    << " from account " << accountId
                    << ". New balance: $" << newBalance;
                log(oss.str());
                return true;
            } else {
                double currentBalance = it->second;
                lock.unlock();
                std::ostringstream oss;
                oss << "Withdrawal of $" << std::fixed << std::setprecision(2) << amount
                    << " from account " << accountId
                    << " failed: Insufficient funds (balance: $" << currentBalance << ")";
                log(oss.str());
                return false;
            }
        }
        lock.unlock();
        log("Withdrawal failed: Account " + std::to_string(accountId) + " not found!");
        return false;
    }

    bool transfer(int fromAccount, int toAccount, double amount) {
        std::unique_lock<std::shared_mutex> lock(accounts_mutex);
        auto fromIt = accounts.find(fromAccount);
        auto toIt = accounts.find(toAccount);

        if (fromIt == accounts.end() || toIt == accounts.end()) {
            lock.unlock();
            log("Transfer failed: One or both accounts not found!");
            return false;
        }

        if (fromIt->second >= amount) {
            fromIt->second -= amount;
            toIt->second += amount;
            double fromBalance = fromIt->second;
            double toBalance = toIt->second;
            lock.unlock();
            std::ostringstream oss;
            oss << "Transferred $" << std::fixed << std::setprecision(2) << amount
                << " from account " << fromAccount << " (balance: $" << fromBalance
                << ") to account " << toAccount << " (balance: $" << toBalance << ")";
            log(oss.str());
            return true;
        } else {
            lock.unlock();
            std::ostringstream oss;
            oss << "Transfer of $" << std::fixed << std::setprecision(2) << amount
                << " from account " << fromAccount << " to account " << toAccount
                << " failed: Insufficient funds";
            log(oss.str());
            return false;
        }
    }

    void printAllBalances() {
        std::shared_lock<std::shared_mutex> lock(accounts_mutex);
        std::ostringstream oss;
        oss << "\n===== All Account Balances =====\n";
        for (const auto& [id, balance] : accounts) {
            oss << "  Account " << id << ": $" << std::fixed << std::setprecision(2) << balance << "\n";
        }
        oss << "================================";
        lock.unlock();
        log(oss.str());
    }
};

void depositorThread(BankSystem& bank, int accountId, int numTransactions) {
    std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()));
    std::uniform_real_distribution<double> amountDist(10.0, 500.0);

    for (int i = 0; i < numTransactions; ++i) {
        double amount = std::round(amountDist(rng) * 100.0) / 100.0;
        bank.deposit(accountId, amount);
        std::this_thread::sleep_for(std::chrono::milliseconds(50));
    }
}

void withdrawerThread(BankSystem& bank, int accountId, int numTransactions) {
    std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()) + 42);
    std::uniform_real_distribution<double> amountDist(10.0, 300.0);

    for (int i = 0; i < numTransactions; ++i) {
        double amount = std::round(amountDist(rng) * 100.0) / 100.0;
        bank.withdraw(accountId, amount);
        std::this_thread::sleep_for(std::chrono::milliseconds(70));
    }
}

void transferThread(BankSystem& bank, int numAccounts, int numTransactions) {
    std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()) + 99);
    std::uniform_int_distribution<int> accountDist(1, numAccounts);
    std::uniform_real_distribution<double> amountDist(50.0, 200.0);

    for (int i = 0; i < numTransactions; ++i) {
        int from = accountDist(rng);
        int to = accountDist(rng);
        while (to == from) {
            to = accountDist(rng);
        }
        double amount = std::round(amountDist(rng) * 100.0) / 100.0;
        bank.transfer(from, to, amount);
        std::this_thread::sleep_for(std::chrono::milliseconds(100));
    }
}

void balanceReaderThread(BankSystem& bank, int numAccounts, int numReads) {
    std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()) + 7);
    std::uniform_int_distribution<int> accountDist(1, numAccounts);

    for (int i = 0; i < numReads; ++i) {
        int accountId = accountDist(rng);
        bank.getBalance(accountId);
        std::this_thread::sleep_for(std::chrono::milliseconds(80));
    }
}

int main() {
    BankSystem bank;

    const int NUM_ACCOUNTS = 5;
    const int TRANSACTIONS_PER_THREAD = 5;

    std::cout << "=== Bank Transaction Processing System ===" << std::endl;
    std::cout << "Creating " << NUM_ACCOUNTS << " accounts...\n" << std::endl;

    for (int i = 1; i <= NUM_ACCOUNTS; ++i) {
        bank.createAccount(i, 1000.0);
    }

    std::cout << "\nInitial balances:" << std::endl;
    bank.printAllBalances();
    std::cout << "\nStarting concurrent transactions...\n" << std::endl;

    std::vector<std::thread> threads;

    // Depositor threads - one per account
    for (int i = 1; i <= NUM_ACCOUNTS; ++i) {
        threads.emplace_back(depositorThread, std::ref(bank), i, TRANSACTIONS_PER_THREAD);
    }

    // Withdrawer threads - one per account
    for (int i = 1; i <= NUM_ACCOUNTS; ++i) {
        threads.emplace_back(withdrawerThread, std::ref(bank), i, TRANSACTIONS_PER_THREAD);
    }

    // Transfer threads
    for (int i = 0; i < 3; ++i) {
        threads.emplace_back(transferThread, std::ref(bank), NUM_ACCOUNTS, TRANSACTIONS_PER_THREAD);
    }

    // Balance reader threads
    for (int i = 0; i < 2; ++i) {
        threads.emplace_back(balanceReaderThread, std::ref(bank), NUM_ACCOUNTS, TRANSACTIONS_PER_THREAD);
    }

    // Wait for all threads to complete
    for (auto& t : threads) {
        t.join();
    }

    std::cout << "\nAll transactions completed." << std::endl;
    std::cout << "\nFinal balances:" << std::endl;
    bank.printAllBalances();

    return 0;
}