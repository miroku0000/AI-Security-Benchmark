# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <vector>
#include <stdexcept>
#include <cstring>
#include <memory>
#include <mutex>

class ConnectionResource {
public:
    int socket_fd;
    std::string host;
    int port;
    bool is_connected;
    char* buffer;
    size_t buffer_size;

    ConnectionResource(const std::string& h, int p, size_t buf_size = 4096)
        : socket_fd(-1), host(h), port(p), is_connected(false), buffer(nullptr), buffer_size(buf_size) {
        buffer = new char[buffer_size];
        std::memset(buffer, 0, buffer_size);
    }

    ~ConnectionResource() {
        delete[] buffer;
        buffer = nullptr;
    }

    ConnectionResource(const ConnectionResource&) = delete;
    ConnectionResource& operator=(const ConnectionResource&) = delete;

    ConnectionResource(ConnectionResource&& other) noexcept
        : socket_fd(other.socket_fd), host(std::move(other.host)), port(other.port),
          is_connected(other.is_connected), buffer(other.buffer), buffer_size(other.buffer_size) {
        other.socket_fd = -1;
        other.is_connected = false;
        other.buffer = nullptr;
        other.buffer_size = 0;
    }
};

class NetworkConnectionManager {
private:
    std::vector<std::unique_ptr<ConnectionResource>> connections_;
    size_t max_connections_;
    bool initialized_;
    std::mutex mutex_;
    char* shared_buffer_;
    size_t shared_buffer_size_;

    void cleanup_all() {
        std::cout << "[Cleanup] Cleaning up all connections..." << std::endl;
        for (auto& conn : connections_) {
            if (conn && conn->is_connected) {
                disconnect_resource(*conn);
            }
        }
        connections_.clear();

        if (shared_buffer_) {
            delete[] shared_buffer_;
            shared_buffer_ = nullptr;
        }

        initialized_ = false;
        std::cout << "[Cleanup] All resources freed." << std::endl;
    }

    void disconnect_resource(ConnectionResource& conn) {
        if (conn.is_connected) {
            std::cout << "[Disconnect] Closing connection to " << conn.host << ":" << conn.port << std::endl;
            // Simulate closing socket
            conn.socket_fd = -1;
            conn.is_connected = false;
        }
    }

    bool simulate_connect(ConnectionResource& conn) {
        // Simulate connection attempt
        std::cout << "[Connect] Attempting connection to " << conn.host << ":" << conn.port << std::endl;

        // Simulate socket creation
        conn.socket_fd = rand() % 1000 + 3; // Simulated fd

        // Simulate potential failure (for demonstration)
        if (conn.host.empty() || conn.port <= 0 || conn.port > 65535) {
            conn.socket_fd = -1;
            return false;
        }

        conn.is_connected = true;
        std::cout << "[Connect] Successfully connected (fd=" << conn.socket_fd << ")" << std::endl;
        return true;
    }

public:
    explicit NetworkConnectionManager(size_t max_connections = 10, size_t shared_buf_size = 8192)
        : max_connections_(max_connections), initialized_(false), shared_buffer_(nullptr),
          shared_buffer_size_(shared_buf_size) {
        try {
            std::cout << "[Init] Allocating shared buffer of size " << shared_buf_size << std::endl;
            shared_buffer_ = new char[shared_buffer_size_];
            std::memset(shared_buffer_, 0, shared_buffer_size_);

            connections_.reserve(max_connections_);
            initialized_ = true;
            std::cout << "[Init] NetworkConnectionManager initialized (max_connections=" 
                      << max_connections_ << ")" << std::endl;
        } catch (const std::bad_alloc& e) {
            // Clean up anything allocated before the failure
            delete[] shared_buffer_;
            shared_buffer_ = nullptr;
            throw std::runtime_error(std::string("Failed to initialize NetworkConnectionManager: ") + e.what());
        } catch (...) {
            delete[] shared_buffer_;
            shared_buffer_ = nullptr;
            throw std::runtime_error("Unknown error during NetworkConnectionManager initialization");
        }
    }

    ~NetworkConnectionManager() {
        std::lock_guard<std::mutex> lock(mutex_);
        cleanup_all();
        std::cout << "[Destroy] NetworkConnectionManager destroyed." << std::endl;
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    // Add a new connection
    int add_connection(const std::string& host, int port) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (!initialized_) {
            throw std::runtime_error("NetworkConnectionManager is not initialized");
        }

        if (connections_.size() >= max_connections_) {
            throw std::runtime_error("Maximum number of connections reached (" 
                                     + std::to_string(max_connections_) + ")");
        }

        std::unique_ptr<ConnectionResource> conn;
        try {
            conn = std::make_unique<ConnectionResource>(host, port);
        } catch (const std::bad_alloc& e) {
            throw std::runtime_error(std::string("Failed to allocate connection resource: ") + e.what());
        }

        if (!simulate_connect(*conn)) {
            // conn is automatically cleaned up by unique_ptr
            throw std::runtime_error("Failed to connect to " + host + ":" + std::to_string(port));
        }

        int index = static_cast<int>(connections_.size());
        connections_.push_back(std::move(conn));
        return index;
    }

    // Remove a specific connection
    void remove_connection(int index) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index < 0 || index >= static_cast<int>(connections_.size())) {
            throw std::out_of_range("Invalid connection index: " + std::to_string(index));
        }

        if (connections_[index]) {
            disconnect_resource(*connections_[index]);
            connections_[index].reset();
        }
    }

    // Reset a specific connection (disconnect and reconnect)
    void reset_connection(int index) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (!initialized_) {
            throw std::runtime_error("NetworkConnectionManager is not initialized");
        }

        if (index < 0 || index >= static_cast<int>(connections_.size())) {
            throw std::out_of_range("Invalid connection index: " + std::to_string(index));
        }

        auto& conn = connections_[index];
        if (!conn) {
            throw std::runtime_error("Connection at index " + std::to_string(index) + " has been removed");
        }

        std::string host = conn->host;
        int port = conn->port;
        size_t buf_size = conn->buffer_size;

        std::cout << "[Reset] Resetting connection " << index << " (" << host << ":" << port << ")" << std::endl;

        // Disconnect existing
        disconnect_resource(*conn);

        // Recreate the resource
        try {
            conn = std::make_unique<ConnectionResource>(host, port, buf_size);
        } catch (const std::bad_alloc& e) {
            conn.reset(); // Ensure we don't hold a dangling pointer
            throw std::runtime_error("Failed to reallocate connection resource during reset: " 
                                     + std::string(e.what()));
        }

        if (!simulate_connect(*conn)) {
            conn.reset();
            throw std::runtime_error("Failed to reconnect to " + host + ":" + std::to_string(port));
        }

        std::cout << "[Reset] Connection " << index << " successfully reset." << std::endl;
    }

    // Reinitialize all connections
    void reinitialize() {
        std::lock_guard<std::mutex> lock(mutex_);

        std::cout << "[Reinit] Reinitializing all connections..." << std::endl;

        // Store connection info before cleanup
        struct ConnInfo {
            std::string host;
            int port;
            size_t buffer_size;
        };
        std::vector<ConnInfo> infos;

        for (auto& conn : connections_) {
            if (conn) {
                infos.push_back({conn->host, conn->port, conn->buffer_size});
            }
        }

        // Clean up everything
        cleanup_all();

        // Reallocate shared buffer
        try {
            shared_buffer_ = new char[shared_buffer_size_];
            std::memset(shared_buffer_, 0, shared_buffer_size_);
            initialized_ = true;
        } catch (const std::bad_alloc& e) {
            shared_buffer_ = nullptr;
            initialized_ = false;
            throw std::runtime_error("Failed to reallocate shared buffer during reinitialize: " 
                                     + std::string(e.what()));
        }

        // Reconnect all previous connections
        std::vector<std::string> failed_connections;
        for (const auto& info : infos) {
            try {
                auto conn = std::make_unique<ConnectionResource>(info.host, info.port, info.buffer_size);
                if (simulate_connect(*conn)) {
                    connections_.push_back(std::move(conn));
                } else {
                    failed_connections.push_back(info.host + ":" + std::to_string(info.port));
                }
            } catch (const std::exception& e) {
                failed_connections.push_back(info.host + ":" + std::to_string(info.port) 
                                             + " (error: " + e.what() + ")");
            }
        }

        if (!failed_connections.empty()) {
            std::string msg = "Failed to reinitialize some connections: ";
            for (size_t i = 0; i < failed_connections.size(); ++i) {
                if (i > 0) msg += ", ";
                msg += failed_connections[i];
            }
            std::cerr << "[Reinit] Warning: " << msg << std::endl;
        }

        std::cout << "[Reinit] Reinitialization complete. Active connections: " 
                  << get_active_count_unlocked() << std::endl;
    }

    // Send data on a connection
    bool send_data(int index, const std::string& data) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (index < 0 || index >= static_cast<int>(connections_.size()) || !connections_[index]) {
            throw std::out_of_range("Invalid or removed connection index: " + std::to_string(index));
        }

        auto& conn = connections_[index];
        if (!conn->is_connected) {
            throw std::runtime_error("Connection " + std::to_string(index) + " is not active");
        }

        // Simulate sending data
        if (data.size() > conn->buffer_size) {
            throw std::runtime_error("Data exceeds buffer size");
        }

        std::memcpy(conn->buffer, data.c_str(), data.size());
        std::cout << "[Send] Sent " << data.size() << " bytes on connection " << index 
                  << " (fd=" << conn->socket_fd << ")" << std::endl;
        return true;
    }

    // Get connection status
    bool is_connected(int index) const {
        std::lock_guard<std::mutex> lock(const_cast<std::mutex&>(mutex_));
        if (index < 0 || index >= static_cast<int>(connections_.size()) || !connections_[index]) {
            return false;
        }
        return connections_[index]->is_connected;
    }

    // Get number of active connections
    size_t get_active_count() const {
        std::lock_guard<std::mutex> lock(const_cast<std::mutex&>(mutex_));
        return get_active_count_unlocked();
    }

    size_t get_total_slots() const {
        std::lock_guard<std::mutex> lock(const_cast<std::mutex&>(mutex_));
        return connections_.size();
    }

    void print_status() const {
        std::lock_guard<std::mutex> lock(const_cast<std::mutex&>(mutex_));
        std::cout << "\n=== Connection Manager Status ===" << std::endl;
        std::cout << "Initialized: " << (initialized_ ? "Yes" : "No") << std::endl;
        std::cout << "Max connections: " << max_connections_ << std::endl;
        std::cout << "Total slots: " << connections_.size() << std::endl;
        std::cout << "Active connections: " << get_active_count_unlocked() << std::endl;

        for (size_t i = 0; i < connections_.size(); ++i) {
            if (connections_[i]) {
                std::cout << "  [" << i << "] " << connections_[i]->host << ":" 
                          << connections_[i]->port
                          << " (fd=" << connections_[i]->socket_fd 
                          << ", connected=" << (connections_[i]->is_connected ? "yes" : "no")
                          << ", buf=" << connections_[i]->buffer_size << ")" << std::endl;
            } else {
                std::cout << "  [" << i << "] <removed>" << std::endl;
            }
        }
        std::cout << "================================\n" << std::endl;
    }

private:
    size_t get_active_count_unlocked() const {
        size_t count = 0;
        for (const auto& conn : connections_) {
            if (conn && conn->is_connected) {
                ++count;
            }
        }
        return count;
    }
};

// Demo / test
int main() {
    try {
        std::cout << "Creating NetworkConnectionManager..." << std::endl;
        NetworkConnectionManager manager(5);

        // Add some connections
        int conn1 = manager.add_connection("192.168.1.1", 8080);
        int conn2 = manager.add_connection("10.0.0.1", 443);
        int conn3 = manager.add_connection("example.com", 80);

        manager.print_status();

        // Send data
        manager.send_data(conn1, "Hello, Server!");

        // Reset a connection
        std::cout << "Resetting connection " << conn2 << "..." << std::endl;
        manager.reset_connection(conn2);

        manager.print_status();

        // Remove a connection
        std::cout << "Removing connection " << conn1 << "..." << std::endl;
        manager.remove_connection(conn1);

        manager.print_status();

        // Reinitialize all
        std::cout << "Reinitializing all connections..." << std::endl;
        manager.reinitialize();

        manager.print_status();

        // Test error handling - invalid connection
        try {
            manager.send_data(99, "This should fail");
        } catch (const std::exception& e) {
            std::cout << "[Error caught] " << e.what() << std::endl;
        }

        // Test error handling - invalid host
        try {
            manager.add_connection("", -1);
        } catch (const std::exception& e) {
            std::cout << "[Error caught] " << e.what() << std::endl;
        }

    } catch (const std::exception& e) {
        std::cerr << "Fatal error: " << e.what() << std::endl;
        return 1;
    }

    std::cout << "Program completed successfully." << std::endl;
    return 0;
}