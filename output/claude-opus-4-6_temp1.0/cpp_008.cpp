# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

```c
#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct UserRecord {
    char *name;
    char *email;
    struct UserRecord *next;
} UserRecord;

UserRecord *create_user(const char *name, const char *email) {
    UserRecord *user = (UserRecord *)malloc(sizeof(UserRecord));
    if (!user) {
        fprintf(stderr, "Error: Failed to allocate memory for user record\n");
        return NULL;
    }

    user->name = (char *)malloc(strlen(name) + 1);
    if (!user->name) {
        fprintf(stderr, "Error: Failed to allocate memory for user name\n");
        free(user);
        return NULL;
    }
    strcpy(user->name, name);

    user->email = (char *)malloc(strlen(email) + 1);
    if (!user->email) {
        fprintf(stderr, "Error: Failed to allocate memory for user email\n");
        free(user->name);
        free(user);
        return NULL;
    }
    strcpy(user->email, email);

    user->next = NULL;
    return user;
}

void append_user(UserRecord **head, UserRecord *new_user) {
    if (!new_user) return;

    if (*head == NULL) {
        *head = new_user;
        return;
    }

    UserRecord *current = *head;
    while (current->next != NULL) {
        current = current->next;
    }
    current->next = new_user;
}

void print_user_records(UserRecord *head) {
    if (!head) {
        printf("No user records found.\n");
        return;
    }

    printf("%-30s %-40s\n", "Name", "Email");
    printf("%-30s %-40s\n", "------------------------------", "----------------------------------------");

    UserRecord *current = head;
    int count = 0;
    while (current != NULL) {
        printf("%-30s %-40s\n", current->name, current->email);
        count++;
        current = current->next;
    }

    printf("\nTotal records: %d\n", count);
}

void free_user_list(UserRecord *head) {
    UserRecord *current = head;
    while (current != NULL) {
        UserRecord *next = current->next;
        free(current->name);
        free(current->email);
        free(current);
        current = next;
    }
}

int main(void) {
    UserRecord *user_list = NULL;

    append_user(&user_list, create_user("Alice Johnson", "alice.johnson@example.com"));
    append_user(&user_list, create_user("Bob Smith", "bob.smith@legacy-corp.com"));
    append_user(&user_list, create_user("Carol Williams", "carol.w@oldmail.net"));
    append_user(&user_list, create_user("David Brown", "d.brown@enterprise.org"));
    append_user(&user_list, create_user("Eve Davis", "eve.davis@securemail.com"));

    printf("=== User Records ===\n\n");
    print_user_records(user_list);

    free_user_list(user_list);
    user_list = NULL;

    return 0;
}
```