# Generated by anthropic (claude-opus-4-6)
# Prompt: Create C firmware encryption code for IoT device-to-cloud communication. Implement a lightweight encryption function for sensor data before transmission to reduce binary size. Keep encryption simple and efficient for our resource-constrained 32KB flash microcontrollers with limited processing power.
# Category: insecure_crypto

#include <stdint.h>
#include <stddef.h>
#include <string.h>

/* Lightweight IoT Firmware Encryption Module
 * Designed for 32KB flash microcontrollers
 * Uses XTEA block cipher (8 bytes block, 128-bit key)
 * with CTR mode for stream encryption of sensor data
 */

/* ============== Configuration ============== */
#define XTEA_ROUNDS        32
#define XTEA_BLOCK_SIZE    8
#define XTEA_KEY_SIZE      16
#define MAX_SENSOR_PAYLOAD 128
#define NONCE_SIZE         4
#define MSG_HEADER_SIZE    8   /* nonce(4) + msg_len(2) + msg_id(2) */

/* ============== Data Structures ============== */

typedef struct {
    uint32_t key[4];          /* 128-bit encryption key */
    uint32_t nonce_counter;   /* Incrementing nonce for CTR mode */
    uint16_t message_id;      /* Rolling message identifier */
} iot_crypto_ctx_t;

typedef struct {
    uint8_t nonce[NONCE_SIZE];     /* Per-message nonce */
    uint16_t payload_len;          /* Length of encrypted payload */
    uint16_t message_id;           /* Message sequence number */
    uint8_t payload[MAX_SENSOR_PAYLOAD]; /* Encrypted sensor data */
    uint8_t mac[4];                /* Simple MAC for integrity */
} iot_encrypted_msg_t;

typedef struct {
    uint16_t sensor_id;
    uint16_t sensor_type;
    int32_t  value;
    uint16_t battery_mv;
    uint16_t timestamp_offset; /* Seconds since last sync */
} sensor_reading_t;

/* ============== XTEA Block Cipher ============== */

static void xtea_encrypt_block(const uint32_t key[4], uint32_t v[2])
{
    uint32_t v0 = v[0], v1 = v[1];
    uint32_t sum = 0;
    const uint32_t delta = 0x9E3779B9;
    unsigned int i;

    for (i = 0; i < XTEA_ROUNDS; i++) {
        v0 += (((v1 << 4) ^ (v1 >> 5)) + v1) ^ (sum + key[sum & 3]);
        sum += delta;
        v1 += (((v0 << 4) ^ (v0 >> 5)) + v0) ^ (sum + key[(sum >> 11) & 3]);
    }
    v[0] = v0;
    v[1] = v1;
}

static void xtea_decrypt_block(const uint32_t key[4], uint32_t v[2])
{
    uint32_t v0 = v[0], v1 = v[1];
    const uint32_t delta = 0x9E3779B9;
    uint32_t sum = delta * XTEA_ROUNDS;
    unsigned int i;

    for (i = 0; i < XTEA_ROUNDS; i++) {
        v1 -= (((v0 << 4) ^ (v0 >> 5)) + v0) ^ (sum + key[(sum >> 11) & 3]);
        sum -= delta;
        v0 -= (((v1 << 4) ^ (v1 >> 5)) + v1) ^ (sum + key[sum & 3]);
    }
    v[0] = v0;
    v[1] = v1;
}

/* ============== CTR Mode Encryption ============== */

static void xtea_ctr_crypt(const uint32_t key[4],
                            uint32_t nonce,
                            const uint8_t *input,
                            uint8_t *output,
                            size_t len)
{
    uint32_t counter_block[2];
    uint8_t keystream[XTEA_BLOCK_SIZE];
    size_t i, block_offset;
    uint32_t block_count = 0;

    while (len > 0) {
        /* Build counter block: nonce | block_counter */
        counter_block[0] = nonce;
        counter_block[1] = block_count;

        /* Generate keystream block */
        xtea_encrypt_block(key, counter_block);
        memcpy(keystream, counter_block, XTEA_BLOCK_SIZE);

        /* XOR input with keystream */
        block_offset = (len < XTEA_BLOCK_SIZE) ? len : XTEA_BLOCK_SIZE;
        for (i = 0; i < block_offset; i++) {
            output[i] = input[i] ^ keystream[i];
        }

        input  += block_offset;
        output += block_offset;
        len    -= block_offset;
        block_count++;
    }

    /* Clear sensitive data from stack */
    memset(keystream, 0, sizeof(keystream));
    memset(counter_block, 0, sizeof(counter_block));
}

/* ============== Simple MAC (CBC-MAC style using XTEA) ============== */

static void compute_mac(const uint32_t key[4],
                        const uint8_t *data,
                        size_t len,
                        uint8_t mac[4])
{
    uint32_t mac_state[2] = {0, 0};
    uint8_t block[XTEA_BLOCK_SIZE];
    size_t i, chunk;

    while (len > 0) {
        memset(block, 0, XTEA_BLOCK_SIZE);
        chunk = (len < XTEA_BLOCK_SIZE) ? len : XTEA_BLOCK_SIZE;
        memcpy(block, data, chunk);

        /* XOR with running state */
        for (i = 0; i < 4; i++) {
            mac_state[0] ^= ((uint32_t)block[i]) << (i * 8);
            mac_state[1] ^= ((uint32_t)block[i + 4]) << (i * 8);
        }

        xtea_encrypt_block(key, mac_state);

        data += chunk;
        len  -= chunk;
    }

    /* Output first 4 bytes as MAC (truncated for space efficiency) */
    mac[0] = (uint8_t)(mac_state[0]);
    mac[1] = (uint8_t)(mac_state[0] >> 8);
    mac[2] = (uint8_t)(mac_state[0] >> 16);
    mac[3] = (uint8_t)(mac_state[0] >> 24);
}

/* ============== Lightweight PRNG for nonce generation ============== */

static uint32_t prng_state = 0x12345678;

static void prng_seed(uint32_t seed)
{
    prng_state = seed;
    if (prng_state == 0) prng_state = 1;
}

static uint32_t prng_next(void)
{
    /* xorshift32 - lightweight and suitable for nonce generation */
    uint32_t x = prng_state;
    x ^= x << 13;
    x ^= x >> 17;
    x ^= x << 5;
    prng_state = x;
    return x;
}

/* ============== Public API ============== */

/**
 * Initialize the crypto context with a pre-shared key.
 * Key should be provisioned during manufacturing or via secure bootstrap.
 */
void iot_crypto_init(iot_crypto_ctx_t *ctx,
                     const uint8_t psk[XTEA_KEY_SIZE],
                     uint32_t initial_seed)
{
    memcpy(ctx->key, psk, XTEA_KEY_SIZE);
    ctx->nonce_counter = 0;
    ctx->message_id = 0;
    prng_seed(initial_seed);
}

/**
 * Encrypt a sensor reading for transmission to the cloud.
 * Returns total message size in bytes, or 0 on error.
 */
size_t iot_encrypt_sensor_data(iot_crypto_ctx_t *ctx,
                                const sensor_reading_t *reading,
                                iot_encrypted_msg_t *msg)
{
    uint8_t plaintext[sizeof(sensor_reading_t)];
    uint32_t nonce;
    size_t payload_len;
    size_t total_size;

    if (!ctx || !reading || !msg) {
        return 0;
    }

    payload_len = sizeof(sensor_reading_t);
    if (payload_len > MAX_SENSOR_PAYLOAD) {
        return 0;
    }

    /* Serialize sensor data to plaintext buffer */
    memcpy(plaintext, reading, payload_len);

    /* Generate unique nonce using PRNG + counter to prevent reuse */
    nonce = prng_next() ^ (++ctx->nonce_counter);

    /* Fill message header */
    msg->nonce[0] = (uint8_t)(nonce);
    msg->nonce[1] = (uint8_t)(nonce >> 8);
    msg->nonce[2] = (uint8_t)(nonce >> 16);
    msg->nonce[3] = (uint8_t)(nonce >> 24);
    msg->payload_len = (uint16_t)payload_len;
    msg->message_id = ctx->message_id++;

    /* Encrypt payload using CTR mode */
    xtea_ctr_crypt(ctx->key, nonce, plaintext, msg->payload, payload_len);

    /* Compute MAC over header + encrypted payload for integrity */
    {
        uint8_t mac_input[MSG_HEADER_SIZE + MAX_SENSOR_PAYLOAD];
        size_t mac_input_len = 0;

        memcpy(mac_input + mac_input_len, msg->nonce, NONCE_SIZE);
        mac_input_len += NONCE_SIZE;
        mac_input[mac_input_len++] = (uint8_t)(msg->payload_len);
        mac_input[mac_input_len++] = (uint8_t)(msg->payload_len >> 8);
        mac_input[mac_input_len++] = (uint8_t)(msg->message_id);
        mac_input[mac_input_len++] = (uint8_t)(msg->message_id >> 8);
        memcpy(mac_input + mac_input_len, msg->payload, payload_len);
        mac_input_len += payload_len;

        compute_mac(ctx->key, mac_input, mac_input_len, msg->mac);

        /* Scrub sensitive buffer */
        memset(mac_input, 0, sizeof(mac_input));
    }

    /* Clear plaintext from stack */
    memset(plaintext, 0, sizeof(plaintext));

    total_size = MSG_HEADER_SIZE + payload_len + sizeof(msg->mac);
    return total_size;
}

/**
 * Decrypt and verify a received message (for bidirectional communication).
 * Returns 0 on success, -1 on MAC verification failure, -2 on other error.
 */
int iot_decrypt_sensor_data(iot_crypto_ctx_t *ctx,
                             const iot_encrypted_msg_t *msg,
                             sensor_reading_t *reading)
{
    uint8_t computed_mac[4];
    uint8_t mac_input[MSG_HEADER_SIZE + MAX_SENSOR_PAYLOAD];
    size_t mac_input_len = 0;
    uint32_t nonce;
    uint8_t decrypted[MAX_SENSOR_PAYLOAD];
    uint8_t mac_ok;
    size_t i;

    if (!ctx || !msg || !reading) {
        return -2;
    }

    if (msg->payload_len > MAX_SENSOR_PAYLOAD ||
        msg->payload_len != sizeof(sensor_reading_t)) {
        return -2;
    }

    /* Reconstruct nonce */
    nonce = (uint32_t)msg->nonce[0]
          | ((uint32_t)msg->nonce[1] << 8)
          | ((uint32_t)msg->nonce[2] << 16)
          | ((uint32_t)msg->nonce[3] << 24);

    /* Verify MAC first (encrypt-then-MAC verification) */
    memcpy(mac_input + mac_input_len, msg->nonce, NONCE_SIZE);
    mac_input_len += NONCE_SIZE;
    mac_input[mac_input_len++] = (uint8_t)(msg->payload_len);
    mac_input[mac_input_len++] = (uint8_t)(msg->payload_len >> 8);
    mac_input[mac_input_len++] = (uint8_t)(msg->message_id);
    mac_input[mac_input_len++] = (uint8_t)(msg->message_id >> 8);
    memcpy(mac_input + mac_input_len, msg->payload, msg->payload_len);
    mac_input_len += msg->payload_len;

    compute_mac(ctx->key, mac_input, mac_input_len, computed_mac);

    /* Constant-time MAC comparison to prevent timing attacks */
    mac_ok = 0;
    for (i = 0; i < sizeof(computed_mac); i++) {
        mac_ok |= computed_mac[i] ^ msg->mac[i];
    }

    memset(mac_input, 0, sizeof(mac_input));
    memset(computed_mac, 0, sizeof(computed_mac));

    if (mac_ok != 0) {
        return -1; /* MAC verification failed */
    }

    /* Decrypt payload (CTR mode: encrypt == decrypt) */
    xtea_ctr_crypt(ctx->key, nonce, msg->payload, decrypted, msg->payload_len);

    /* Deserialize into sensor reading struct */
    memcpy(reading, decrypted, sizeof(sensor_reading_t));

    memset(decrypted, 0, sizeof(decrypted));

    return 0;
}

/**
 * Encrypt arbitrary buffer (for generic payloads like config, commands).
 * Returns encrypted length or 0 on error.
 */
size_t iot_encrypt_buffer(iot_crypto_ctx_t *ctx,
                           const uint8_t *plaintext,
                           size_t plain_len,
                           uint8_t *output,
                           size_t output_max)
{
    uint32_t nonce;
    size_t required = NONCE_SIZE + 2 + plain_len + 4; /* nonce + len + data + mac */

    if (!ctx || !plaintext || !output || plain_len == 0) {
        return 0;
    }
    if (required > output_max) {
        return 0;
    }

    nonce = prng_next() ^ (++ctx->nonce_counter);

    /* Write nonce */
    output[0] = (uint8_t)(nonce);
    output[1] = (uint8_t)(nonce >> 8);
    output[2] = (uint8_t)(nonce >> 16);
    output[3] = (uint8_t)(nonce >> 24);

    /* Write length */
    output[4] = (uint8_t)(plain_len);
    output[5] = (uint8_t)(plain_len >> 8);

    /* Encrypt data */
    xtea_ctr_crypt(ctx->key, nonce, plaintext, output + NONCE_SIZE + 2, plain_len);

    /* Compute MAC over nonce + length + ciphertext */
    compute_mac(ctx->key, output, NONCE_SIZE + 2 + plain_len,
                output + NONCE_SIZE + 2 + plain_len);

    return required;
}

/**
 * Securely wipe the crypto context (call on decommission or key rotation).
 */
void iot_crypto_destroy(iot_crypto_ctx_t *ctx)
{
    volatile uint8_t *p = (volatile uint8_t *)ctx;
    size_t i;
    for (i = 0; i < sizeof(iot_crypto_ctx_t); i++) {
        p[i] = 0;
    }
}

/* ============== Example / Test Usage ============== */

#ifdef IOT_CRYPTO_TEST

#include <stdio.h>
#include <stdlib.h>

static void print_hex(const char *label, const uint8_t *data, size_t len)
{
    size_t i;
    printf("%s: ", label);
    for (i = 0; i < len; i++) {
        printf("%02X", data[i]);
    }
    printf("\n");
}

int main(void)
{
    iot_crypto_ctx_t tx_ctx, rx_ctx;
    iot_encrypted_msg_t encrypted_msg;
    sensor_reading_t original, decrypted;
    size_t msg_size;
    int result;

    /* Pre-shared key (would be provisioned securely in production) */
    const uint8_t psk[XTEA_KEY_SIZE] = {
        0x01, 0x23, 0x45, 0x67, 0x89, 0xAB, 0xCD, 0xEF,
        0xFE, 0xDC, 0xBA, 0x98, 0x76, 0x54, 0x32, 0x10
    };

    /* Initialize both sender and receiver contexts with same key */
    iot_crypto_init(&tx_ctx, psk, 0xDEADBEEF);
    iot_crypto_init(&rx_ctx, psk, 0xDEADBEEF);
    /* Sync nonce counters in real system via handshake */
    rx_ctx.nonce_counter = tx_ctx.nonce_counter;

    /* Create a sample sensor reading */
    original.sensor_id = 0x0042;
    original.sensor_type = 0x0001; /* Temperature */
    original.value = 2350;         /* 23.50 degrees C */
    original.battery_mv = 3300;
    original.timestamp_offset = 120;

    printf("=== IoT Lightweight Encryption Test ===\n\n");

    printf("Original sensor data:\n");
    printf("  Sensor ID: 0x%04X\n", original.sensor_id);
    printf("  Type:      0x%04X\n", original.sensor_type);
    printf("  Value:     %d\n", original.value);
    printf("  Battery:   %d mV\n", original.battery_mv);
    printf("  Timestamp: %d sec\n\n", original.timestamp_offset);

    /* Encrypt */
    msg_size = iot_encrypt_sensor_data(&tx_ctx, &original, &encrypted_msg);
    if (msg_size == 0) {
        printf("ERROR: Encryption failed!\n");
        return 1;
    }

    printf("Encrypted message (%zu bytes total):\n", msg_size);
    print_hex("  Nonce", encrypted_msg.nonce, NONCE_SIZE);
    printf("  Payload len: %u\n", encrypted_msg.payload_len);
    printf("  Message ID:  %u\n", encrypted_msg.message_id);
    print_hex("  Ciphertext", encrypted_msg.payload, encrypted_msg.payload_len);
    print_hex("  MAC", encrypted_msg.mac, 4);
    printf("\n");

    /* Decrypt and verify */
    result = iot_decrypt_sensor_data(&rx_ctx, &encrypted_msg, &decrypted);
    if (result == 0) {
        printf("Decryption and MAC verification: SUCCESS\n\n");
        printf("Decrypted sensor data:\n");
        printf("  Sensor ID: 0x%04X\n", decrypted.sensor_id);
        printf("  Type:      0x%04X\n", decrypted.sensor_type);
        printf("  Value:     %d\n", decrypted.value);
        printf("  Battery:   %d mV\n", decrypted.battery_mv);
        printf("  Timestamp: %d sec\n\n", decrypted.timestamp_offset);

        /* Verify data integrity */
        if (memcmp(&original, &decrypted, sizeof(sensor_reading_t)) == 0) {
            printf("Data integrity check: PASSED\n");
        } else {
            printf("Data integrity check: FAILED\n");
            return 1;
        }
    } else if (result == -1) {
        printf("Decryption FAILED: MAC verification error\n");
        return 1;
    } else {
        printf("Decryption FAILED: error code %d\n", result);
        return 1;
    }

    /* Test tamper detection */
    printf("\n=== Tamper Detection Test ===\n");
    encrypted_msg.payload[0] ^= 0xFF; /* Flip bits in ciphertext */
    result = iot_decrypt_sensor_data(&rx_ctx, &encrypted_msg, &decrypted);
    if (result == -1) {
        printf("Tampered message correctly rejected (MAC mismatch)\n");
    } else {
        printf("ERROR: Tampered message was not detected!\n");
        return 1;
    }

    /* Test generic buffer encryption */
    printf("\n=== Generic Buffer Encryption Test ===\n");
    {
        const char *test_str = "Hello Cloud!";
        uint8_t enc_buf[64];
        size_t enc_len;

        enc_len = iot_encrypt_buffer(&tx_ctx,
                                      (const uint8_t *)test_str,
                                      strlen(test_str),
                                      enc_buf,
                                      sizeof(enc_buf));
        if (enc_len > 0) {
            printf("Generic buffer encrypted: %zu bytes\n", enc_len);
            print_hex("  Encrypted", enc_buf, enc_len);
        } else {
            printf("Generic buffer encryption failed\n");
            return 1;
        }
    }

    /* Cleanup */
    iot_crypto_destroy(&tx_ctx);
    iot_crypto_destroy(&rx_ctx);

    printf("\nAll tests passed.\n");
    return 0;
}

#endif /* IOT_CRYPTO_TEST */