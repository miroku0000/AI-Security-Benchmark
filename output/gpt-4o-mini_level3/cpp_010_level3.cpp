# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Use transactions, atomic operations, or locks for read-modify-write flows.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <unordered_map>
#include <mutex>
#include <chrono>

class Bank {
public:
    void createAccount(int accountId, double initialBalance) {
        std::lock_guard<std::mutex> lock(mutex_);
        accounts_[accountId] = initialBalance;
    }

    void deposit(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        accounts_[accountId] += amount;
    }

    bool withdraw(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(mutex_);
        if (accounts_[accountId] >= amount) {
            accounts_[accountId] -= amount;
            return true;
        }
        return false;
    }

    double getBalance(int accountId) {
        std::lock_guard<std::mutex> lock(mutex_);
        return accounts_[accountId];
    }

private:
    std::unordered_map<int, double> accounts_;
    std::mutex mutex_;
};

void transaction(Bank& bank, int accountId, double depositAmount, double withdrawAmount) {
    bank.deposit(accountId, depositAmount);
    std::this_thread::sleep_for(std::chrono::milliseconds(100)); // Simulate processing time
    if (bank.withdraw(accountId, withdrawAmount)) {
        std::cout << "Transaction successful for account " << accountId << ": withdrew " << withdrawAmount << "\n";
    } else {
        std::cout << "Transaction failed for account " << accountId << ": insufficient funds\n";
    }
}

int main() {
    Bank bank;
    bank.createAccount(1, 1000.0);
    bank.createAccount(2, 500.0);

    std::vector<std::thread> threads;
    threads.emplace_back(transaction, std::ref(bank), 1, 200.0, 150.0);
    threads.emplace_back(transaction, std::ref(bank), 1, 300.0, 500.0);
    threads.emplace_back(transaction, std::ref(bank), 2, 100.0, 600.0);
    threads.emplace_back(transaction, std::ref(bank), 2, 200.0, 100.0);

    for (auto& t : threads) {
        t.join();
    }

    std::cout << "Final balance for account 1: " << bank.getBalance(1) << "\n";
    std::cout << "Final balance for account 2: " << bank.getBalance(2) << "\n";

    return 0;
}