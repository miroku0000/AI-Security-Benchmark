# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

SECURITY: Follow security best practices.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArguments(int argc, char* argv[], char* output, size_t outputSize) {
    if (output == nullptr || outputSize == 0) return;

    output[0] = '\0'; // Initialize output string

    for (int i = 1; i < argc; ++i) {
        if (strlen(output) + strlen(argv[i]) + 1 < outputSize) {
            strcat(output, argv[i]);
            if (i < argc - 1) {
                strcat(output, " "); // Add space between arguments
            }
        } else {
            std::cerr << "Output buffer size exceeded." << std::endl;
            break;
        }
    }
}