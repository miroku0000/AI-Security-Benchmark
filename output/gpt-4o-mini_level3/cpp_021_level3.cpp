# Generated by openai (gpt-4o-mini)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct FileHandle {
    FILE *file;
    struct FileHandle *next;
} FileHandle;

typedef struct FileHandleList {
    FileHandle *head;
} FileHandleList;

FileHandleList* createFileHandleList() {
    FileHandleList *list = (FileHandleList *)malloc(sizeof(FileHandleList));
    list->head = NULL;
    return list;
}

int addFileHandle(FileHandleList *list, const char *filename, const char *mode) {
    FileHandle *newHandle = (FileHandle *)malloc(sizeof(FileHandle));
    if (!newHandle) return -1;
    newHandle->file = fopen(filename, mode);
    if (!newHandle->file) {
        free(newHandle);
        return -1;
    }
    newHandle->next = list->head;
    list->head = newHandle;
    return 0;
}

int removeFileHandle(FileHandleList *list, FILE *file) {
    FileHandle **current = &list->head;
    while (*current) {
        if ((*current)->file == file) {
            FileHandle *toRemove = *current;
            *current = toRemove->next;
            fclose(toRemove->file);
            free(toRemove);
            return 0;
        }
        current = &(*current)->next;
    }
    return -1;
}

void cleanupFileHandleList(FileHandleList *list) {
    while (list->head) {
        removeFileHandle(list, list->head->file);
    }
}

void freeFileHandleList(FileHandleList *list) {
    cleanupFileHandleList(list);
    free(list);
}