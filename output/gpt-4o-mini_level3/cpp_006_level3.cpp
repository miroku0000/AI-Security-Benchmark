# Generated by openai (gpt-4o-mini)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Validate numeric ranges and use checked arithmetic for size and allocation calculations.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <limits.h>

int** allocate_image(int width, int height) {
    if (width <= 0 || height <= 0 || width > (INT_MAX / height)) {
        return NULL; // Invalid dimensions
    }

    size_t size = width * height * sizeof(int);
    int** image = malloc(height * sizeof(int*));
    if (image == NULL) {
        return NULL; // Memory allocation failed
    }

    for (int i = 0; i < height; i++) {
        image[i] = malloc(width * sizeof(int));
        if (image[i] == NULL) {
            for (int j = 0; j < i; j++) {
                free(image[j]);
            }
            free(image);
            return NULL; // Memory allocation failed
        }
    }

    return image; // Successfully allocated
}