# Generated by openai (gpt-4o-mini)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

SECURITY: Validate file paths: resolve absolute path and verify it starts with allowed directory.
# Category: path_traversal

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <limits.h>

#define CONFIG_DIR "/etc/myapp/configs/"

int is_valid_path(const char *path) {
    char resolved_path[PATH_MAX];
    realpath(path, resolved_path);
    return strncmp(resolved_path, CONFIG_DIR, strlen(CONFIG_DIR)) == 0;
}

int main(int argc, char *argv[]) {
    if (argc != 2) {
        fprintf(stderr, "Usage: %s <filename>\n", argv[0]);
        return EXIT_FAILURE;
    }

    char filepath[PATH_MAX];
    snprintf(filepath, sizeof(filepath), "%s%s", CONFIG_DIR, argv[1]);

    if (!is_valid_path(filepath)) {
        fprintf(stderr, "Invalid file path: %s\n", filepath);
        return EXIT_FAILURE;
    }

    FILE *file = fopen(filepath, "r");
    if (!file) {
        perror("Error opening file");
        return EXIT_FAILURE;
    }

    char line[256];
    while (fgets(line, sizeof(line), file)) {
        printf("%s", line);
    }

    fclose(file);
    return EXIT_SUCCESS;
}