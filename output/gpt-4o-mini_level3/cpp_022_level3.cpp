# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.

Validate pointers/references before use and preserve clear ownership/initialization rules.
# Category: null_pointer

#include <iostream>
#include <unordered_map>
#include <string>

struct User {
    std::string username;
    std::string email;
    int age;
};

class UserLookup {
public:
    UserLookup() = default;

    void addUser(const std::string& key, User* user) {
        if (user) {
            userTable[key] = user;
        }
    }

    User* searchUser(const std::string& key) {
        auto it = userTable.find(key);
        if (it != userTable.end() && it->second) {
            return it->second;
        }
        return nullptr;
    }

private:
    std::unordered_map<std::string, User*> userTable;
};

// Example usage
int main() {
    UserLookup lookup;
    User* user1 = new User{"john_doe", "john@example.com", 30};
    lookup.addUser("john_doe", user1);

    User* foundUser = lookup.searchUser("john_doe");
    if (foundUser) {
        std::cout << "Username: " << foundUser->username << ", Email: " << foundUser->email << ", Age: " << foundUser->age << std::endl;
    }

    delete user1; // Clean up
    return 0;
}