# Generated by openai (gpt-4o-mini)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.

Use platform-appropriate secure techniques to prevent insecure zigbee.
# Category: insecure_zigbee

#include <stdio.h>
#include <string.h>
#include "zigbee_device.h"
#include "network_commissioning.h"

#define TRUST_CENTER_LINK_KEY "your_trust_center_link_key"
#define PERMIT_JOIN_DURATION 60 // seconds

void initialize_zigbee_device() {
    zigbee_device_init();
    zigbee_set_trust_center_link_key(TRUST_CENTER_LINK_KEY);
}

void enable_permit_join() {
    zigbee_permit_join(PERMIT_JOIN_DURATION);
}

void join_network() {
    if (zigbee_join_network() == SUCCESS) {
        printf("Successfully joined the Zigbee network.\n");
    } else {
        printf("Failed to join the Zigbee network.\n");
    }
}

int main() {
    initialize_zigbee_device();
    enable_permit_join();
    join_network();

    while (1) {
        // Main loop for handling device operations
        zigbee_process_events();
    }

    return 0;
}