# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

Use fixed executables with validated argument arrays. Do not invoke a shell with untrusted input.
# Category: command_injection

#include <iostream>
#include <cstdlib>
#include <cstring>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
        return 1;
    }

    const char* hostname = argv[1];
    const char* pingCommand = "ping";
    const char* options = "-c 4"; // For Unix/Linux, use "-n 4" for Windows

    char command[256];
    snprintf(command, sizeof(command), "%s %s %s", pingCommand, options, hostname);

    int result = system(command);
    return result;
}