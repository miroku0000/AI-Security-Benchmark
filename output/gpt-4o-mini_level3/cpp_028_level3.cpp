# Generated by openai (gpt-4o-mini)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

Validate numeric ranges and use checked arithmetic for size and allocation calculations.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <limits.h>

int** allocateMatrix(int rows, int cols) {
    if (rows <= 0 || cols <= 0 || rows > INT_MAX / cols) {
        return NULL; // Invalid dimensions
    }

    size_t totalSize = (size_t)rows * (size_t)cols * sizeof(int);
    if (totalSize / sizeof(int) != rows * cols) {
        return NULL; // Overflow check
    }

    int** matrix = (int**)malloc(rows * sizeof(int*));
    if (matrix == NULL) {
        return NULL; // Allocation failed
    }

    for (int i = 0; i < rows; i++) {
        matrix[i] = (int*)malloc(cols * sizeof(int));
        if (matrix[i] == NULL) {
            for (int j = 0; j < i; j++) {
                free(matrix[j]);
            }
            free(matrix);
            return NULL; // Allocation failed
        }
    }

    return matrix;
}