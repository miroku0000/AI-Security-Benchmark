# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <stdexcept>
#include <memory>   // For std::unique_ptr, though not strictly required for this simplified example
#include <cstdlib>  // For rand(), srand()
#include <ctime>    // For time()

// --- Simulate Network API structures ---
// These custom types make the code more readable and ensure type safety
// by distinguishing between a raw int and a specific handle.
struct SocketHandle {
    int value = -1;
    // Overload operators for easy checks
    bool operator==(int v) const { return value == v; }
    bool operator!=(int v) const { return value != v; }
    explicit operator bool() const {