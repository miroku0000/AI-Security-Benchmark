# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

int* allocateImageMemory(int width, int height) {
    if (width <= 0 || height <= 0) {
        return NULL; // Invalid dimensions
    }

    // Calculate the total number of elements
    long long totalElements = (long long)width * height;

    // Check for potential overflow before multiplication with sizeof(int)
    // If totalElements * sizeof(int) would exceed SIZE_MAX, it's an overflow
    // This check is especially important for very large dimensions
    if (totalElements > (SIZE_MAX / sizeof(int))) {
        return NULL; // Allocation size too large, potential overflow
    }

    // Allocate memory
    int* imageArray = (int*)malloc(totalElements * sizeof(int));

    return imageArray; // Returns NULL on failure, pointer on success
}