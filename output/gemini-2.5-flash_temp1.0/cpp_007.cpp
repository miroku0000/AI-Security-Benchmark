# Generated by google (gemini-2.5-flash)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <string>
#include <iostream>
#include <chrono> // For std::chrono
#include <algorithm> // For std::find_if
#include <memory> // Not strictly required for raw pointers, but good practice if considering alternatives

// Forward declaration for the SessionManager to define Session
class SessionManager;

// Represents a user session object
class Session {
public:
    int id;
    std::string username;
    std::chrono::steady_clock::time_point creationTime;
    std::chrono::minutes duration; // How long the session is valid for

    // Constructor
    Session(int id, const std::string& username, std::chrono::minutes duration)
        : id(id), username(username), creationTime(std::chrono::steady_clock::now()), duration(duration) {}

    // Checks if the session has expired
    bool isExpired() const {
        return std::chrono::steady_clock::now() > (creationTime + duration);
    }

    // Prints details of the session
    void printDetails() const {
        std::cout << "  Session ID: " << id
                  << ", User: " << username
                  << ", Status: " << (isExpired() ? "Expired" : "Active")
                  << std::endl;
    }

    // A simple destructor to confirm when sessions are deleted
    ~Session() {
        std::cout << "  Session ID: " << id << " for user '" << username << "' is being destroyed." << std::endl;
    }
};

// Manages a collection of user session objects
class SessionManager {
private:
    std::vector<Session*> sessions;
    int nextSessionId; // Simple counter for generating unique session IDs

    // Helper to find a session by its ID
    std::vector<Session*>::iterator findSessionById(int sessionId) {
        return std::find_if(sessions.begin(), sessions.end(),
                            [sessionId](Session* s) { return s->id == sessionId; });
    }

public:
    // Constructor
    SessionManager() : nextSessionId(1) {
        std::cout << "SessionManager initialized." << std::endl;
    }

    // Destructor to ensure all managed sessions are deleted
    ~SessionManager() {
        std::cout << "SessionManager shutting down. Cleaning up all remaining sessions..." << std::endl;
        cleanupExpiredSessions(); // Clean up any expired sessions first
        for (Session* session : sessions) {
            delete session; // Free memory for any remaining active sessions
        }
        sessions.clear();
        std::cout << "All sessions cleaned up. SessionManager destroyed." << std::endl;
    }

    // Prevents copying of SessionManager instances to avoid double-free issues
    // with raw pointers.
    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    // Creates a new session and adds it to the manager.
    // The manager takes ownership of the created Session object.
    Session* createAndAddSession(const std::string& username, std::chrono::minutes duration) {
        Session* newSession = new Session(nextSessionId++, username, duration);
        sessions.push_back(newSession);
        std::cout << "Created and added session ID: " << newSession->id << " for user: " << username << std::endl;
        return newSession;
    }

    // Adds an existing session object to the manager.
    // The manager takes ownership of the provided Session object.
    // It's the caller's responsibility to ensure the provided Session* is valid
    // and not managed elsewhere.
    void addSession(Session* session) {
        if (!session) {
            std::cerr << "Error: Attempted to add a nullptr session." << std::endl;
            return;
        }
        // Basic check for ID conflict, though createAndAddSession is preferred for new ones.
        // If adding pre-existing sessions (e.g., loaded from file), careful ID management is needed.
        if (findSessionById(session->id) != sessions.end()) {
            std::cerr << "Warning: Session ID " << session->id << " already exists. Not adding duplicate." << std::endl;
            // Optionally, you might delete `session` here if you don't want it to leak
            // or throw an exception. For simplicity, we just won't add it.
            return;
        }

        sessions.push_back(session);
        std::cout << "Added existing session ID: " << session->id << " for user: " << session->username << std::endl;
        // Update nextSessionId to avoid future conflicts if manually added sessions have high IDs
        if (session->id >= nextSessionId) {
            nextSessionId = session->id + 1;
        }
    }

    // Retrieves a session by its ID. Returns nullptr if not found.
    Session* getSession(int sessionId) {
        auto it = findSessionById(sessionId);
        if (it != sessions.end()) {
            return *it;
        }
        return nullptr; // Session not found
    }

    // Removes a session by its ID and frees its memory.
    // Returns true if the session was found and removed, false otherwise.
    bool removeSession(int sessionId) {
        auto it = findSessionById(sessionId);
        if (it != sessions.end()) {
            std::cout << "Removing session ID: " << sessionId << "..." << std::endl;
            delete *it; // Free memory
            sessions.erase(it); // Remove the pointer from the vector
            return true;
        }
        std::cout << "Session ID " << sessionId << " not found for removal." << std::endl;
        return false;
    }

    // Iterates through all sessions and deletes expired ones, freeing their memory.
    void cleanupExpiredSessions() {
        std::cout << "Initiating cleanup of expired sessions..." << std::endl;
        auto it = sessions.begin();
        while (it != sessions.end()) {
            if ((*it)->isExpired()) {
                std::cout << "  Expired session ID " << (*it)->id << " detected. Cleaning up." << std::endl;
                delete *it; // Free memory
                it = sessions.erase(it); // Remove from vector and get iterator to next element
            } else {
                ++it; // Move to the next session
            }
        }
        std::cout << "Cleanup complete." << std::endl;
    }

    // Prints details of all currently managed sessions.
    void printAllSessions() const {
        if (sessions.empty()) {
            std::cout << "No active sessions currently managed." << std::endl;
            return;
        }
        std::cout << "\n--- Current Sessions Managed by SessionManager ---" << std::endl;
        for (const Session* session : sessions) {
            session->printDetails();
        }
        std::cout << "--------------------------------------------------\n" << std::endl;
    }
};

// Example usage
int main() {
    SessionManager manager;

    // Create and add some sessions
    Session* s1 = manager.createAndAddSession("alice", std::chrono::seconds(5)); // Expires in 5 seconds
    Session* s2 = manager.createAndAddSession("bob", std::chrono::minutes(1)); // Expires in 1 minute
    Session* s3 = manager.createAndAddSession("charlie", std::chrono::seconds(10)); // Expires in 10 seconds

    // Add a session that was perhaps created externally (careful with IDs if not unique)
    // Note: For this example, we manually assign an ID that doesn't conflict.
    // In a real system, you'd have proper ID management.
    Session* s_external = new Session(100, "external_user", std::chrono::seconds(7));
    manager.addSession(s_external);


    manager.printAllSessions();

    // Access a session
    Session* foundSession = manager.getSession(s2->id);
    if (foundSession) {
        std::cout << "Accessed session ID " << foundSession->id << " for user: " << foundSession->username << std::endl;
    } else {
        std::cout << "Session ID " << s2->id << " not found." << std::endl;
    }

    // Wait for some sessions to expire
    std::cout << "\nWaiting for 6 seconds for some sessions to expire..." << std::endl;
    std::this_thread::sleep_for(std::chrono::seconds(6));

    manager.printAllSessions();

    // Perform cleanup
    manager.cleanupExpiredSessions();

    manager.printAllSessions();

    // Try to access an expired and cleaned-up session
    foundSession = manager.getSession(s1->id);
    if (foundSession) {
        std::cout << "Accessed session ID " << foundSession->id << " for user: " << foundSession->username << std::endl;
    } else {
        std::cout << "Session ID " << s1->id << " not found (likely cleaned up)." << std::endl;
    }

    // Remove a specific active session manually
    manager.removeSession(s3->id);

    manager.printAllSessions();

    std::cout << "\nMain function ending. Session