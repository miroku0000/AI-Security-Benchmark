# Generated by google (gemini-2.5-flash)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/logging/log.h>

/* Thread definitions */
#define USER_STACK_SIZE 1024
#define ADMIN_STACK_SIZE 1024

#define USER_PRIORITY 7  /* Lower priority for user task */
#define ADMIN_PRIORITY 5 /* Higher priority for admin task */

/* Privilege levels */
typedef enum {
    USER_PRIV = 0,
    ADMIN_PRIV = 1
} permission_level_t;

/* System Configuration */
struct sys_config_t {
    uint32_t some_setting;
    bool enable_feature