# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>  // For file operations (fopen, fclose, fseek, ftell, fread)
#include <stdlib.h> // For memory allocation (malloc, free)

char* readConfigFile(const char* filePath, size_t* outSize) {
    FILE* file = NULL;
    char* buffer = NULL;
    long fileSize = 0;
    size_t readBytes = 0;

    // Initialize outSize to 0 in case of early exit or failure
    if (outSize != NULL) {
        *outSize = 0;
    }

    // Basic input validation
    if (filePath == NULL || outSize == NULL) {
        return NULL;
    }

    // Open the file in binary read mode ('rb') for accurate size determination
    file = fopen(filePath, "rb");
    if (file == NULL) {
        return NULL; // File could not be opened
    }

    // Seek to the end of the file to determine its size
    if (fseek(file, 0, SEEK_END) != 0) {
        fclose(file);
        return NULL; // Failed to seek
    }

    // Get the current position, which represents the file size
    fileSize = ftell(file);
    if (fileSize == -1) { // ftell returns -1 on error
        fclose(file);
        return NULL; // Failed to get file size
    }

    // Rewind to the beginning of the file for reading
    if (fseek(file, 0, SEEK_SET) != 0) {
        fclose(file);
        return NULL; // Failed to rewind
    }

    // Allocate memory for the file content plus one byte for a null terminator.
    // The null terminator makes the buffer compatible with string functions if the
    // configuration file contains text, even if it's treated as raw bytes.
    buffer = (char*)malloc((size_t)fileSize + 1);
    if (buffer == NULL) {
        fclose(file);
        return NULL; // Memory allocation failed
    }

    // Read the file content into the allocated buffer
    readBytes = fread(buffer, 1, (size_t)fileSize, file);
    if (readBytes != (size_t)fileSize) {
        // If the number of bytes read does not match the file size, an error occurred
        free(buffer); // Free partially allocated memory
        fclose(file);
        return NULL;
    }

    // Null-terminate the buffer. This is crucial if the content is to be treated as a string.
    buffer[readBytes] = '\0';

    // Store the actual size of the data read (excluding the null terminator)
    *outSize = readBytes;

    // Close the file
    fclose(file);

    return buffer; // Return the pointer to the dynamically allocated buffer
}