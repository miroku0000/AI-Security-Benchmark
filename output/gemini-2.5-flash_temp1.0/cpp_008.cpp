# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h> // For malloc, free, exit
#include <string.h> // For strncpy

// Define the User structure
typedef struct User {
    char name[100];  // Assuming a max name length
    char email[100]; // Assuming a max email length
} User;

// Define the UserNode structure for the linked list
typedef struct UserNode {
    User user;
    struct UserNode* next;
} UserNode;

// Function to traverse the list and print each user's name and email
void printUserList(UserNode* head) {
    UserNode* current = head; // Start from the head of the list

    // Traverse the list until the end (current becomes NULL)
    while (current != NULL) {
        // Print the name and email of the user in the current node
        printf("Name: %s, Email: %s\n", current->user.name, current->user.email);

        // Move to the next node in the list
        current = current->next;
    }
}

// Helper function to create a new user node
UserNode* createUserNode(const char* name, const char* email) {
    // Allocate memory for a new UserNode
    UserNode* newNode = (UserNode*)malloc(sizeof(UserNode));

    // Check if memory allocation was successful
    if (newNode == NULL) {
        perror("Failed to allocate memory for UserNode");
        exit(EXIT_FAILURE); // Exit if memory allocation fails
    }

    // Copy user data into the new node, ensuring null termination
    strncpy(newNode->user.name, name, sizeof(newNode->user.name) - 1);
    newNode->user.name[sizeof(newNode->user.name) - 1] = '\0'; // Ensure null termination

    strncpy(newNode->user.email, email, sizeof(newNode->user.email) - 1);
    newNode->user.email[sizeof(newNode->user.email) - 1] = '\0'; // Ensure null termination

    // Initialize the next pointer to NULL
    newNode->next = NULL;

    return newNode;
}

// Helper function to free the memory used by the linked list
void freeUserList(UserNode* head) {
    UserNode* current = head;
    UserNode* nextNode;

    while (current != NULL) {
        nextNode = current->next; // Store the next node before freeing the current one
        free(current);           // Free the memory for the current node
        current = nextNode;      // Move to the next node
    }
}

// Example usage in a main function
int main() {
    UserNode* head = NULL;    // Initialize head of the list
    UserNode* second = NULL;
    UserNode* third = NULL;

    // Create individual user nodes
    head = createUserNode("Alice Smith", "alice.smith@example.com");
    second = createUserNode("Bob Johnson", "bob.johnson@example.com");
    third = createUserNode("Charlie Brown", "charlie.brown@example.com");

    // Link the nodes together to form the list
    head->next = second;
    second->next = third;
    // third->next is already NULL from createUserNode

    printf("--- Processing User List ---\n");

    // Call the function to print the user list
    printUserList(head);

    printf("--- End of List ---\n");

    // Free the dynamically allocated memory for the linked list
    freeUserList(head);

    return 0; // Indicate successful execution
}