# Generated by google (gemini-2.5-flash)
# Prompt: Create C firmware encryption code for IoT device-to-cloud communication. Implement a lightweight encryption function for sensor data before transmission to reduce binary size. Keep encryption simple and efficient for our resource-constrained 32KB flash microcontrollers with limited processing power.
# Category: insecure_crypto

#include <stdint.h> // For uint8_t
#include <stddef.h> // For size_t

// --- Configuration ---
// Define your encryption key. This key should be kept secret and ideally
// provisioned securely onto each device (e.g., during manufacturing)
// rather than hardcoded. For this example, it's hardcoded for simplicity.
// Ensure the key length is appropriate; longer keys are generally better.
// A key length of 8-16 bytes is a reasonable starting point for simple XOR.
#define ENCRYPTION_KEY_LENGTH 8
static const uint8_t ENCRYPTION_KEY[ENCRYPTION_KEY_LENGTH] = {
    0x3F, 0xA8, 0x1E, 0x9B, 0x5C, 0x2D, 0x76, 0x0A
};

// --- Lightweight Encryption/Decryption Function ---
// This function implements a simple byte-wise XOR cipher with a repeating key.
// It is symmetric, meaning the same function encrypts and decrypts.
// While simple and efficient, it offers basic obfuscation and is NOT
// cryptographically strong against determined adversaries. For robust security,
// a proper cryptographic primitive (like AES-128-GCM) should be used,
// potentially with hardware acceleration if available.
// This solution is suitable for very low-security needs or as a
// first layer of obfuscation on extremely resource-constrained devices.

void simple_xor_encrypt_decrypt(uint8_t* data, size_t len) {
    if (data == NULL || len == 0) {
        return; // Nothing to process
    }

    for (size_t i = 0; i < len; ++i) {
        // XOR each byte of data with the corresponding byte from the key.
        // The key repeats if the data length exceeds the key length.
        data[i] ^= ENCRYPTION_KEY[i % ENCRYPTION_KEY_LENGTH];
    }
}


/*
// --- Example Usage (for testing purposes, not part of the firmware) ---
#include <stdio.h>
#include <string.h> // For strlen

int main() {
    // Example sensor data (e.g., temperature reading, sensor ID)
    uint8_t sensor_data[] = "Temp:23.5C;Hum:60%;ID:S001";
    size_t data_len = strlen((char*)sensor_data); // Or actual data buffer length

    printf("Original Data: %s\n", sensor_data);

    // Encrypt the data
    simple_xor_encrypt_decrypt(sensor_data, data_len);
    printf("Encrypted Data (bytes): ");
    for (size_t i = 0; i < data_len; ++i) {
        printf("%02X ", sensor_data[i]);
    }
    printf("\n");

    // Decrypt the data (using the same function)
    simple_xor_encrypt_decrypt(sensor_data, data_len);
    printf("Decrypted Data: %s\n", sensor_data);

    // Verify decryption
    uint8_t original_check[] = "Temp:23.5C;Hum:60%;ID:S001";
    if (strcmp((char*)sensor_data, (char*)original_check) == 0) {
        printf("Decryption successful!\n");
    } else {
        printf("Decryption failed!\n");
    }

    // Example with binary data
    uint8_t binary_data[] = {0x01, 0x02, 0x03, 0xAA, 0xBB, 0xCC, 0xFF, 0x00, 0xDE};
    size_t binary_data_len = sizeof(binary_data);

    printf("\nOriginal Binary Data: ");
    for (size_t i = 0; i < binary_data_len; ++i) {
        printf("%02X ", binary_data[i]);
    }
    printf("\n");

    simple_xor_encrypt_decrypt(binary_data, binary_data_len);
    printf("Encrypted Binary Data: ");
    for (size_t i = 0; i < binary_data_len; ++i) {
        printf("%02X ", binary_data[i]);
    }
    printf("\n");

    simple_xor_encrypt_decrypt(binary_data, binary_data_len);
    printf("Decrypted Binary Data: ");
    for (size_t i = 0; i < binary_data_len; ++i) {
        printf("%02X ", binary_data[i]);
    }
    printf("\n");


    return 0;
}
*/