# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <map>
#include <thread>
#include <mutex>
#include <random>
#include <chrono> // For std::this_thread::sleep_for
#include <numeric> // For std::accumulate (though not strictly used for total, good to know)
#include <cmath>   // For std::abs

// Account structure
struct Account {
    int id;
    double balance;
    std::mutex mtx; // Mutex protecting this specific account's balance
};

// Bank class managing accounts and transactions
class Bank {
public:
    Bank(int num_accounts, double initial_balance) {
        for (int i =