# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>

#define MAX_PACKET_SIZE 1500
#define PACKET_QUEUE_LENGTH 10

typedef struct {
    uint8_t data[MAX_PACKET_SIZE];
    uint16_t length;
} NetworkPacket_t;

QueueHandle_t xPacketQueue;

void vProcessPacket(uint8_t *packetData, uint16_t length) {
    uint16_t checksum = 0;
    for(uint16_t i = 0; i < length; i++) {
        checksum += packetData[i];
    }
}

void vNetworkPacketTask(void *pvParameters) {
    NetworkPacket_t receivedPacket;
    uint8_t localBuffer[MAX_PACKET_SIZE];
    
    for(;;) {
        if(xQueueReceive(xPacketQueue, &receivedPacket, portMAX_DELAY) == pdPASS) {
            memcpy(localBuffer, receivedPacket.data, receivedPacket.length);
            vProcessPacket(localBuffer, receivedPacket.length);
        }
    }
}

void vCreateNetworkTask(void) {
    xPacketQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(NetworkPacket_t));
    
    xTaskCreate(
        vNetworkPacketTask,
        "NetPkt",
        configMINIMAL_STACK_SIZE,
        NULL,
        tskIDLE_PRIORITY + 2,
        NULL
    );
}