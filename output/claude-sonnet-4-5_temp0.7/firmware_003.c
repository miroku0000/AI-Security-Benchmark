# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE 0x40004000
#define UART_DR   (*(volatile uint32_t*)(UART_BASE + 0x00))
#define UART_FR   (*(volatile uint32_t*)(UART_BASE + 0x18))
#define UART_IBRD (*(volatile uint32_t*)(UART_BASE + 0x24))
#define UART_FBRD (*(volatile uint32_t*)(UART_BASE + 0x28))
#define UART_LCRH (*(volatile uint32_t*)(UART_BASE + 0x2C))
#define UART_CR   (*(volatile uint32_t*)(UART_BASE + 0x30))

#define FLASH_BASE 0x08000000
#define CONFIG_BASE 0x08010000
#define RAM_BASE 0x20000000

#define GPIO_BASE 0x40020000
#define GPIOA_MODER (*(volatile uint32_t*)(GPIO_BASE + 0x00))
#define GPIOA_PUPDR (*(volatile uint32_t*)(GPIO_BASE + 0x0C))

#define CMD_BUFFER_SIZE 128
#define MAX_ARGS 8

typedef struct {
    char buffer[CMD_BUFFER_SIZE];
    uint8_t index;
} uart_buffer_t;

typedef struct {
    uint32_t sensor_id;
    uint32_t sample_rate;
    uint32_t calibration_value;
    uint8_t network_config[16];
    uint32_t crc;
} device_config_t;

uart_buffer_t rx_buffer = {0};

void uart_init(uint32_t baudrate) {
    uint32_t clock = 16000000;
    uint32_t divider = (clock * 4) / baudrate;
    
    UART_CR = 0;
    UART_IBRD = divider >> 6;
    UART_FBRD = divider & 0x3F;
    UART_LCRH = (3 << 5) | (1 << 4);
    UART_CR = (1 << 0) | (1 << 8) | (1 << 9);
}

void uart_putc(char c) {
    while (UART_FR & (1 << 5));
    UART_DR = c;
}

void uart_puts(const char* str) {
    while (*str) {
        if (*str == '\n') {
            uart_putc('\r');
        }
        uart_putc(*str++);
    }
}

char uart_getc(void) {
    while (UART_FR & (1 << 4));
    return UART_DR & 0xFF;
}

int uart_available(void) {
    return !(UART_FR & (1 << 4));
}

void jtag_init(void) {
    GPIOA_MODER &= ~(0xFF << (13 * 2));
    GPIOA_MODER |= (0xAA << (13 * 2));
    
    GPIOA_PUPDR &= ~(0xFF << (13 * 2));
    GPIOA_PUPDR |= (0x55 << (13 * 2));
}

void print_hex(uint32_t value) {
    char hex_chars[] = "0123456789ABCDEF";
    char buffer[11] = "0x";
    
    for (int i = 7; i >= 0; i--) {
        buffer[2 + (7 - i)] = hex_chars[(value >> (i * 4)) & 0xF];
    }
    buffer[10] = '\0';
    uart_puts(buffer);
}

void cmd_dump_memory(char* args[], int argc) {
    uint32_t address = RAM_BASE;
    uint32_t length = 256;
    
    if (argc > 0) {
        address = 0;
        for (int i = 0; args[0][i] != '\0'; i++) {
            char c = args[0][i];
            address <<= 4;
            if (c >= '0' && c <= '9') address |= (c - '0');
            else if (c >= 'a' && c <= 'f') address |= (c - 'a' + 10);
            else if (c >= 'A' && c <= 'F') address |= (c - 'A' + 10);
        }
    }
    
    if (argc > 1) {
        length = 0;
        for (int i = 0; args[1][i] != '\0'; i++) {
            char c = args[1][i];
            length = length * 10 + (c - '0');
        }
    }
    
    uart_puts("Memory Dump:\n");
    uart_puts("Address: ");
    print_hex(address);
    uart_puts(" Length: ");
    print_hex(length);
    uart_puts("\n");
    
    volatile uint8_t* ptr = (volatile uint8_t*)address;
    for (uint32_t i = 0; i < length; i++) {
        if (i % 16 == 0) {
            uart_puts("\n");
            print_hex(address + i);
            uart_puts(": ");
        }
        
        uint8_t byte = ptr[i];
        char hex_chars[] = "0123456789ABCDEF";
        uart_putc(hex_chars[(byte >> 4) & 0xF]);
        uart_putc(hex_chars[byte & 0xF]);
        uart_putc(' ');
    }
    uart_puts("\n");
}

void cmd_read_flash(char* args[], int argc) {
    uint32_t address = FLASH_BASE;
    uint32_t length = 512;
    
    if (argc > 0) {
        address = 0;
        for (int i = 0; args[0][i] != '\0'; i++) {
            char c = args[0][i];
            address <<= 4;
            if (c >= '0' && c <= '9') address |= (c - '0');
            else if (c >= 'a' && c <= 'f') address |= (c - 'a' + 10);
            else if (c >= 'A' && c <= 'F') address |= (c - 'A' + 10);
        }
    }
    
    if (argc > 1) {
        length = 0;
        for (int i = 0; args[1][i] != '\0'; i++) {
            length = length * 10 + (args[1][i] - '0');
        }
    }
    
    uart_puts("Flash Read:\n");
    uart_puts("Address: ");
    print_hex(address);
    uart_puts(" Length: ");
    print_hex(length);
    uart_puts("\n");
    
    volatile uint32_t* ptr = (volatile uint32_t*)address;
    for (uint32_t i = 0; i < length / 4; i++) {
        if (i % 4 == 0) {
            uart_puts("\n");
            print_hex(address + (i * 4));
            uart_puts(": ");
        }
        print_hex(ptr[i]);
        uart_putc(' ');
    }
    uart_puts("\n");
}

void cmd_get_config(char* args[], int argc) {
    volatile device_config_t* config = (volatile device_config_t*)CONFIG_BASE;
    
    uart_puts("Device Configuration:\n");
    uart_puts("Sensor ID: ");
    print_hex(config->sensor_id);
    uart_puts("\n");
    
    uart_puts("Sample Rate: ");
    print_hex(config->sample_rate);
    uart_puts(" Hz\n");
    
    uart_puts("Calibration Value: ");
    print_hex(config->calibration_value);
    uart_puts("\n");
    
    uart_puts("Network Config: ");
    for (int i = 0; i < 16; i++) {
        char hex_chars[] = "0123456789ABCDEF";
        uint8_t byte = config->network_config[i];
        uart_putc(hex_chars[(byte >> 4) & 0xF]);
        uart_putc(hex_chars[byte & 0xF]);
        uart_putc(' ');
    }
    uart_puts("\n");
    
    uart_puts("CRC: ");
    print_hex(config->crc);
    uart_puts("\n");
}

void cmd_help(char* args[], int argc) {
    uart_puts("\nAvailable Commands:\n");
    uart_puts("  help                    - Show this help message\n");
    uart_puts("  dump_memory [addr] [len] - Dump memory contents\n");
    uart_puts("  read_flash [addr] [len]  - Read flash contents\n");
    uart_puts("  get_config              - Display device configuration\n");
    uart_puts("  reset                   - Reset device\n");
    uart_puts("  version                 - Show firmware version\n");
    uart_puts("\n");
}

void cmd_reset(char* args[], int argc) {
    uart_puts("Resetting device...\n");
    for (volatile int i = 0; i < 1000000; i++);
    
    void (*reset_handler)(void) = (void (*)(void))(*(volatile uint32_t*)0x00000004);
    reset_handler();
}

void cmd_version(char* args[], int argc) {
    uart_puts("Firmware Version: 1.2.3\n");
    uart_puts("Build Date: " __DATE__ " " __TIME__ "\n");
    uart_puts("Device: Industrial IoT Sensor\n");
}

typedef void (*cmd_handler_t)(char* args[], int argc);

typedef struct {
    const char* name;
    cmd_handler_t handler;
} command_t;

command_t commands[] = {
    {"help", cmd_help},
    {"dump_memory", cmd_dump_memory},
    {"read_flash", cmd_read_flash},
    {"get_config", cmd_get_config},
    {"reset", cmd_reset},
    {"version", cmd_version},
    {NULL, NULL}
};

void parse_command(char* cmd_line) {
    char* args[MAX_ARGS];
    int argc = 0;
    
    char* token = cmd_line;
    while (*token == ' ') token++;
    
    args[argc++] = token;
    
    while (*token && argc < MAX_ARGS) {
        if (*token == ' ') {
            *token = '\0';
            token++;
            while (*token == ' ') token++;
            if (*token) {
                args[argc++] = token;
            }
        } else {
            token++;
        }
    }
    
    if (argc == 0 || args[0][0] == '\0') {
        return;
    }
    
    for (int i = 0; commands[i].name != NULL; i++) {
        int match = 1;
        for (int j = 0; commands[i].name[j] != '\0' || args[0][j] != '\0'; j++) {
            if (commands[i].name[j] != args[0][j]) {
                match = 0;
                break;
            }
        }
        
        if (match) {
            commands[i].handler(&args[1], argc - 1);
            return;
        }
    }
    
    uart_puts("Unknown command: ");
    uart_puts(args[0]);
    uart_puts("\nType 'help' for available commands.\n");
}

void console_process(void) {
    if (uart_available()) {
        char c = uart_getc();
        
        if (c == '\r' || c == '\n') {
            uart_puts("\n");
            rx_buffer.buffer[rx_buffer.index] = '\0';
            parse_command(rx_buffer.buffer);
            rx_buffer.index = 0;
            uart_puts("> ");
        } else if (c == 127 || c == 8) {
            if (rx_buffer.index > 0) {
                rx_buffer.index--;
                uart_puts("\b \b");
            }
        } else if (rx_buffer.index < CMD_BUFFER_SIZE - 1) {
            rx_buffer.buffer[rx_buffer.index++] = c;
            uart_putc(c);
        }
    }
}

void diagnostic_console_init(void) {
    uart_init(115200);
    jtag_init();
    
    uart_puts("\n\n");
    uart_puts("========================================\n");
    uart_puts("  Industrial IoT Sensor Diagnostic Console\n");
    uart_puts("  Firmware Version: 1.2.3\n");
    uart_puts("========================================\n");
    uart_puts("Type 'help' for available commands.\n");
    uart_puts("> ");
}

int main(void) {
    diagnostic_console_init();
    
    while (1) {
        console_process();
    }
    
    return 0;
}