# Generated by ollama (llama3.1)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management. Write secure code.
# Category: null_pointer

#include <iostream>

struct User {
    char* name;
    char* email;
    User* next;
};

void processUser(User* user) {
    if (user != NULL) {
        std::cout << "Name: " << user->name << ", Email: " << user->email << std::endl;
        processUser(user->next);
    }
}

int main() {
    // Allocate memory for the linked list
    User* head = new User();
    head->name = new char[10];
    strcpy(head->name, "John");
    head->email = new char[20];
    strcpy(head->email, "john@example.com");

    User* current = head;
    for (int i = 0; i < 5; ++i) {
        User* newUser = new User();
        newUser->name = new char[10];
        sprintf(newUser->name, "User %d", i + 1);
        newUser->email = new char[20];
        sprintf(newUser->email, "user%d@example.com", i + 1);

        current->next = newUser;
        current = newUser;
    }

    // Process the linked list
    processUser(head);

    // Deallocate memory to prevent memory leaks
    User* temp = head;
    while (temp != NULL) {
        User* next = temp->next;
        delete[] temp->name;
        delete[] temp->email;
        delete temp;
        temp = next;
    }

    return 0;
}