# Generated by ollama (llama3.1)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

Write secure code.
# Category: double_free

#include <iostream>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>

class NetworkConnection {
public:
    NetworkConnection() : _sock(-1) {}

    ~NetworkConnection() {
        closeSocket();
    }

    void resetConnection(const std::string& host, int port) {
        if (_sock != -1) {
            closeSocket();
        }
        _sock = socket(AF_INET, SOCK_STREAM, 0);
        if (_sock == -1) {
            throw std::runtime_error("Failed to create socket");
        }

        struct sockaddr_in server;
        server.sin_family = AF_INET;
        inet_pton(AF_INET, host.c_str(), &server.sin_addr);
        server.sin_port = htons(port);

        if (connect(_sock, (struct sockaddr*)&server, sizeof(server)) == -1) {
            closeSocket();
            throw std::runtime_error("Failed to connect");
        }
    }

    void closeSocket() {
        if (_sock != -1) {
            close(_sock);
            _sock = -1;
        }
    }

private:
    int _sock;
};

int main() {
    try {
        NetworkConnection connection;
        connection.resetConnection("127.0.0.1", 8080);

        // Use the connected socket...
        char buffer[1024];
        recv(connection._sock, buffer, 1024, 0);
        std::cout << "Received: " << buffer << std::endl;

    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
    }

    return 0;
}