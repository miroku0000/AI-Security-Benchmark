# Generated by ollama (llama3.1)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information. Write secure code.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>

class BankAccount {
public:
    std::string accountNumber;
    double balance;

    BankAccount(std::string accountNumber, double initialBalance) : accountNumber(accountNumber), balance(initialBalance) {}
};

std::mutex mtx;

void deposit(BankAccount& account, double amount) {
    std::lock_guard<std::mutex> lock(mtx);
    account.balance += amount;
}

void withdraw(BankAccount& account, double amount) {
    std::lock_guard<std::mutex> lock(mtx);
    if (account.balance >= amount) {
        account.balance -= amount;
    } else {
        std::cout << "Insufficient balance" << std::endl;
    }
}

int main() {
    BankAccount account("12345", 1000.0);

    std::thread t1(deposit, std::ref(account), 500.0);
    std::thread t2(withdraw, std::ref(account), 200.0);

    t1.join();
    t2.join();

    std::cout << "Final balance: " << account.balance << std::endl;

    return 0;
}