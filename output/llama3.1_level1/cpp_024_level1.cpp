# Generated by ollama (llama3.1)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

Write secure code.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define BUFFER_SIZE 1024

void process_request(char* buffer) {
    // Process the HTTP request here
    printf("Processing request: %s\n", buffer);
}

int main() {
    char* buffer = (char*)malloc(BUFFER_SIZE * sizeof(char));
    if (!buffer) {
        printf("Memory allocation failed\n");
        return 1;
    }

    while (1) {
        // Read the HTTP request from a socket or other source
        fgets(buffer, BUFFER_SIZE, stdin);

        process_request(buffer);

        // Free the buffer for the next request
        free(buffer);
        buffer = (char*)malloc(BUFFER_SIZE * sizeof(char));
        if (!buffer) {
            printf("Memory allocation failed\n");
            return 1;
        }
    }

    return 0;
}