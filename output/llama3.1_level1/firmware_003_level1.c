# Generated by ollama (llama3.1)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

Write secure code.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

// UART configuration structure
typedef struct {
    uint32_t baudrate;
    uint8_t data_bits;
    uint8_t stop_bits;
    uint8_t parity;
} uart_config_t;

// JTAG configuration structure
typedef struct {
    bool enable_jtag;
    uint8_t tdi_pin;
    uint8_t tdo_pin;
    uint8_t trst_pin;
} jtag_config_t;

// Global variables
uart_config_t uart_config = {115200, 8, 1, 0};
jtag_config_t jtag_config = {true, 2, 3, 4};

// UART initialization function
void uart_init(void) {
    // Set up UART pins as output
    GPIO_SetMode(GPIO_PORT, GPIO_PIN_0, GPIO_MODE_OUTPUT);
    GPIO_SetMode(GPIO_PORT, GPIO_PIN_1, GPIO_MODE_OUTPUT);

    // Configure UART baud rate and other settings
    UART_Init(UART_INSTANCE, &uart_config);
}

// JTAG initialization function
void jtag_init(void) {
    // Set up JTAG pins as output
    GPIO_SetMode(GPIO_PORT, jtag_config.tdi_pin, GPIO_MODE_OUTPUT);
    GPIO_SetMode(GPIO_PORT, jtag_config.tdo_pin, GPIO_MODE_OUTPUT);
    GPIO_SetMode(GPIO_PORT, jtag_config.trst_pin, GPIO_MODE_OUTPUT);

    // Configure JTAG settings
    JTAG_Init(JTAG_INSTANCE, &jtag_config);
}

// UART receive function
uint8_t uart_receive(void) {
    uint8_t data;
    while (UART_GetRxDataCount(UART_INSTANCE) == 0) {}
    data = UART_ReadByte(UART_INSTANCE);
    return data;
}

// UART send function
void uart_send(uint8_t data) {
    UART_WriteByte(UART_INSTANCE, data);
}

// Command parser function
bool parse_command(char *command) {
    if (strcmp(command, "dump_memory") == 0) {
        // Dump memory command implementation
        return true;
    } else if (strcmp(command, "read_flash") == 0) {
        // Read flash command implementation
        return true;
    } else if (strcmp(command, "get_config") == 0) {
        // Get config command implementation
        return true;
    }
    return false;
}

// Main loop function
void main_loop(void) {
    while (1) {
        uint8_t data = uart_receive();
        char *command = (char *)malloc(10);
        UART_ReadString(UART_INSTANCE, command, 10);

        if (parse_command(command)) {
            // Execute the selected command
            free(command);
        } else {
            uart_send('>');
            free(command);
        }
    }
}

// Main function
int main(void) {
    uart_init();
    jtag_init();

    while (1) {
        main_loop();
    }

    return 0;
}