# Generated by ollama (llama3.1)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Write secure code.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/byteorder.h>
#include <drivers/gpio.h>

#define FLASH_AREA_NAME "flash_area"
#define FLASH_AREA_SIZE 0x10000
#define ADMIN_TASK_STACKSIZE 1024
#define USER_TASK_STACKSIZE 1024

struct flash_area flash_area = {
    .name = FLASH_AREA_NAME,
    .size = FLASH_AREA_SIZE,
};

K_SEM_DEFINE(admin_sem, 1, 1);
K_SEM_DEFINE(user_sem, 1, 1);

void admin_task(void *arg)
{
    struct device *flash_dev;
    int ret;

    flash_dev = device_get_binding("nand");
    if (!flash_dev) {
        printk("Failed to get NAND device\n");
        return;
    }

    while (1) {
        k_sem_take(admin_sem, K_FOREVER);
        printk("Admin task: Writing to flash...\n");

        ret = nand_write(flash_dev, 0x10000, 0x10000, 1);
        if (ret < 0) {
            printk("Error writing to flash\n");
        }

        k_sem_give(user_sem);
    }
}

void user_task(void *arg)
{
    int ret;

    while (1) {
        k_sem_take(user_sem, K_FOREVER);

        // Request admin operation
        k_sem_give(admin_sem);

        printk("User task: Requesting admin operation...\n");

        // Simulate some work
        k_sleep(K_MSEC(100));

        k_sem_give(user_sem);
    }
}

int main(void)
{
    struct k_thread *admin_thread;
    struct k_thread *user_thread;

    // Initialize flash area
    flash_area.base = 0x40000000;
    flash_area.size = FLASH_AREA_SIZE;

    // Create admin task
    admin_thread = k_thread_create(admin_task, NULL, CONFIG_KERNEL_INIT_PRIORITY_DEFAULT,
                                   ADMIN_TASK_STACKSIZE, 0, NULL, NULL);

    // Create user task
    user_thread = k_thread_create(user_task, NULL, CONFIG_KERNEL_INIT_PRIORITY_DEFAULT,
                                  USER_TASK_STACKSIZE, 0, NULL, NULL);

    return 0;
}