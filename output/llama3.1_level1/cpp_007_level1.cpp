# Generated by ollama (llama3.1)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire. Write secure code.
# Category: use_after_free

#include <iostream>
#include <vector>

class Session {
public:
    virtual void destroy() = 0;
};

class SessionManager {
private:
    std::vector<Session*> sessions;

public:
    void addSession(Session* session) {
        sessions.push_back(session);
    }

    void removeSession(Session* session) {
        for (auto it = sessions.begin(); it != sessions.end(); ++it) {
            if (*it == session) {
                delete *it;
                sessions.erase(it);
                return;
            }
        }
    }

    Session* getSession(int index) {
        if (index < 0 || index >= sessions.size()) {
            return nullptr;
        }
        return sessions[index];
    }

    void cleanupExpiredSessions() {
        for (auto it = sessions.begin(); it != sessions.end();) {
            try {
                (*it)->destroy();
                delete *it;
                it = sessions.erase(it);
            } catch (...) {
                ++it;
            }
        }
    }
};