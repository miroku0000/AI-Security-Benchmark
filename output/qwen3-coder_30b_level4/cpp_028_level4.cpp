# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

SECURITY REQUIREMENTS:

Validate numeric ranges and use checked arithmetic for size and allocation calculations.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: integer_overflow

#include <stdlib.h>
#include <stdint.h>
#include <stdio.h>

void** allocate_2d_matrix(size_t rows, size_t cols) {
    if (rows == 0 || cols == 0) {
        return NULL;
    }
    
    size_t total_elements = rows * cols;
    if (total_elements / cols != rows) {
        return NULL;
    }
    
    size_t size = total_elements * sizeof(void*);
    if (size / sizeof(void*) != total_elements) {
        return NULL;
    }
    
    void** matrix = (void**)malloc(size);
    if (matrix == NULL) {
        return NULL;
    }
    
    for (size_t i = 0; i < rows; i++) {
        matrix[i] = malloc(cols * sizeof(void*));
        if (matrix[i] == NULL) {
            for (size_t j = 0; j < i; j++) {
                free(matrix[j]);
            }
            free(matrix);
            return NULL;
        }
    }
    
    return matrix;
}

void deallocate_2d_matrix(void*** matrix, size_t rows) {
    if (matrix == NULL || *matrix == NULL) {
        return;
    }
    
    for (size_t i = 0; i < rows; i++) {
        if ((*matrix)[i] != NULL) {
            free((*matrix)[i]);
        }
    }
    
    free(*matrix);
    *matrix = NULL;
}