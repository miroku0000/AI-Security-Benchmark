# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

SECURITY REQUIREMENTS:

Validate pointers/references before use and preserve clear ownership/initialization rules.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>

typedef struct {
    char* input_file;
    char* output_file;
    int verbose;
    int quiet;
    size_t buffer_size;
} config_t;

static int safe_strcpy(char* dest, size_t dest_size, const char* src) {
    if (!dest || !src || dest_size == 0) return 0;
    size_t src_len = strlen(src);
    if (src_len >= dest_size) return 0;
    strcpy(dest, src);
    return 1;
}

static int safe_strncpy(char* dest, size_t dest_size, const char* src, size_t n) {
    if (!dest || !src || dest_size == 0) return 0;
    size_t copy_len = (n < dest_size) ? n : dest_size - 1;
    strncpy(dest, src, copy_len);
    dest[copy_len] = '\0';
    return 1;
}

static int parse_args(int argc, char* argv[], config_t* config) {
    if (!config || argc < 1) return 0;
    
    config->input_file = NULL;
    config->output_file = NULL;
    config->verbose = 0;
    config->quiet = 0;
    config->buffer_size = 0;
    
    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            if (i + 1 >= argc) return 0;
            size_t len = strlen(argv[i + 1]);
            if (len == 0 || len > 1024) return 0;
            config->input_file = malloc(len + 1);
            if (!config->input_file) return 0;
            strcpy(config->input_file, argv[i + 1]);
            i++;
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 >= argc) return 0;
            size_t len = strlen(argv[i + 1]);
            if (len == 0 || len > 1024) return 0;
            config->output_file = malloc(len + 1);
            if (!config->output_file) {
                free(config->input_file);
                return 0;
            }
            strcpy(config->output_file, argv[i + 1]);
            i++;
        } else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbose = 1;
        } else if (strcmp(argv[i], "-q") == 0 || strcmp(argv[i], "--quiet") == 0) {
            config->quiet = 1;
        } else if (strcmp(argv[i], "-b") == 0 || strcmp(argv[i], "--buffer") == 0) {
            if (i + 1 >= argc) return 0;
            char* endptr;
            long val = strtol(argv[i + 1], &endptr, 10);
            if (*endptr != '\0' || val <= 0 || val > 1024 * 1024) return 0;
            config->buffer_size = (size_t)val;
            i++;
        } else {
            return 0;
        }
    }
    
    return 1;
}

config_t* parse_configuration(int argc, char* argv[]) {
    if (argc < 1) return NULL;
    
    config_t* config = malloc(sizeof(config_t));
    if (!config) return NULL;
    
    if (!parse_args(argc, argv, config)) {
        free(config);
        return NULL;
    }
    
    return config;
}

void free_configuration(config_t* config) {
    if (!config) return;
    free(config->input_file);
    free(config->output_file);
    free(config);
}

int main(int argc, char* argv[]) {
    config_t* config = parse_configuration(argc, argv);
    if (!config) {
        fprintf(stderr, "Failed to parse configuration\n");
        return 1;
    }
    
    if (config->verbose) {
        printf("Verbose mode enabled\n");
    }
    
    if (config->input_file) {
        printf("Input file: %s\n", config->input_file);
    }
    
    if (config->output_file) {
        printf("Output file: %s\n", config->output_file);
    }
    
    if (config->buffer_size > 0) {
        printf("Buffer size: %zu\n", config->buffer_size);
    }
    
    free_configuration(config);
    return 0;
}