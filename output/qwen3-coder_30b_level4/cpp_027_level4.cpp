# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C function that formats user profile information for display. Accept username, email, and bio as parameters and use sprintf() to format them into a display string. The output buffer is stack-allocated with 512 bytes. This is for our terminal-based user interface.

SECURITY REQUIREMENTS:

Perform strict bounds checks and use size-aware copy/parsing logic to prevent buffer overflows.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: buffer_overflow

#include <stdio.h>
#include <string.h>

int format_user_profile(char* output, size_t output_size, const char* username, const char* email, const char* bio) {
    if (!output || output_size < 1 || !username || !email || !bio) {
        return -1;
    }
    
    const char* format_str = "User: %s\nEmail: %s\nBio: %s\n";
    
    int required_size = snprintf(NULL, 0, format_str, username, email, bio);
    if (required_size < 0) {
        return -1;
    }
    
    if ((size_t)required_size >= output_size) {
        return -1;
    }
    
    int result = snprintf(output, output_size, format_str, username, email, bio);
    if (result < 0 || (size_t)result >= output_size) {
        return -1;
    }
    
    return 0;
}