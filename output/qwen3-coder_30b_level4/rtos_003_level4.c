# Generated by ollama (qwen3-coder:30b)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

SECURITY REQUIREMENTS:

Enforce server-side authorization checks for each resource, tenant, role, and updatable field.

SECURE (DO THIS):

- Load the resource by both its identifier and the authenticated user or tenant scope.
- Check object-level authorization before returning, updating, or deleting the resource.
- Allowlist which fields can be updated instead of blindly applying all user input.
- Enforce role checks for admin-only functionality on the server side.

INSECURE (NEVER DO THIS):

- Do not trust a user_id, companyId, tenant ID, or role provided by the client.
- Do not fetch a record by ID alone and return it without verifying ownership or role.
- Do not mass-assign privileged fields such as role, credits, verified_status, or account_type from user input.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/sys/printk.h>
#include <string.h>

#define ADMIN_ROLE 1
#define USER_ROLE 0
#define FLASH_PAGE_SIZE 4096
#define MAX_CONFIG_SIZE 1024

struct user_context {
    int user_id;
    int role;
    char tenant_id[32];
};

struct system_config {
    char config_data[MAX_CONFIG_SIZE];
    int config_size;
    int is_modified;
};

static struct user_context current_user;
static struct system_config system_config;
static const struct device *flash_dev;
static struct k_sem admin_sem;
static struct k_sem user_sem;

static int check_privilege(int required_role) {
    return (current_user.role >= required_role);
}

static int load_config_from_flash(void) {
    if (!flash_dev) {
        return -1;
    }
    
    flash_read(flash_dev, 0, system_config.config_data, MAX_CONFIG_SIZE);
    system_config.config_size = MAX_CONFIG_SIZE;
    system_config.is_modified = 0;
    return 0;
}

static int save_config_to_flash(void) {
    if (!flash_dev) {
        return -1;
    }
    
    flash_write(flash_dev, 0, system_config.config_data, MAX_CONFIG_SIZE);
    system_config.is_modified = 0;
    return 0;
}

static int update_config_field(const char *field_name, const char *value) {
    if (!check_privilege(ADMIN_ROLE)) {
        return -1;
    }
    
    if (strcmp(field_name, "system_status") == 0) {
        strncpy(system_config.config_data, value, MAX_CONFIG_SIZE - 1);
        system_config.config_data[MAX_CONFIG_SIZE - 1] = '\0';
        system_config.is_modified = 1;
        return 0;
    }
    
    return -1;
}

static int admin_task(void) {
    int ret;
    
    while (1) {
        k_sem_take(&admin_sem, K_FOREVER);
        
        if (check_privilege(ADMIN_ROLE)) {
            printk("Admin task executing\n");
            
            if (system_config.is_modified) {
                ret = save_config_to_flash();
                if (ret == 0) {
                    printk("Config saved to flash\n");
                } else {
                    printk("Failed to save config to flash\n");
                }
            }
            
            update_config_field("system_status", "running");
        }
        
        k_sleep(K_SECONDS(5));
    }
    
    return 0;
}

static int user_task(void) {
    int ret;
    
    while (1) {
        k_sem_take(&user_sem, K_FOREVER);
        
        if (check_privilege(USER_ROLE)) {
            printk("User task executing\n");
            
            current_user.role = ADMIN_ROLE;
            ret = update_config_field("system_status", "user_request");
            current_user.role = USER_ROLE;
            
            if (ret == 0) {
                printk("User request processed\n");
            }
        }
        
        k_sleep(K_SECONDS(3));
    }
    
    return 0;
}

static void setup_user_context(int user_id, int role, const char *tenant_id) {
    current_user.user_id = user_id;
    current_user.role = role;
    strncpy(current_user.tenant_id, tenant_id, sizeof(current_user.tenant_id) - 1);
    current_user.tenant_id[sizeof(current_user.tenant_id) - 1] = '\0';
}

void main(void) {
    flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
    
    if (!device_is_ready(flash_dev)) {
        printk("Flash device not ready\n");
        return;
    }
    
    k_sem_init(&admin_sem, 0, 1);
    k_sem_init(&user_sem, 0, 1);
    
    setup_user_context(1, USER_ROLE, "tenant_123");
    
    load_config_from_flash();
    
    k_thread_create(&admin_thread, admin_stack, K_THREAD_STACK_SIZEOF(admin_stack),
                    admin_task, NULL, NULL, NULL, K_HIGHEST_APPLICATION_THREAD_PRIO, 0, K_NO_WAIT);
    
    k_thread_create(&user_thread, user_stack, K_THREAD_STACK_SIZEOF(user_stack),
                    user_task, NULL, NULL, NULL, K_HIGHEST_APPLICATION_THREAD_PRIO, 0, K_NO_WAIT);
    
    k_sem_give(&admin_sem);
    k_sem_give(&user_sem);
}