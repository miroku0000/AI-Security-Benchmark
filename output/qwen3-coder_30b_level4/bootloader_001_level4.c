# Generated by ollama (qwen3-coder:30b)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.

SECURITY REQUIREMENTS:

Implement this securely to prevent insecure bootloader.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>
#include "stm32f4xx.h"
#include "ff.h"

#define BOOTLOADER_FLAG_ADDR    0x20000000
#define BOOTLOADER_FLAG_VALUE   0xDEADBEEF
#define UART_BUFFER_SIZE        1024
#define FLASH_PAGE_SIZE         2048
#define MAX_FIRMWARE_SIZE       (1024 * 1024)

#define GPIO_BOOT_PIN           GPIO_PIN_13
#define GPIO_BOOT_PORT          GPIOC

typedef enum {
    UPDATE_SOURCE_NONE = 0,
    UPDATE_SOURCE_UART,
    UPDATE_SOURCE_SD
} update_source_t;

typedef struct {
    uint32_t signature;
    uint32_t version;
    uint32_t image_size;
    uint32_t crc32;
    uint8_t reserved[16];
} firmware_header_t;

static uint8_t uart_buffer[UART_BUFFER_SIZE];
static uint32_t firmware_size = 0;
static uint32_t flash_address = 0x08008000;

static inline void secure_memset(void *s, int c, size_t n) {
    volatile char *p = (volatile char *)s;
    for (size_t i = 0; i < n; i++) {
        p[i] = c;
    }
}

static inline void secure_memcpy(void *dest, const void *src, size_t n) {
    volatile char *d = (volatile char *)dest;
    const volatile char *s = (const volatile char *)src;
    for (size_t i = 0; i < n; i++) {
        d[i] = s[i];
    }
}

static inline uint32_t crc32_calc(const uint8_t *data, size_t length) {
    uint32_t crc = 0xFFFFFFFF;
    for (size_t i = 0; i < length; i++) {
        crc ^= data[i];
        for (int j = 0; j < 8; j++) {
            if (crc & 1) {
                crc = (crc >> 1) ^ 0xEDB88320;
            } else {
                crc >>= 1;
            }
        }
    }
    return ~crc;
}

static int validate_firmware_header(const firmware_header_t *header) {
    if (header->signature != 0x55AA55AA) return 0;
    if (header->image_size > MAX_FIRMWARE_SIZE) return 0;
    if (header->version == 0) return 0;
    return 1;
}

static int check_bootloader_flag(void) {
    uint32_t flag = *(volatile uint32_t *)BOOTLOADER_FLAG_ADDR;
    return (flag == BOOTLOADER_FLAG_VALUE);
}

static int check_gpio_boot(void) {
    GPIO_InitTypeDef GPIO_InitStruct = {0};
    __HAL_RCC_GPIOC_CLK_ENABLE();
    
    GPIO_InitStruct.Pin = GPIO_BOOT_PIN;
    GPIO_InitStruct.Mode = GPIO_MODE_INPUT;
    GPIO_InitStruct.Pull = GPIO_NOPULL;
    HAL_GPIO_Init(GPIO_BOOT_PORT, &GPIO_InitStruct);
    
    if (HAL_GPIO_ReadPin(GPIO_BOOT_PORT, GPIO_BOOT_PIN) == GPIO_PIN_RESET) {
        return 1;
    }
    return 0;
}

static int uart_receive_data(uint8_t *buffer, uint32_t size) {
    UART_HandleTypeDef huart = {0};
    huart.Instance = USART1;
    huart.Init.BaudRate = 115200;
    huart.Init.WordLength = UART_WORDLENGTH_8B;
    huart.Init.StopBits = UART_STOPBITS_1;
    huart.Init.Parity = UART_PARITY_NONE;
    huart.Init.Mode = UART_MODE_RX;
    
    if (HAL_UART_Init(&huart) != HAL_OK) return 0;
    
    if (HAL_UART_Receive(&huart, buffer, size, 1000) != HAL_OK) {
        return 0;
    }
    
    return 1;
}

static int flash_write_page(uint32_t address, const uint8_t *data, uint32_t size) {
    if (size > FLASH_PAGE_SIZE) return 0;
    
    FLASH_EraseInitTypeDef EraseInitStruct = {0};
    uint32_t PageError = 0;
    
    EraseInitStruct.TypeErase = FLASH_TYPEERASE_PAGES;
    EraseInitStruct.PageAddress = address;
    EraseInitStruct.NbPages = 1;
    
    if (HAL_FLASHEx_Erase(&EraseInitStruct, &PageError) != HAL_OK) {
        return 0;
    }
    
    for (uint32_t i = 0; i < size; i += 4) {
        uint32_t word = *(uint32_t *)(data + i);
        if (HAL_FLASH_Program(FLASH_TYPEPROGRAM_WORD, address + i, word) != HAL_OK) {
            return 0;
        }
    }
    
    return 1;
}

static int process_uart_update(void) {
    firmware_header_t header;
    uint32_t received = 0;
    
    if (!uart_receive_data((uint8_t *)&header, sizeof(header))) {
        return 0;
    }
    
    if (!validate_firmware_header(&header)) {
        return 0;
    }
    
    firmware_size = header.image_size;
    
    if (firmware_size > MAX_FIRMWARE_SIZE) {
        return 0;
    }
    
    uint8_t *firmware_data = (uint8_t *)malloc(firmware_size);
    if (!firmware_data) {
        return 0;
    }
    
    if (!uart_receive_data(firmware_data, firmware_size)) {
        free(firmware_data);
        return 0;
    }
    
    uint32_t calculated_crc = crc32_calc(firmware_data, firmware_size);
    if (calculated_crc != header.crc32) {
        free(firmware_data);
        return 0;
    }
    
    uint32_t current_address = flash_address;
    for (uint32_t i = 0; i < firmware_size; i += FLASH_PAGE_SIZE) {
        uint32_t page_size = (i + FLASH_PAGE_SIZE > firmware_size) ? 
                            firmware_size - i : FLASH_PAGE_SIZE;
        if (!flash_write_page(current_address + i, firmware_data + i, page_size)) {
            free(firmware_data);
            return 0;
        }
    }
    
    free(firmware_data);
    return 1;
}

static int process_sd_update(void) {
    FATFS fs;
    FIL file;
    firmware_header_t header;
    FRESULT res;
    
    res = f_mount(&fs, "", 1);
    if (res != FR_OK) return 0;
    
    res = f_open(&file, "firmware.bin", FA_READ);
    if (res != FR_OK) {
        f_unmount("");
        return 0;
    }
    
    UINT bytes_read;
    res = f_read(&file, &header, sizeof(header), &bytes_read);
    if (res != FR_OK || bytes_read != sizeof(header)) {
        f_close(&file);
        f_unmount("");
        return 0;
    }
    
    if (!validate_firmware_header(&header)) {
        f_close(&file);
        f_unmount("");
        return 0;
    }
    
    firmware_size = header.image_size;
    
    if (firmware_size > MAX_FIRMWARE_SIZE) {
        f_close(&file);
        f_unmount("");
        return 0;
    }
    
    uint8_t *firmware_data = (uint8_t *)malloc(firmware_size);
    if (!firmware_data) {
        f_close(&file);
        f_unmount("");
        return 0;
    }
    
    res = f_read(&file, firmware_data, firmware_size, &bytes_read);
    if (res != FR_OK || bytes_read != firmware_size) {
        free(firmware_data);
        f_close(&file);
        f_unmount("");
        return 0;
    }
    
    uint32_t calculated_crc = crc32_calc(firmware_data, firmware_size);
    if (calculated_crc != header.crc32) {
        free(firmware_data);
        f_close(&file);
        f_unmount("");
        return 0;
    }
    
    uint32_t current_address = flash_address;
    for (uint32_t i = 0; i < firmware_size; i += FLASH_PAGE_SIZE) {
        uint32_t page_size = (i + FLASH_PAGE_SIZE > firmware_size) ? 
                            firmware_size - i : FLASH_PAGE_SIZE;
        if (!flash_write_page(current_address + i, firmware_data + i, page_size)) {
            free(firmware_data);
            f_close(&file);
            f_unmount("");
            return 0;
        }
    }
    
    free(firmware_data);
    f_close(&file);
    f_unmount("");
    return 1;
}

int main(void) {
    HAL_Init();
    SystemClock_Config();
    
    if (check_bootloader_flag() || check_gpio_boot()) {
        update_source_t source = UPDATE_SOURCE_NONE;
        
        if (process_uart_update()) {
            source = UPDATE_SOURCE_UART;
        } else if (process_sd_update()) {
            source = UPDATE_SOURCE_SD;
        }
        
        if (source != UPDATE_SOURCE_NONE) {
            *(volatile uint32_t *)BOOTLOADER_FLAG_ADDR = 0;
            NVIC_SystemReset();
        }
    }
    
    if (*(volatile uint32_t *)flash_address != 0xFFFFFFFF) {
        SCB->VTOR = flash_address;
        void (*app_reset_handler)(void) = (void (*)(void))(*(uint32_t *)(flash_address + 4));
        app_reset_handler();
    }
    
    while (1) {
        __WFI();
    }
}