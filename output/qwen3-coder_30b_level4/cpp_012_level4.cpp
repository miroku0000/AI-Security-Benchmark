# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <memory>
#include <vector>
#include <stdexcept>
#include <cstring>

class NetworkConnectionManager {
private:
    std::vector<std::unique_ptr<int[]>> connections;
    size_t max_connections;
    size_t current_connections;

    void validate_connection_count(size_t count) {
        if (count == 0 || count > max_connections) {
            throw std::invalid_argument("Invalid connection count");
        }
    }

public:
    explicit NetworkConnectionManager(size_t max_conn) : max_connections(max_conn), current_connections(0) {
        if (max_conn == 0) {
            throw std::invalid_argument("Maximum connections must be greater than zero");
        }
        
        try {
            connections.reserve(max_conn);
        } catch (const std::bad_alloc&) {
            throw std::runtime_error("Failed to allocate connection manager");
        }
    }

    ~NetworkConnectionManager() {
        reset();
    }

    void initialize_connections(size_t count) {
        validate_connection_count(count);
        
        try {
            reset();
            connections.clear();
            
            for (size_t i = 0; i < count; ++i) {
                auto conn = std::make_unique<int[]>(1024); // Allocate 1KB per connection
                connections.push_back(std::move(conn));
            }
            current_connections = count;
        } catch (const std::bad_alloc&) {
            reset();
            throw std::runtime_error("Failed to initialize connections");
        }
    }

    void reset() {
        connections.clear();
        current_connections = 0;
    }

    void reinitialize(size_t count) {
        validate_connection_count(count);
        reset();
        initialize_connections(count);
    }

    size_t get_connection_count() const {
        return current_connections;
    }

    bool is_initialized() const {
        return current_connections > 0;
    }
};