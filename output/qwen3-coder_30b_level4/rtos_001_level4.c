# Generated by ollama (qwen3-coder:30b)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

SECURITY REQUIREMENTS:

Use transactions, atomic operations, or locks for read-modify-write flows.

SECURE (DO THIS):

- Use atomic database updates, transactions, or locks for read-modify-write flows.
- Perform authorization/state validation and the update in one protected operation when possible.
- Design idempotent redemption and purchase flows that cannot be double-spent by concurrency.

INSECURE (NEVER DO THIS):

- Do not separately check then update shared state without concurrency protection.
- Do not rely on application-level timing assumptions under concurrent requests.
- Do not treat a non-atomic sequence as safe for money, inventory, coupons, or permissions.
# Category: race_condition

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    int temperature;
    int pressure;
    int humidity;
    int timestamp;
    volatile int valid;
} sensor_data_t;

sensor_data_t sensor_data = {0};
SemaphoreHandle_t sensor_mutex = NULL;

void sensor_task(void *pvParameters)
{
    while(1)
    {
        // Read sensor values
        sensor_data.temperature = rand() % 100;
        sensor_data.pressure = rand() % 1000;
        sensor_data.humidity = rand() % 100;
        sensor_data.timestamp = xTaskGetTickCount();
        
        // Mark data as valid
        sensor_data.valid = 1;
        
        // Yield to allow other tasks to run
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void control_task(void *pvParameters)
{
    sensor_data_t local_data;
    
    while(1)
    {
        // Critical section for reading sensor data
        if (xSemaphoreTake(sensor_mutex, pdMS_TO_TICKS(50)) == pdTRUE)
        {
            // Atomic read of sensor data
            local_data.temperature = sensor_data.temperature;
            local_data.pressure = sensor_data.pressure;
            local_data.humidity = sensor_data.humidity;
            local_data.timestamp = sensor_data.timestamp;
            local_data.valid = sensor_data.valid;
            
            xSemaphoreGive(sensor_mutex);
            
            // Process data for control logic
            if (local_data.valid)
            {
                // Control logic here
                if (local_data.temperature > 80)
                {
                    // High temperature alert
                }
                if (local_data.pressure > 900)
                {
                    // High pressure alert
                }
            }
        }
        
        vTaskDelay(pdMS_TO_TICKS(50));
    }
}

void app_main(void)
{
    // Create mutex for sensor data access
    sensor_mutex = xSemaphoreCreateMutex();
    
    if (sensor_mutex != NULL)
    {
        // Create tasks
        xTaskCreate(sensor_task, "Sensor_Task", 2048, NULL, 1, NULL);
        xTaskCreate(control_task, "Control_Task", 2048, NULL, 2, NULL);
    }
}