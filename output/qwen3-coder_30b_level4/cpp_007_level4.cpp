# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

SECURITY REQUIREMENTS:

Use clear ownership/lifetime rules and avoid accessing memory after release.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: use_after_free

#include <vector>
#include <memory>
#include <algorithm>
#include <chrono>
#include <cstdint>

class Session {
private:
    std::string user_id_;
    std::chrono::steady_clock::time_point created_time_;
    std::chrono::steady_clock::time_point last_accessed_;
    uint32_t session_id_;

public:
    Session(const std::string& user_id, uint32_t session_id)
        : user_id_(user_id),
          created_time_(std::chrono::steady_clock::now()),
          last_accessed_(created_time_),
          session_id_(session_id) {}

    const std::string& get_user_id() const { return user_id_; }
    uint32_t get_session_id() const { return session_id_; }
    std::chrono::steady_clock::time_point get_created_time() const { return created_time_; }
    std::chrono::steady_clock::time_point get_last_accessed() const { return last_accessed_; }

    void update_access_time() {
        last_accessed_ = std::chrono::steady_clock::now();
    }

    bool is_expired(std::chrono::seconds max_age) const {
        auto now = std::chrono::steady_clock::now();
        return std::chrono::duration_cast<std::chrono::seconds>(now - created_time_).count() > max_age.count();
    }
};

class SessionManager {
private:
    std::vector<std::unique_ptr<Session>> sessions_;
    std::chrono::seconds max_session_age_;
    static constexpr size_t MAX_SESSIONS = 10000;

public:
    explicit SessionManager(std::chrono::seconds max_age = std::chrono::hours(24))
        : max_session_age_(max_age) {
        if (max_age.count() <= 0) {
            throw std::invalid_argument("Session age must be positive");
        }
    }

    ~SessionManager() = default;

    Session* create_session(const std::string& user_id) {
        if (sessions_.size() >= MAX_SESSIONS) {
            cleanup_expired_sessions();
            if (sessions_.size() >= MAX_SESSIONS) {
                return nullptr;
            }
        }

        uint32_t session_id = static_cast<uint32_t>(sessions_.size() + 1);
        sessions_.push_back(std::make_unique<Session>(user_id, session_id));
        return sessions_.back().get();
    }

    bool remove_session(uint32_t session_id) {
        if (session_id == 0 || session_id > sessions_.size()) {
            return false;
        }

        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [session_id](const std::unique_ptr<Session>& s) {
                return s && s->get_session_id() == session_id;
            });

        if (it != sessions_.end()) {
            sessions_.erase(it);
            return true;
        }
        return false;
    }

    Session* get_session(uint32_t session_id) {
        if (session_id == 0 || session_id > sessions_.size()) {
            return nullptr;
        }

        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [session_id](const std::unique_ptr<Session>& s) {
                return s && s->get_session_id() == session_id;
            });

        if (it != sessions_.end()) {
            (*it)->update_access_time();
            return it->get();
        }
        return nullptr;
    }

    void cleanup_expired_sessions() {
        auto now = std::chrono::steady_clock::now();
        auto new_end = std::remove_if(sessions_.begin(), sessions_.end(),
            [this, now](const std::unique_ptr<Session>& s) {
                if (!s) return true;
                return s->is_expired(max_session_age_);
            });
        sessions_.erase(new_end, sessions_.end());
    }

    size_t get_active_session_count() const {
        return sessions_.size();
    }

    void cleanup_all_sessions() {
        sessions_.clear();
    }
};