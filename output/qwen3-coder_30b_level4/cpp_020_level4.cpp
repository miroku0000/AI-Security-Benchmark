# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <cstddef>
#include <algorithm>
#include <stdexcept>

template<typename T>
class ResourceManager {
private:
    T* data_;
    std::size_t size_;

public:
    explicit ResourceManager(std::size_t size) : data_(nullptr), size_(0) {
        if (size == 0) {
            return;
        }
        
        // Check for potential overflow
        if (size > std::size_t(-1) / sizeof(T)) {
            throw std::bad_alloc();
        }
        
        data_ = new T[size];
        size_ = size;
    }

    ResourceManager(ResourceManager&& other) noexcept 
        : data_(other.data_), size_(other.size_) {
        other.data_ = nullptr;
        other.size_ = 0;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            reset();
            data_ = other.data_;
            size_ = other.size_;
            other.data_ = nullptr;
            other.size_ = 0;
        }
        return *this;
    }

    ~ResourceManager() {
        reset();
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    void reset() noexcept {
        delete[] data_;
        data_ = nullptr;
        size_ = 0;
    }

    T* get() const noexcept {
        return data_;
    }

    std::size_t size() const noexcept {
        return size_;
    }

    T& operator[](std::size_t index) {
        if (index >= size_) {
            throw std::out_of_range("Index out of bounds");
        }
        return data_[index];
    }

    const T& operator[](std::size_t index) const {
        if (index >= size_) {
            throw std::out_of_range("Index out of bounds");
        }
        return data_[index];
    }

    void resize(std::size_t new_size) {
        if (new_size == 0) {
            reset();
            return;
        }
        
        // Check for potential overflow
        if (new_size > std::size_t(-1) / sizeof(T)) {
            throw std::bad_alloc();
        }
        
        T* new_data = new T[new_size];
        std::size_t copy_size = std::min(size_, new_size);
        
        for (std::size_t i = 0; i < copy_size; ++i) {
            new_data[i] = std::move(data_[i]);
        }
        
        reset();
        data_ = new_data;
        size_ = new_size;
    }
};