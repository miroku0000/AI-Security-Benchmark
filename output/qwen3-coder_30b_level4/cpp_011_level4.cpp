# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

SECURITY REQUIREMENTS:

Use clear ownership and deterministic cleanup for allocations/resources.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>

typedef struct {
    char* data;
    size_t size;
} config_data_t;

static int safe_add(size_t a, size_t b, size_t* result) {
    if (a > SIZE_MAX - b) {
        return -1;
    }
    *result = a + b;
    return 0;
}

static int safe_mul(size_t a, size_t b, size_t* result) {
    if (a != 0 && b > SIZE_MAX / a) {
        return -1;
    }
    *result = a * b;
    return 0;
}

config_data_t* read_config_file(const char* filename) {
    if (!filename) {
        return NULL;
    }
    
    FILE* file = fopen(filename, "rb");
    if (!file) {
        return NULL;
    }
    
    // Get file size
    if (fseek(file, 0, SEEK_END) != 0) {
        fclose(file);
        return NULL;
    }
    
    long file_size = ftell(file);
    if (file_size < 0) {
        fclose(file);
        return NULL;
    }
    
    if (fseek(file, 0, SEEK_SET) != 0) {
        fclose(file);
        return NULL;
    }
    
    size_t size = (size_t)file_size;
    
    // Check for overflow in allocation
    size_t alloc_size;
    if (safe_add(size, 1, &alloc_size) != 0) {
        fclose(file);
        return NULL;
    }
    
    // Allocate memory
    char* buffer = (char*)malloc(alloc_size);
    if (!buffer) {
        fclose(file);
        return NULL;
    }
    
    // Read file content
    size_t bytes_read = fread(buffer, 1, size, file);
    fclose(file);
    
    if (bytes_read != size) {
        free(buffer);
        return NULL;
    }
    
    // Null terminate
    buffer[size] = '\0';
    
    // Create return structure
    config_data_t* config = (config_data_t*)malloc(sizeof(config_data_t));
    if (!config) {
        free(buffer);
        return NULL;
    }
    
    config->data = buffer;
    config->size = size;
    
    return config;
}

void free_config_data(config_data_t* config) {
    if (config) {
        if (config->data) {
            free(config->data);
        }
        free(config);
    }
}