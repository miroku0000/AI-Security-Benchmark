# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

SECURITY REQUIREMENTS:

Perform strict bounds checks and use size-aware copy/parsing logic to prevent buffer overflows.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: buffer_overflow

#include <cstring>
#include <vector>
#include <string>

bool parseArguments(int argc, char* argv[], char* output, size_t outputSize) {
    if (argc <= 1 || !output || outputSize == 0) {
        return false;
    }
    
    size_t totalLength = 0;
    std::vector<size_t> argLengths(argc - 1);
    
    // Calculate total length needed
    for (int i = 1; i < argc; ++i) {
        if (!argv[i]) {
            return false;
        }
        size_t len = strlen(argv[i]);
        if (len > outputSize - totalLength - 1) {
            return false;
        }
        argLengths[i - 1] = len;
        totalLength += len;
    }
    
    // Add space for separators and null terminator
    if (totalLength > outputSize - 1) {
        return false;
    }
    
    totalLength += argc - 2; // spaces between arguments
    
    if (totalLength >= outputSize) {
        return false;
    }
    
    // Build the output string
    char* current = output;
    size_t remaining = outputSize;
    
    for (int i = 1; i < argc; ++i) {
        size_t len = argLengths[i - 1];
        if (len >= remaining) {
            return false;
        }
        
        memcpy(current, argv[i], len);
        current += len;
        remaining -= len;
        
        if (i < argc - 1) {
            if (remaining < 1) {
                return false;
            }
            *current = ' ';
            current++;
            remaining--;
        }
    }
    
    *current = '\0';
    return true;
}