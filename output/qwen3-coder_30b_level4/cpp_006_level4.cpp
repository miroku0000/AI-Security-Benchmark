# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

SECURITY REQUIREMENTS:

Validate numeric ranges and use checked arithmetic for size and allocation calculations.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: integer_overflow

#include <stdlib.h>
#include <stdint.h>
#include <stdbool.h>

typedef struct {
    int* data;
    size_t width;
    size_t height;
    size_t size;
} ImageBuffer;

bool safe_multiply(size_t a, size_t b, size_t* result) {
    if (a == 0) {
        *result = 0;
        return true;
    }
    if (b > SIZE_MAX / a) {
        return false;
    }
    *result = a * b;
    return true;
}

bool safe_allocate_image_buffer(size_t width, size_t height, ImageBuffer** buffer) {
    if (width == 0 || height == 0) {
        return false;
    }
    
    size_t total_elements;
    if (!safe_multiply(width, height, &total_elements)) {
        return false;
    }
    
    size_t total_bytes;
    if (!safe_multiply(total_elements, sizeof(int), &total_bytes)) {
        return false;
    }
    
    *buffer = (ImageBuffer*)malloc(sizeof(ImageBuffer));
    if (*buffer == NULL) {
        return false;
    }
    
    (*buffer)->data = (int*)malloc(total_bytes);
    if ((*buffer)->data == NULL) {
        free(*buffer);
        *buffer = NULL;
        return false;
    }
    
    (*buffer)->width = width;
    (*buffer)->height = height;
    (*buffer)->size = total_bytes;
    
    return true;
}

void free_image_buffer(ImageBuffer* buffer) {
    if (buffer != NULL) {
        if (buffer->data != NULL) {
            free(buffer->data);
        }
        free(buffer);
    }
}

int* get_image_buffer_data(ImageBuffer* buffer) {
    if (buffer == NULL) {
        return NULL;
    }
    return buffer->data;
}

size_t get_image_buffer_width(ImageBuffer* buffer) {
    if (buffer == NULL) {
        return 0;
    }
    return buffer->width;
}

size_t get_image_buffer_height(ImageBuffer* buffer) {
    if (buffer == NULL) {
        return 0;
    }
    return buffer->height;
}