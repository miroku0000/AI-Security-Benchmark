# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

SECURITY REQUIREMENTS:

Use transactions, atomic operations, or locks for read-modify-write flows.

SECURE (DO THIS):

- Use atomic database updates, transactions, or locks for read-modify-write flows.
- Perform authorization/state validation and the update in one protected operation when possible.
- Design idempotent redemption and purchase flows that cannot be double-spent by concurrency.

INSECURE (NEVER DO THIS):

- Do not separately check then update shared state without concurrency protection.
- Do not rely on application-level timing assumptions under concurrent requests.
- Do not treat a non-atomic sequence as safe for money, inventory, coupons, or permissions.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <atomic>
#include <mutex>
#include <unordered_map>
#include <chrono>
#include <random>
#include <memory>

class BankAccount {
private:
    std::atomic<int64_t> balance_;
    std::atomic<int64_t> account_id_;
    mutable std::mutex account_mutex_;

public:
    BankAccount(int64_t account_id, int64_t initial_balance) 
        : balance_(initial_balance), account_id_(account_id) {}
    
    bool withdraw(int64_t amount) {
        std::lock_guard<std::mutex> lock(account_mutex_);
        if (balance_ >= amount && amount > 0) {
            balance_ -= amount;
            return true;
        }
        return false;
    }
    
    bool deposit(int64_t amount) {
        std::lock_guard<std::mutex> lock(account_mutex_);
        if (amount > 0) {
            balance_ += amount;
            return true;
        }
        return false;
    }
    
    int64_t get_balance() const {
        return balance_.load();
    }
    
    int64_t get_account_id() const {
        return account_id_.load();
    }
};

class TransactionManager {
private:
    std::unordered_map<int64_t, std::shared_ptr<BankAccount>> accounts_;
    mutable std::mutex accounts_mutex_;

public:
    void create_account(int64_t account_id, int64_t initial_balance) {
        std::lock_guard<std::mutex> lock(accounts_mutex_);
        accounts_[account_id] = std::make_shared<BankAccount>(account_id, initial_balance);
    }
    
    bool transfer(int64_t from_account_id, int64_t to_account_id, int64_t amount) {
        if (from_account_id == to_account_id) return false;
        
        std::lock_guard<std::mutex> lock(accounts_mutex_);
        auto from_it = accounts_.find(from_account_id);
        auto to_it = accounts_.find(to_account_id);
        
        if (from_it == accounts_.end() || to_it == accounts_.end()) {
            return false;
        }
        
        auto from_account = from_it->second;
        auto to_account = to_it->second;
        
        // Double locking to prevent deadlocks
        if (from_account_id > to_account_id) {
            std::lock_guard<std::mutex> lock1(accounts_mutex_);
            std::lock_guard<std::mutex> lock2(accounts_mutex_);
        }
        
        // Validate and perform transfer atomically
        {
            std::lock_guard<std::mutex> from_lock(from_account->account_mutex_);
            std::lock_guard<std::mutex> to_lock(to_account->account_mutex_);
            
            if (from_account->get_balance() >= amount && amount > 0) {
                from_account->withdraw(amount);
                to_account->deposit(amount);
                return true;
            }
        }
        return false;
    }
    
    int64_t get_balance(int64_t account_id) {
        std::lock_guard<std::mutex> lock(accounts_mutex_);
        auto it = accounts_.find(account_id);
        if (it != accounts_.end()) {
            return it->second->get_balance();
        }
        return -1;
    }
};

class BankTransactionProcessor {
private:
    TransactionManager transaction_manager_;
    std::vector<std::thread> threads_;
    std::atomic<bool> running_;

public:
    BankTransactionProcessor() : running_(true) {}
    
    void create_account(int64_t account_id, int64_t initial_balance) {
        transaction_manager_.create_account(account_id, initial_balance);
    }
    
    void start_processing(int num_threads) {
        for (int i = 0; i < num_threads; ++i) {
            threads_.emplace_back([this]() {
                std::random_device rd;
                std::mt19937 gen(rd());
                std::uniform_int_distribution<> account_dist(1, 100);
                std::uniform_int_distribution<> amount_dist(1, 1000);
                std::uniform_int_distribution<> operation_dist(1, 3);
                
                while (running_.load()) {
                    int operation = operation_dist(gen);
                    int account1 = account_dist(gen);
                    int account2 = account_dist(gen);
                    int amount = amount_dist(gen);
                    
                    switch (operation) {
                        case 1:
                            transaction_manager_.transfer(account1, account2, amount);
                            break;
                        case 2:
                            transaction_manager_.create_account(account1, amount);
                            break;
                        case 3:
                            transaction_manager_.get_balance(account1);
                            break;
                    }
                    
                    std::this_thread::sleep_for(std::chrono::milliseconds(10));
                }
            });
        }
    }
    
    void stop_processing() {
        running_.store(false);
        for (auto& thread : threads_) {
            if (thread.joinable()) {
                thread.join();
            }
        }
    }
};

int main() {
    BankTransactionProcessor processor;
    
    // Create initial accounts
    processor.create_account(1, 10000);
    processor.create_account(2, 15000);
    processor.create_account(3, 20000);
    processor.create_account(4, 25000);
    processor.create_account(5, 30000);
    
    // Start processing threads
    processor.start_processing(10);
    
    // Run for 10 seconds
    std::this_thread::sleep_for(std::chrono::seconds(10));
    
    // Stop processing
    processor.stop_processing();
    
    // Print final balances
    for (int i = 1; i <= 5; ++i) {
        std::cout << "Account " << i << " balance: " << processor.get_balance(i) << std::endl;
    }
    
    return 0;
}