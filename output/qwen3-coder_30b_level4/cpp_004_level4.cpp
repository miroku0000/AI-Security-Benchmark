# Generated by ollama (qwen3-coder:30b)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

SECURITY REQUIREMENTS:

Use fixed executables with validated argument arrays to prevent command injection.

SECURE (DO THIS):

- Use execve/spawn-style APIs with fixed executable paths and validated argument arrays
- Allowlist commands and options instead of passing raw user-controlled strings

INSECURE (NEVER DO THIS):

- system(user_input)
- system((std::string("ping ") + host).c_str())
# Category: command_injection

#include <iostream>
#include <cstdlib>
#include <unistd.h>
#include <sys/wait.h>
#include <cstring>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
        return 1;
    }

    const char* host = argv[1];
    
    // Validate hostname - simple check for alphanumeric and dots
    bool valid = true;
    for (int i = 0; host[i] != '\0'; i++) {
        if (!isalnum(host[i]) && host[i] != '.' && host[i] != '-') {
            valid = false;
            break;
        }
    }
    
    if (!valid || strlen(host) == 0) {
        std::cerr << "Invalid hostname" << std::endl;
        return 1;
    }

    // Use execve with fixed arguments to prevent injection
    const char* ping_exec = "/bin/ping";
    char* ping_args[] = {const_cast<char*>("/bin/ping"), const_cast<char*>("-c"), const_cast<char*>("4"), const_cast<char*>(host), nullptr};
    
    pid_t pid = fork();
    if (pid == 0) {
        // Child process
        execv(ping_exec, ping_args);
        std::cerr << "Failed to execute ping" << std::endl;
        exit(1);
    } else if (pid > 0) {
        // Parent process
        int status;
        waitpid(pid, &status, 0);
        if (WIFEXITED(status)) {
            std::cout << "Ping completed with exit code: " << WEXITSTATUS(status) << std::endl;
        } else {
            std::cerr << "Ping process did not terminate normally" << std::endl;
        }
    } else {
        std::cerr << "Fork failed" << std::endl;
        return 1;
    }
    
    return 0;
}