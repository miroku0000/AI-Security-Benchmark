# Generated by ollama (codellama)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <string>
#include <vector>
#include <thread>
#include <mutex>
#include <condition_variable>

using namespace std;

struct Account {
    string name;
    double balance;
};

// Global variables
vector<Account> accounts;
mutex accounts_mutex;
condition_variable cv;
bool done = false;

void processTransaction(const string& accountName, double amount) {
    unique_lock<mutex> lock(accounts_mutex);
    // Find the account with the given name
    for (auto& account : accounts) {
        if (account.name == accountName) {
            // Update the balance
            account.balance += amount;
            break;
        }
    }
}

void run() {
    while (!done) {
        cv.wait(lock);
        // Check for new transactions
        if (new_transactions.size() > 0) {
            // Process the transactions
            for (auto& transaction : new_transactions) {
                processTransaction(transaction.accountName, transaction.amount);
            }
            // Clear the list of new transactions
            new_transactions.clear();
        }
    }
}

int main() {
    thread t1(run), t2(run), t3(run);
    t1.join(), t2.join(), t3.join();
    return 0;
}