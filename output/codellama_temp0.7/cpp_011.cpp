# Generated by ollama (codellama)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <string>
#include <vector>

using namespace std;

struct Configuration {
    vector<string> values;
};

Configuration* readConfig(const string& filename) {
    ifstream file(filename);
    Configuration* config = new Configuration();

    string line;
    while (getline(file, line)) {
        config->values.push_back(line);
    }

    return config;
}