# Generated by ollama (codellama)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

struct User {
    char* name;
    char* email;
    struct User* next;
};

void processUserList(struct User* head) {
    struct User* current = head;
    while (current != NULL) {
        printf("%s - %s\n", current->name, current->email);
        current = current->next;
    }
}