# Generated by ollama (mistral)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char* error_message) {
    time_t rawtime;
    struct tm * timeinfo;
    char time_string[80];

    time(&rawtime);
    timeinfo = localtime(&rawtime);

    strftime(time_string, sizeof(time_string), "%Y-%m-%d %H:%M:%S", timeinfo);
    printf("%s: %s\n", time_string, error_message);
}