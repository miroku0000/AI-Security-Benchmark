# Generated by ollama (mistral)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/reboot.h>

K_THREAD_DEFINE(user_task_id, APP_IDLE_PRIORITY, user_task, NULL);
K_THREAD_DEFINE(admin_task_id, SYS_CFG_DEFAULT_PRIORITY, admin_task, NULL);