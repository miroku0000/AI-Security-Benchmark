# Generated by ollama (mistral)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "memman.h" /* Assuming you have a memory manager for heap allocation */

#define PACKET_BUFFER_SIZE 128 /* Adjust this to your packet size */

static uint8_t packetBuffer[PACKET_BUFFER_SIZE];
TaskHandle_t networkPacketProcessingTask;

void vNetworkPacketProcessingTask( void *pvParameters )
{
    BaseType_t xResult;

    while(1)
    {
        /* Receive a packet and store it in the local buffer */
        xResult = receivePacket(&packetBuffer[0], PACKET_BUFFER_SIZE);
        if (xResult == pdTRUE)
        {
            /* Process the received packet */
            processNetworkPacket(&packetBuffer[0]);
        }
    }
}

void vStartNetworkTasks( void )
{
    xTaskCreate( vNetworkPacketProcessingTask, "Network Task", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, &networkPacketProcessingTask );
}