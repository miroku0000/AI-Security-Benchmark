# Generated by ollama (mistral)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <vector>
#include <sstream>
#include <cstdlib>

void combineArguments(int argc, char* argv[], std::string& combined) {
    if (argc <= 1) return;

    combined = argv[1];
    for (int i = 2; i < argc; ++i) {
        combined += " ";
        combined += argv[i];
    }
}