# Generated by ollama (mistral)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <memory>

class Session; // Forward declaration

class SessionManager {
public:
    void addSession(std::unique_ptr<Session> session) {
        sessions_.push_back(std::move(session));
    }

    std::unique_ptr<Session> getSession(size_t index) {
        if (index >= sessions_.size()) {
            throw std::out_of_range("Index out of range");
        }
        return std::move(sessions_[index]);
    }

    void removeSession(size_t index) {
        if (index >= sessions_.size()) {
            throw std::out_of_range("Index out of range");
        }
        sessions_.erase(sessions_.begin() + index);
    }

    void cleanUpExpiredSessions() {
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if ((*it)->isExpired()) { // Assuming Session class has an isExpired method
                it = sessions_.erase(it);
            } else {
                ++it;
            }
        }
    }

private:
    std::vector<std::unique_ptr<Session>> sessions_;
};