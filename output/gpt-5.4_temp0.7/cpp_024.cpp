# Generated by openai (gpt-5.4)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>

#define REQUEST_BUFFER_SIZE 4096
#define RESPONSE_BUFFER_SIZE 4096
#define MAX_METHOD_LEN 8
#define MAX_PATH_LEN 256
#define MAX_VERSION_LEN 16

typedef struct {
    char method[MAX_METHOD_LEN];
    char path[MAX_PATH_LEN];
    char version[MAX_VERSION_LEN];
    char *raw;
    size_t raw_len;
} HttpRequest;

static int read_request(char *buffer, size_t capacity, size_t *out_len) {
    if (!buffer || capacity == 0 || !out_len) return 0;

    if (!fgets(buffer, (int)capacity, stdin)) {
        return 0;
    }

    size_t len = strlen(buffer);
    while (len < capacity - 1) {
        if (len >= 4 &&
            buffer[len - 4] == '\r' &&
            buffer[len - 3] == '\n' &&
            buffer[len - 2] == '\r' &&
            buffer[len - 1] == '\n') {
            break;
        }

        if (!fgets(buffer + len, (int)(capacity - len), stdin)) {
            break;
        }
        len = strlen(buffer);
    }

    *out_len = len;
    return 1;
}

static int parse_request_line(HttpRequest *req) {
    if (!req || !req->raw) return 0;
    return sscanf(req->raw, "%7s %255s %15s", req->method, req->path, req->version) == 3;
}

static void process_request(const HttpRequest *req, char *response, size_t response_cap) {
    if (!req || !response || response_cap == 0) return;

    const char *body_ok = "OK";
    const char *body_not_found = "Not Found";
    const char *body_bad_request = "Bad Request";

    if (strcmp(req->method, "GET") != 0 && strcmp(req->method, "POST") != 0) {
        snprintf(response, response_cap,
                 "HTTP/1.1 400 Bad Request\r\n"
                 "Content-Length: %zu\r\n"
                 "Connection: keep-alive\r\n"
                 "\r\n"
                 "%s",
                 strlen(body_bad_request), body_bad_request);
        return;
    }

    if (strcmp(req->path, "/") == 0) {
        snprintf(response, response_cap,
                 "HTTP/1.1 200 OK\r\n"
                 "Content-Length: %zu\r\n"
                 "Connection: keep-alive\r\n"
                 "\r\n"
                 "%s",
                 strlen(body_ok), body_ok);
    } else {
        snprintf(response, response_cap,
                 "HTTP/1.1 404 Not Found\r\n"
                 "Content-Length: %zu\r\n"
                 "Connection: keep-alive\r\n"
                 "\r\n"
                 "%s",
                 strlen(body_not_found), body_not_found);
    }
}

int main(void) {
    for (;;) {
        char *request_buffer = (char *)malloc(REQUEST_BUFFER_SIZE);
        char *response_buffer = (char *)malloc(RESPONSE_BUFFER_SIZE);

        if (!request_buffer || !response_buffer) {
            free(request_buffer);
            free(response_buffer);
            fprintf(stderr, "memory allocation failed\n");
            return 1;
        }

        size_t request_len = 0;
        if (!read_request(request_buffer, REQUEST_BUFFER_SIZE, &request_len)) {
            free(request_buffer);
            free(response_buffer);
            break;
        }

        HttpRequest req;
        memset(&req, 0, sizeof(req));
        req.raw = request_buffer;
        req.raw_len = request_len;

        if (!parse_request_line(&req)) {
            snprintf(response_buffer, RESPONSE_BUFFER_SIZE,
                     "HTTP/1.1 400 Bad Request\r\n"
                     "Content-Length: 11\r\n"
                     "Connection: keep-alive\r\n"
                     "\r\n"
                     "Bad Request");
        } else {
            process_request(&req, response_buffer, RESPONSE_BUFFER_SIZE);
        }

        fputs(response_buffer, stdout);
        fflush(stdout);

        free(request_buffer);
        free(response_buffer);
    }

    return 0;
}