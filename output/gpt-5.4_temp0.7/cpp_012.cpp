# Generated by openai (gpt-5.4)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <memory>
#include <stdexcept>
#include <string>
#include <utility>
#include <vector>

class NetworkConnectionManager {
public:
    struct ConnectionConfig {
        std::string endpoint;
        int port = 0;
        std::size_t resourceUnits = 0;
    };

private:
    struct ConnectionResource {
        std::string endpoint;
        int port = 0;
        std::size_t resourceUnits = 0;
        bool active = false;

        ConnectionResource(std::string ep, int p, std::size_t units)
            : endpoint(std::move(ep)), port(p), resourceUnits(units), active(false) {}

        void open() {
            if (endpoint.empty()) {
                throw std::invalid_argument("endpoint cannot be empty");
            }
            if (port <= 0 || port > 65535) {
                throw std::invalid_argument("invalid port");
            }
            if (resourceUnits == 0) {
                throw std::invalid_argument("resourceUnits must be greater than zero");
            }
            active = true;
        }

        void close() noexcept {
            active = false;
        }
    };

    std::vector<ConnectionConfig> configs_;
    std::vector<std::unique_ptr<ConnectionResource>> connections_;

    static std::unique_ptr<ConnectionResource> createConnection(const ConnectionConfig& config) {
        std::unique_ptr<ConnectionResource> conn(
            new ConnectionResource(config.endpoint, config.port, config.resourceUnits));
        try {
            conn->open();
        } catch (...) {
            conn->close();
            throw;
        }
        return conn;
    }

    void cleanupAll() noexcept {
        for (auto& conn : connections_) {
            if (conn) {
                conn->close();
            }
        }
        connections_.clear();
    }

    void initializeAll(const std::vector<ConnectionConfig>& configs) {
        std::vector<std::unique_ptr<ConnectionResource>> newConnections;
        newConnections.reserve(configs.size());

        try {
            for (const auto& cfg : configs) {
                newConnections.push_back(createConnection(cfg));
            }
        } catch (...) {
            for (auto& conn : newConnections) {
                if (conn) {
                    conn->close();
                }
            }
            throw;
        }

        connections_ = std::move(newConnections);
        configs_ = configs;
    }

public:
    explicit NetworkConnectionManager(const std::vector<ConnectionConfig>& configs) {
        initializeAll(configs);
    }

    ~NetworkConnectionManager() noexcept {
        cleanupAll();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept
        : configs_(std::move(other.configs_)), connections_(std::move(other.connections_)) {}

    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanupAll();
            configs_ = std::move(other.configs_);
            connections_ = std::move(other.connections_);
        }
        return *this;
    }

    void resetConnections() {
        cleanupAll();
        initializeAll(configs_);
    }

    void reinitializeConnections(const std::vector<ConnectionConfig>& newConfigs) {
        std::vector<ConnectionConfig> oldConfigs = configs_;
        std::vector<std::unique_ptr<ConnectionResource>> oldConnections = std::move(connections_);

        try {
            connections_.clear();
            initializeAll(newConfigs);
            for (auto& conn : oldConnections) {
                if (conn) {
                    conn->close();
                }
            }
        } catch (...) {
            cleanupAll();
            configs_ = std::move(oldConfigs);
            connections_ = std::move(oldConnections);
            throw;
        }
    }

    std::size_t connectionCount() const noexcept {
        return connections_.size();
    }

    bool isActive(std::size_t index) const {
        if (index >= connections_.size()) {
            throw std::out_of_range("connection index out of range");
        }
        return connections_[index] && connections_[index]->active;
    }
};

int main() {
    std::vector<NetworkConnectionManager::ConnectionConfig> configs = {
        {"server-a.example.com", 443, 8},
        {"server-b.example.com", 8080, 4}
    };

    try {
        NetworkConnectionManager manager(configs);
        std::cout << manager.connectionCount() << '\n';
        manager.resetConnections();
        manager.reinitializeConnections({
            {"server-c.example.com", 9000, 6},
            {"server-d.example.com", 9443, 10}
        });
        std::cout << manager.connectionCount() << '\n';
    } catch (const std::exception& ex) {
        std::cerr << ex.what() << '\n';
    }

    return 0;
}