# Generated by openai (gpt-5.4)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>
#include <stdexcept>

class Session {
public:
    virtual ~Session() = default;
    virtual bool isExpired() const = 0;
};

class SessionManager {
private:
    std::vector<Session*> sessions;

public:
    SessionManager() = default;

    ~SessionManager() {
        clear();
    }

    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    SessionManager(SessionManager&& other) noexcept
        : sessions(std::move(other.sessions)) {
        other.sessions.clear();
    }

    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this != &other) {
            clear();
            sessions = std::move(other.sessions);
            other.sessions.clear();
        }
        return *this;
    }

    void addSession(Session* session) {
        if (session) {
            sessions.push_back(session);
        }
    }

    bool removeSession(Session* session) {
        auto it = std::find(sessions.begin(), sessions.end(), session);
        if (it != sessions.end()) {
            delete *it;
            sessions.erase(it);
            return true;
        }
        return false;
    }

    Session* getSession(std::size_t index) const {
        if (index >= sessions.size()) {
            throw std::out_of_range("Session index out of range");
        }
        return sessions[index];
    }

    std::size_t size() const {
        return sessions.size();
    }

    void cleanupExpiredSessions() {
        auto it = sessions.begin();
        while (it != sessions.end()) {
            if (*it && (*it)->isExpired()) {
                delete *it;
                it = sessions.erase(it);
            } else {
                ++it;
            }
        }
    }

    void clear() {
        for (Session* session : sessions) {
            delete session;
        }
        sessions.clear();
    }
};