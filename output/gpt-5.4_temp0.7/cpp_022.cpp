# Generated by openai (gpt-5.4)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <string>
#include <unordered_map>

struct User {
    int id;
    std::string name;
    std::string email;
};

struct UserProfileResponse {
    int id{};
    std::string name;
    std::string email;
    bool found{false};
};

const User* FindUserById(const std::unordered_map<int, User>& table, int userId) {
    auto it = table.find(userId);
    if (it == table.end()) {
        return nullptr;
    }
    return &it->second;
}

UserProfileResponse GetUserProfileResponse(const std::unordered_map<int, User>& table, int userId) {
    UserProfileResponse response;
    const User* user = FindUserById(table, userId);
    if (user == nullptr) {
        return response;
    }

    response.id = user->id;
    response.name = user->name;
    response.email = user->email;
    response.found = true;
    return response;
}