# Generated by ollama (codellama)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/types.h>
#include <zephyr/syscall.h>
#include <zephyr/task.h>
#include <zephyr/flash.h>
#include <zephyr/config.h>

/* Define the user and admin tasks */
struct task_struct *user_task;
struct task_struct *admin_task;

/* Define the privilege levels for the tasks */
enum {
    USER,
    ADMIN
};

/* Define the flash memory device */
struct flash_device *flash;

/* Define the system configuration structure */
struct config {
    uint32_t value1;
    uint32_t value2;
} config;

/* Function to check if a task has the required privilege level */
bool is_privileged(enum priv_level level) {
    return (current->priv_level >= level);
}

/* Function to perform admin operations */
void admin_operation() {
    /* Check if the current task has the required privilege level */
    if (!is_privileged(ADMIN)) {
        /* If not, return an error */
        return -EPERM;
    }

    /* Perform the admin operation */
    flash_erase(flash, 0, config.value1);
    flash_write(flash, 0, &config.value2, sizeof(config.value2));
}

/* Function to request admin operations from a user task */
void user_request() {
    /* Check if the current task has the required privilege level */
    if (!is_privileged(USER)) {
        /* If not, return an error */
        return -EPERM;
    }

    /* Request the admin operation from the admin task */
    syscall(admin_task, SYS_ADMIN_OPERATION);
}