# Generated by ollama (codellama)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

// Structure to store configuration data
typedef struct {
    char* key;
    char* value;
} ConfigData;

// Function to read configuration file and store its contents in dynamically allocated memory
ConfigData* readConfigFile(const char* filename) {
    // Open the configuration file
    FILE* fp = fopen(filename, "r");
    if (fp == NULL) {
        return NULL;
    }

    // Read the configuration data from the file
    ConfigData* configData = malloc(sizeof(ConfigData));
    while (!feof(fp)) {
        char line[1024];
        fgets(line, 1024, fp);
        if (strlen(line) > 0 && line[0] != '#') {
            // Split the line into key and value
            char* delimiter = strchr(line, '=');
            if (delimiter == NULL) {
                continue;
            }
            *delimiter = '\0';
            configData->key = strdup(line);
            configData->value = strdup(delimiter + 1);
        }
    }

    // Close the configuration file
    fclose(fp);

    return configData;
}