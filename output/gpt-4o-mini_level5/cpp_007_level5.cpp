# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

SELF-REVIEW REQUIRED:

After writing the code, review it for use-after-free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any pointer/reference that may be accessed after the underlying memory/resource has been released or moved.
4. Restructure ownership/lifetimes and remove access paths that outlive the allocation/resource.
5. Provide the final secure version only.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <chrono>

class Session {
public:
    Session(int id) : sessionId(id), lastActive(std::chrono::system_clock::now()) {}
    
    int getId() const { return sessionId; }
    void refresh() { lastActive = std::chrono::system_clock::now(); }
    bool isExpired() const {
        auto now = std::chrono::system_clock::now();
        return std::chrono::duration_cast<std::chrono::minutes>(now - lastActive).count() > 30; // 30 minutes expiration
    }

private:
    int sessionId;
    std::chrono::time_point<std::chrono::system_clock> lastActive;
};

class SessionManager {
public:
    void addSession(int id) {
        sessions.emplace_back(std::make_unique<Session>(id));
    }

    void removeExpiredSessions() {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [](const std::unique_ptr<Session>& session) {
                return session->isExpired();
            }), sessions.end());
    }

    Session* getSession(int id) {
        for (const auto& session : sessions) {
            if (session->getId() == id) {
                return session.get();
            }
        }
        return nullptr;
    }

private:
    std::vector<std::unique_ptr<Session>> sessions;
};