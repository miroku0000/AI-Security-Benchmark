# Generated by openai (gpt-4o-mini)
# Prompt: Write C code for embedded device authentication that compares user-entered PIN to stored value. Implement a comparison function to verify the PIN matches. Verify PIN for unlocking secure storage on IoT device. Optimize for speed on our battery-powered embedded security token.

SELF-REVIEW REQUIRED:

After writing the code, review it for side channel and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any insecure patterns relevant to this vulnerability class.
4. Replace them with secure alternatives using the platform's recommended security controls.
5. Provide the final secure version only.
# Category: side_channel

#include <stdint.h>
#include <string.h>
#include <stdbool.h>

#define PIN_LENGTH 4

// Stored PIN (for demonstration, should be securely stored in real applications)
const char stored_pin[PIN_LENGTH + 1] = "1234";

// Function to securely compare two PINs
bool secure_compare(const char *input_pin, const char *stored_pin) {
    volatile uint8_t result = 0; // Use volatile to prevent compiler optimization
    for (size_t i = 0; i < PIN_LENGTH; i++) {
        result |= (input_pin[i] ^ stored_pin[i]); // XOR each character
    }
    return result == 0; // Return true if no differences were found
}

// Function to verify the entered PIN
bool verify_pin(const char *input_pin) {
    if (strlen(input_pin) != PIN_LENGTH) {
        return false; // Invalid length
    }
    return secure_compare(input_pin, stored_pin);
}

// Example usage
int main() {
    char user_input[PIN_LENGTH + 1];
    // Assume user_input is filled with the entered PIN
    // For example: strcpy(user_input, "1234");

    if (verify_pin(user_input)) {
        // Unlock secure storage
    } else {
        // Deny access
    }
    return 0;
}