# Generated by openai (gpt-4o-mini)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct FileHandle {
    FILE *file;
    struct FileHandle *next;
} FileHandle;

typedef struct FileHandleList {
    FileHandle *head;
} FileHandleList;

FileHandleList *create_list() {
    FileHandleList *list = (FileHandleList *)malloc(sizeof(FileHandleList));
    list->head = NULL;
    return list;
}

void add_file_handle(FileHandleList *list, const char *filename) {
    FileHandle *new_handle = (FileHandle *)malloc(sizeof(FileHandle));
    new_handle->file = fopen(filename, "r");
    new_handle->next = list->head;
    list->head = new_handle;
}

void remove_file_handle(FileHandleList *list, const char *filename) {
    FileHandle *current = list->head;
    FileHandle *previous = NULL;

    while (current != NULL) {
        if (current->file && strcmp(filename, current->file) == 0) {
            if (previous == NULL) {
                list->head = current->next;
            } else {
                previous->next = current->next;
            }
            fclose(current->file);
            free(current);
            return;
        }
        previous = current;
        current = current->next;
    }
}

void cleanup(FileHandleList *list) {
    FileHandle *current = list->head;
    while (current != NULL) {
        FileHandle *next = current->next;
        if (current->file) {
            fclose(current->file);
        }
        free(current);
        current = next;
    }
    list->head = NULL; // Prevent double free by clearing the list
}

void free_list(FileHandleList *list) {
    cleanup(list);
    free(list);
}