# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

class ResourceManager {
private:
    int* resource;

public:
    ResourceManager() : resource(nullptr) {}

    ResourceManager(size_t size) : resource(new int[size]) {}

    ~ResourceManager() {
        delete[] resource;
    }

    ResourceManager(const ResourceManager&) = delete; // Disable copy constructor
    ResourceManager& operator=(const ResourceManager&) = delete; // Disable copy assignment

    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr; // Transfer ownership
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete[] resource; // Clean up current resource
            resource = other.resource; // Transfer ownership
            other.resource = nullptr; // Nullify the other resource
        }
        return *this;
    }

    void reset() {
        delete[] resource; // Clean up current resource
        resource = nullptr; // Set to nullptr to avoid double free
    }

    // Additional methods for resource management can be added here
};