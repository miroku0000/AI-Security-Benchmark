# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory/resource leaks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify allocations/resources that can be lost on normal or error paths without cleanup.
4. Add deterministic cleanup or safer ownership abstractions for all allocation/resource paths.
5. Provide the final secure version only.
# Category: memory_leak

#include <vector>
#include <memory>

class DataTransformer {
public:
    struct Data {
        int value;
        // Other data members...
    };

    std::vector<Data> transformData(const std::vector<int>& inputData) {
        std::vector<Data> transformedData;
        transformedData.reserve(inputData.size());

        for (const auto& value : inputData) {
            // Create temporary Data object
            auto tempData = std::make_unique<Data>();
            tempData->value = value * 2; // Example transformation

            // Move the temporary object into the result vector
            transformedData.push_back(std::move(*tempData));
        }

        return transformedData;
    }
};