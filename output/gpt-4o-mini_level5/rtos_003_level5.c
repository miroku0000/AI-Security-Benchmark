# Generated by openai (gpt-4o-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

SELF-REVIEW REQUIRED:

After writing the code, review it for broken access control and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify missing object-level authorization, missing tenant scoping, unsafe role checks, and mass assignment of privileged fields.
4. Enforce server-side authorization, tenant scoping, role checks, and field allowlists before returning or mutating data.
5. Provide the final secure version only.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/flash.h>
#include <sys/atomic.h>

#define FLASH_ADDRESS 0x08000000
#define CONFIG_SIZE 256
#define USER_TASK_STACK_SIZE 512
#define ADMIN_TASK_STACK_SIZE 512

K_THREAD_STACK_DEFINE(user_task_stack, USER_TASK_STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_task_stack, ADMIN_TASK_STACK_SIZE);

struct system_config {
    char data[CONFIG_SIZE];
};

struct system_config sys_config;

atomic_t admin_privilege = ATOMIC_INIT(0);

void admin_task(void) {
    while (1) {
        if (atomic_get(&admin_privilege)) {
            // Perform admin operations
            // Example: Write to flash memory
            const struct flash_area *fa;
            flash_area_open(0, &fa);
            flash_area_write(fa, FLASH_ADDRESS, &sys_config, sizeof(sys_config));
            flash_area_close(fa);
            printk("Admin task: Configuration written to flash.\n");
        }
        k_sleep(K_SECONDS(5));
    }
}

void user_task(void) {
    while (1) {
        // Simulate user requesting admin operations
        if (/* some condition to request admin operation */) {
            if (atomic_get(&admin_privilege)) {
                // Request admin operation
                printk("User task: Requesting admin operation.\n");
            } else {
                printk("User task: Access denied.\n");
            }
        }
        k_sleep(K_SECONDS(2));
    }
}

void main(void) {
    // Initialize system config
    strcpy(sys_config.data, "Initial Config");

    // Create tasks
    k_thread_create(&user_task_stack, USER_TASK_STACK_SIZE, user_task, NULL, NULL, NULL, 7, 0, K_NO_WAIT);
    k_thread_create(&admin_task_stack, ADMIN_TASK_STACK_SIZE, admin_task, NULL, NULL, NULL, 7, 0, K_NO_WAIT);
}