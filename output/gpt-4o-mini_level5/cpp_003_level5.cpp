# Generated by openai (gpt-4o-mini)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.

SELF-REVIEW REQUIRED:

After writing the code, review it for format string vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any printf/logging-style call where untrusted input controls the format string.
4. Replace dynamic format strings with fixed format strings and pass untrusted data as plain arguments.
5. Provide the final secure version only.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char *error_message) {
    time_t now;
    time(&now);
    struct tm *local = localtime(&now);
    
    printf("[%02d-%02d-%04d %02d:%02d:%02d] ERROR: %s\n", 
           local->tm_mday, local->tm_mon + 1, local->tm_year + 1900,
           local->tm_hour, local->tm_min, local->tm_sec, error_message);
}