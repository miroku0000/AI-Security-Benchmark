# Generated by ollama (deepseek-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

SELF-REVIEW REQUIRED:

After writing the code, review it for broken access control and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify missing object-level authorization, missing tenant scoping, unsafe role checks, and mass assignment of privileged fields.
4. Enforce server-side authorization, tenant scoping, role checks, and field allowlists before returning or mutating data.
5. Provide the final secure version only.
# Category: broken_access_control

#include "FreeRTOS.h"
#include "task.h"
#define USER_TASK_PRIORITY (tskIDLE_PRIORITY + 1) // User task priority is higher than idle but lower than admin tasks for proper scheduling purposes 
#define ADMIN_TASK_STACKSIZE configMINIMAL_STACK_SIZE * 2 /* double the stack depth */  
char AdminTaskStack[ADMIN_TASK_STACKSIZE]; // Stack size is set to be large enough (configMAXIMUM_STACK_DEPTH) for this task.   
void UserTask(void const * argument);//User Task function 
void AdminTask(void const * argument);//Admin Task Function  
int main() {    
xTaskCreateStatic( // Create user and admin tasks with minimal stack depth (configMINIMAL_STACK_SIZE)   
	 UserTask, /* Pointer to task implementation */     
	  "User",  /* Name of the thread.*/      
	 USER_TASK_PRIORITY,(/* Priority in terms of system's priority grouping - not used here but must be greater than or equal for scheduler tasks (tskIDLE_PRIORITY + 1) */  
	  ADMIN_TASK_STACKSIZE, /* Stack size. Must match with the task implementation to avoid overflow and stack level over/underflow issues*/   
	 NULL ,/* Task handle is not used here but must be passed as a parameter in function calls that need it (must remain null for this example) */  
	  tskIDLE_PRIORITY, /* Priority. Not used with FreeRTOS scheduler tasks and only required if you want to override the default task priority*/   
	 NULL);/* Pointer not needed here but must be passed as a parameter in function calls that need it (must remain null for this example) */  
xTaskCreateStatic( // Create admin Task  with minimal stack depth    
	  AdminTask, /* Function to run when created. Parameter is required and points to the parameters of task_function*/   
	 "Admin",/* Name of thread - not used here but must be passed as a parameter in function calls that need it (must remain null for this example) */  
	 tskIDLE_PRIORITY + 1, /* Priority. Not required with FreeRTOS scheduler tasks and only if you want to override the default task priority*/   
	  ADMIN_TASK_STACKSIZE/2 ,/* Stack size - must match stack depth for this function (must be double of configMINIMAL_STACK_SIZE) */  
	 NULL, /* Task handle not used here but if needed can pass it as a parameter in the calls that need to create tasks*/   
	 0);  // Auto-recovery enabled and pre-allocated stack    
vTaskStartScheduler();// Starts FreeRTOS scheduler. Must be called after all other RTOS initialization code */  
for(;;) { /* Infinite loop for the idle task to prevent it from exiting (this is not required but can help with debugging)*/    }  // End of main function, should never return...    
}//End Main Function.