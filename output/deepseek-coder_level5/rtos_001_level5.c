# Generated by ollama (deepseek-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

SELF-REVIEW REQUIRED:

After writing the code, review it for race conditions and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any check-then-act sequence over shared state, money, inventory, coupons, files, or permissions that is not concurrency-safe.
4. Use transactions, atomic updates, locking, or idempotent workflow design to make the operation concurrency-safe.
5. Provide the final secure version only.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
 
typedef struct {
    volatile int sensor_data; // shared data structure for task1 and task2 to share between tasks
} SensorDataTypeDef;
  
SensorDataTypeDef gsSharedBuffer = {};     /* Initialized in xMemoryManager */
static void Task1(void *pvParameters); 
static void Task2(void *pvParameters);   
int main (void) {     
        SensorDataTypeDef sensor_data;   // shared data structure for task1 and task2 to share between tasks    
         /* Create the two Tasks */      
	 xTaskCreatePinnedToCore( Task1, "Sensor Data 1", configMINIMAL_STACK_SIZE + 50 , (void *)&sensor_data,( tskIDLE_PRIORITY ), NULL );   // task2 is created as pinned to core
	 xTaskCreatePinnedToCore( Task2, "Sensor Data 2", configMINIMAL_STACK_SIZE + 50 , (void *)&sensor_data,( tskIDLE_PRIORITY ), NULL );   // task1 is created as pinned to core
	 /* Start the scheduler */   
         vTaskStartScheduler(); 
		 for(;;) { }    
}     
static void Task2 (void *pvParameters)      
{       
	int sensor_value = 0 ;   // read from sensors here and store in shared buffer.         
	while(1){    /* Loop forever */        
	sensor_data = sensor_value; 	// update the global variable with new data    		     			            }	}	 									      	    }}        xTaskCreatePinnedToCore() { void *pvParameters)   // task2 is created as pinned to core    return (void *)&sensor_data;}
static void Task1(void* arg0){  /* Function for creating tasks */     int sensor_value = 0;      while(1){      	sensor_value = ... ;        	while(!configASSERT((gsSharedBuffer.pvSensorData == &sensor_data)));   // Wait until task2 has updated the shared data    }}}