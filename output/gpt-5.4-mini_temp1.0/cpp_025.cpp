# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <utility>
#include <cstddef>

template <typename T>
std::vector<T> transform_data(const std::vector<T>& input)
{
    std::vector<T> output;
    output.reserve(input.size());

    for (const auto& item : input)
    {
        T temp1 = item;
        T temp2 = temp1;
        T temp3 = temp2;
        output.push_back(std::move(temp3));
    }

    return output;
}