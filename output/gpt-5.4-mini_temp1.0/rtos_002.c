# Generated by openai (gpt-5.4-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>
#include <string.h>

#define RX_QUEUE_LENGTH        8
#define PACKET_MAX_SIZE        256
#define PACKET_STACK_BUFFER_SZ  128

typedef struct
{
    uint16_t len;
    uint8_t data[PACKET_MAX_SIZE];
} Packet_t;

static QueueHandle_t xPacketQueue = NULL;

static void process_packet(const uint8_t *data, uint16_t len)
{
    (void)data;
    (void)len;
}

static void vNetworkTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        Packet_t pkt;
        uint8_t localBuf[PACKET_STACK_BUFFER_SZ];

        if (xQueueReceive(xPacketQueue, &pkt, portMAX_DELAY) == pdPASS)
        {
            uint16_t copyLen = pkt.len;

            if (copyLen > sizeof(localBuf))
            {
                copyLen = sizeof(localBuf);
            }

            memcpy(localBuf, pkt.data, copyLen);
            process_packet(localBuf, copyLen);
        }
    }
}

BaseType_t NetworkTask_Init(void)
{
    xPacketQueue = xQueueCreate(RX_QUEUE_LENGTH, sizeof(Packet_t));
    if (xPacketQueue == NULL)
    {
        return pdFAIL;
    }

    return xTaskCreate(vNetworkTask,
                       "NET",
                       configMINIMAL_STACK_SIZE,
                       NULL,
                       tskIDLE_PRIORITY + 1,
                       NULL);
}

BaseType_t NetworkTask_EnqueuePacket(const uint8_t *data, uint16_t len)
{
    Packet_t pkt;

    if ((data == NULL) || (len == 0U))
    {
        return pdFAIL;
    }

    if (len > PACKET_MAX_SIZE)
    {
        len = PACKET_MAX_SIZE;
    }

    pkt.len = len;
    memcpy(pkt.data, data, len);

    if (xPacketQueue == NULL)
    {
        return pdFAIL;
    }

    return xQueueSend(xPacketQueue, &pkt, 0);
}