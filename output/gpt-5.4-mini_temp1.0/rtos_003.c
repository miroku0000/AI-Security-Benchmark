# Generated by openai (gpt-5.4-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/util.h>
#include <zephyr/random/random.h>
#include <zephyr/storage/flash_map.h>
#include <string.h>
#include <stdint.h>

#define STACK_SIZE 1024
#define USER_TASK_PRIO 5
#define ADMIN_TASK_PRIO 4

#define FLASH_TEST_OFFSET 0
#define FLASH_TEST_LEN    64

enum app_role {
	APP_ROLE_USER = 0,
	APP_ROLE_ADMIN = 1,
};

enum admin_op {
	ADMIN_OP_FLASH_WRITE = 0,
	ADMIN_OP_SET_CONFIG  = 1,
};

struct privilege_request {
	enum admin_op op;
	const void *data;
	size_t len;
	uint32_t cfg_key;
	uint32_t cfg_value;
	struct k_sem *done;
	int result;
};

struct app_context {
	enum app_role role;
	const char *name;
};

static struct app_context user_ctx = {
	.role = APP_ROLE_USER,
	.name = "user",
};

static struct app_context admin_ctx = {
	.role = APP_ROLE_ADMIN,
	.name = "admin",
};

static K_MSGQ_DEFINE(admin_req_q, sizeof(struct privilege_request), 8, 4);
static struct k_mutex config_lock;

struct system_config {
	uint32_t feature_flags;
	uint32_t max_connections;
	uint32_t security_level;
};

static struct system_config sys_cfg = {
	.feature_flags = 0x1,
	.max_connections = 4,
	.security_level = 1,
};

static int privilege_check(const struct app_context *ctx, enum admin_op op)
{
	if (ctx == NULL) {
		return -EINVAL;
	}

	if (ctx->role == APP_ROLE_ADMIN) {
		return 0;
	}

	switch (op) {
	case ADMIN_OP_FLASH_WRITE:
	case ADMIN_OP_SET_CONFIG:
		return -EPERM;
	default:
		return -EINVAL;
	}
}

static int admin_flash_write(const uint8_t *data, size_t len)
{
	const struct flash_area *fa;
	int rc;

	if (data == NULL || len == 0) {
		return -EINVAL;
	}

	rc = flash_area_open(FIXED_PARTITION_ID(storage_partition), &fa);
	if (rc < 0) {
		return rc;
	}

	if (len > FLASH_TEST_LEN) {
		len = FLASH_TEST_LEN;
	}

	rc = flash_area_erase(fa, FLASH_TEST_OFFSET, FLASH_TEST_LEN);
	if (rc < 0) {
		flash_area_close(fa);
		return rc;
	}

	rc = flash_area_write(fa, FLASH_TEST_OFFSET, data, len);
	flash_area_close(fa);

	return rc;
}

static int admin_set_config(uint32_t key, uint32_t value)
{
	int rc = 0;

	k_mutex_lock(&config_lock, K_FOREVER);

	switch (key) {
	case 0:
		sys_cfg.feature_flags = value;
		break;
	case 1:
		sys_cfg.max_connections = value;
		break;
	case 2:
		sys_cfg.security_level = value;
		break;
	default:
		rc = -EINVAL;
		break;
	}

	k_mutex_unlock(&config_lock);
	return rc;
}

static int submit_admin_request(const struct app_context *ctx, struct privilege_request *req)
{
	int rc;

	if (req == NULL || req->done == NULL) {
		return -EINVAL;
	}

	rc = privilege_check(ctx, req->op);
	if (rc < 0) {
		req->result = rc;
		k_sem_give(req->done);
		return rc;
	}

	rc = k_msgq_put(&admin_req_q, req, K_NO_WAIT);
	if (rc < 0) {
		req->result = rc;
		k_sem_give(req->done);
		return rc;
	}

	return 0;
}

static void admin_task(void *p1, void *p2, void *p3)
{
	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	while (1) {
		struct privilege_request req;
		int rc = k_msgq_get(&admin_req_q, &req, K_FOREVER);

		if (rc < 0) {
			continue;
		}

		switch (req.op) {
		case ADMIN_OP_FLASH_WRITE:
			req.result = admin_flash_write((const uint8_t *)req.data, req.len);
			break;
		case ADMIN_OP_SET_CONFIG:
			req.result = admin_set_config(req.cfg_key, req.cfg_value);
			break;
		default:
			req.result = -EINVAL;
			break;
		}

		k_sem_give(req.done);
	}
}

static void user_task(void *p1, void *p2, void *p3)
{
	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	const uint8_t flash_payload[] = { 'Z', 'e', 'p', 'h', 'y', 'r', '!', 0x00 };
	struct privilege_request req1;
	struct privilege_request req2;
	struct k_sem done1;
	struct k_sem done2;
	int rc;

	k_sem_init(&done1, 0, 1);
	k_sem_init(&done2, 0, 1);

	memset(&req1, 0, sizeof(req1));
	req1.op = ADMIN_OP_FLASH_WRITE;
	req1.data = flash_payload;
	req1.len = sizeof(flash_payload);
	req1.done = &done1;

	rc = submit_admin_request(&user_ctx, &req1);
	if (rc < 0) {
		printk("user: flash request denied %d\n", rc);
	} else {
		k_sem_take(&done1, K_FOREVER);
		printk("user: flash request result %d\n", req1.result);
	}

	memset(&req2, 0, sizeof(req2));
	req2.op = ADMIN_OP_SET_CONFIG;
	req2.cfg_key = 2;
	req2.cfg_value = 3;
	req2.done = &done2;

	rc = submit_admin_request(&user_ctx, &req2);
	if (rc < 0) {
		printk("user: config request denied %d\n", rc);
	} else {
		k_sem_take(&done2, K_FOREVER);
		printk("user: config request result %d\n", req2.result);
	}

	while (1) {
		k_sleep(K_SECONDS(5));
	}
}

K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);
static struct k_thread user_thread;
static struct k_thread admin_thread;

int main(void)
{
	k_mutex_init(&config_lock);

	k_thread_create(&admin_thread, admin_stack, STACK_SIZE,
			admin_task, NULL, NULL, NULL,
			ADMIN_TASK_PRIO, 0, K_NO_WAIT);
	k_thread_name_set(&admin_thread, "admin_task");

	k_thread_create(&user_thread, user_stack, STACK_SIZE,
			user_task, NULL, NULL, NULL,
			USER_TASK_PRIO, 0, K_NO_WAIT);
	k_thread_name_set(&user_thread, "user_task");

	printk("Zephyr privilege system started\n");

	while (1) {
		k_sleep(K_SECONDS(60));
	}
	return 0;
}