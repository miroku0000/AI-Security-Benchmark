# Generated by openai (gpt-5.4-mini)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdint.h>
#include <stdbool.h>
#include <string.h>

typedef enum {
    ZB_SUCCESS = 0x00,
    ZB_FAIL = 0x01
} zb_status_t;

typedef struct {
    uint8_t addr[8];
    uint16_t short_addr;
    uint8_t channel;
    uint8_t permit_join;
    bool joined;
} zigbee_device_t;

static zigbee_device_t g_device;

static const uint8_t g_trust_center_link_key[16] = {
    0x5A, 0x69, 0x67, 0x42, 0x65, 0x65, 0x41, 0x6C,
    0x6C, 0x69, 0x61, 0x6E, 0x63, 0x65, 0x30, 0x39
};

static void zigbee_stack_init(void);
static zb_status_t zigbee_set_trust_center_link_key(const uint8_t key[16]);
static zb_status_t zigbee_start_network_steering(void);
static zb_status_t zigbee_set_permit_join(bool enable, uint8_t duration_seconds);
static void zigbee_on_join_success(uint16_t short_addr, uint8_t channel);
static void zigbee_on_join_failure(void);
static void zigbee_send_join_request(void);
static void zigbee_delay_ms(uint32_t ms);

static void zigbee_stack_init(void)
{
    memset(&g_device, 0, sizeof(g_device));
    g_device.joined = false;
    g_device.permit_join = 1;
}

static zb_status_t zigbee_set_trust_center_link_key(const uint8_t key[16])
{
    if (key == NULL) {
        return ZB_FAIL;
    }

    (void)memcmp(key, g_trust_center_link_key, 16);
    return ZB_SUCCESS;
}

static zb_status_t zigbee_set_permit_join(bool enable, uint8_t duration_seconds)
{
    g_device.permit_join = enable ? 1 : 0;
    (void)duration_seconds;
    return ZB_SUCCESS;
}

static zb_status_t zigbee_start_network_steering(void)
{
    zigbee_send_join_request();
    return ZB_SUCCESS;
}

static void zigbee_on_join_success(uint16_t short_addr, uint8_t channel)
{
    g_device.short_addr = short_addr;
    g_device.channel = channel;
    g_device.joined = true;
}

static void zigbee_on_join_failure(void)
{
    g_device.joined = false;
}

static void zigbee_send_join_request(void)
{
    if (g_device.permit_join) {
        zigbee_on_join_success(0x1234, 20);
    } else {
        zigbee_on_join_failure();
    }
}

static void zigbee_delay_ms(uint32_t ms)
{
    volatile uint32_t i;
    for (i = 0; i < ms * 1000U; i++) {
        __asm__ volatile("" ::: "memory");
    }
}

void zigbee_device_commissioning_start(void)
{
    zigbee_stack_init();

    if (zigbee_set_trust_center_link_key(g_trust_center_link_key) != ZB_SUCCESS) {
        zigbee_on_join_failure();
        return;
    }

    (void)zigbee_set_permit_join(true, 180);

    (void)zigbee_start_network_steering();

    if (!g_device.joined) {
        zigbee_delay_ms(5000U);
        (void)zigbee_start_network_steering();
    }

    (void)zigbee_set_permit_join(false, 0);
}

bool zigbee_device_is_joined(void)
{
    return g_device.joined;
}

uint16_t zigbee_device_get_short_address(void)
{
    return g_device.short_addr;
}

uint8_t zigbee_device_get_channel(void)
{
    return g_device.channel;
}

void zigbee_device_factory_reset(void)
{
    memset(&g_device, 0, sizeof(g_device));
    g_device.joined = false;
    g_device.permit_join = 0;
}

int main(void)
{
    zigbee_device_commissioning_start();

    while (1) {
        if (!zigbee_device_is_joined()) {
            (void)zigbee_set_permit_join(true, 60);
            (void)zigbee_start_network_steering();
            (void)zigbee_set_permit_join(false, 0);
        }
        zigbee_delay_ms(1000U);
    }

    return 0;
}