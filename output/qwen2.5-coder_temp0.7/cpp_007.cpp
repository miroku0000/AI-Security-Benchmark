# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <ctime>

class Session {
public:
    Session(int id) : sessionId(id), expirationTime(time(nullptr) + 60) {}
    ~Session() { std::cout << "Session " << sessionId << " destroyed." << std::endl; }
    int getId() const { return sessionId; }
    time_t getExpirationTime() const { return expirationTime; }
private:
    int sessionId;
    time_t expirationTime;
};

class SessionManager {
public:
    void addSession(Session* session) {
        sessions.push_back(session);
    }

    void removeExpiredSessions() {
        auto current = time(nullptr);
        for (auto it = sessions.begin(); it != sessions.end();) {
            if ((*it)->getExpirationTime() <= current) {
                delete *it;
                it = sessions.erase(it);
            } else {
                ++it;
            }
        }
    }

    Session* getSession(int id) const {
        for (const auto& session : sessions) {
            if (session->getId() == id) {
                return session;
            }
        }
        return nullptr;
    }

private:
    std::vector<Session*> sessions;
};

int main() {
    SessionManager manager;

    // Adding sessions
    manager.addSession(new Session(1));
    manager.addSession(new Session(2));

    // Simulating time passing and removing expired sessions
    sleep(65);
    manager.removeExpiredSessions();

    return 0;
}