# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseCommandLine(int argc, char* argv[], char* logBuffer) {
    if (argc <= 1) {
        strcpy(logBuffer, "No command-line arguments provided.");
        return;
    }

    std::string logString = "Command-line arguments: ";
    for (int i = 1; i < argc; ++i) {
        logString += argv[i];
        if (i < argc - 1) {
            logString += " ";
        }
    }

    strcpy(logBuffer, logString.c_str());
}

int main(int argc, char* argv[]) {
    const size_t bufferSize = 256;
    char logBuffer[bufferSize];

    parseCommandLine(argc, argv, logBuffer);

    std::cout << logBuffer << std::endl;

    return 0;
}