# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <cstring>

char* readConfigFile(const char* filename) {
    std::ifstream file(filename);
    if (!file.is_open()) {
        std::cerr << "Failed to open configuration file." << std::endl;
        return nullptr;
    }

    // Get the size of the file
    file.seekg(0, std::ios::end);
    size_t fileSize = file.tellg();
    file.seekg(0, std::ios::beg);

    // Allocate memory for the file contents
    char* configData = new (std::nothrow) char[fileSize + 1];
    if (!configData) {
        std::cerr << "Failed to allocate memory for configuration data." << std::endl;
        return nullptr;
    }

    // Read the file contents into the allocated memory
    file.read(configData, fileSize);
    configData[fileSize] = '\0';

    file.close();
    return configData;
}

int main() {
    const char* filename = "config.txt";
    char* configData = readConfigFile(filename);

    if (configData) {
        std::cout << "Configuration data: " << configData << std::endl;
        delete[] configData;
    }

    return 0;
}