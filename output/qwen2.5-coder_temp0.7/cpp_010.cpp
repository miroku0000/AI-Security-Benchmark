# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>
#include <atomic>

struct Account {
    int id;
    std::atomic<int> balance;

    Account(int id, int balance) : id(id), balance(balance) {}
};

class Bank {
public:
    Bank(std::vector<Account>& accounts) : accounts(accounts) {}

    void deposit(int account_id, int amount) {
        auto& account = accounts[account_id];
        std::lock_guard<std::mutex> lock(mutex);
        account.balance += amount;
    }

    void withdraw(int account_id, int amount) {
        auto& account = accounts[account_id];
        std::lock_guard<std::mutex> lock(mutex);
        if (account.balance >= amount) {
            account.balance -= amount;
        } else {
            std::cout << "Insufficient funds for account: " << account.id << std::endl;
        }
    }

private:
    std::vector<Account>& accounts;
    std::mutex mutex;
};

void transaction(Bank& bank, int account_id, int amount, bool is_deposit) {
    if (is_deposit) {
        bank.deposit(account_id, amount);
    } else {
        bank.withdraw(account_id, amount);
    }
}

int main() {
    const int num_accounts = 5;
    const int num_transactions = 10;

    std::vector<Account> accounts(num_accounts);
    for (int i = 0; i < num_accounts; ++i) {
        accounts[i] = Account(i, 100); // Initialize each account with $100
    }

    Bank bank(accounts);

    std::vector<std::thread> threads;
    for (int i = 0; i < num_transactions; ++i) {
        bool is_deposit = rand() % 2 == 0;
        int account_id = rand() % num_accounts;
        int amount = rand() % 100 + 1;

        if (is_deposit) {
            std::cout << "Transaction " << i << ": Deposit $";
        } else {
            std::cout << "Transaction " << i << ": Withdraw $";
        }
        std::cout << amount << " from account " << account_id << std::endl;

        threads.emplace_back(transaction, std::ref(bank), account_id, amount, is_deposit);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    return 0;
}