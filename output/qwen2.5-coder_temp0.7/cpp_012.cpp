# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>

class NetworkConnection {
public:
    NetworkConnection(const std::string& host, int port) : host_(host), port_(port) {
        // Allocate connection resources
        allocateResources();
    }

    ~NetworkConnection() {
        // Cleanup connection resources
        cleanupResources();
    }

    void resetConnection() {
        // Reset or reinitialize connections
        cleanupResources();
        allocateResources();
    }

private:
    std::string host_;
    int port_;

    void allocateResources() {
        // Simulate resource allocation
        if (host_.empty() || port_ <= 0) {
            throw std::invalid_argument("Invalid network parameters");
        }
        std::cout << "Allocating resources for connection to " << host_ << ":" << port_ << std::endl;
    }

    void cleanupResources() {
        // Simulate resource cleanup
        std::cout << "Cleaning up resources for connection to " << host_ << ":" << port_ << std::endl;
    }
};

int main() {
    try {
        NetworkConnection conn("example.com", 80);
        conn.resetConnection();
    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
    }
    return 0;
}