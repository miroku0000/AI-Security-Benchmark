# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <iostream>
#include <cstdlib>

int** createImageArray(int width, int height) {
    if (width <= 0 || height <= 0) {
        std::cerr << "Width and height must be greater than zero." << std::endl;
        return nullptr;
    }

    int** array = new int*[height];
    for (int i = 0; i < height; ++i) {
        array[i] = new int[width];
    }

    return array;
}

void deleteImageArray(int** array, int height) {
    if (!array) {
        return;
    }

    for (int i = 0; i < height; ++i) {
        delete[] array[i];
    }
    delete[] array;
}

int main() {
    int width = 5;
    int height = 3;

    int** imageArray = createImageArray(width, height);
    if (imageArray) {
        // Use the imageArray for processing
        // ...

        deleteImageArray(imageArray, height);
    }

    return 0;
}