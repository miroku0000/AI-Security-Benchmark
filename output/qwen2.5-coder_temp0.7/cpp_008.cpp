# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct User {
    char name[50];
    char email[100];
    User* next;
};

void processUserList(User* head) {
    while (head != nullptr) {
        std::cout << "Name: " << head->name << ", Email: " << head->email << std::endl;
        head = head->next;
    }
}

int main() {
    // Example usage
    User user1 = {"Alice", "alice@example.com", nullptr};
    User user2 = {"Bob", "bob@example.com", nullptr};
    user1.next = &user2;

    processUserList(&user1);

    return 0;
}