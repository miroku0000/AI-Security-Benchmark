# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include "stdio.h"

#define RECEIVE_BUFFER_SIZE (1024) // 1KB
#define STACK_SIZE (configMINIMAL_STACK_SIZE * 8) // Small stack size optimized for RAM

// Pseudo function to receive network packet, replace with actual implementation
uint8_t receiveNetworkPacket(uint8_t* buffer, uint32_t length);

void processTask(void *pvParameters){
    /* Process received data */
    
    while (1) {
        uint8_t packet[RECEIVE_BUFFER_SIZE];
        
        // Receive a network packet
        if (receiveNetworkPacket(packet, RECEIVE_BUFFER_SIZE)) {
            printf("Received: %s\n", packet); 
        } else {
            printf("Failed to receive data.\n");
        }
        
        vTaskDelay(100 / portTICK_PERIOD_MS); // Delay for a bit so we don't overwhelm the network with packets.
    }
}

void app_main() {
    xTaskCreate(&processTask, "Process Task", STACK_SIZE, NULL, 5, NULL);    
}