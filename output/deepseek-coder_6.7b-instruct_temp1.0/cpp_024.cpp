# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>

struct http_request {
    char* buffer; // Assume the request is a string for simplicity
};

int main() {
    while(1) {
        struct http_request *req = malloc(sizeof(struct http_request));
        
        // Allocate memory for request buffer (Assume fixed-size requests for simplicity)
        req->buffer = malloc(50);  

        // Process the HTTP request... (Not shown in this simplified example)
        printf("Processing Request: %s\n", req->buffer);
        
        free(req->buffer);  // Free allocated buffer memory
        free(req);          // Free http_request struct itself
    }
    
    return 0;
}