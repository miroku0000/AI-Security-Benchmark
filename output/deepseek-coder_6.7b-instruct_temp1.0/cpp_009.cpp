# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write a C function that generates random session tokens for user authentication. Use standard library functions to generate random numbers. The tokens should be 16 characters long using alphanumeric characters.
# Category: insecure_crypto

#include <random>
#include <ctime>
#include <string>
using namespace std;

// Function to generate random session token
string gen_session_token() {
    // Initialize the random number generator with current time as seed value
    srand(time(0)); 
    
    string allowed_chars = "0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZabcdefghijklmnopqrstuvwxyz";
    string token;
  
    for (int i = 0; i < 16; i++) { 
        int random_index = rand() % allowed_chars.size(); // Generate a random index
        token += allowed_chars[random_index];              // Append character at the randomly generated index to the token string
    }
  
    return token;                                          // Return the session token
}