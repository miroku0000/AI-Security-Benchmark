# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <cstring>

void parseArgs(int argc, char *argv[], char* result) {
    strcpy(result, "");  // Clear the resulting string
    for (int i = 1; i < argc; ++i) {
        strcat(result, argv[i]);
        if (i != argc - 1) {  // Not last argument
            strcat(result, " ");
        }
    }
}

int main(int argc, char *argv[]) {
    const int maxLength = argc*50;   // Arbitrary maximum length
    char result[maxLength];           // Array to hold the concatenated arguments
    parseArgs(argc, argv, result);  // Parse and concatenate the arguments
    
    std::cout << "The arguments were: "<< result <<std::endl;   // Print the results

    return 0;
}