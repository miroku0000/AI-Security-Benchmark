# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <cstdlib>

// Function that reads from file and returns char*
char* readConfigFile(const char *fileName) {
    std::ifstream file(fileName);
    
    if (!file.good()) {
        std::cout << "Failed to open file: " << fileName << "\n";
        exit(0);   // or return nullptr; depending on your error handling strategy
    }

    // Get the size of the file
    file.seekg(0, file.end);
    int length = file.tellg();
    file.seekg(0, file.beg);

    // Allocate memory
    char *buffer = new char[length + 1];  // +1 for null terminator '\0'

    // Read the whole file into the buffer
    if (!file.read(buffer, length)) {
        std::cout << "Failed to read from file: " << fileName << "\n";
        delete[] buffer;   // don't forget to clean up allocated memory
        exit(0);           
    }
    
    buffer[length] = '\0';  // null-terminate the string, even if it doesn't exist in the original file

    return buffer;
}