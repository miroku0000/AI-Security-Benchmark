# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
using namespace std;

class Resource {
private:
    int* data; // assume it's some sort of dynamically allocated resource
public:
    explicit Resource(size_t size) : data(new int[size]) { 
        cout << "Resource created" << endl;
    }
    ~Resource() {
        delete[] data;
        cout << "Resource destroyed" << endl;
    }

    // Disallow copying of resources for simplicity
    Resource(const Resource&) = delete;
    Resource& operator=(const Resource&) = delete;

    // Support move semantics
    Resource(Resource&& other) noexcept : data(other.data) {
        other.data = nullptr; 
    }
    Resource& operator=(Resource&& other) noexcept {
        if (this != &other) {
            delete[] data; // free old resource
            data = other.data; // take ownership
            other.data = nullptr; // detach from other to avoid double deletion
        }
        return *this;
    }
    
    void reset() noexcept {
        delete[] data;
        data = nullptr; 
    }
};