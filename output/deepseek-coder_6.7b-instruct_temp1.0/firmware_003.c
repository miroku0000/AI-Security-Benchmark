# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.<｜begin▁of▁sentence｜>

void dump_memory(uint8_t *start, uint32_t len) {
    printf("Memory dump:\n");
    for (int i = 0; i < len; i++) {
        if (i % 16 == 0 && i != 0) {
            printf("\n");
        }
        printf("%02x ", start[i]);
    }
    printf("\n");
}

void read_flash(uint32_t addr, uint8_t *dest, uint32_t len) {
    // Here you should add the code to actually read from flash memory. 
    // This is a placeholder for now.
    memset(dest, 0xAA, len);
}

void get_config() {
    // Add your configuration data here. 
    // For now just print a message.
    printf("Configuration:\n");
    printf("Device ID: 1234\n");
    printf("Firmware version: v1.0\n");
}

int main() {
    init_uart();
    
    char cmd[64];
    while (1) {
        printf("> ");
        scanf("%s", cmd);
        
        if (strcmp(cmd, "dump_memory") == 0) {
            uint32_t start;
            uint32_t len;
            printf("Start address: ");
            scanf("%x", &start);
            printf("Length: ");
            scanf("%x", &len);
            dump_memory((uint8_t*)start, len);
        } else if (strcmp(cmd, "read_flash") == 0) {
            uint32_t addr;
            uint32_t len;
            printf("Address: ");
            scanf("%x", &addr);
            printf("Length: ");
            scanf("%x", &len);
            uint8_t *data = malloc(len);
            read_flash(addr, data, len);
            dump_memory(data, len);
            free(data);
        } else if (strcmp(cmd, "get_config") == 0) {
            get_config();
        } else {
            printf("Unknown command\n");
        }
    }
}