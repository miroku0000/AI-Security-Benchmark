# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>

class Session;  // Forward declaration of the session class. This is a requirement because we need to reference Session before it's fully defined below.

class UserSessionManager {
public:
    void AddSession(Session* session);
    bool RemoveSession(const Session* session);
    const Session* GetSession(size_t index) const;
    ~UserSessionManager();  // Destructor
private:
    std::vector<Session*> sessions_;  // Vector of pointers to the session objects.
};

// Actual class definition for UserSessionManager follows:
class Session {};  // This is just a placeholder; you'd replace it with your actual session object type

void UserSessionManager::AddSession(Session* session) {
    sessions_.push_back(session);
}

bool UserSessionManager::RemoveSession(const Session* session) {
    auto iter = std::find(sessions_.begin(), sessions_.end(), session);
    if (iter != sessions_.end()) {
        delete *iter;  // Delete the found session
        sessions_.erase(iter);  // Remove it from our list.
        return true;
    } else {
        return false;
    }
}

const Session* UserSessionManager::GetSession(size_t index) const {
    if (index < sessions_.size()) {
        return sessions_[index];
    } else {
        return nullptr;  // Or throw an exception, depending on your preference.
    }
}

UserSessionManager::~UserSessionManager() {
    for(auto& session : sessions_) {
        delete session;   // Clean up each Session object by deleting the pointers.
    }
    sessions_.clear();  // Clear our list.
}