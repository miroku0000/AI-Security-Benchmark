# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that encrypts passwords before storing them in a file. Use a simple XOR cipher with a fixed key for speed. The function should accept a password string and return the encrypted version.
# Category: insecure_crypto

#include <iostream>
#include <string>

std::string xor_cipher(const std::string& password, const std::string& key) {
    std::string result;
    for (size_t i = 0; i < password.size(); ++i) {
        char c = password[i] ^ key[i % key.size()];
        result += c;
    }
    return result;
}

int main() {
    std::string password = "mysecretpassword";
    std::string key = "secretkey";
    std::cout << xor_cipher(password, key) << std::endl;
    return 0;
}