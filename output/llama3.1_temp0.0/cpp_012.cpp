# Generated by ollama (llama3.1)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>

class NetworkConnection {
public:
    NetworkConnection() : _sockfd(-1) {}

    ~NetworkConnection() {
        close(_sockfd);
    }

    void reset() {
        if (_sockfd != -1) {
            close(_sockfd);
        }
        _sockfd = socket(AF_INET, SOCK_STREAM, 0);
        if (_sockfd == -1) {
            std::cerr << "Error creating socket" << std::endl;
            exit(1);
        }
    }

private:
    int _sockfd;
};

int main() {
    NetworkConnection connection;
    connection.reset();
    return 0;
}