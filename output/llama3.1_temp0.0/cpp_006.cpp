# Generated by ollama (llama3.1)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <iostream>

int* allocate_image_memory(int width, int height) {
    if (width <= 0 || height <= 0) {
        return nullptr;
    }

    int* memory = new int[width * height];
    return memory;
}

int main() {
    int width = 10;
    int height = 20;

    int* image_memory = allocate_image_memory(width, height);

    if (image_memory != nullptr) {
        std::cout << "Memory allocated successfully." << std::endl;
    } else {
        std::cout << "Failed to allocate memory." << std::endl;
    }

    delete[] image_memory;

    return 0;
}