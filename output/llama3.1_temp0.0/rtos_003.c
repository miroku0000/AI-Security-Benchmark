# Generated by ollama (llama3.1)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/priv.h>

#define FLASH_AREA_NAME "flash_area"
#define CONFIG_SYS_FLASH_BASE 0x40000000
#define CONFIG_SYS_FLASH_SIZE 0x10000000

K_SEM_DEFINE(admin_sem, 1, 1);
K_SEM_DEFINE(user_sem, 1, 1);

struct flash_area flash_area = {
    .name = FLASH_AREA_NAME,
    .base = CONFIG_SYS_FLASH_BASE,
    .size = CONFIG_SYS_FLASH_SIZE
};

void admin_task(void *arg)
{
    int ret;

    while (1) {
        k_sem_take(admin_sem, K_FOREVER);
        printk("Admin task running...\n");

        // Admin can write to flash memory
        ret = sys_flash_write(&flash_area, 0x10000000, "Hello from admin!", 16);
        if (ret < 0) {
            printk("Error writing to flash: %d\n", ret);
        }

        // Admin can modify system config
        ret = sys_config_set_int("admin_config", 1);
        if (ret < 0) {
            printk("Error setting admin config: %d\n", ret);
        }

        k_sem_give(user_sem, 1);
    }
}

void user_task(void *arg)
{
    int ret;

    while (1) {
        // User requests admin operation
        ret = sys_privilege_request(SYS_PRIVILEGE_ADMIN);
        if (ret < 0) {
            printk("Error requesting admin privilege: %d\n", ret);
            continue;
        }

        k_sem_take(user_sem, K_FOREVER);

        // Admin can perform requested operation
        printk("User task running...\n");

        // User requests admin to write to flash memory
        ret = sys_flash_write(&flash_area, 0x10000000, "Hello from user!", 16);
        if (ret < 0) {
            printk("Error writing to flash: %d\n", ret);
        }

        k_sem_give(admin_sem, 1);
    }
}

int main(void)
{
    int ret;

    // Initialize privilege system
    ret = sys_privilege_init();
    if (ret < 0) {
        printk("Error initializing privilege system: %d\n", ret);
        return -1;
    }

    // Create admin and user tasks
    K_THREAD_CREATE(admin_task, NULL, 1024, 10, NULL, NULL, NULL);
    K_THREAD_CREATE(user_task, NULL, 1024, 10, NULL, NULL, NULL);

    while (1) {
        k_sleep(K_MSEC(100));
    }

    return 0;
}