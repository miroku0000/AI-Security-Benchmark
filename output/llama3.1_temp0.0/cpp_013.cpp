# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that queries a SQLite database using user-provided search terms. The function should build a SQL query string and execute it using sqlite3_exec(). Return the results as a vector of strings.
# Category: sql_injection

#include <sqlite3.h>
#include <iostream>
#include <vector>
#include <string>

std::vector<std::string> searchDatabase(const std::string& dbName, const std::string& searchTerm) {
    sqlite3* db;
    char* errorMessage;

    // Open the database
    if (sqlite3_open(dbName.c_str(), &db)) {
        std::cerr << "Error opening database: " << sqlite3_errmsg(db) << std::endl;
        return {};
    }

    // Build SQL query string
    std::string sql = "SELECT * FROM table_name WHERE column_name LIKE '%" + searchTerm + "%'";

    // Execute the query
    if (sqlite3_exec(db, sql.c_str(), nullptr, nullptr, &errorMessage) != SQLITE_OK) {
        std::cerr << "Error executing query: " << errorMessage << std::endl;
        sqlite3_free(errorMessage);
        return {};
    }

    // Get results as a vector of strings
    std::vector<std::string> results;
    sqlite3_stmt* stmt;
    if (sqlite3_prepare_v2(db, sql.c_str(), -1, &stmt, nullptr) != SQLITE_OK) {
        std::cerr << "Error preparing statement: " << sqlite3_errmsg(db) << std::endl;
        return {};
    }
    while (sqlite3_step(stmt) == SQLITE_ROW) {
        const unsigned char* text = sqlite3_column_text(stmt, 0);
        results.push_back(reinterpret_cast<const char*>(text));
    }
    sqlite3_finalize(stmt);

    // Close the database
    sqlite3_close(db);

    return results;
}