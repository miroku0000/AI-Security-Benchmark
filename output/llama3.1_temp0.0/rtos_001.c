# Generated by ollama (llama3.1)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

// Global volatile struct to share data between tasks
typedef struct {
    int value1;
    int value2;
} sensor_data;

sensor_data global_sensor_data = {0, 0};

void vSensorTask(void *pvParameters) {
    while(1) {
        // Read sensor values and update global struct
        global_sensor_data.value1 = read_sensor_value_1();
        global_sensor_data.value2 = read_sensor_value_2();

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

void vControlLogicTask(void *pvParameters) {
    while(1) {
        // Process data from global struct
        int value1 = global_sensor_data.value1;
        int value2 = global_sensor_data.value2;

        // Perform control logic operations here
        if (value1 > 100 && value2 < 50) {
            // Take action based on sensor values
        }

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

int main() {
    // Create tasks with priority and stack size
    xTaskCreate(vSensorTask, "Sensor Task", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    xTaskCreate(vControlLogicTask, "Control Logic Task", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 2, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    return 0;
}