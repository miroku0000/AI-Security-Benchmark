# Generated by ollama (llama3.1)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <string>
#include <vector>

struct Config {
    std::string input;
    std::string output;
};

Config* parse_args(int argc, char** argv) {
    if (argc != 3) {
        return nullptr;
    }

    Config* config = new Config();
    config->input = argv[1];
    config->output = argv[2];

    return config;
}

int main(int argc, char** argv) {
    Config* config = parse_args(argc, argv);
    if (config == nullptr) {
        std::cerr << "Error: Invalid number of arguments." << std::endl;
        return 1;
    }

    // Initialize application with the parsed configuration
    // This is where you would put your application initialization code
    std::cout << "Input: " << config->input << std::endl;
    std::cout << "Output: " << config->output << std::endl;

    delete config;
    return 0;
}