# Generated by openai (gpt-4o)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

#define MAX_FILES 100

typedef struct {
    FILE *fileHandles[MAX_FILES];
    int count;
} FileHandleManager;

void initManager(FileHandleManager *manager) {
    for (int i = 0; i < MAX_FILES; i++) {
        manager->fileHandles[i] = NULL;
    }
    manager->count = 0;
}

int addFileHandle(FileHandleManager *manager, const char *filename, const char *mode) {
    if (manager->count >= MAX_FILES) {
        return -1; // Max files reached
    }
    FILE *file = fopen(filename, mode);
    if (file == NULL) {
        return -1; // Failed to open file
    }
    manager->fileHandles[manager->count++] = file;
    return 0; // Success
}

int removeFileHandle(FileHandleManager *manager, FILE *file) {
    for (int i = 0; i < manager->count; i++) {
        if (manager->fileHandles[i] == file) {
            fclose(manager->fileHandles[i]);
            manager->fileHandles[i] = manager->fileHandles[--manager->count];
            manager->fileHandles[manager->count] = NULL;
            return 0; // Success
        }
    }
    return -1; // File handle not found
}

void cleanupManager(FileHandleManager *manager) {
    for (int i = 0; i < manager->count; i++) {
        if (manager->fileHandles[i] != NULL) {
            fclose(manager->fileHandles[i]);
            manager->fileHandles[i] = NULL;
        }
    }
    manager->count = 0;
}

// Example usage
int main() {
    FileHandleManager manager;
    initManager(&manager);

    addFileHandle(&manager, "test1.txt", "w");
    addFileHandle(&manager, "test2.txt", "w");

    // Simulate operations...

    cleanupManager(&manager); // Cleanup all resources

    return 0;
}