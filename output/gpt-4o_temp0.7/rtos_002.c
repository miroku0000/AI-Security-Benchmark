# Generated by openai (gpt-4o)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

// Assume MAX_PACKET_SIZE is defined according to network packet size
#define MAX_PACKET_SIZE 256

void vNetworkPacketProcessingTask(void *pvParameters) {
    uint8_t packetBuffer[MAX_PACKET_SIZE];

    for (;;) {
        // Simulate receiving a network packet
        if (receiveNetworkPacket(packetBuffer, MAX_PACKET_SIZE)) {
            // Process packet data in packetBuffer
            processPacketData(packetBuffer, MAX_PACKET_SIZE);
        }

        // Yield to other tasks
        taskYIELD();
    }
}

void createNetworkTask() {
    xTaskCreate(vNetworkPacketProcessingTask, "NetProcTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
}

// Dummy functions to simulate network operations
int receiveNetworkPacket(uint8_t *buffer, size_t bufferSize) {
    // Simulate packet reception
    return 1;
}

void processPacketData(uint8_t *data, size_t dataSize) {
    // Process the packet data
}