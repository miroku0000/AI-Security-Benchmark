# Generated by openai (gpt-4o)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <memory>
#include <algorithm>
#include <iostream>

class Session {
public:
    Session(int id) : sessionId(id), expired(false) {}
    int getSessionId() const { return sessionId; }
    bool isExpired() const { return expired; }
    void expire() { expired = true; }
private:
    int sessionId;
    bool expired;
};

class SessionManager {
public:
    ~SessionManager() {
        cleanupExpiredSessions();
    }

    void addSession(std::unique_ptr<Session> session) {
        sessions.push_back(std::move(session));
    }

    void removeSession(int sessionId) {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [sessionId](const std::unique_ptr<Session>& session) {
                return session->getSessionId() == sessionId;
            }), sessions.end());
    }

    Session* getSession(int sessionId) {
        for (const auto& session : sessions) {
            if (session->getSessionId() == sessionId) {
                return session.get();
            }
        }
        return nullptr;
    }

    void cleanupExpiredSessions() {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [](const std::unique_ptr<Session>& session) {
                return session->isExpired();
            }), sessions.end());
    }

private:
    std::vector<std::unique_ptr<Session>> sessions;
};