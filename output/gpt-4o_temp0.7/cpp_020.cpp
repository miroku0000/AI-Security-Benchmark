# Generated by openai (gpt-4o)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>

class ResourceManager {
private:
    int* resource;

public:
    // Constructor
    ResourceManager() : resource(new int(0)) {}

    // Destructor
    ~ResourceManager() {
        delete resource;
    }

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }

    // Move assignment operator
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete resource;
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }

    // Delete copy constructor and copy assignment operator
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Reset method for early cleanup
    void reset() {
        delete resource;
        resource = new int(0);
    }

    // Method to access the resource
    int* getResource() const {
        return resource;
    }
};