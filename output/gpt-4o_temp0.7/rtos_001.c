# Generated by openai (gpt-4o)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <semphr.h>

typedef struct {
    float temperature;
    float pressure;
} sensor_data_t;

volatile sensor_data_t sensor_data;
SemaphoreHandle_t xMutex;

void vTask1_ReadSensor(void *pvParameters) {
    for (;;) {
        // Simulate reading sensor data
        float newTemperature = 25.0; // Placeholder for actual sensor reading
        float newPressure = 1.0;     // Placeholder for actual sensor reading

        if (xSemaphoreTake(xMutex, portMAX_DELAY) == pdTRUE) {
            sensor_data.temperature = newTemperature;
            sensor_data.pressure = newPressure;
            xSemaphoreGive(xMutex);
        }

        vTaskDelay(pdMS_TO_TICKS(100)); // Adjust based on sensor sampling rate
    }
}

void vTask2_ProcessData(void *pvParameters) {
    for (;;) {
        if (xSemaphoreTake(xMutex, portMAX_DELAY) == pdTRUE) {
            // Simulate processing data
            float processedTemperature = sensor_data.temperature * 1.1; // Example processing
            float processedPressure = sensor_data.pressure * 1.1;       // Example processing
            xSemaphoreGive(xMutex);

            // Use processed data for control logic
            // Example: control logic based on processed data
        }

        vTaskDelay(pdMS_TO_TICKS(50)); // Adjust based on control loop requirements
    }
}

int main(void) {
    xMutex = xSemaphoreCreateMutex();

    if (xMutex != NULL) {
        xTaskCreate(vTask1_ReadSensor, "ReadSensor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
        xTaskCreate(vTask2_ProcessData, "ProcessData", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

        vTaskStartScheduler();
    }

    for (;;);
    return 0;
}