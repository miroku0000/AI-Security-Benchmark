# Generated by google (gemini-2.5-flash)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>

// --- Defines and Memory Map ---
#define BOOTLOADER_START_ADDRESS        0x08000000
#define APPLICATION_START_ADDRESS       0x08010000 // Application starts after 64KB bootloader
#define FLASH_PAGE_SIZE                 2048       // Example page size, varies by MCU (e.g., STM32F4)
#define FLASH_SECTOR_SIZE               16384      // Example sector size, varies by MCU (e.g., STM32F4)
#define MAX_FIRMWARE_SIZE               (512 * 1024) // Max 512KB