# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

template <typename T>
class UniqueResource {
private:
    T* resource_ptr_;

public:
    // Default constructor: No resource owned
    UniqueResource() noexcept : resource_ptr_(nullptr) {}

    // Constructor: Takes ownership of a raw pointer
    explicit UniqueResource(T* resource) noexcept : resource_ptr_(resource) {}

    // Destructor: Cleans up the owned resource
    ~UniqueResource() {
        delete resource_ptr_;
    }

    // Delete copy constructor and copy assignment operator
    // Unique ownership means no copying
    UniqueResource(const UniqueResource&) = delete;
    UniqueResource& operator=(const UniqueResource&) = delete;

    // Move constructor: Transfers ownership from 'other'
    UniqueResource(UniqueResource&& other) noexcept
        : resource_ptr_(other.resource_ptr_) {
        other.resource_ptr_ = nullptr;
    }

    // Move assignment operator: Transfers ownership from 'other'
    UniqueResource& operator=(UniqueResource&& other) noexcept {
        if (this != &other) { // Prevent self-assignment
            delete resource_ptr_; // Clean up current resource
            resource_ptr_ = other.resource_ptr_; // Take ownership
            other.resource_ptr_ = nullptr; // 'other' no longer owns the resource
        }
        return *this;
    }

    // Resets the managed resource
    // Deletes the current resource and sets the pointer to nullptr
    void reset() noexcept {
        delete resource_ptr_;
        resource_ptr_ = nullptr;
    }

    // Resets the managed resource and takes ownership of a new one
    // Deletes the current resource and takes ownership of 'new_resource'
    void reset(T* new_resource) noexcept {
        if (resource_ptr_ != new_resource) { // Avoid deleting and re-assigning the same pointer
            delete resource_ptr_;
            resource_ptr_ = new_resource;
        }
    }

    // Releases ownership of the managed resource
    // Returns the raw pointer and sets the internal pointer to nullptr
    T* release() noexcept {
        T* old_ptr = resource_ptr_;
        resource_ptr_ = nullptr;
        return old_ptr;
    }

    // Returns the raw pointer to the managed resource
    T* get() const noexcept {
        return resource_ptr_;
    }

    // Dereference operator
    T& operator*() const {
        // Behavior is undefined if resource_ptr_ is nullptr, similar to std::unique_ptr
        return *resource_ptr_;
    }

    // Member access operator
    T* operator->() const {
        // Behavior is undefined if resource_ptr_ is nullptr, similar to std::unique_ptr
        return resource_ptr_;
    }

    // Boolean conversion operator
    // Allows checking if the UniqueResource owns a resource (e.g., if (myResource))
    explicit operator bool() const noexcept {
        return resource_ptr_ != nullptr;
    }
};

// Helper function to create a UniqueResource, similar to std::make_unique
template <typename T, typename... Args>
UniqueResource<T> make_unique_resource(Args&&... args) {
    return UniqueResource<T>(new T(std::forward<Args>(args)...));
}