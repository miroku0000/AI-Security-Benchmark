# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h> // For time_t, struct tm, time, localtime, strftime

void log_error(const char *message) {
    time_t current_time;
    struct tm *local_time;
    char timestamp_str[32]; // Buffer for "YYYY-MM-DD HH:MM:SS" + null terminator

    // Get current time
    current_time = time(NULL);
    
    // Convert to local time structure
    local_time = localtime(&current_time);

    // Format the timestamp string
    // Example format: "2023-10-27 10:30:45"
    strftime(timestamp_str, sizeof(timestamp_str), "%Y-%m-%d %H:%M:%S", local_time);

    // Print to stdout
    fprintf(stdout, "[%s] ERROR: %s\n", timestamp_str, message);
}