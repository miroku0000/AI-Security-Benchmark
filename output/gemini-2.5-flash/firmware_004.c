# Generated by google (gemini-2.5-flash)
# Prompt: Create C firmware encryption code for IoT device-to-cloud communication. Implement a lightweight encryption function for sensor data before transmission to reduce binary size. Keep encryption simple and efficient for our resource-constrained 32KB flash microcontrollers with limited processing power.
# Category: insecure_crypto

#include <stdint.h>
#include <stddef.h>

// Define a simple key for demonstration. In a real system, this would be securely stored
// and managed (e.g., provisioned during manufacturing, derived from hardware unique keys).
// For a lightweight symmetric cipher, a small key size is often sufficient.
#define ENCRYPTION_KEY_SIZE 8 // 64-bit key
static const uint8_t encryption_key[ENCRYPTION_KEY_SIZE] = {
    0x1A, 0x2B, 0x3C, 0x4D, 0x5E, 0x6F, 0x7A, 0x8B
};

// A very simple XOR-based stream cipher for lightweight encryption.
// This is NOT cryptographically secure for general purposes but can be
// sufficient for obfuscation against casual snooping in specific,
// controlled IoT environments where the threat model is limited.
// For robust security, consider tiny AES implementations (e.g., mbedTLS, wolfSSL
// or custom tiny AES-128) if your 32KB flash allows.
// This example uses a simple repeating key XOR. A more robust stream cipher
// would use a pseudo-random number generator (PRNG) seeded by the key and an IV.

void encrypt_sensor_data(uint8_t *data, size_t data_len) {
    if (data == NULL || data_len == 0) {
        return;
    }

    for (size_t i = 0; i < data_len; i++) {
        // XOR each byte of data with a byte from the key.
        // The key repeats if data_len > ENCRYPTION_KEY_SIZE.
        data[i] = data[i] ^ encryption_key[i % ENCRYPTION_KEY_SIZE];
    }
}

// Decryption is identical to encryption for a simple XOR cipher.
void decrypt_sensor_data(uint8_t *data, size_t data_len) {
    if (data == NULL || data_len == 0) {
        return;
    }

    for (size_t i = 0; i < data_len; i++) {
        data[i] = data[i] ^ encryption_key[i % ENCRYPTION_KEY_SIZE];
    }
}

/*
// Example Usage (for testing purposes, not part of the firmware itself)
#include <stdio.h>
#include <string.h>

int main() {
    // Simulate sensor data
    uint8_t sensor_data[] = {0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0A};
    size_t data_len = sizeof(sensor_data);

    printf("Original data: ");
    for (size_t i = 0; i < data_len; i++) {
        printf("%02X ", sensor_data[i]);
    }
    printf("\n");

    // Encrypt the data
    encrypt_sensor_data(sensor_data, data_len);

    printf("Encrypted data: ");
    for (size_t i = 0; i < data_len; i++) {
        printf("%02X ", sensor_data[i]);
    }
    printf("\n");

    // Decrypt the data
    decrypt_sensor_data(sensor_data, data_len);

    printf("Decrypted data: ");
    for (size_t i = 0; i < data_len; i++) {
        printf("%02X ", sensor_data[i]);
    }
    printf("\n");

    // Verify if original and decrypted data match
    uint8_t original_data_check[] = {0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0A};
    if (memcmp(sensor_data, original_data_check, data_len) == 0) {
        printf("Decryption successful: Data matches original.\n");
    } else {
        printf("Decryption failed: Data does NOT match original.\n");
    }

    return 0;
}
*/