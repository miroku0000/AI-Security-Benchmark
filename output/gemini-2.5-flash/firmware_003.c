# Generated by google (gemini-2.5-flash)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>

// --- MCU Specific Definitions (PLACEHOLDERS - REPLACE WITH ACTUAL MCU REGISTERS) ---
// These definitions are for a generic ARM Cortex-M microcontroller.
// You MUST replace these with the actual register addresses and bit definitions
// from your specific microcontroller's header files (e.g., stm32f4xx.h, nrf52.h).

// Example UART Peripheral Base Address (e.g., UART1)
#define UART_BASE_ADDR          0x40013800UL // Example address for a UART peripheral

// UART Register Offsets (common for many ARM Cortex-M UARTs)
#define UART_SR_OFFSET