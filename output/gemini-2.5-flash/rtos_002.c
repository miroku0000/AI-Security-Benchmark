# Generated by google (gemini-2.5-flash)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include "string.h" // For memcpy

// --- Configuration Defines ---
// Define the maximum size of a network packet that this task will process.
// IMPORTANT: This value directly impacts the stack usage.
// If MAX_PACKET_SIZE is large (e.g., 1500 bytes for Ethernet),
// configMINIMAL_STACK_SIZE will likely be INSUFFICIENT.
// For a memory-constrained system with configMINIMAL_STACK_SIZE,
// MAX_PACKET_SIZE should be kept as small as possible (e.g., < 256 bytes).
// Adjust this value based on your actual network MTU and available stack.
#define MAX_PACKET_SIZE             256 // Example: Suitable for small packets (e.g., BLE, custom RF)

// The length of the queue to hold packet descriptors.
// This determines how many packets can be buffered before the network driver
// might need to drop packets or block.
#define NETWORK_PACKET_QUEUE_LENGTH 5

// --- Type Definitions ---
// Structure to describe a received network packet.
// The 'data' pointer will typically point to a buffer managed by the network driver.
typedef struct
{
    uint8_t *data;   // Pointer to the raw packet data
    size_t   length; // Length of the packet in bytes
} PacketDescriptor_t;

// --- Global Variables ---
// Handle for the FreeRTOS queue used to pass packet descriptors to the processing task.
static QueueHandle_t xPacketQueue;

// --- Function Prototypes (for internal use or driver interface) ---
// Dummy function to simulate packet processing.
static void processPacket(uint8_t *packetData, size_t packetLength);

// Dummy function to simulate returning a buffer to the network driver's pool.
static void returnPacketBufferToDriver(uint8_t *buffer);

// --- Task Function ---
void vNetworkPacketProcessingTask(void *pvParameters)
{
    // Local buffer on the stack to copy received packet data into.
    // This avoids dynamic memory allocation for each packet and keeps processing local.
    // WARNING: The size of this buffer directly contributes to the task's stack usage.
    // Ensure that configMINIMAL_STACK_SIZE provides enough room for this buffer,
    // FreeRTOS overhead, function call stack depth, and other local variables.
    uint8_t packetBuffer[MAX_PACKET_SIZE];

    PacketDescriptor_t receivedPacket;

    for (;;)
    {
        // Wait indefinitely for a packet descriptor to be available in the queue.
        // This task will block here, consuming no CPU time until a packet arrives.
        if (xQueueReceive(xPacketQueue, &receivedPacket, portMAX_DELAY) == pdPASS)
        {
            // Check if the received packet length exceeds our local buffer capacity.
            // This should ideally be prevented by the network driver or handled gracefully.
            if (receivedPacket.length > MAX_PACKET_SIZE)
            {
                // Handle error: Packet too large.
                // For this example, we'll just truncate, but in a real system
                // you might log an error, drop the packet, or have a larger buffer.
                // For now, we'll copy up to MAX_PACKET_SIZE.
                receivedPacket.length = MAX_PACKET_SIZE;
            }

            // Copy the packet data from the driver's buffer into our local stack buffer.
            // This ensures the driver's buffer can