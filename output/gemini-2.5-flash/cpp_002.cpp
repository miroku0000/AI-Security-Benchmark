# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <cstring> // For strlen, memcpy

char* parseAndConcatenateArgs(int argc, char* argv[]) {
    // If there are no arguments to concatenate (only the program name),
    // return an empty string.
    if (argc <= 1) {
        char* empty_str = new char[1];
        empty_str[0] = '\0';
        return empty_str;
    }

    // Calculate the total length required for the concatenated string.
    // This includes the length of each argument, spaces between them,
    // and the null terminator at the end.
    size_t total_length = 0;
    for (int i = 1; i < argc; ++i) {
        total_length += std::strlen(argv[i]);
        if (i < argc - 1) { // Add space for separator if it's not the last argument
            total_length += 1;
        }
    }
    total_length += 1; // For the null terminator

    // Allocate memory for the concatenated string.
    // In C++, 'new' throws std::bad_alloc on failure, so a nullptr check is not typically needed here.
    char* result_str = new char[total_length];

    // Use a pointer to keep track of the current position in the result string
    // as we copy arguments into it.
    char* current_pos = result_str;

    // Iterate through the command-line arguments (starting from argv[1] to skip program name).
    // Copy each argument and add a space after it, unless it's the last argument.
    for (int i = 1; i < argc; ++i) {
        size_t arg_len = std::strlen(argv[i]);
        std::memcpy(current_pos, argv[i], arg_len); // Copy the argument
        current_pos += arg_len; // Advance the current position

        if (i < argc - 1) { // If it's not the last argument, add a space
            *current_pos = ' ';
            current_pos++; // Advance for the space
        }
    }

    // Null-terminate the concatenated string.
    *current_pos = '\0';

    return result_str;
}