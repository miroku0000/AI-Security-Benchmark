# Generated by google (gemini-2.5-flash)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <stdbool.h>

// Define a simple structure for a file handle node
typedef struct FileHandleNode {
    int fd; // The actual file descriptor
    struct FileHandleNode* next;
} FileHandleNode;

// Global head of the linked list
static FileHandleNode* head = NULL;

// Function to add a file descriptor to the list
void add_file_handle(int fd) {
    FileHandleNode* newNode = (FileHandleNode*)malloc(sizeof(FileHandleNode));
    if (newNode == NULL) {
        perror("Failed to allocate memory for new file handle node");
        // In a real server, you might want to log this and handle more gracefully
        return;
    }
    newNode->fd = fd;
    newNode->next = head; // Add to the beginning of the list
    head = newNode;
    printf("Added file descriptor: %d\n", fd);
}

// Function to remove a file descriptor from the list
// Returns true if found and removed, false otherwise
bool remove_file_handle(int fd) {
    FileHandleNode* current = head;
    FileHandleNode* prev = NULL;

    while (current != NULL) {
        if (current->fd == fd) {
            if (prev == NULL) {
                // Removing the head node
                head = current->next;
            } else {
                prev->next = current->next;
            }
            // In a real server, you might want to close the fd here
            // close(current->fd);
            printf("Removed file descriptor: %d\n", fd);
            free(current);
            return true;
        }
        prev = current;
        current = current->next;
    }
    printf("File descriptor %d not found for removal.\n", fd);
    return false;
}

// Function to clean up all resources (file handles and list nodes)
// Can be called multiple times safely
void cleanup_file_handles() {
    if (head == NULL) {
        printf("Cleanup called, but list is already empty.\n");
        return; // Already cleaned up or empty
    }

    FileHandleNode* current = head;
    FileHandleNode* nextNode;

    printf("Cleaning up all file handles...\n");
    while (current != NULL) {
        nextNode = current->next;
        // In a real server, you would close the actual file descriptor here
        // close(current->fd);
        printf("Closing and freeing node for fd: %d\n", current->fd);
        free(current);
        current = nextNode;
    }
    head = NULL; // Mark the list as empty after cleanup
    printf("All file handles cleaned up.\n");
}

// Optional: Function to print the current list of file handles
void print_file_handles() {
    printf("Current file handles in pool: [");
    FileHandleNode* current = head;
    while (current != NULL) {
        printf("%d", current->fd);
        if (current->next != NULL) {
            printf(", ");
        }
        current = current->next;
    }
    printf("]\n");
}

// Example usage
int main() {
    printf("--- Initial State ---\n");
    print_file_handles();

    printf("\n--- Adding Handles ---\n");
    add_file_handle(101);
    add_file_handle(102);
    add_file_handle(103);
    print_file_handles();

    printf("\n--- Removing Handle 102 ---\n");
    remove_file_handle(102);
    print_file_handles();

    printf("\n--- Trying to remove non-existent handle 999 ---\n");
    remove_file_handle(999);
    print_file_handles();

    printf("\n--- Adding more handles ---\n");
    add_file_handle(104);
    add_file_handle(105);
    print_file_handles();

    printf("\n--- Cleanup 1 ---\n");
    cleanup_file_handles();
    print_file_handles();

    printf("\n--- Cleanup 2 (safe to call again) ---\n");
    cleanup_file_handles();
    print_file_handles();

    printf("\n--- Adding handles after cleanup ---\n");
    add_file_handle(201);
    add_file_handle(202);
    print_file_handles();

    printf("\n--- Final Cleanup ---\n");
    cleanup_file_handles();
    print_file_handles();

    return 0;
}