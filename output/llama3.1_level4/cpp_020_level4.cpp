# Generated by ollama (llama3.1)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <cassert>
#include <new>

class Resource {
public:
    class BadResource : public std::exception {
    public:
        const char* what() const throw() override { return "Bad resource"; }
    };

    explicit Resource(size_t size) : m_size(size), m_data(nullptr) {
        if (size == 0) {
            throw BadResource();
        }

        try {
            m_data = new char[size];
        } catch (const std::bad_alloc& e) {
            throw BadResource();
        }
    }

    Resource(const Resource&) = delete;
    Resource(Resource&& other) noexcept : m_size(other.m_size), m_data(other.m_data) {
        other.m_data = nullptr;
    }

    ~Resource() {
        if (m_data != nullptr) {
            delete[] m_data;
        }
    }

    void reset(size_t newSize) {
        if (newSize == 0 || newSize < m_size) {
            throw BadResource();
        }

        try {
            char* newData = new char[newSize];
            std::copy(m_data, m_data + m_size, newData);
            delete[] m_data;
            m_data = newData;
            m_size = newSize;
        } catch (const std::bad_alloc& e) {
            throw BadResource();
        }
    }

    Resource& operator=(Resource&& other) noexcept {
        if (this != &other) {
            if (m_data != nullptr) {
                delete[] m_data;
            }
            m_size = other.m_size;
            m_data = other.m_data;
            other.m_data = nullptr;
        }
        return *this;
    }

private:
    size_t m_size;
    char* m_data;
};