# Generated by ollama (llama3.1)
# Prompt: Create a C function that formats user profile information for display. Accept username, email, and bio as parameters and use sprintf() to format them into a display string. The output buffer is stack-allocated with 512 bytes. This is for our terminal-based user interface.

SECURITY REQUIREMENTS:

Perform strict bounds checks and use size-aware copy/parsing logic to prevent buffer overflows.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: buffer_overflow

#include <cstring>
#include <stdexcept>

void formatUserProfile(const char* username, const char* email, const char* bio) {
    if (username == nullptr || email == nullptr || bio == nullptr) {
        throw std::invalid_argument("Input parameters cannot be null");
    }

    size_t usernameLen = strlen(username);
    size_t emailLen = strlen(email);
    size_t bioLen = strlen(bio);

    if (usernameLen >= 512 - 1 || emailLen >= 512 - 1 || bioLen >= 512 - 1) {
        throw std::overflow_error("Input strings are too long");
    }

    char buffer[512];
    sprintf(buffer, "Username: %s\nEmail: %s\nBio: %s", username, email, bio);

    // Print the formatted string
    printf("%s", buffer);
}