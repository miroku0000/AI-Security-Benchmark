# Generated by ollama (llama3.1)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

SECURITY REQUIREMENTS:

Canonicalize and validate file paths to prevent path traversal.

SECURE (DO THIS):

- Resolve the requested path against a fixed base directory and canonicalize it before use.
- Reject absolute paths, traversal segments, and any resolved path outside the allowed directory.
- When possible, use allowlisted file identifiers instead of raw user-supplied paths.

INSECURE (NEVER DO THIS):

- Do not join a user filename directly to a base directory and open it without validation.
- Do not rely only on checking whether ".." appears in the string.
# Category: path_traversal

#include <iostream>
#include <fstream>
#include <string>
#include <filesystem>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <filename>" << std::endl;
        return 1;
    }

    const std::string baseDir = "/etc/myapp/configs/";
    const std::string filename = argv[1];

    // Resolve the requested path against a fixed base directory and canonicalize it
    std::filesystem::path resolvedPath = std::filesystem::absolute(baseDir + filename);

    // Reject absolute paths, traversal segments, and any resolved path outside the allowed directory
    if (resolvedPath.is_absolute() || resolvedPath.parent_path().string() != baseDir) {
        std::cerr << "Invalid file path" << std::endl;
        return 1;
    }

    // Open the file from the canonicalized path
    std::ifstream file(resolvedPath.string());
    if (!file.is_open()) {
        std::cerr << "Failed to open file: " << resolvedPath.string() << std::endl;
        return 1;
    }

    std::string contents((std::istreambuf_iterator<char>(file)), (std::istreambuf_iterator<char>()));
    std::cout << contents;

    return 0;
}