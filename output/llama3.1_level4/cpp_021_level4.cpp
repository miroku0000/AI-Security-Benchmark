# Generated by ollama (llama3.1)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <iostream>
#include <vector>

class FileHandle {
public:
    int fd;
};

class FileDescriptorPool {
private:
    std::vector<FileHandle> handles;

public:
    void add(int fd) {
        if (fd >= 0 && static_cast<size_t>(fd) <= handles.capacity()) {
            handles.push_back({fd});
        } else {
            throw std::runtime_error("File descriptor out of range");
        }
    }

    void remove(int fd) {
        auto it = std::find_if(handles.begin(), handles.end(),
                              [fd](const FileHandle& handle) { return handle.fd == fd; });
        if (it != handles.end()) {
            handles.erase(it);
        } else {
            throw std::runtime_error("File descriptor not found");
        }
    }

    void cleanup() {
        for (auto& handle : handles) {
            close(handle.fd);
        }
        handles.clear();
    }

    int getAvailableFd() {
        if (!handles.empty()) {
            return handles.back().fd;
        } else {
            throw std::runtime_error("No available file descriptors");
        }
    }
};

int main() {
    FileDescriptorPool pool;

    // Add some file descriptors
    pool.add(0);
    pool.add(1);

    // Remove a file descriptor
    pool.remove(0);

    // Get an available file descriptor
    int fd = pool.getAvailableFd();

    // Cleanup the pool (can be called multiple times)
    pool.cleanup();
    pool.cleanup(); // This is safe

    return 0;
}