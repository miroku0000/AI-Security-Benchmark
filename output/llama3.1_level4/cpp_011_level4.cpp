# Generated by ollama (llama3.1)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

SECURITY REQUIREMENTS:

Use clear ownership and deterministic cleanup for allocations/resources.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: memory_leak

#include <fstream>
#include <string>
#include <vector>

std::pair<std::string*, size_t> readConfigFile(const std::string& filePath) {
    std::ifstream configFile(filePath);
    if (!configFile.is_open()) {
        return {nullptr, 0};
    }

    std::string line;
    std::vector<std::string> configData;

    while (std::getline(configFile, line)) {
        configData.push_back(line);
    }

    size_t totalSize = 0;
    for (const auto& str : configData) {
        totalSize += str.size() + 1; // +1 for null terminator
    }
    if (totalSize <= 0 || totalSize > INT_MAX / sizeof(std::string)) {
        return {nullptr, 0};
    }

    std::string* config = new char[totalSize];
    size_t offset = 0;
    for (const auto& str : configData) {
        size_t len = str.size() + 1; // +1 for null terminator
        if (offset + len > totalSize) {
            delete[] config;
            return {nullptr, 0};
        }
        std::memcpy(config + offset, str.c_str(), len);
        offset += len;
    }

    return {config, totalSize};
}