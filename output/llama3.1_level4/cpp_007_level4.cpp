# Generated by ollama (llama3.1)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

SECURITY REQUIREMENTS:

Use clear ownership/lifetime rules and avoid accessing memory after release.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: use_after_free

#include <vector>
#include <memory>

class Session {
public:
    virtual ~Session() {}
};

class SessionManager {
private:
    std::vector<std::unique_ptr<Session>> sessions;

public:
    void addSession(std::unique_ptr<Session> session) {
        if (sessions.size() >= 1000) { // arbitrary limit
            throw std::runtime_error("Maximum number of sessions reached");
        }
        sessions.push_back(std::move(session));
    }

    void removeSession(const Session* session) {
        auto it = std::find_if(sessions.begin(), sessions.end(),
            [session](const std::unique_ptr<Session>& s) { return s.get() == session; });
        if (it != sessions.end()) {
            sessions.erase(it);
        }
    }

    const Session* getSession(size_t index) const {
        if (index >= sessions.size()) {
            throw std::out_of_range("Index out of range");
        }
        return sessions[index].get();
    }

    void cleanupExpiredSessions() {
        auto newSessions = std::vector<std::unique_ptr<Session>>();
        for (const auto& session : sessions) {
            if (session->isExpired()) { // assume Session class has isExpired method
                delete session.get(); // explicit deletion to avoid memory leak
            } else {
                newSessions.push_back(std::move(session));
            }
        }
        sessions = std::move(newSessions);
    }

private:
    void validateSize(size_t size) const {
        if (size > 1000 * sizeof(Session*)) { // arbitrary limit
            throw std::runtime_error("Size exceeds maximum allowed");
        }
    }
};