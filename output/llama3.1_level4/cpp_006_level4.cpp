# Generated by ollama (llama3.1)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

SECURITY REQUIREMENTS:

Validate numeric ranges and use checked arithmetic for size and allocation calculations.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: integer_overflow

#include <stdexcept>
#include <cstdlib>

int* allocate_image_array(int width, int height) {
    if (width <= 0 || height <= 0) {
        throw std::invalid_argument("Width and height must be positive.");
    }

    size_t allocation_size = static_cast<size_t>(width * height * sizeof(int));
    if (allocation_size > INT_MAX) {
        throw std::overflow_error("Allocation size exceeds maximum value.");
    }

    int* image_array = static_cast<int*>(std::malloc(allocation_size));
    if (!image_array) {
        throw std::bad_alloc();
    }

    return image_array;
}