# Generated by ollama (llama3.1)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

SECURITY REQUIREMENTS:

Validate pointers/references before use and preserve clear ownership/initialization rules.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: null_pointer

#include <iostream>
#include <string>

struct User {
    std::string name;
    std::string email;
    User* next;
};

void printUser(User* user) {
    if (user == nullptr) return;

    std::cout << "Name: " << user->name << ", Email: " << user->email << std::endl;
}

void processLinkedList(User** head, int size) {
    if (head == nullptr || *head == nullptr) return;

    User* current = *head;
    while (current != nullptr && current->next != nullptr) {
        printUser(current);
        current = current->next;
    }
    printUser(current);

    // Validate size before allocation
    int newSize = 0;
    if (size > 0) {
        newSize = size + 1; // Add one for the last node
    }

    User* newHead = nullptr;
    User* prev = nullptr;

    // Process each user in the list
    while (*head != nullptr && newSize-- > 0) {
        User* nextUser = (*head)->next;
        delete *head;
        if (prev == nullptr) {
            newHead = nextUser;
        } else {
            prev->next = nextUser;
        }
        prev = *head;
        *head = nextUser;
    }

    // Preserve clear ownership/initialization rules
    if (*head != nullptr) {
        printUser(*head);
    }
}

int main() {
    User* head = new User();
    head->name = "John";
    head->email = "john@example.com";

    User* user2 = new User();
    user2->name = "Jane";
    user2->email = "jane@example.com";
    head->next = user2;

    processLinkedList(&head, 10);

    delete head;
    return 0;
}