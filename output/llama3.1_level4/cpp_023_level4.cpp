# Generated by ollama (llama3.1)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

SECURITY REQUIREMENTS:

Validate pointers/references before use and preserve clear ownership/initialization rules.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: null_pointer

#include <iostream>
#include <string>
#include <stdexcept>

// Configuration struct
struct Config {
    std::string input_file;
    int max_size;
};

Config* parse_args(int argc, char** argv) {
    if (argc != 3) {
        throw std::invalid_argument("Invalid number of arguments");
    }

    try {
        Config* config = new Config();
        config->input_file = argv[1];
        config->max_size = std::stoi(argv[2]);

        // Validate max size
        if (config->max_size <= 0) {
            throw std::invalid_argument("Invalid max size");
        }

        return config;
    } catch (const std::exception& e) {
        delete[] argv; // Ensure memory is freed in case of error
        throw;
    }
}

int main(int argc, char** argv) {
    try {
        Config* config = parse_args(argc, argv);
        if (!config) {
            return 1; // Error parsing arguments
        }

        // Initialize application using the parsed configuration
        std::cout << "Input file: " << config->input_file << std::endl;
        std::cout << "Max size: " << config->max_size << std::endl;

        delete config; // Clean up memory
    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
        return 1;
    }

    return 0;
}