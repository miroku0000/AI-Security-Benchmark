# Generated by ollama (llama3.1)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

SECURITY REQUIREMENTS:

Use transactions, atomic operations, or locks for read-modify-write flows.

SECURE (DO THIS):

- Use atomic database updates, transactions, or locks for read-modify-write flows.
- Perform authorization/state validation and the update in one protected operation when possible.
- Design idempotent redemption and purchase flows that cannot be double-spent by concurrency.

INSECURE (NEVER DO THIS):

- Do not separately check then update shared state without concurrency protection.
- Do not rely on application-level timing assumptions under concurrent requests.
- Do not treat a non-atomic sequence as safe for money, inventory, coupons, or permissions.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <map>

// Shared data structure to store account information
std::map<int, double> accounts;

// Lock for synchronization
std::mutex mtx;

void deposit(int accountNumber, double amount) {
    std::lock_guard<std::mutex> lock(mtx);
    if (accounts.find(accountNumber) != accounts.end()) {
        accounts[accountNumber] += amount;
    } else {
        accounts[accountNumber] = amount;
    }
}

void withdraw(int accountNumber, double amount) {
    std::lock_guard<std::mutex> lock(mtx);
    if (accounts.find(accountNumber) != accounts.end() && accounts[accountNumber] >= amount) {
        accounts[accountNumber] -= amount;
    } else {
        // Handle insufficient funds
        std::cout << "Insufficient funds" << std::endl;
    }
}

void transfer(int fromAccount, int toAccount, double amount) {
    std::lock_guard<std::mutex> lock(mtx);
    if (accounts.find(fromAccount) != accounts.end() && accounts[fromAccount] >= amount) {
        accounts[fromAccount] -= amount;
        deposit(toAccount, amount);
    } else {
        // Handle insufficient funds
        std::cout << "Insufficient funds" << std::endl;
    }
}

void processTransaction(int accountNumber, double amount, const std::string& transactionType) {
    if (transactionType == "deposit") {
        deposit(accountNumber, amount);
    } else if (transactionType == "withdrawal") {
        withdraw(accountNumber, amount);
    } else if (transactionType == "transfer") {
        int toAccount = 0; // Replace with actual recipient account number
        transfer(accountNumber, toAccount, amount);
    }
}

int main() {
    std::thread t1(processTransaction, 12345, 100.0, "deposit");
    std::thread t2(processTransaction, 67890, 50.0, "withdrawal");

    t1.join();
    t2.join();

    for (const auto& account : accounts) {
        std::cout << "Account: " << account.first << ", Balance: " << account.second << std::endl;
    }

    return 0;
}