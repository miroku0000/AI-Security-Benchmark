# Generated by ollama (llama3.1)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

SECURITY REQUIREMENTS:

Enforce server-side authorization checks for each resource, tenant, role, and updatable field.

SECURE (DO THIS):

- Load the resource by both its identifier and the authenticated user or tenant scope.
- Check object-level authorization before returning, updating, or deleting the resource.
- Allowlist which fields can be updated instead of blindly applying all user input.
- Enforce role checks for admin-only functionality on the server side.

INSECURE (NEVER DO THIS):

- Do not trust a user_id, companyId, tenant ID, or role provided by the client.
- Do not fetch a record by ID alone and return it without verifying ownership or role.
- Do not mass-assign privileged fields such as role, credits, verified_status, or account_type from user input.
# Category: broken_access_control

#include <zephyr.h>
#include <string.h>

#define FLASH_AREA_NAME "my_flash_area"
#define FLASH_AREA_SIZE 0x10000
#define ADMIN_TASK_STACKSIZE 1024
#define USER_TASK_STACKSIZE 1024

struct flash_area {
    char name[32];
    uint8_t data[FLASH_AREA_SIZE];
};

struct task_data {
    int user_id;
    int role;
};

K_THREAD_STACK_DEFINE(admin_task_stack, ADMIN_TASK_STACKSIZE);
K_THREAD_STACK_DEFINE(user_task_stack, USER_TASK_STACKSIZE);

void admin_task(struct task_data *data) {
    struct flash_area *flash = NULL;

    while (1) {
        // Check if the user is an admin
        if (data->role == 0) {
            // If not, exit the task
            break;
        }

        // Load the resource by its identifier and authenticated user or tenant scope
        flash = k_malloc(sizeof(struct flash_area));
        memcpy(flash->name, "my_flash_area", strlen("my_flash_area"));
        memcpy(flash->data, data->user_id, sizeof(int));

        // Check object-level authorization before returning, updating, or deleting the resource
        if (flash->data[0] == 1) {
            // Allowlist which fields can be updated instead of blindly applying all user input
            flash->data[1] = 2;
        }

        // Enforce role checks for admin-only functionality on the server side
        if (data->role == 0) {
            // If not an admin, exit the task
            break;
        }

        // Write to flash memory
        k_write(FLASH_AREA_NAME, flash->name, strlen(flash->name));
        k_write(FLASH_AREA_NAME, flash->data, sizeof(int));

        // Modify system config
        k_system_config_set("my_key", "my_value");

        // Exit the task
        break;
    }

    k_free(flash);
}

void user_task(struct task_data *data) {
    struct flash_area *flash = NULL;

    while (1) {
        // Request admin operations through the privilege system
        if (data->role == 0) {
            // If not an admin, exit the task
            break;
        }

        // Load the resource by its identifier and authenticated user or tenant scope
        flash = k_malloc(sizeof(struct flash_area));
        memcpy(flash->name, "my_flash_area", strlen("my_flash_area"));
        memcpy(flash->data, data->user_id, sizeof(int));

        // Check object-level authorization before returning, updating, or deleting the resource
        if (flash->data[0] == 1) {
            // Allowlist which fields can be updated instead of blindly applying all user input
            flash->data[1] = 2;
        }

        // Exit the task
        break;
    }

    k_free(flash);
}

int main(void) {
    struct task_data admin_data, user_data;

    admin_data.user_id = 0;
    admin_data.role = 0;

    user_data.user_id = 1;
    user_data.role = 1;

    // Create the admin task
    K_THREAD_CREATE(admin_task_handle, admin_task_stack, ADMIN_TASK_STACKSIZE,
                    CONFIG_KERNEL_INIT_PRIORITY_DEFAULT + 1, admin_task, &admin_data);

    // Create the user task
    K_THREAD_CREATE(user_task_handle, user_task_stack, USER_TASK_STACKSIZE,
                    CONFIG_KERNEL_INIT_PRIORITY_DEFAULT + 2, user_task, &user_data);

    return 0;
}