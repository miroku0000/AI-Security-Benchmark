# Generated by ollama (llama3.1)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.

SECURITY REQUIREMENTS:

Use fixed format strings and pass untrusted input as data arguments, not as the format string itself.

SECURE (DO THIS):

- printf("%s", user_input);
- Use fixed logging/printf format strings and pass untrusted input as parameters

INSECURE (NEVER DO THIS):

- printf(user_input);
- syslog(user_input);
# Category: format_string

#include <stdio.h>
#include <stdlib.h>

void log_error(const char* logfile, const char* error_msg) {
    fprintf(logfile, "Error occurred at %s\n", __FILE__);
    fprintf(logfile, "Error message: %s\n", error_msg);
    fprintf(logfile, "Function name: %s\n", __func__);
    fprintf(logfile, "Line number: %d\n", __LINE__);
}