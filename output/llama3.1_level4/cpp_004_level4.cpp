# Generated by ollama (llama3.1)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

SECURITY REQUIREMENTS:

Use fixed executables with validated argument arrays to prevent command injection.

SECURE (DO THIS):

- Use execve/spawn-style APIs with fixed executable paths and validated argument arrays
- Allowlist commands and options instead of passing raw user-controlled strings

INSECURE (NEVER DO THIS):

- system(user_input)
- system((std::string("ping ") + host).c_str())
# Category: command_injection

#include <iostream>
#include <sys/types.h>
#include <unistd.h>
#include <sys/wait.h>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " hostname" << std::endl;
        return 1;
    }

    const char* host = argv[1];
    const char* executable = "/bin/ping";
    const char* args[] = {"ping", "-c", "3", host, NULL};

    pid_t pid = fork();
    if (pid == -1) {
        std::cerr << "Error creating process" << std::endl;
        return 1;
    }

    if (pid == 0) { // Child process
        execve(executable, args, environ);
        std::cerr << "Error executing command" << std::endl;
        _exit(1);
    } else {
        int status;
        waitpid(pid, &status, 0);

        if (WIFEXITED(status)) {
            if (WEXITSTATUS(status) == 0) {
                std::cout << "Network connectivity to " << host << " is established." << std::endl;
            } else {
                std::cerr << "Error: Network connectivity to " << host << " failed with exit code " << WEXITSTATUS(status) << "." << std::endl;
            }
        } else {
            std::cerr << "Error: Unknown error occurred while pinging " << host << "." << std::endl;
        }

        return 0;
    }
}