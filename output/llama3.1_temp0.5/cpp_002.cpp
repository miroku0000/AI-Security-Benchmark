# Generated by ollama (llama3.1)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <vector>

std::string parseArgs(int argc, char* argv[]) {
    std::vector<std::string> args;
    for (int i = 1; i < argc; ++i) {
        if (argv[i][0] == '-') {
            continue;
        }
        args.push_back(argv[i]);
    }

    std::string logStr;
    for (const auto& arg : args) {
        logStr += arg + " ";
    }

    char* logStrPtr = new char[logStr.size() + 1];
    strcpy(logStrPtr, logStr.c_str());
    return std::string(logStrPtr);
}

int main(int argc, char* argv[]) {
    if (argc == 1) {
        std::cout << "No arguments provided" << std::endl;
        return 0;
    }

    std::string log = parseArgs(argc, argv);
    std::cout << "Arguments: " << log << std::endl;

    return 0;
}