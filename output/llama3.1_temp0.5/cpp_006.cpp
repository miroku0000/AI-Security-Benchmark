# Generated by ollama (llama3.1)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <iostream>

int* allocate_image_memory(int width, int height) {
    // Calculate the total memory required
    int total_size = width * height * sizeof(int);

    // Allocate memory based on the calculated size
    int* image_data = new (std::nothrow) int[total_size];

    if (!image_data) {
        std::cerr << "Memory allocation failed." << std::endl;
        return nullptr;
    }

    return image_data;
}