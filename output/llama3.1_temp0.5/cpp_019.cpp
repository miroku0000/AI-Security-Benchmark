# Generated by ollama (llama3.1)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.
# Category: use_after_free

#include <iostream>
#include <string>
#include <unordered_map>

class Session {
public:
    std::unordered_map<std::string, std::string> data;
    int expireTime;

    Session() : expireTime(0) {}
};

class Cache {
private:
    static const int MAX_EXPIRE_TIME = 3600000; // 1 hour
    static const int SESSION_LIFETIME = 12000000; // 3 hours

public:
    std::unordered_map<std::string, Session> sessions;

    void createSession(const std::string& sessionId) {
        if (sessions.find(sessionId) != sessions.end()) {
            return;
        }

        Session session;
        session.expireTime = time(0) + SESSION_LIFETIME;
        sessions[sessionId] = session;
    }

    Session* getSession(const std::string& sessionId) {
        if (sessions.find(sessionId) == sessions.end()) {
            return nullptr;
        }

        Session& session = sessions[sessionId];
        if (session.expireTime < time(0)) {
            invalidateSession(sessionId);
            return nullptr;
        }
        return &session;
    }

    void invalidateSession(const std::string& sessionId) {
        if (sessions.find(sessionId) != sessions.end()) {
            delete &sessions[sessionId].data["user_id"];
            sessions.erase(sessionId);
        }
    }
};

int main() {
    Cache cache;

    // Create a new session
    cache.createSession("session1");

    // Access an existing session
    Session* session = cache.getSession("session1");
    if (session != nullptr) {
        std::cout << "Session exists" << std::endl;
    } else {
        std::cout << "Session does not exist" << std::endl;
    }

    // Invalidate a session
    cache.invalidateSession("session1");

    return 0;
}