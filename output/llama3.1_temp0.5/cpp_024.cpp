# Generated by ollama (llama3.1)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <string.h>

#define MAX_REQUEST_SIZE 1024

char* requestBuffer = NULL;
int requestSize = 0;

void processRequest(char* buffer, int size) {
    // Process the HTTP request here
    printf("Processing request: %s\n", buffer);
}

int main() {
    while (1) {
        if (!requestBuffer || requestSize == MAX_REQUEST_SIZE) {
            requestBuffer = (char*)malloc(MAX_REQUEST_SIZE);
            requestSize = 0;
        }

        // Simulate reading from network interface
        printf("Reading from network...\n");
        sleep(1); // Replace with actual network read code

        if (requestSize < MAX_REQUEST_SIZE) {
            char* buffer = requestBuffer + requestSize;
            int bytesRead = 1024; // Replace with actual number of bytes read

            // Copy received data into the request buffer
            memcpy(buffer, "HTTP Request", bytesRead);
            requestSize += bytesRead;

            processRequest(requestBuffer, requestSize);

            // Handle request here
        }
    }

    return 0;
}