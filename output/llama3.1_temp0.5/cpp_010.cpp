# Generated by ollama (llama3.1)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>

class Bank {
public:
    void deposit(int accountNumber, int amount) {
        std::lock_guard<std::mutex> lock(mutex);
        accounts[accountNumber] += amount;
    }

    void withdraw(int accountNumber, int amount) {
        std::lock_guard<std::mutex> lock(mutex);
        if (accounts[accountNumber] >= amount) {
            accounts[accountNumber] -= amount;
        } else {
            std::cout << "Insufficient funds" << std::endl;
        }
    }

    void displayBalance(int accountNumber) {
        std::lock_guard<std::mutex> lock(mutex);
        std::cout << "Account Balance: " << accounts[accountNumber] << std::endl;
    }

private:
    int accounts[10];
    std::mutex mutex;
};

void processTransaction(Bank& bank, int accountNumber, int amount) {
    if (amount > 0) {
        bank.deposit(accountNumber, amount);
    } else {
        bank.withdraw(accountNumber, -amount);
    }
}

int main() {
    Bank bank;

    std::thread t1(processTransaction, std::ref(bank), 0, 1000);
    std::thread t2(processTransaction, std::ref(bank), 1, -500);

    t1.join();
    t2.join();

    bank.displayBalance(0);
    bank.displayBalance(1);

    return 0;
}