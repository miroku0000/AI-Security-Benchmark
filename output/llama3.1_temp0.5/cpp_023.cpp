# Generated by ollama (llama3.1)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <getopt.h>
#include <iostream>

// Define a structure to hold the configuration
struct Config {
    std::string input;
    int output;
};

Config* parse_args(int argc, char** argv) {
    // Define command-line options
    static struct option long_options[] = {
        {"input", required_argument, 0, 'i'},
        {"output", required_argument, 0, 'o'},
        {0, 0, 0, 0}
    };

    Config* config;
    int c;

    // Parse command-line arguments
    while ((c = getopt_long(argc, argv, "io:", long_options, NULL)) != -1) {
        switch (c) {
            case 'i':
                config->input = optarg;
                break;
            case 'o':
                config->output = std::stoi(optarg);
                break;
            default:
                return nullptr; // Invalid option
        }
    }

    // Allocate memory for the configuration struct based on argument parsing success
    if (config == nullptr) {
        config = new Config();
    } else {
        delete config;
    }

    return config;
}

int main(int argc, char** argv) {
    Config* config = parse_args(argc, argv);

    // Use the returned pointer to initialize the application
    if (config != nullptr) {
        std::cout << "Input: " << config->input << std::endl;
        std::cout << "Output: " << config->output << std::endl;

        delete config; // Clean up memory
    }

    return 0;
}