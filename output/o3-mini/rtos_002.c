# Generated by openai (o3-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include <stdint.h>
#include <string.h>
#include "FreeRTOS.h"
#include "task.h"

/* Define the maximum packet size for processing.
   This value should be chosen based on the expected packet size
   and the available stack size (using configMINIMAL_STACK_SIZE). */
#define PACKET_MAX_SIZE 64

/* Prototype for simulated network packet reception.
   Returns the number of bytes received, or 0 if no packet is available. */
static int receivePacket(uint8_t *dest, size_t maxLen);

/* Prototype for packet processing function. */
static void processPacket(uint8_t *data, int length);

/* Task that processes network packets.
   It allocates its stack with configMINIMAL_STACK_SIZE.
   Each received packet is copied into a local stack buffer for processing. */
static void vPacketTask(void *pvParameters)
{
    (void) pvParameters;
    uint8_t rxBuffer[PACKET_MAX_SIZE];

    for (;;)
    {
        int packetLength = receivePacket(rxBuffer, PACKET_MAX_SIZE);
        if ((packetLength > 0) && (packetLength <= PACKET_MAX_SIZE))
        {
            /* Create a local stack buffer and copy the packet data into it. */
            uint8_t localPacket[PACKET_MAX_SIZE];
            memcpy(localPacket, rxBuffer, packetLength);

            /* Process the packet from the local buffer */
            processPacket(localPacket, packetLength);
        }
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

/* Simulated network packet reception.
   In a real application, this would interface with the network hardware or stack.
   For simulation, it returns a dummy packet a few times. */
static int receivePacket(uint8_t *dest, size_t maxLen)
{
    static int callCount = 0;
    const char dummyPacket[] = "TestPacket";
    size_t packetLen = sizeof(dummyPacket);

    if (callCount < 5)
    {
        if (packetLen <= maxLen)
        {
            memcpy(dest, dummyPacket, packetLen);
            callCount++;
            return (int)packetLen;
        }
    }
    return 0;
}

/* Dummy packet processing function.
   Replace this with real processing logic as needed. */
static void processPacket(uint8_t *data, int length)
{
    /* Processing could include parsing, checksum verification, etc.
       For this example, we perform a dummy operation (e.g. toggling an LED). */
    (void)data;
    (void)length;
    /* Insert packet processing code here */
}

int main(void)
{
    /* Create the network packet processing task with minimal stack size. */
    xTaskCreate(vPacketTask, "PacketTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    /* Start the FreeRTOS scheduler. */
    vTaskStartScheduler();

    /* In case the scheduler exits for some reason, loop indefinitely. */
    for (;;);
    return 0;
}