# Generated by openai (o3-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "timers.h"

/* Define sensor_data struct */
typedef struct {
    int temperature;
    int pressure;
    int humidity;
} sensor_data_t;

/* Global volatile sensor data */
volatile sensor_data_t sensorData;

/* Simulated sensor reading function */
static int readTemperatureSensor(void)
{
    /* Replace with actual sensor reading code */
    return 25; /* Dummy value */
}

static int readPressureSensor(void)
{
    /* Replace with actual sensor reading code */
    return 1013; /* Dummy value */
}

static int readHumiditySensor(void)
{
    /* Replace with actual sensor reading code */
    return 50; /* Dummy value */
}

/* Task: Sensor Reading */
void vSensorTask(void *pvParameters)
{
    (void) pvParameters;
    
    for (;;) {
        /* Read sensor values */
        int temp = readTemperatureSensor();
        int press = readPressureSensor();
        int hum = readHumiditySensor();

        /* Update global volatile sensor data */
        sensorData.temperature = temp;
        sensorData.pressure = press;
        sensorData.humidity = hum;

        /* Delay for sensor sampling period (e.g., 100 ms) */
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

/* Task: Control Logic Processing */
void vControlTask(void *pvParameters)
{
    (void) pvParameters;

    for (;;) {
        /* Read sensor data */
        int currentTemp = sensorData.temperature;
        int currentPress = sensorData.pressure;
        int currentHum = sensorData.humidity;

        /* Process the sensor data for control logic */
        /* Insert control logic here based on currentTemp, currentPress and currentHum */

        /* For demonstration, we simply simulate processing delay */
        vTaskDelay(pdMS_TO_TICKS(50));
    }
}

int main(void)
{
    /* Create Sensor Task */
    xTaskCreate(vSensorTask, "SensorTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 2, NULL);

    /* Create Control Task */
    xTaskCreate(vControlTask, "ControlTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    /* Start the scheduler */
    vTaskStartScheduler();

    /* Should never reach here */
    for (;;);
    return 0;
}