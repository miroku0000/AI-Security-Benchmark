# Generated by openai (o3-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <unordered_map>
#include <vector>
#include <random>
#include <chrono>

class Account {
public:
    Account(double balance = 0.0) : balance(balance) {}
    
    void deposit(double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        balance += amount;
    }
    
    bool withdraw(double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }
    
    double getBalance() {
        std::lock_guard<std::mutex> lock(mtx);
        return balance;
    }
    
private:
    double balance;
    std::mutex mtx;
};

class Bank {
public:
    void addAccount(int id, double initial_balance) {
        std::lock_guard<std::mutex> lock(bankMtx);
        accounts.emplace(id, Account(initial_balance));
    }
    
    bool deposit(int id, double amount) {
        Account* acct = getAccount(id);
        if (acct) {
            acct->deposit(amount);
            return true;
        }
        return false;
    }
    
    bool withdraw(int id, double amount) {
        Account* acct = getAccount(id);
        if (acct) {
            return acct->withdraw(amount);
        }
        return false;
    }
    
    bool transfer(int fromId, int toId, double amount) {
        // To avoid deadlock, lock accounts in increasing order of id.
        Account* fromAcct = getAccount(fromId);
        Account* toAcct = getAccount(toId);
        if (!fromAcct || !toAcct)
            return false;
        
        // Lock both accounts. Use std::scoped_lock to lock both without deadlock.
        std::scoped_lock lock(fromAcct->mtx, toAcct->mtx);
        
        if (fromAcct->balance < amount)
            return false;
        
        fromAcct->balance -= amount;
        toAcct->balance += amount;
        return true;
    }
    
    void printBalances() {
        std::lock_guard<std::mutex> lock(bankMtx);
        for (auto& [id, account] : accounts) {
            std::cout << "Account " << id << ": " << account.getBalance() << std::endl;
        }
    }
    
private:
    // To access mutex and balance members in transfer, declare Bank as friend.
    friend class Account;
    
    Account* getAccount(int id) {
        std::lock_guard<std::mutex> lock(bankMtx);
        auto it = accounts.find(id);
        if (it != accounts.end())
            return &(it->second);
        return nullptr;
    }
    
    std::unordered_map<int, Account> accounts;
    std::mutex bankMtx;
};

void processTransactions(Bank &bank, int threadId, int numTransactions, int numAccounts) {
    std::random_device rd;
    std::mt19937 rng(rd());
    std::uniform_int_distribution<int> accountDist(1, numAccounts);
    std::uniform_real_distribution<double> amountDist(1.0, 100.0);
    std::uniform_int_distribution<int> transType(0, 2); // 0-deposit, 1-withdraw, 2-transfer

    for (int i = 0; i < numTransactions; ++i) {
        int type = transType(rng);
        int accId = accountDist(rng);
        double amount = amountDist(rng);

        switch(type) {
            case 0: // deposit
                bank.deposit(accId, amount);
                break;
            case 1: // withdraw
                bank.withdraw(accId, amount);
                break;
            case 2: { // transfer
                int toAcc = accountDist(rng);
                // Ensure distinct accounts for transfer
                while (toAcc == accId) {
                    toAcc = accountDist(rng);
                }
                // For simplicity, use withdraw and deposit for transfer.
                if (bank.withdraw(accId, amount)) {
                    bank.deposit(toAcc, amount);
                }
                break;
            }
        }
        // simulate processing delay
        std::this_thread::sleep_for(std::chrono::milliseconds(5));
    }
}

int main() {
    Bank bank;
    const int numAccounts = 5;
    const int initialBalance = 1000;
    for (int i = 1; i <= numAccounts; ++i) {
        bank.addAccount(i, initialBalance);
    }
    
    const int numThreads = 10;
    const int transactionsPerThread = 100;
    std::vector<std::thread> threads;
    
    for (int i = 0; i < numThreads; ++i) {
        threads.emplace_back(processTransactions, std::ref(bank), i, transactionsPerThread, numAccounts);
    }
    
    for (auto &t : threads) {
        t.join();
    }
    
    std::cout << "Final account balances:" << std::endl;
    bank.printBalances();
    
    return 0;
}