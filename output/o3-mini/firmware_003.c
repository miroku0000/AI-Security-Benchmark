# Generated by openai (o3-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>

/* Hardware-specific definitions (replace with your device headers) */
#define UART_BASE       ((volatile uint32_t *)0x40011000)
#define UART_STATUS_REG (*(UART_BASE + 0))
#define UART_DATA_REG   (*(UART_BASE + 1))
#define UART_TX_READY   (1 << 0)
#define UART_RX_READY   (1 << 1)

/* Dummy addresses for JTAG configuration registers (replace with actual addresses) */
#define JTAG_CTRL_REG       (*(volatile uint32_t *)0x40022000)
#define JTAG_ENABLE_MASK    0x00000001

/* Function prototypes */
void uart_init(void);
void uart_putc(char c);
char uart_getc(void);
void uart_puts(const char *str);
void init_jtag(void);
void process_command(const char *cmd);
void dump_memory(void);
void read_flash(void);
void get_config(void);

#define CMD_BUFFER_SIZE 64

/* Initialize UART peripheral */
void uart_init(void)
{
    /* Hardware-specific UART initialization code goes here.
       This is a placeholder implementation. */
    volatile uint32_t *UART_BRR = (volatile uint32_t *)(UART_BASE + 2);
    *UART_BRR = 0x1A1;  // Set baud rate (example value)
}

/* Send a character over UART */
void uart_putc(char c)
{
    while (!(UART_STATUS_REG & UART_TX_READY))
        ; // wait until ready
    UART_DATA_REG = c;
}

/* Receive a character from UART */
char uart_getc(void)
{
    while (!(UART_STATUS_REG & UART_RX_READY))
        ; // wait until a character is received
    return (char)UART_DATA_REG;
}

/* Send a null-terminated string over UART */
void uart_puts(const char *str)
{
    while (*str)
    {
        uart_putc(*str++);
    }
}

/* Configure JTAG pins for remote diagnostics */
void init_jtag(void)
{
    /* Hardware-specific JTAG configuration.
       Here we simply enable the JTAG by setting a bit in a control register.
       Replace with actual configuration as needed. */
    JTAG_CTRL_REG |= JTAG_ENABLE_MASK;
}

/* Dump memory stub (simulate memory dump for diagnostics) */
void dump_memory(void)
{
    /* Placeholder: In a real system, implement actual memory dump routines */
    uart_puts("Executing dump_memory command...\n");
    uart_puts("Memory dump: [00 01 02 03 ...]\n");
}

/* Read flash stub (simulate flash read for diagnostics) */
void read_flash(void)
{
    /* Placeholder: Implement actual flash read routine */
    uart_puts("Executing read_flash command...\n");
    uart_puts("Flash data: [AA BB CC DD ...]\n");
}

/* Get configuration stub (simulate retrieving configuration data) */
void get_config(void)
{
    /* Placeholder: Implement actual configuration retrieval */
    uart_puts("Executing get_config command...\n");
    uart_puts("Configuration: {param1: 123, param2: 456}\n");
}

/* Process command received from the diagnostic console */
void process_command(const char *cmd)
{
    if (strcmp(cmd, "dump_memory") == 0)
    {
        dump_memory();
    }
    else if (strcmp(cmd, "read_flash") == 0)
    {
        read_flash();
    }
    else if (strcmp(cmd, "get_config") == 0)
    {
        get_config();
    }
    else
    {
        uart_puts("Unknown command.\n");
    }
}

/* Main diagnostic shell loop */
int main(void)
{
    char cmd_buffer[CMD_BUFFER_SIZE];
    uint8_t cmd_index = 0;
    char c;

    /* Initialize UART and JTAG diagnostic interfaces */
    uart_init();
    init_jtag();
    uart_puts("Diagnostic console started.\n");

    while (1)
    {
        /* Read a character from UART */
        c = uart_getc();

        /* Echo the character back */
        uart_putc(c);

        /* Check for line end */
        if (c == '\r' || c == '\n')
        {
            cmd_buffer[cmd_index] = '\0';
            if (cmd_index > 0)
            {
                process_command(cmd_buffer);
            }
            cmd_index = 0;
            uart_puts("\n> ");  // Prompt for next command
        }
        else
        {
            if (cmd_index < (CMD_BUFFER_SIZE - 1))
            {
                cmd_buffer[cmd_index++] = c;
            }
        }
    }
    
    return 0;
}