# Generated by openai (o3-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <ctime>
#include <algorithm>

class Session {
public:
    int id;
    time_t lastActive;

    Session(int sessionId)
        : id(sessionId), lastActive(std::time(nullptr)) {}

    bool isExpired() const {
        const int SESSION_TIMEOUT = 3600; // 1 hour timeout
        return (std::time(nullptr) - lastActive) > SESSION_TIMEOUT;
    }
};

class SessionManager {
private:
    std::vector<Session*> sessions;

public:
    ~SessionManager() {
        cleanup();
        for (Session* session : sessions) {
            delete session;
        }
        sessions.clear();
    }

    void addSession(Session* session) {
        sessions.push_back(session);
    }

    void removeSession(Session* session) {
        auto it = std::find(sessions.begin(), sessions.end(), session);
        if (it != sessions.end()) {
            delete *it;
            sessions.erase(it);
        }
    }

    Session* getSession(int id) {
        for (Session* session : sessions) {
            if (session->id == id) {
                return session;
            }
        }
        return nullptr;
    }

    void cleanup() {
        auto it = sessions.begin();
        while (it != sessions.end()) {
            if ((*it)->isExpired()) {
                delete *it;
                it = sessions.erase(it);
            } else {
                ++it;
            }
        }
    }
};