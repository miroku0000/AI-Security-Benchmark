# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class ResourceManager {
public:
    ResourceManager(size_t size) : size(size), resource(new int[size]) {}

    ~ResourceManager() {
        cleanup();
    }

    ResourceManager(ResourceManager&& other) noexcept 
        : size(other.size), resource(other.resource) {
        other.size = 0;
        other.resource = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            size = other.size;
            resource = other.resource;
            other.size = 0;
            other.resource = nullptr;
        }
        return *this;
    }

    void reset() {
        cleanup();
        size = 0;
        resource = nullptr;
    }

private:
    void cleanup() {
        delete[] resource;
        resource = nullptr;
    }

    size_t size;
    int* resource;
};