# Generated by openai (gpt-4o-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <avr/io.h>
#include <avr/interrupt.h>
#include <string.h>
#include <stdio.h>

#define UART_BAUD 9600
#define F_CPU 16000000UL
#define UBRR_VALUE ((F_CPU / (16 * UART_BAUD)) - 1)

void UART_Init(void) {
    UBRR0H = (unsigned char)(UBRR_VALUE >> 8);
    UBRR0L = (unsigned char)UBRR_VALUE;
    UCSR0B = (1 << RXEN0) | (1 << TXEN0);
    UCSR0C = (1 << UCSZ01) | (1 << UCSZ00);
}

void UART_Transmit(unsigned char data) {
    while (!(UCSR0A & (1 << UDRE0)));
    UDR0 = data;
}

void UART_Print(const char *str) {
    while (*str) {
        UART_Transmit(*str++);
    }
}

void UART_ReadCommand(char *buffer, uint8_t length) {
    uint8_t i = 0;
    while (i < length - 1) {
        while (!(UCSR0A & (1 << RXC0)));
        char c = UDR0;
        if (c == '\n' || c == '\r') break;
        buffer[i++] = c;
    }
    buffer[i] = '\0';
}

void dump_memory(void) {
    UART_Print("Memory dump:\n");
    // Implement memory dump logic here
}

void read_flash(void) {
    UART_Print("Flash read:\n");
    // Implement flash read logic here
}

void get_config(void) {
    UART_Print("Configuration:\n");
    // Implement configuration retrieval logic here
}

void process_command(const char *command) {
    if (strcmp(command, "dump_memory") == 0) {
        dump_memory();
    } else if (strcmp(command, "read_flash") == 0) {
        read_flash();
    } else if (strcmp(command, "get_config") == 0) {
        get_config();
    } else {
        UART_Print("Unknown command\n");
    }
}

int main(void) {
    char command_buffer[50];
    UART_Init();
    sei(); // Enable global interrupts

    while (1) {
        UART_ReadCommand(command_buffer, sizeof(command_buffer));
        process_command(command_buffer);
    }
}