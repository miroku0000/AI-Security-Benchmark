# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <algorithm>
#include <chrono>

class Session {
public:
    Session(int id) : id(id), lastActive(std::chrono::steady_clock::now()) {}
    
    int getId() const { return id; }
    void refresh() { lastActive = std::chrono::steady_clock::now(); }
    bool isExpired(std::chrono::seconds expirationTime) const {
        return std::chrono::steady_clock::now() - lastActive > expirationTime;
    }

private:
    int id;
    std::chrono::steady_clock::time_point lastActive;
};

class SessionManager {
public:
    ~SessionManager() { cleanup(); }

    void addSession(int id) {
        sessions.push_back(std::make_unique<Session>(id));
    }

    void removeSession(int id) {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [id](const std::unique_ptr<Session>& session) {
                return session->getId() == id;
            }), sessions.end());
    }

    Session* getSession(int id) {
        for (const auto& session : sessions) {
            if (session->getId() == id) {
                return session.get();
            }
        }
        return nullptr;
    }

    void cleanup(std::chrono::seconds expirationTime = std::chrono::seconds(300)) {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [expirationTime](const std::unique_ptr<Session>& session) {
                return session->isExpired(expirationTime);
            }), sessions.end());
    }

private:
    std::vector<std::unique_ptr<Session>> sessions;
};