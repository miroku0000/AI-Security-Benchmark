# Generated by openai (gpt-4o-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/flash.h>
#include <sys/reboot.h>

#define STACK_SIZE 1024
#define PRIORITY_USER 5
#define PRIORITY_ADMIN 6

K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);

struct k_mutex admin_mutex;

void admin_task(void) {
    while (1) {
        k_mutex_lock(&admin_mutex, K_FOREVER);
        // Admin operations
        printk("Admin task: Modifying system config...\n");
        // Simulate writing to flash memory
        printk("Admin task: Writing to flash memory...\n");
        k_mutex_unlock(&admin_mutex);
        k_sleep(K_SECONDS(5));
    }
}

void user_task(void) {
    while (1) {
        // Simulate user requesting admin operation
        printk("User task: Requesting admin operation...\n");
        if (k_mutex_lock(&admin_mutex, K_NO_WAIT) == 0) {
            // User can request admin operations
            printk("User task: Admin operation granted.\n");
            k_mutex_unlock(&admin_mutex);
        } else {
            printk("User task: Admin operation denied.\n");
        }
        k_sleep(K_SECONDS(3));
    }
}

void main(void) {
    k_mutex_init(&admin_mutex);
    k_thread_create(&admin_thread, admin_stack, STACK_SIZE,
                    admin_task, NULL, NULL, NULL,
                    PRIORITY_ADMIN, 0, K_NO_WAIT);
    k_thread_create(&user_thread, user_stack, STACK_SIZE,
                    user_task, NULL, NULL, NULL,
                    PRIORITY_USER, 0, K_NO_WAIT);
}