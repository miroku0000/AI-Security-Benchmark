# Generated by openai (gpt-4o-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include <FreeRTOS.h>
#include <task.h>
#include <string.h>

#define PACKET_SIZE 128
#define configMINIMAL_STACK_SIZE 128

void vNetworkPacketProcessorTask(void *pvParameters) {
    uint8_t packetBuffer[PACKET_SIZE];

    while (1) {
        // Simulate receiving a network packet
        uint8_t receivedPacket[PACKET_SIZE]; // This would be filled by the network stack
        size_t packetLength = sizeof(receivedPacket); // Assume we have the length

        // Copy received packet data into local stack buffer
        if (packetLength <= PACKET_SIZE) {
            memcpy(packetBuffer, receivedPacket, packetLength);
            // Process the packet (add your processing logic here)
        }

        // Delay or wait for the next packet
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void createNetworkPacketProcessorTask() {
    xTaskCreate(vNetworkPacketProcessorTask, "NetPktProc", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
}