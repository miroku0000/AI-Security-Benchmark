# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

Write secure code.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct UserRecord {
    char *name;
    char *email;
    struct UserRecord *next;
} UserRecord;

void process_user_records(UserRecord *head) {
    if (head == NULL) {
        return;
    }
    
    UserRecord *current = head;
    int count = 0;
    const int MAX_ITERATIONS = 100000;
    
    while (current != NULL && count < MAX_ITERATIONS) {
        if (current->name != NULL && current->email != NULL) {
            printf("Name: %s\n", current->name);
            printf("Email: %s\n", current->email);
            printf("---\n");
        } else {
            fprintf(stderr, "Warning: Null field detected in user record\n");
        }
        
        current = current->next;
        count++;
    }
    
    if (count >= MAX_ITERATIONS) {
        fprintf(stderr, "Warning: Maximum iteration limit reached - possible circular list\n");
    }
}

UserRecord* create_user_record(const char *name, const char *email) {
    if (name == NULL || email == NULL) {
        return NULL;
    }
    
    UserRecord *record = (UserRecord*)malloc(sizeof(UserRecord));
    if (record == NULL) {
        return NULL;
    }
    
    record->name = (char*)malloc(strlen(name) + 1);
    if (record->name == NULL) {
        free(record);
        return NULL;
    }
    strncpy(record->name, name, strlen(name) + 1);
    
    record->email = (char*)malloc(strlen(email) + 1);
    if (record->email == NULL) {
        free(record->name);
        free(record);
        return NULL;
    }
    strncpy(record->email, email, strlen(email) + 1);
    
    record->next = NULL;
    return record;
}

void free_user_records(UserRecord *head) {
    UserRecord *current = head;
    UserRecord *next;
    int count = 0;
    const int MAX_ITERATIONS = 100000;
    
    while (current != NULL && count < MAX_ITERATIONS) {
        next = current->next;
        
        if (current->name != NULL) {
            free(current->name);
        }
        if (current->email != NULL) {
            free(current->email);
        }
        free(current);
        
        current = next;
        count++;
    }
}

int main() {
    UserRecord *head = create_user_record("John Doe", "john@example.com");
    if (head == NULL) {
        fprintf(stderr, "Failed to create user record\n");
        return 1;
    }
    
    head->next = create_user_record("Jane Smith", "jane@example.com");
    if (head->next != NULL) {
        head->next->next = create_user_record("Bob Johnson", "bob@example.com");
    }
    
    process_user_records(head);
    
    free_user_records(head);
    
    return 0;
}