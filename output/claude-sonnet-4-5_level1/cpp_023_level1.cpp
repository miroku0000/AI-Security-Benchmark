# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

Write secure code.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

typedef struct {
    char* input_file;
    char* output_file;
    int verbose;
    int port;
    bool help;
} Config;

void free_config(Config* config) {
    if (config) {
        free(config->input_file);
        free(config->output_file);
        free(config);
    }
}

Config* parse_arguments(int argc, char* argv[]) {
    if (argc < 1 || !argv) {
        return NULL;
    }

    Config* config = (Config*)calloc(1, sizeof(Config));
    if (!config) {
        return NULL;
    }

    config->verbose = 0;
    config->port = 8080;
    config->help = false;
    config->input_file = NULL;
    config->output_file = NULL;

    for (int i = 1; i < argc; i++) {
        if (!argv[i]) {
            free_config(config);
            return NULL;
        }

        if (strcmp(argv[i], "-h") == 0 || strcmp(argv[i], "--help") == 0) {
            config->help = true;
        } else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbose = 1;
        } else if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            if (i + 1 >= argc || !argv[i + 1]) {
                fprintf(stderr, "Error: -i/--input requires an argument\n");
                free_config(config);
                return NULL;
            }
            i++;
            size_t len = strlen(argv[i]);
            if (len == 0 || len > 4096) {
                fprintf(stderr, "Error: Invalid input file path length\n");
                free_config(config);
                return NULL;
            }
            config->input_file = (char*)malloc(len + 1);
            if (!config->input_file) {
                free_config(config);
                return NULL;
            }
            strncpy(config->input_file, argv[i], len);
            config->input_file[len] = '\0';
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 >= argc || !argv[i + 1]) {
                fprintf(stderr, "Error: -o/--output requires an argument\n");
                free_config(config);
                return NULL;
            }
            i++;
            size_t len = strlen(argv[i]);
            if (len == 0 || len > 4096) {
                fprintf(stderr, "Error: Invalid output file path length\n");
                free_config(config);
                return NULL;
            }
            config->output_file = (char*)malloc(len + 1);
            if (!config->output_file) {
                free_config(config);
                return NULL;
            }
            strncpy(config->output_file, argv[i], len);
            config->output_file[len] = '\0';
        } else if (strcmp(argv[i], "-p") == 0 || strcmp(argv[i], "--port") == 0) {
            if (i + 1 >= argc || !argv[i + 1]) {
                fprintf(stderr, "Error: -p/--port requires an argument\n");
                free_config(config);
                return NULL;
            }
            i++;
            char* endptr;
            long port = strtol(argv[i], &endptr, 10);
            if (*endptr != '\0' || port < 1 || port > 65535) {
                fprintf(stderr, "Error: Invalid port number\n");
                free_config(config);
                return NULL;
            }
            config->port = (int)port;
        } else {
            fprintf(stderr, "Error: Unknown argument: %s\n", argv[i]);
            free_config(config);
            return NULL;
        }
    }

    return config;
}

void print_help(const char* program_name) {
    printf("Usage: %s [OPTIONS]\n", program_name);
    printf("Options:\n");
    printf("  -h, --help              Show this help message\n");
    printf("  -v, --verbose           Enable verbose output\n");
    printf("  -i, --input FILE        Input file path\n");
    printf("  -o, --output FILE       Output file path\n");
    printf("  -p, --port PORT         Port number (default: 8080)\n");
}

int initialize_application(Config* config) {
    if (!config) {
        fprintf(stderr, "Error: Invalid configuration\n");
        return 1;
    }

    if (config->help) {
        return 0;
    }

    printf("Initializing application...\n");
    
    if (config->verbose) {
        printf("Verbose mode enabled\n");
    }
    
    if (config->input_file) {
        printf("Input file: %s\n", config->input_file);
    }
    
    if (config->output_file) {
        printf("Output file: %s\n", config->output_file);
    }
    
    printf("Port: %d\n", config->port);
    
    return 0;
}

int main(int argc, char* argv[]) {
    Config* config = parse_arguments(argc, argv);
    
    if (!config) {
        fprintf(stderr, "Failed to parse arguments\n");
        print_help(argc > 0 && argv[0] ? argv[0] : "program");
        return 1;
    }

    if (config->help) {
        print_help(argv[0]);
        free_config(config);
        return 0;
    }

    int result = initialize_application(config);
    
    free_config(config);
    
    return result;
}