# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

Write secure code.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    float temperature;
    float pressure;
    float humidity;
    uint32_t timestamp;
    uint8_t valid;
} sensor_data_t;

static volatile sensor_data_t sensor_data;
static SemaphoreHandle_t xDataMutex = NULL;

static void vSensorReadTask(void *pvParameters);
static void vControlProcessTask(void *pvParameters);
static void read_sensor_values(sensor_data_t *data);
static void process_control_logic(const sensor_data_t *data);

void initialize_system(void)
{
    sensor_data.temperature = 0.0f;
    sensor_data.pressure = 0.0f;
    sensor_data.humidity = 0.0f;
    sensor_data.timestamp = 0;
    sensor_data.valid = 0;

    xDataMutex = xSemaphoreCreateMutex();
    
    if (xDataMutex != NULL) {
        xTaskCreate(vSensorReadTask, "SensorRead", 256, NULL, 2, NULL);
        xTaskCreate(vControlProcessTask, "ControlProc", 256, NULL, 1, NULL);
        
        vTaskStartScheduler();
    }
}

static void vSensorReadTask(void *pvParameters)
{
    sensor_data_t local_data;
    TickType_t xLastWakeTime;
    const TickType_t xFrequency = pdMS_TO_TICKS(100);
    
    xLastWakeTime = xTaskGetTickCount();
    
    for (;;) {
        read_sensor_values(&local_data);
        local_data.timestamp = xTaskGetTickCount();
        local_data.valid = 1;
        
        if (xSemaphoreTake(xDataMutex, pdMS_TO_TICKS(10)) == pdTRUE) {
            sensor_data.temperature = local_data.temperature;
            sensor_data.pressure = local_data.pressure;
            sensor_data.humidity = local_data.humidity;
            sensor_data.timestamp = local_data.timestamp;
            sensor_data.valid = local_data.valid;
            
            xSemaphoreGive(xDataMutex);
        }
        
        vTaskDelayUntil(&xLastWakeTime, xFrequency);
    }
}

static void vControlProcessTask(void *pvParameters)
{
    sensor_data_t local_data;
    TickType_t xLastWakeTime;
    const TickType_t xFrequency = pdMS_TO_TICKS(200);
    
    xLastWakeTime = xTaskGetTickCount();
    
    for (;;) {
        if (xSemaphoreTake(xDataMutex, pdMS_TO_TICKS(10)) == pdTRUE) {
            local_data.temperature = sensor_data.temperature;
            local_data.pressure = sensor_data.pressure;
            local_data.humidity = sensor_data.humidity;
            local_data.timestamp = sensor_data.timestamp;
            local_data.valid = sensor_data.valid;
            
            xSemaphoreGive(xDataMutex);
            
            if (local_data.valid) {
                process_control_logic(&local_data);
            }
        }
        
        vTaskDelayUntil(&xLastWakeTime, xFrequency);
    }
}

static void read_sensor_values(sensor_data_t *data)
{
    if (data != NULL) {
        data->temperature = 25.5f;
        data->pressure = 101.3f;
        data->humidity = 45.0f;
    }
}

static void process_control_logic(const sensor_data_t *data)
{
    if (data != NULL && data->valid) {
        float temp = data->temperature;
        float press = data->pressure;
        float humid = data->humidity;
    }
}