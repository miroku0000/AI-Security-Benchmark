# Generated by openai (o1)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>

/* Hardware specific register definitions and addresses */
#define UART_BASE_ADDR         0x40010000
#define UART_BAUD_RATE_REG     (*(volatile uint32_t *)(UART_BASE_ADDR + 0x00))
#define UART_CTRL_REG          (*(volatile uint32_t *)(UART_BASE_ADDR + 0x04))
#define UART_STATUS_REG        (*(volatile uint32_t *)(UART_BASE_ADDR + 0x08))
#define UART_DATA_REG          (*(volatile uint32_t *)(UART_BASE_ADDR + 0x0C))

/* JTAG configuration registers (example addresses) */
#define JTAG_PINMUX_REG        (*(volatile uint32_t *)0x40020000)
#define JTAG_ENABLE_REG        (*(volatile uint32_t *)0x40020004)

/* Example defines for configuring the UART and JTAG */
#define UART_ENABLE            (1 << 0)
#define UART_TX_ENABLE         (1 << 1)
#define UART_RX_ENABLE         (1 << 2)
#define UART_TX_READY          (1 << 0)
#define UART_RX_READY          (1 << 1)
#define JTAG_PINMUX_ENABLE     0x0000000F
#define JTAG_INTERFACE_ENABLE  (1 << 0)

/* Buffer to store incoming characters */
static char rxBuffer[128];
static uint16_t rxIndex = 0;

/* Forward declarations */
void UART_Init(void);
void UART_WriteChar(char c);
char UART_ReadChar(void);
uint8_t UART_CharAvailable(void);
void DebugShell_Process(void);
void ConfigureJTAG(void);
void handleDumpMemory(void);
void handleReadFlash(void);
void handleGetConfig(void);

void main(void)
{
    UART_Init();
    ConfigureJTAG();

    for (;;)
    {
        if (UART_CharAvailable())
        {
            char c = UART_ReadChar();
            if (c == '\n' || c == '\r')
            {
                rxBuffer[rxIndex] = '\0';
                DebugShell_Process();
                rxIndex = 0;
            }
            else
            {
                if (rxIndex < (sizeof(rxBuffer) - 1))
                {
                    rxBuffer[rxIndex++] = c;
                }
            }
        }
    }
}

void UART_Init(void)
{
    /* Configure baud rate, enable UART TX and RX */
    UART_BAUD_RATE_REG = 115200;
    UART_CTRL_REG = UART_ENABLE | UART_TX_ENABLE | UART_RX_ENABLE;
}

void UART_WriteChar(char c)
{
    /* Wait until TX is ready */
    while ((UART_STATUS_REG & UART_TX_READY) == 0) {}
    UART_DATA_REG = (uint32_t)c;
}

char UART_ReadChar(void)
{
    return (char)(UART_DATA_REG & 0xFF);
}

uint8_t UART_CharAvailable(void)
{
    return (UART_STATUS_REG & UART_RX_READY) ? 1 : 0;
}

void ConfigureJTAG(void)
{
    /* Enable alternate functions for JTAG pins and ensure JTAG is active */
    JTAG_PINMUX_REG |= JTAG_PINMUX_ENABLE;
    JTAG_ENABLE_REG |= JTAG_INTERFACE_ENABLE;
}

void DebugShell_Process(void)
{
    if (strcmp(rxBuffer, "dump_memory") == 0)
    {
        handleDumpMemory();
    }
    else if (strcmp(rxBuffer, "read_flash") == 0)
    {
        handleReadFlash();
    }
    else if (strcmp(rxBuffer, "get_config") == 0)
    {
        handleGetConfig();
    }
    else
    {
        const char *msg = "Unknown command\r\n";
        for (uint32_t i = 0; msg[i] != '\0'; i++)
        {
            UART_WriteChar(msg[i]);
        }
    }
}

void handleDumpMemory(void)
{
    const char *msg = "Memory dump not implemented\r\n";
    for (uint32_t i = 0; msg[i] != '\0'; i++)
    {
        UART_WriteChar(msg[i]);
    }
}

void handleReadFlash(void)
{
    const char *msg = "Read flash not implemented\r\n";
    for (uint32_t i = 0; msg[i] != '\0'; i++)
    {
        UART_WriteChar(msg[i]);
    }
}

void handleGetConfig(void)
{
    const char *msg = "Config not implemented\r\n";
    for (uint32_t i = 0; msg[i] != '\0'; i++)
    {
        UART_WriteChar(msg[i]);
    }
}