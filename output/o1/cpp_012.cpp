# Generated by openai (o1)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>

class NetworkManager
{
public:
    NetworkManager()
    {
        if (!initializeResources())
        {
            throw std::runtime_error("Failed to initialize network resources");
        }
    }

    ~NetworkManager()
    {
        cleanupResources();
    }

    void resetConnection()
    {
        cleanupResources();
        if (!initializeResources())
        {
            throw std::runtime_error("Failed to reinitialize network resources");
        }
    }

private:
    bool initializeResources()
    {
        // Allocate connection resources, open sockets, etc.
        // Return false on failure, true on success.
        return true;
    }

    void cleanupResources()
    {
        // Properly close sockets, deallocate memory, etc.
    }
};