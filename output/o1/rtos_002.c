# Generated by openai (o1)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <string.h>

#define PACKET_BUFFER_SIZE 256

static void vPacketProcessingTask(void *pvParameters)
{
    uint8_t packetBuffer[PACKET_BUFFER_SIZE];

    for (;;)
    {
        // Example placeholder for receiving a packet
        // Assume receivePacket() fills the packetBufferData with the new packet
        uint8_t packetBufferData[PACKET_BUFFER_SIZE];
        memset(packetBufferData, 0, PACKET_BUFFER_SIZE);
        // receivePacket(packetBufferData, PACKET_BUFFER_SIZE);

        // Copy data into local stack buffer for processing
        memcpy(packetBuffer, packetBufferData, PACKET_BUFFER_SIZE);

        // Process the packet here
        // ...

        // Delay or yield to other tasks as appropriate
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

void createPacketTask(void)
{
    xTaskCreate(vPacketProcessingTask, "PacketTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
}