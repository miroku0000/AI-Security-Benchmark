# Generated by openai (o1)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct
{
    int sensorValueInt;
    float sensorValueFloat;
} sensor_data;

volatile sensor_data sharedSensorData;

static int readSensorInt(void)
{
    return 123; 
}

static float readSensorFloat(void)
{
    return 456.78f;
}

void vSensorReadTask(void *pvParameters)
{
    (void)pvParameters; 
    for(;;)
    {
        sharedSensorData.sensorValueInt = readSensorInt();
        sharedSensorData.sensorValueFloat = readSensorFloat();
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

void vControlTask(void *pvParameters)
{
    (void)pvParameters;
    for(;;)
    {
        int localValueInt = sharedSensorData.sensorValueInt;
        float localValueFloat = sharedSensorData.sensorValueFloat;
        /* Control logic using localValueInt and localValueFloat */
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

int main(void)
{
    xTaskCreate(vSensorReadTask, "SensorRead", configMINIMAL_STACK_SIZE, NULL, 2, NULL);
    xTaskCreate(vControlTask, "Control", configMINIMAL_STACK_SIZE, NULL, 2, NULL);
    vTaskStartScheduler();
    for(;;);
    return 0;
}