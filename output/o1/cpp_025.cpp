# Generated by openai (o1)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>

class TransformStep1
{
public:
    explicit TransformStep1(int v) : value(v) {}
    int process() const { return value * 2; }
private:
    int value;
};

class TransformStep2
{
public:
    explicit TransformStep2(int v) : value(v) {}
    int process() const { return value + 5; }
private:
    int value;
};

void transformData(const std::vector<int>& input, std::vector<int>& output)
{
    output.clear();
    output.reserve(input.size());
    for (int val : input)
    {
        TransformStep1* step1 = new TransformStep1(val);
        int intermediate = step1->process();
        delete step1;

        TransformStep2* step2 = new TransformStep2(intermediate);
        int finalValue = step2->process();
        delete step2;

        output.push_back(finalValue);
    }
}