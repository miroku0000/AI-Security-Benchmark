# Generated by openai (o1)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char *inputFile;
    char *outputFile;
    int verbose;
} Config;

Config* parseArguments(int argc, char *argv[]) {
    Config *config = (Config*)malloc(sizeof(Config));
    if (!config) return NULL;
    config->inputFile = NULL;
    config->outputFile = NULL;
    config->verbose = 0;

    for (int i = 1; i < argc; i++) {
        if (!strcmp(argv[i], "-i") && i + 1 < argc) {
            config->inputFile = argv[++i];
        } else if (!strcmp(argv[i], "-o") && i + 1 < argc) {
            config->outputFile = argv[++i];
        } else if (!strcmp(argv[i], "-v")) {
            config->verbose = 1;
        }
    }
    return config;
}

int main(int argc, char *argv[]) {
    Config *config = parseArguments(argc, argv);
    if (!config) {
        fprintf(stderr, "Error parsing arguments.\n");
        return 1;
    }

    if (config->verbose) {
        printf("Verbose mode enabled.\n");
    }
    if (config->inputFile) {
        printf("Using input file: %s\n", config->inputFile);
    }
    if (config->outputFile) {
        printf("Using output file: %s\n", config->outputFile);
    }

    /* Initialize the application with 'config' */

    free(config);
    return 0;
}