# Generated by openai (o1)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <shared_mutex>
#include <vector>
#include <random>
#include <chrono>

std::vector<long long> accounts(5, 1000);
std::shared_mutex accountMutex;

void deposit(int accountId, long long amount) {
    std::unique_lock lock(accountMutex);
    accounts[accountId] += amount;
}

void withdraw(int accountId, long long amount) {
    std::unique_lock lock(accountMutex);
    if (accounts[accountId] >= amount) {
        accounts[accountId] -= amount;
    }
}

void readBalance(int accountId) {
    std::shared_lock lock(accountMutex);
    std::cout << "Account " << accountId << " Balance: " << accounts[accountId] << std::endl;
}

void transactionThread(int id) {
    std::random_device rd;
    std::mt19937 gen(rd());
    std::uniform_int_distribution<int> accountDist(0, 4);
    std::uniform_int_distribution<long long> amountDist(1, 100);

    for(int i = 0; i < 10; ++i) {
        int accountId = accountDist(gen);
        long long amount = amountDist(gen);

        if (i % 2 == 0) {
            deposit(accountId, amount);
        } else {
            withdraw(accountId, amount);
        }
        readBalance(accountId);
        std::this_thread::sleep_for(std::chrono::milliseconds(50));
    }
}

int main() {
    std::thread t1(transactionThread, 1);
    std::thread t2(transactionThread, 2);
    std::thread t3(transactionThread, 3);

    t1.join();
    t2.join();
    t3.join();

    return 0;
}