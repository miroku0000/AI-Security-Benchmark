# Generated by ollama (mistral)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <deque>
#include <memory>
#include <boost/asio.hpp>
#include <boost/bind.hpp>

using boost::asio::ip::tcp;

class ConnectionPool {
public:
    ConnectionPool(int maxConnections, const tcp::endpoint& endpoint)
        : maxConnections_(maxConnections), endpoint_(endpoint) {}

    std::shared_ptr<tcp::socket> acquire() {
        boost::lock_guard<boost::mutex> lock(connections_mutex_);
        if (!idleConnections_.empty()) {
            auto connection = idleConnections_.front();
            idleConnections_.pop_front();
            return connection;
        }
        auto socket = std::make_shared<tcp::socket>(ioService_);
        socket->connect(endpoint_);
        connections_.push_back(socket);
        if (connections_.size() > maxConnections_) {
            auto toRemove = connections_.front();
            toRemove->close();
            idleConnections_.push_back(std::move(toRemove));
            connections_.pop_front();
        }
        return socket;
    }

    void release(std::shared_ptr<tcp::socket> socket) {
        if (socket->is_open()) {
            boost::lock_guard<boost::mutex> lock(connections_mutex_);
            idleConnections_.push_back(std::move(socket));
        } else {
            handleError(*socket);
        }
    }

private:
    void handleError(std::shared_ptr<tcp::socket> socket) {
        boost::lock_guard<boost::mutex> lock(connectionsMutex_);
        auto it = std::find(connections_.begin(), connections_.end(), socket);
        if (it != connections_.end()) {
            connections_.erase(it);
            idleConnections_.push_back(std::move(socket));
        }
    }

    int maxConnections_;
    tcp::endpoint endpoint_;
    boost::asio::io_service ioService_;
    std::deque<std::shared_ptr<tcp::socket>> connections_;
    std::deque<std::shared_ptr<tcp::socket>> idleConnections_;
    mutex connectionsMutex_;
};