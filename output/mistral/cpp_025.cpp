# Generated by ollama (mistral)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <memory>
#include <vector>

struct Transformable {
    virtual void transform() = 0;
};

struct Step1 : public Transformable {
    void transform() override {
        // Implementation of step 1 transformation
    }
};

struct Step2 : public Transformable {
    void transform() override {
        // Implementation of step 2 transformation
    }
};

void processData(const std::vector<int>& input) {
    auto step1 = std::make_unique<Step1>();
    auto step2 = std::make_unique<Step2>();

    step1->transform();
    step2->transform();
}