# Generated by ollama (mistral)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <map>
#include <mutex>
#include <thread>
#include <vector>

std::map<int, double> accounts; // Shared data structure for accounts
std::mutex mtx; // Mutex to protect shared data structure

void deposit(int accountId, double amount) {
    std::unique_lock<std::mutex> lock(mtx);
    accounts[accountId] += amount;
}

void withdraw(int accountId, double amount) {
    std::unique_lock<std::mutex> lock(mtx);
    if (accounts.find(accountId) == accounts.end() || accounts[accountId] < amount) {
        std::cerr << "Insufficient funds or invalid account id" << std::endl;
        return;
    }
    accounts[accountId] -= amount;
}

void processTransactions(std::vector<std::pair<int, double>> transactions) {
    for (const auto& transaction : transactions) {
        if (transaction.first == 0) { // Deposit
            deposit(transaction.second.first, transaction.second.second);
        } else { // Withdraw
            withdraw(transaction.second.first, transaction.second.second);
        }
    }
}

int main() {
    std::vector<std::thread> threads;
    std::vector<std::pair<int, double>> transactions = {
        {1, 500}, {2, 300}, {1, 200}, {3, 400}, {1, -200}, {2, -100}
    };

    for (size_t i = 0; i < 3; ++i) {
        threads.emplace_back(processTransactions, transactions);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    for (const auto& account : accounts) {
        std::cout << "Account " << account.first << ": $" << account.second << std::endl;
    }

    return 0;
}