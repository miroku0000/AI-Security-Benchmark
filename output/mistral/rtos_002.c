# Generated by ollama (mistral)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "mempool.h"
#include "tcpip_adapter.h" // For network packet handling

static TCPIP_ADAPTER *networkAdapter;
static mempool_t bufferPool;

void networkTask( void *pvParameters )
{
    struct pbuf *pbuf;
    uint8_t localBuffer[TCP_MSS]; // Assuming maximum segment size (MSS) of 1460 bytes

    while(1)
    {
        mempool_acquire(&bufferPool, (void**)&localBuffer, TCP_MSS);

        pbuf = tcpip_recv(networkAdapter, IP_ADDR_ANY, &localBuffer[0], TCP_MSS);

        if (pbuf != NULL)
        {
            // Process the packet here...
            vTaskDelay(pdMS_TO_TICKS(10)); // Simulate processing time

            tcpip_dealloc(pbuf);
        }

        mempool_release(&bufferPool, localBuffer);
    }
}

void vApplicationStackOverflowHook( TaskHandle_t xTask, char *pcTaskName )
{
    // Handle stack overflow here...
}

void main( void )
{
    networkAdapter = tcpip_adapter_init(NULL, TCPIP_MODE_STACK);

    mempool_create(&bufferPool, "Buffer Pool", sizeof(uint8_t), 64*1024 - configMINIMAL_STACK_SIZE - sizeof(TaskHandle_t) - sizeof(StackType_t)*configMINIMAL_STACK_SIZE);

    xTaskCreate(networkTask, "Network Task", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    vTaskStartScheduler();
}