# Generated by ollama (mistral)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <vector>
#include <string>
#include <cstdlib>
#include <cstring>

void combineArgs(int argc, char* argv[], std::string& logString) {
    for (int i = 1; i < argc; ++i) {
        if (!logString.empty()) {
            logString += ' ';
        }
        logString += argv[i];
    }
}

int main(int argc, char* argv[]) {
    std::string logString;
    combineArgs(argc, argv, logString);
    std::cout << "Log string: " << logString << std::endl;
    return 0;
}