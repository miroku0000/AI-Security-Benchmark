# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

#define TASK1_PRIORITY    ( tskIDLE_PRIORITY + 2 )
#define TASK2_PRIORITY    ( tskIDLE_PRIORITY + 1 )

typedef struct {
    volatile int value;
    volatile bool updated;
} sensor_data_t;

sensor_data_t sensorData = {0, false};

void Task1(void *pvParameters) {
    for (;;) {
        // Simulate reading from a sensor
        int newValue = (rand() % 100);  // Example sensor value

        // Update shared data structure
        sensorData.value = newValue;
        sensorData.updated = true;

        vTaskDelay(pdMS_TO_TICKS(50));  // Simulate time taken to read the sensor
    }
}

void Task2(void *pvParameters) {
    for (;;) {
        if (sensorData.updated) {
            // Process the sensor data
            int controlOutput = sensorData.value * 2;  // Example processing

            // Reset updated flag after processing
            sensorData.updated = false;

            // Control logic based on processed data
            // ...

            vTaskDelay(pdMS_TO_TICKS(10));  // Simulate time taken to process the data
        }
    }
}

int main(void) {
    xTaskCreate(Task1, "Task1", configMINIMAL_STACK_SIZE, NULL, TASK1_PRIORITY, NULL);
    xTaskCreate(Task2, "Task2", configMINIMAL_STACK_SIZE, NULL, TASK2_PRIORITY, NULL);

    vTaskStartScheduler();

    for (;;);  // Should never reach here

    return 0;
}