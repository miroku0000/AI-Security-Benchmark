# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"

#define STACK_BUFFER_SIZE 128

void vNetworkPacketProcessingTask(void *pvParameters) {
    uint8_t stackBuffer[STACK_BUFFER_SIZE];
    for (;;) {
        // Assume we have a function to receive packets from the network interface
        size_t packetSize = xReceivePacketFromInterface(stackBuffer, STACK_BUFFER_SIZE);

        if (packetSize > 0 && packetSize <= STACK_BUFFER_SIZE) {
            // Process the packet data in the stack buffer
            processPacket(stackBuffer, packetSize);
        }

        // Yield to allow other tasks to run
        taskYIELD();
    }
}

void setupNetworkProcessingTask(void) {
    xTaskCreate(vNetworkPacketProcessingTask, "NetworkProcessor", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
}