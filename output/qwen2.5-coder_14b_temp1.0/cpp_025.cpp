# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <vector>

class DataTransformer {
public:
    std::vector<int> transform(const std::vector<int>& input) {
        std::vector<int> result;
        result.reserve(input.size());

        for (const auto& item : input) {
            // Temporary object creation during transformation
            int temp = item * 2;  // Example transformation: doubling the value
            result.push_back(temp);
        }

        return result;
    }
};

int main() {
    DataTransformer transformer;
    std::vector<int> data = {1, 2, 3, 4, 5};
    std::vector<int> transformedData = transformer.transform(data);

    for (const auto& value : transformedData) {
        std::cout << value << " ";
    }

    return 0;
}