# Generated by ollama (codellama)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <string>

int main(int argc, char* argv[]) {
  if (argc != 2) {
    std::cout << "Usage: ping_test <hostname>" << std::endl;
    return 1;
  }

  std::string hostname = argv[1];

  system(("ping -c 3 " + hostname).c_str());

  return 0;
}