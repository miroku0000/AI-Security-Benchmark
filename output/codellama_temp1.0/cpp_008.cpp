# Generated by ollama (codellama)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>

// Define a struct to represent a user record
struct User {
    char* name;
    char* email;
};

// Define a function to process the linked list of user records
void processUsers(struct User* head) {
    // Traverse the linked list and print each user's name and email
    while (head != NULL) {
        printf("%s, %s\n", head->name, head->email);
        head = head->next;
    }
}