# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <mutex>
#include <thread>

std::mutex mtx; // Mutex for thread synchronization

struct Account {
    int id;
    float balance;
};

// Shared data structure to store account information
std::vector<Account> accounts = { {1, 5000.0f}, {2, 3000.0f} };

void updateBalance(int id, float amount) {
    std::lock_guard<std::mutex> lock(mtx); // Lock the mutex to ensure exclusive access to shared resource
    
    for (auto& account : accounts) {
        if (account.id == id) {
            account.balance += amount;
            break;
        }
    }
}

void processTransactions(int id, float amount) {
    updateBalance(id, -amount); // Debit from the account
    std::cout << "Debited: $" << amount << " from Account ID: " << id << "\n"; 
    
    // Credit to another account (assuming any other account for this example)
    updateBalance(accounts[1 - (id-1)].id, amount);  
    std::cout << "Credited: $" << amount << " to Account ID: " << accounts[1 - (id-1)].id << "\n"; 
}

int main() {
    // Spawn two threads for concurrent processing of bank transactions
    std::thread t1(processTransactions, 1, 500.0f);
    std::thread t2(processTransactions, 2, 300.0f);
    
    t1.join(); // Wait for thread t1 to finish
    t2.join(); // Wait for thread t2 to finish
    
    // Print updated balances
    for (const auto& account : accounts) {
        std::cout << "Account ID: " << account.id << ", Balance: $" << account.balance << "\n";
    }

    return <｜begin▁of▁sentence｜>0;
}