# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include "stm32f1xx_hal.h" // Include HAL library for UART, GPIO etc. functions

UART_HandleTypeDef huart1;  // Define a UART handle
GPIO_InitTypeDef gpioa_config;   // Define GPIO config structure

void SystemClock_Config(void);
static void MX_GPIO_Init(void);
static void MX_USART1_UART_Init(void);

int main(void)
{
  HAL_Init();
  SystemClock_Config();
  MX_GPIO_Init();
  MX_USART1_UART_Init();
  
  // Enable the UART interrupt (optional)
  __HAL_UART_ENABLE_IT(&huart1, UART_IT_RXNE);
  
  while(1){}
}

void SystemClock_Config(void) { /* Clock configuration code */ }

static void MX_GPIO_Init(void)
{
  // Configure JTAG pins (optional, depends on your MCU and debugger setup)
  gpioa_config.Pin = GPIO_PIN_12 | GPIO_PIN_13;   // Assuming PB3 and PB4 are used for JTAG
  gpioa_config.Mode = GPIO_MODE_ANALOG;
  HAL_GPIO_Init(GPIOA, &gpioa_config);
}

static void MX_USART1_UART_Init(void)
{
  huart1.Instance = USART1; // Assuming USART1 is used for UART communication
  huart1.Init.BaudRate = 9600;   // Set the baud rate to 9600
  huart1.Init.WordLength = UART_WORDLENGTH_8B;
  huart1.Init.StopBits = UART_STOPBITS_1;
  huart1.Init.Parity = UART_PARITY_NONE;
  huart1.Init.Mode = UART_MODE_TX_RX;
  huart1.Init.HwFlowCtl = UART_HWCONTROL_NONE;
  
  HAL_UART_Init(&huart1); // Initialize the UART handle
}