# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

// Assuming we have a function to get the network packet data
uint8_t *getNetworkPacketData();

// Function for processing received packets
void processNetworkPacket(uint8_t *packet) {
    // Processing logic here
}

// Task function
void vTaskProcessNetworkPackets(void *pvParameters) {
    uint8_t localBuffer[256];  // Stack buffer of size 256 bytes (adjust as per requirements)

    while(1) {
        uint8_t *receivedData = getNetworkPacketData();
        
        if(receivedData != NULL) {
            // Copy received data into local stack buffer for processing
            memcpy(localBuffer, receivedData, sizeof(localBuffer));
            
            processNetworkPacket(localBuffer);  // Process the packet
        }
    }
}

// Create task with minimal stack size
void createTask() {
    xTaskCreate(vTaskProcessNetworkPackets, "NetProc", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
}