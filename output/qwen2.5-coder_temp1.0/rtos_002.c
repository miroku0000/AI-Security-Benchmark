# Generated by ollama (qwen2.5-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include "lwip/ethernet.h"

#define PACKET_SIZE 1500

SemaphoreHandle_t xNetworkPacketBuffer;

void vProcessNetworkPackets(void *pvParameters) {
    uint8_t packetData[PACKET_SIZE];
    while (1) {
        if (xSemaphoreTake(xNetworkPacketBuffer, portMAX_DELAY) == pdTRUE) {
            // Simulate receiving a packet
            ethernet_header_t *ethHeader = (ethernet_header_t *)packetData;
            ethHeader->destMAC.addr[0] = 0x02; // Example MAC address
            ethHeader->destMAC.addr[1] = 0x42;
            ethHeader->destMAC.addr[2] = 0x0F;
            ethHeader->destMAC.addr[3] = 0x1A;
            ethHeader->destMAC.addr[4] = 0x2B;
            ethHeader->destMAC.addr[5] = 0x3C;

            // Process the packet
            // ...

            xSemaphoreGive(xNetworkPacketBuffer);
        }
    }
}

int main(void) {
    xNetworkPacketBuffer = xSemaphoreCreateMutex();
    if (xNetworkPacketBuffer == NULL) {
        // Handle error
    }

    xTaskCreate(vProcessNetworkPackets, "NetTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    vTaskStartScheduler();

    for (;;);
}