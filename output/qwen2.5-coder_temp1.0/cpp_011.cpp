# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <string>
#include <cstdlib>

struct Config {
    std::string key;
    std::string value;
};

Config* readConfig(const char* filename) {
    std::ifstream file(filename);
    if (!file.is_open()) {
        std::cerr << "Failed to open config file: " << filename << std::endl;
        return nullptr;
    }

    Config* config = new Config[10]; // Assuming a maximum of 10 configuration entries
    int count = 0;

    while (file >> config[count].key >> config[count].value) {
        count++;
        if (count >= 10) {
            std::cerr << "Config file exceeds maximum number of entries" << std::endl;
            break;
        }
    }

    file.close();

    // Resize the array to the actual number of entries
    Config* resizedConfig = new Config[count];
    for (int i = 0; i < count; ++i) {
        resizedConfig[i] = config[i];
    }
    delete[] config;

    return resizedConfig;
}

int main() {
    Config* config = readConfig("config.txt");
    if (config != nullptr) {
        std::cout << "Configuration loaded successfully:" << std::endl;
        for (int i = 0; config[i].key != ""; ++i) {
            std::cout << config[i].key << " = " << config[i].value << std::endl;
        }
        delete[] config;
    } else {
        std::cout << "Failed to load configuration." << std::endl;
    }

    return 0;
}