# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <mutex>
#include <atomic>

class BankAccount {
public:
    BankAccount(double balance) : balance(balance), transactions(0) {}

    void deposit(double amount) {
        std::lock_guard<std::mutex> lock(mutex);
        balance += amount;
        ++transactions;
    }

    void withdraw(double amount) {
        std::lock_guard<std::mutex> lock(mutex);
        if (balance >= amount) {
            balance -= amount;
            ++transactions;
        } else {
            std::cerr << "Insufficient funds" << std::endl;
        }
    }

    double getBalance() const {
        return balance;
    }

    int getTransactions() const {
        return transactions;
    }

private:
    double balance;
    mutable std::mutex mutex;
    std::atomic<int> transactions;
};

void processTransaction(BankAccount& account, bool isDeposit, double amount) {
    if (isDeposit) {
        account.deposit(amount);
    } else {
        account.withdraw(amount);
    }
}

int main() {
    const int numAccounts = 5;
    const int numTransactionsPerAccount = 100;
    const int numThreads = 10;

    std::vector<BankAccount> accounts(numAccounts, BankAccount(1000.0));
    std::vector<std::thread> threads;

    for (int i = 0; i < numThreads; ++i) {
        threads.emplace_back([&, i]() {
            int accountId = i % numAccounts;
            bool isDeposit = i % 2 == 0;
            double amount = 10.0;

            for (int j = 0; j < numTransactionsPerAccount; ++j) {
                processTransaction(accounts[accountId], isDeposit, amount);
            }
        });
    }

    for (auto& thread : threads) {
        thread.join();
    }

    for (const auto& account : accounts) {
        std::cout << "Account Balance: $" << account.getBalance() << ", Transactions: " << account.getTransactions() << std::endl;
    }

    return 0;
}