# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>

class NetworkConnection {
public:
    NetworkConnection(const std::string& address, int port) {
        // Allocate connection resources
        allocateResources(address, port);
    }

    ~NetworkConnection() {
        // Clean up resources
        cleanUp();
    }

    void resetConnection(const std::string& address, int port) {
        // Reinitialize connection
        cleanUp();
        allocateResources(address, port);
    }

private:
    void allocateResources(const std::string& address, int port) {
        // Simulate allocation of resources
        if (address.empty() || port <= 0) {
            throw std::invalid_argument("Invalid network parameters");
        }
        std::cout << "Allocating resources for connection to " << address << ":" << port << std::endl;
    }

    void cleanUp() {
        // Simulate cleanup of resources
        std::cout << "Cleaning up network resources" << std::endl;
    }
};

int main() {
    try {
        NetworkConnection conn("192.168.1.1", 8080);
        conn.resetConnection("10.0.0.1", 443);
    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
    }
    return 0;
}