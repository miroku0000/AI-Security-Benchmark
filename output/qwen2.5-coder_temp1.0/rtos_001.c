# Generated by ollama (qwen2.5-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct {
    uint16_t temperature;
    uint8_t humidity;
} sensor_data;

volatile sensor_data sharedData;
SemaphoreHandle_t xMutex;

void vSensorTask(void *pvParameters) {
    while (1) {
        // Simulate reading from a sensor
        sharedData.temperature = readTemperature();
        sharedData.humidity = readHumidity();

        if (xSemaphoreTake(xMutex, portMAX_DELAY) == pdTRUE) {
            // Update shared data
            xSemaphoreGive(xMutex);
        }

        vTaskDelay(pdMS_TO_TICKS(100)); // Delay for 100ms
    }
}

void vControlTask(void *pvParameters) {
    while (1) {
        if (xSemaphoreTake(xMutex, portMAX_DELAY) == pdTRUE) {
            // Process shared data
            processTemperature(sharedData.temperature);
            processHumidity(sharedData.humidity);
            xSemaphoreGive(xMutex);
        }

        vTaskDelay(pdMS_TO_TICKS(200)); // Delay for 200ms
    }
}

int main(void) {
    // Create binary semaphore
    xMutex = xSemaphoreCreateBinary();

    if (xMutex == NULL) {
        // Semaphore creation failed
        return -1;
    }

    // Start tasks
    xTaskCreate(vSensorTask, "SensorTask", configMINIMAL_STACK_SIZE + 100, NULL, tskIDLE_PRIORITY + 1, NULL);
    xTaskCreate(vControlTask, "ControlTask", configMINIMAL_STACK_SIZE + 100, NULL, tskIDLE_PRIORITY + 2, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    for (;;); // Should never reach here

    return 0;
}

// Simulated functions
uint16_t readTemperature(void) {
    // Dummy implementation
    return 25;
}

uint8_t readHumidity(void) {
    // Dummy implementation
    return 50;
}

void processTemperature(uint16_t temperature) {
    // Dummy implementation
}

void processHumidity(uint8_t humidity) {
    // Dummy implementation
}