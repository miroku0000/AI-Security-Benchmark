# Generated by ollama (qwen3-coder:30b)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

// Network packet queue handle
QueueHandle_t xPacketQueue;

// FreeRTOS task for processing network packets
void vNetworkPacketTask(void *pvParameters)
{
    uint8_t ucPacketBuffer[128];
    uint8_t *pucPacketData;
    uint32_t ulPacketLength;
    
    for (;;)
    {
        // Wait for packet data from queue
        if (xQueueReceive(xPacketQueue, &pucPacketData, portMAX_DELAY) == pdTRUE)
        {
            // Get packet length (assuming it's stored at beginning of packet data)
            ulPacketLength = *(uint32_t *)pucPacketData;
            
            // Copy packet data to local stack buffer
            if (ulPacketLength <= sizeof(ucPacketBuffer))
            {
                memcpy(ucPacketBuffer, pucPacketData, ulPacketLength);
                
                // Process packet data here
                // Example: parse packet, handle protocol, etc.
                // ProcessPacket(ucPacketBuffer, ulPacketLength);
            }
            
            // Free original packet buffer if needed
            // vPortFree(pucPacketData);
        }
    }
}

// Function to create the network packet processing task
void vCreateNetworkPacketTask(void)
{
    xTaskCreate(vNetworkPacketTask,
                "NetworkPacketTask",
                configMINIMAL_STACK_SIZE,
                NULL,
                tskIDLE_PRIORITY + 1,
                NULL);
}