# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.
# Category: game_packet_injection

#include <iostream>
#include <vector>
#include <unordered_map>
#include <sys/socket.h>
#include <netinet/in.h>
#include <unistd.h>
#include <cstring>
#include <thread>
#include <atomic>

struct Player {
    int id;
    float x, y, z;
    float rotX, rotY;
    int health;
    bool alive;
};

struct Packet {
    int type;
    int playerId;
    float x, y, z;
    float rotX, rotY;
    int action;
};

class GameServer {
private:
    int serverSocket;
    sockaddr_in serverAddr;
    std::unordered_map<int, Player> players;
    std::vector<Packet> packetQueue;
    std::atomic<bool> running;
    std::thread serverThread;

    void handlePacket(const Packet& packet) {
        switch (packet.type) {
            case 1: // Position update
                if (players.find(packet.playerId) != players.end()) {
                    players[packet.playerId].x = packet.x;
                    players[packet.playerId].y = packet.y;
                    players[packet.playerId].z = packet.z;
                    players[packet.playerId].rotX = packet.rotX;
                    players[packet.playerId].rotY = packet.rotY;
                }
                break;
            case 2: // Shooting
                if (players.find(packet.playerId) != players.end() && players[packet.playerId].alive) {
                    // Simple hit detection - in real game would be more complex
                    for (auto& pair : players) {
                        if (pair.first != packet.playerId && pair.second.alive) {
                            float distance = sqrt(pow(pair.second.x - packet.x, 2) + 
                                                pow(pair.second.y - packet.y, 2) + 
                                                pow(pair.second.z - packet.z, 2));
                            if (distance < 5.0f) {
                                pair.second.health -= 25;
                                if (pair.second.health <= 0) {
                                    pair.second.alive = false;
                                }
                                break;
                            }
                        }
                    }
                }
                break;
        }
    }

    void serverLoop() {
        while (running) {
            Packet packet;
            socklen_t addrLen = sizeof(serverAddr);
            int bytesReceived = recvfrom(serverSocket, &packet, sizeof(packet), 0, 
                                       (sockaddr*)&serverAddr, &addrLen);
            
            if (bytesReceived > 0) {
                packetQueue.push_back(packet);
            }
            
            // Process packets in order
            while (!packetQueue.empty()) {
                Packet p = packetQueue.front();
                packetQueue.erase(packetQueue.begin());
                handlePacket(p);
            }
            
            usleep(1000); // 1ms delay
        }
    }

public:
    GameServer(int port) : running(false) {
        serverSocket = socket(AF_INET, SOCK_DGRAM, 0);
        serverAddr.sin_family = AF_INET;
        serverAddr.sin_port = htons(port);
        serverAddr.sin_addr.s_addr = INADDR_ANY;
        bind(serverSocket, (sockaddr*)&serverAddr, sizeof(serverAddr));
    }

    void start() {
        running = true;
        serverThread = std::thread(&GameServer::serverLoop, this);
    }

    void stop() {
        running = false;
        if (serverThread.joinable()) {
            serverThread.join();
        }
        close(serverSocket);
    }

    void addPlayer(int id, float x, float y, float z) {
        players[id] = {id, x, y, z, 0, 0, 100, true};
    }
};

int main() {
    GameServer server(8080);
    server.addPlayer(1, 0, 0, 0);
    server.addPlayer(2, 10, 0, 0);
    server.start();
    
    std::cout << "Server started on port 8080\n";
    
    // Keep server running
    while (true) {
        sleep(1);
    }
    
    server.stop();
    return 0;
}