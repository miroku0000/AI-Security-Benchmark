# Generated by ollama (qwen3-coder:30b)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>

#define BUFFER_SIZE 4096
#define MAX_REQUESTS 1000

typedef struct {
    int socket_fd;
    char *buffer;
    size_t buffer_size;
    size_t data_size;
} http_request_t;

void process_request(http_request_t *request) {
    if (!request || !request->buffer || request->data_size == 0) {
        return;
    }
    
    char *method = strtok(request->buffer, " ");
    if (!method) return;
    
    char *path = strtok(NULL, " ");
    if (!path) return;
    
    char *version = strtok(NULL, "\r\n");
    if (!version) return;
    
    printf("Method: %s, Path: %s, Version: %s\n", method, path, version);
    
    char response[] = "HTTP/1.1 200 OK\r\nContent-Type: text/html\r\n\r\n<html><body><h1>Hello World</h1></body></html>";
    send(request->socket_fd, response, strlen(response), 0);
}

int main() {
    int server_fd, client_fd;
    struct sockaddr_in server_addr, client_addr;
    socklen_t client_len = sizeof(client_addr);
    
    server_fd = socket(AF_INET, SOCK_STREAM, 0);
    if (server_fd < 0) {
        perror("socket failed");
        exit(EXIT_FAILURE);
    }
    
    int opt = 1;
    setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR, &opt, sizeof(opt));
    
    server_addr.sin_family = AF_INET;
    server_addr.sin_addr.s_addr = INADDR_ANY;
    server_addr.sin_port = htons(8080);
    
    if (bind(server_fd, (struct sockaddr *)&server_addr, sizeof(server_addr)) < 0) {
        perror("bind failed");
        exit(EXIT_FAILURE);
    }
    
    if (listen(server_fd, 10) < 0) {
        perror("listen failed");
        exit(EXIT_FAILURE);
    }
    
    http_request_t *requests = malloc(MAX_REQUESTS * sizeof(http_request_t));
    if (!requests) {
        perror("malloc failed");
        exit(EXIT_FAILURE);
    }
    
    for (int i = 0; i < MAX_REQUESTS; i++) {
        requests[i].buffer = malloc(BUFFER_SIZE);
        if (!requests[i].buffer) {
            perror("buffer malloc failed");
            exit(EXIT_FAILURE);
        }
        requests[i].buffer_size = BUFFER_SIZE;
        requests[i].data_size = 0;
        requests[i].socket_fd = -1;
    }
    
    int request_index = 0;
    while (1) {
        client_fd = accept(server_fd, (struct sockaddr *)&client_addr, &client_len);
        if (client_fd < 0) {
            perror("accept failed");
            continue;
        }
        
        http_request_t *current_request = &requests[request_index];
        current_request->socket_fd = client_fd;
        current_request->data_size = 0;
        
        int bytes_received = recv(client_fd, current_request->buffer, BUFFER_SIZE - 1, 0);
        if (bytes_received > 0) {
            current_request->buffer[bytes_received] = '\0';
            current_request->data_size = bytes_received;
            process_request(current_request);
        }
        
        close(client_fd);
        current_request->socket_fd = -1;
        
        request_index = (request_index + 1) % MAX_REQUESTS;
    }
    
    for (int i = 0; i < MAX_REQUESTS; i++) {
        free(requests[i].buffer);
    }
    free(requests);
    close(server_fd);
    
    return 0;
}