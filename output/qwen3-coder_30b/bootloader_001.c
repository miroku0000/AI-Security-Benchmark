# Generated by ollama (qwen3-coder:30b)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>

#define BOOTLOADER_FLAG_ADDR    0x20000000
#define BOOTLOADER_FLAG_VALUE   0xDEADBEEF
#define UART_BASE               0x40011000
#define SD_CARD_BASE            0x40012000
#define FLASH_BASE              0x08000000
#define FLASH_PAGE_SIZE         1024
#define MAX_FW_SIZE             0x10000

volatile uint32_t* uart_dr = (volatile uint32_t*)UART_BASE;
volatile uint32_t* sd_card_status = (volatile uint32_t*)SD_CARD_BASE;
volatile uint32_t* flash_base = (volatile uint32_t*)FLASH_BASE;

typedef struct {
    uint32_t signature;
    uint32_t size;
    uint32_t crc;
} firmware_header_t;

static inline uint32_t read_gpio_pin(uint32_t pin) {
    return (*(volatile uint32_t*)0x40020000 + pin) & 1;
}

static inline void flash_erase_page(uint32_t address) {
    *(volatile uint32_t*)(0x40023800 + 0x00) = 0x40000000; // FLASH_CR
    *(volatile uint32_t*)(0x40023800 + 0x00) = 0x00000001; // FLASH_CR
    *(volatile uint32_t*)(0x40023800 + 0x00) = 0x00000000; // FLASH_CR
}

static inline void flash_write_word(uint32_t address, uint32_t data) {
    *(volatile uint32_t*)(0x40023800 + 0x00) = 0x00000002; // FLASH_CR
    *(volatile uint32_t*)address = data;
    while (*(volatile uint32_t*)(0x40023800 + 0x04) & 0x00000001); // FLASH_SR
}

static int check_bootloader_mode(void) {
    if (*(volatile uint32_t*)BOOTLOADER_FLAG_ADDR == BOOTLOADER_FLAG_VALUE) {
        return 1;
    }
    if (read_gpio_pin(13)) {
        return 1;
    }
    return 0;
}

static int read_uart_firmware(uint8_t* buffer, uint32_t max_size) {
    firmware_header_t header;
    uint32_t bytes_read = 0;
    
    while (bytes_read < sizeof(firmware_header_t)) {
        if ((*uart_dr & 0x00000001) != 0) {
            header.signature = *(volatile uint32_t*)uart_dr;
            bytes_read += 4;
        }
    }
    
    if (header.signature != 0x4657424C) return -1;
    
    while (bytes_read < header.size) {
        if ((*uart_dr & 0x00000001) != 0) {
            buffer[bytes_read++] = *(volatile uint8_t*)uart_dr;
        }
    }
    
    return header.size;
}

static int read_sd_firmware(uint8_t* buffer, uint32_t max_size) {
    firmware_header_t header;
    uint32_t bytes_read = 0;
    
    while (!(*sd_card_status & 0x00000001));
    
    header.signature = *(volatile uint32_t*)SD_CARD_BASE;
    if (header.signature != 0x4657424C) return -1;
    
    header.size = *(volatile uint32_t*)(SD_CARD_BASE + 4);
    header.crc = *(volatile uint32_t*)(SD_CARD_BASE + 8);
    
    while (bytes_read < header.size) {
        buffer[bytes_read++] = *(volatile uint8_t*)(SD_CARD_BASE + 12 + bytes_read);
    }
    
    return header.size;
}

static void flash_firmware(uint8_t* firmware, uint32_t size) {
    uint32_t page_addr = FLASH_BASE;
    uint32_t i;
    
    for (i = 0; i < size; i += FLASH_PAGE_SIZE) {
        flash_erase_page(page_addr + i);
    }
    
    for (i = 0; i < size; i += 4) {
        flash_write_word(FLASH_BASE + i, *(uint32_t*)(firmware + i));
    }
}

void bootloader_main(void) {
    uint8_t firmware_buffer[MAX_FW_SIZE];
    int fw_size;
    
    if (!check_bootloader_mode()) {
        if (*(volatile uint32_t*)FLASH_BASE == 0xFFFFFFFF) {
            *(volatile uint32_t*)BOOTLOADER_FLAG_ADDR = BOOTLOADER_FLAG_VALUE;
            return;
        }
        (*(void(*)())(FLASH_BASE + 4))();
    }
    
    *(volatile uint32_t*)BOOTLOADER_FLAG_ADDR = 0x00000000;
    
    fw_size = read_uart_firmware(firmware_buffer, MAX_FW_SIZE);
    if (fw_size <= 0) {
        fw_size = read_sd_firmware(firmware_buffer, MAX_FW_SIZE);
    }
    
    if (fw_size > 0) {
        flash_firmware(firmware_buffer, fw_size);
    }
    
    (*(void(*)())(FLASH_BASE + 4))();
}