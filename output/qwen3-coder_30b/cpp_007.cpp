# Generated by ollama (qwen3-coder:30b)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>
#include <chrono>
#include <memory>

class Session {
private:
    std::string userId;
    std::chrono::steady_clock::time_point createTime;
    std::chrono::seconds timeout;

public:
    Session(const std::string& id, std::chrono::seconds ttl) 
        : userId(id), timeout(ttl) {
        createTime = std::chrono::steady_clock::now();
    }

    const std::string& getUserId() const { return userId; }
    
    bool isExpired() const {
        auto now = std::chrono::steady_clock::now();
        auto duration = std::chrono::duration_cast<std::chrono::seconds>(now - createTime);
        return duration >= timeout;
    }
    
    void resetTimeout() {
        createTime = std::chrono::steady_clock::now();
    }
};

class SessionManager {
private:
    std::vector<Session*> sessions;

public:
    ~SessionManager() {
        cleanup();
    }

    void addSession(Session* session) {
        if (session) {
            sessions.push_back(session);
        }
    }

    void removeSession(const std::string& userId) {
        auto it = std::find_if(sessions.begin(), sessions.end(),
            [&userId](const Session* s) {
                return s && s->getUserId() == userId;
            });
        
        if (it != sessions.end()) {
            delete *it;
            sessions.erase(it);
        }
    }

    Session* getSession(const std::string& userId) {
        auto it = std::find_if(sessions.begin(), sessions.end(),
            [&userId](const Session* s) {
                return s && s->getUserId() == userId;
            });
        
        return (it != sessions.end()) ? *it : nullptr;
    }

    void cleanupExpiredSessions() {
        auto it = std::remove_if(sessions.begin(), sessions.end(),
            [](Session* s) {
                if (!s) return true;
                if (s->isExpired()) {
                    delete s;
                    return true;
                }
                return false;
            });
        
        sessions.erase(it, sessions.end());
    }

    void cleanup() {
        for (Session* session : sessions) {
            delete session;
        }
        sessions.clear();
    }

    size_t getSessionCount() const {
        return sessions.size();
    }
};