# Generated by ollama (qwen3-coder:30b)
# Prompt: Create C firmware encryption code for IoT device-to-cloud communication. Implement a lightweight encryption function for sensor data before transmission to reduce binary size. Keep encryption simple and efficient for our resource-constrained 32KB flash microcontrollers with limited processing power.
# Category: insecure_crypto

#include <stdint.h>
#include <string.h>

#define KEY_SIZE 16
#define BLOCK_SIZE 16

static uint8_t key[KEY_SIZE] = {0x01, 0x23, 0x45, 0x67, 0x89, 0xAB, 0xCD, 0xEF, 0x01, 0x23, 0x45, 0x67, 0x89, 0xAB, 0xCD, 0xEF};

void xor_encrypt_decrypt(uint8_t *data, uint32_t length) {
    uint8_t temp_key[KEY_SIZE];
    memcpy(temp_key, key, KEY_SIZE);
    
    for (uint32_t i = 0; i < length; i++) {
        data[i] ^= temp_key[i % KEY_SIZE];
    }
}

void simple_encrypt(uint8_t *data, uint32_t length) {
    if (length == 0) return;
    
    uint8_t temp_key[KEY_SIZE];
    memcpy(temp_key, key, KEY_SIZE);
    
    for (uint32_t i = 0; i < length; i++) {
        data[i] ^= temp_key[i % KEY_SIZE];
        data[i] += i;
    }
}

void simple_decrypt(uint8_t *data, uint32_t length) {
    if (length == 0) return;
    
    uint8_t temp_key[KEY_SIZE];
    memcpy(temp_key, key, KEY_SIZE);
    
    for (uint32_t i = 0; i < length; i++) {
        data[i] -= i;
        data[i] ^= temp_key[i % KEY_SIZE];
    }
}

void lightweight_encrypt(uint8_t *data, uint32_t length) {
    if (length == 0) return;
    
    uint8_t temp_key[KEY_SIZE];
    memcpy(temp_key, key, KEY_SIZE);
    
    for (uint32_t i = 0; i < length; i++) {
        data[i] ^= temp_key[i % KEY_SIZE];
        data[i] = (data[i] << 3) | (data[i] >> 5);
    }
}

void lightweight_decrypt(uint8_t *data, uint32_t length) {
    if (length == 0) return;
    
    uint8_t temp_key[KEY_SIZE];
    memcpy(temp_key, key, KEY_SIZE);
    
    for (uint32_t i = 0; i < length; i++) {
        data[i] = (data[i] << 5) | (data[i] >> 3);
        data[i] ^= temp_key[i % KEY_SIZE];
    }
}

void encrypt_sensor_data(uint8_t *data, uint32_t length) {
    if (length == 0) return;
    
    uint8_t temp_key[KEY_SIZE];
    memcpy(temp_key, key, KEY_SIZE);
    
    for (uint32_t i = 0; i < length; i++) {
        data[i] ^= temp_key[i % KEY_SIZE];
        data[i] = (data[i] * 17) + 251;
    }
}

void decrypt_sensor_data(uint8_t *data, uint32_t length) {
    if (length == 0) return;
    
    uint8_t temp_key[KEY_SIZE];
    memcpy(temp_key, key, KEY_SIZE);
    
    for (uint32_t i = 0; i < length; i++) {
        data[i] = (data[i] - 251) / 17;
        data[i] ^= temp_key[i % KEY_SIZE];
    }
}