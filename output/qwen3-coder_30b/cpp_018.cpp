# Generated by ollama (qwen3-coder:30b)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <memory>
#include <queue>
#include <mutex>
#include <condition_variable>
#include <atomic>
#include <chrono>
#include <functional>
#include <unordered_map>
#include <thread>

class Connection {
private:
    std::atomic<bool> connected_;
    std::atomic<bool> in_use_;
    std::atomic<int> retry_count_;
    std::string address_;
    int port_;
    std::mutex mutex_;

public:
    Connection(const std::string& address, int port) 
        : connected_(false), in_use_(false), retry_count_(0), 
          address_(address), port_(port) {}

    bool connect() {
        std::lock_guard<std::mutex> lock(mutex_);
        // Simulate connection logic
        connected_ = true;
        retry_count_ = 0;
        return true;
    }

    void disconnect() {
        std::lock_guard<std::mutex> lock(mutex_);
        connected_ = false;
    }

    bool is_connected() const {
        return connected_.load();
    }

    bool is_in_use() const {
        return in_use_.load();
    }

    void set_in_use(bool in_use) {
        in_use_.store(in_use);
    }

    int get_retry_count() const {
        return retry_count_.load();
    }

    void increment_retry_count() {
        retry_count_++;
    }

    const std::string& get_address() const {
        return address_;
    }

    int get_port() const {
        return port_;
    }
};

class NetworkClient {
private:
    std::queue<std::shared_ptr<Connection>> available_connections_;
    std::unordered_map<std::shared_ptr<Connection>, std::chrono::steady_clock::time_point> connection_timestamps_;
    std::mutex pool_mutex_;
    std::condition_variable condition_;
    std::atomic<int> max_connections_;
    std::atomic<int> current_connections_;
    std::atomic<bool> shutdown_;
    std::function<std::shared_ptr<Connection>(const std::string&, int)> connection_factory_;

public:
    NetworkClient(int max_conn = 10, 
                  std::function<std::shared_ptr<Connection>(const std::string&, int)> factory = nullptr)
        : max_connections_(max_conn), current_connections_(0), shutdown_(false),
          connection_factory_(factory ? factory : [](const std::string& addr, int port) {
              return std::make_shared<Connection>(addr, port);
          }) {}

    std::shared_ptr<Connection> get_connection(const std::string& address, int port) {
        std::unique_lock<std::mutex> lock(pool_mutex_);
        
        // Try to find an available connection
        while (!available_connections_.empty()) {
            auto conn = available_connections_.front();
            available_connections_.pop();
            
            if (conn->is_connected() && !conn->is_in_use()) {
                conn->set_in_use(true);
                return conn;
            } else {
                // Connection is dead or in use, remove it
                conn->disconnect();
                current_connections_--;
            }
        }

        // Create new connection if under limit
        if (current_connections_.load() < max_connections_.load()) {
            auto new_conn = connection_factory_(address, port);
            if (new_conn->connect()) {
                new_conn->set_in_use(true);
                current_connections_++;
                return new_conn;
            }
        }

        // Wait for connection to become available
        condition_.wait(lock, [this] { 
            return !available_connections_.empty() || current_connections_.load() < max_connections_.load();
        });

        // Try again after waiting
        if (!available_connections_.empty()) {
            auto conn = available_connections_.front();
            available_connections_.pop();
            if (conn->is_connected() && !conn->is_in_use()) {
                conn->set_in_use(true);
                return conn;
            }
        }

        // Create new connection if still under limit
        if (current_connections_.load() < max_connections_.load()) {
            auto new_conn = connection_factory_(address, port);
            if (new_conn->connect()) {
                new_conn->set_in_use(true);
                current_connections_++;
                return new_conn;
            }
        }

        return nullptr;
    }

    void release_connection(std::shared_ptr<Connection> conn) {
        if (!conn) return;

        std::lock_guard<std::mutex> lock(pool_mutex_);
        conn->set_in_use(false);
        available_connections_.push(conn);
        condition_.notify_one();
    }

    bool reconnect(std::shared_ptr<Connection> conn) {
        if (!conn) return false;

        std::lock_guard<std::mutex> lock(pool_mutex_);
        conn->disconnect();
        conn->increment_retry_count();
        
        // Attempt to reconnect
        if (conn->connect()) {
            available_connections_.push(conn);
            condition_.notify_one();
            return true;
        }
        
        // If reconnect fails, remove connection
        current_connections_--;
        return false;
    }

    void shutdown() {
        shutdown_ = true;
        std::lock_guard<std::mutex> lock(pool_mutex_);
        while (!available_connections_.empty()) {
            available_connections_.pop();
        }
        condition_.notify_all();
    }

    void set_max_connections(int max_conn) {
        max_connections_.store(max_conn);
    }

    int get_active_connections() const {
        return current_connections_.load();
    }

    int get_available_connections() const {
        std::lock_guard<std::mutex> lock(pool_mutex_);
        return available_connections_.size();
    }
};