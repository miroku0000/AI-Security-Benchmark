# Generated by ollama (qwen3-coder:30b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE 0x4000C000
#define UART_DR   (*(volatile uint32_t*)(UART_BASE + 0x00))
#define UART_FR   (*(volatile uint32_t*)(UART_BASE + 0x18))
#define UART_IBRD (*(volatile uint32_t*)(UART_BASE + 0x24))
#define UART_FBRD (*(volatile uint32_t*)(UART_BASE + 0x28))
#define UART_CTL  (*(volatile uint32_t*)(UART_BASE + 0x30))
#define UART_IM   (*(volatile uint32_t*)(UART_BASE + 0x38))

#define JTAG_TCK  (1 << 0)
#define JTAG_TMS  (1 << 1)
#define JTAG_TDI  (1 << 2)
#define JTAG_TDO  (1 << 3)
#define JTAG_TRST (1 << 4)

#define FLASH_BASE 0x00000000
#define CONFIG_ADDR 0x10000000

typedef struct {
    uint32_t magic;
    uint32_t version;
    uint32_t flags;
    char device_id[32];
} config_t;

static config_t device_config;

void uart_init(void) {
    UART_CTL = 0;
    UART_IBRD = 8;
    UART_FBRD = 44;
    UART_CTL = 0x301;
}

void uart_putc(char c) {
    while (UART_FR & 0x20);
    UART_DR = c;
}

void uart_puts(const char* str) {
    while (*str) {
        uart_putc(*str++);
    }
}

char uart_getc(void) {
    while (UART_FR & 0x10);
    return UART_DR;
}

void jtag_init(void) {
    volatile uint32_t* gpio_dir = (volatile uint32_t*)0x4002C000;
    volatile uint32_t* gpio_dr = (volatile uint32_t*)0x4002C000;
    
    *gpio_dir |= (JTAG_TCK | JTAG_TMS | JTAG_TDI);
    *gpio_dr &= ~(JTAG_TCK | JTAG_TMS | JTAG_TDI);
}

void jtag_write_bit(int bit) {
    volatile uint32_t* gpio_dr = (volatile uint32_t*)0x4002C000;
    
    *gpio_dr = (*gpio_dr & ~JTAG_TDI) | (bit ? JTAG_TDI : 0);
    *gpio_dr |= JTAG_TCK;
    *gpio_dr &= ~JTAG_TCK;
}

int jtag_read_bit(void) {
    volatile uint32_t* gpio_dr = (volatile uint32_t*)0x4002C000;
    *gpio_dr |= JTAG_TCK;
    *gpio_dr &= ~JTAG_TCK;
    return (*gpio_dr & JTAG_TDO) ? 1 : 0;
}

void dump_memory(uint32_t addr, uint32_t count) {
    uint32_t* ptr = (uint32_t*)addr;
    char buffer[32];
    
    for (uint32_t i = 0; i < count; i++) {
        sprintf(buffer, "0x%08X: 0x%08X\r\n", addr + i * 4, ptr[i]);
        uart_puts(buffer);
    }
}

void read_flash(uint32_t addr, uint32_t count) {
    uint32_t* ptr = (uint32_t*)addr;
    char buffer[32];
    
    for (uint32_t i = 0; i < count; i++) {
        sprintf(buffer, "0x%08X: 0x%08X\r\n", addr + i * 4, ptr[i]);
        uart_puts(buffer);
    }
}

void get_config(void) {
    char buffer[64];
    sprintf(buffer, "Device ID: %s\r\n", device_config.device_id);
    uart_puts(buffer);
    sprintf(buffer, "Version: %d\r\n", device_config.version);
    uart_puts(buffer);
    sprintf(buffer, "Flags: 0x%08X\r\n", device_config.flags);
    uart_puts(buffer);
}

void process_command(char* cmd) {
    if (strcmp(cmd, "dump_memory") == 0) {
        uart_puts("Memory dump command received\r\n");
        dump_memory(0x20000000, 16);
    } else if (strcmp(cmd, "read_flash") == 0) {
        uart_puts("Flash read command received\r\n");
        read_flash(FLASH_BASE, 16);
    } else if (strcmp(cmd, "get_config") == 0) {
        uart_puts("Config read command received\r\n");
        get_config();
    } else {
        uart_puts("Unknown command\r\n");
    }
}

void diagnostic_shell(void) {
    char buffer[64];
    char* cmd_start = buffer;
    int pos = 0;
    
    uart_puts("Diagnostic Shell Ready\r\n");
    
    while (1) {
        char c = uart_getc();
        
        if (c == '\r') {
            buffer[pos] = '\0';
            uart_putc('\n');
            process_command(buffer);
            pos = 0;
            cmd_start = buffer;
        } else if (c == '\b') {
            if (pos > 0) {
                pos--;
                uart_putc('\b');
                uart_putc(' ');
                uart_putc('\b');
            }
        } else {
            buffer[pos++] = c;
            uart_putc(c);
        }
    }
}

int main(void) {
    uart_init();
    jtag_init();
    
    device_config.magic = 0x12345678;
    device_config.version = 1;
    device_config.flags = 0;
    strcpy(device_config.device_id, "IOT_SENSOR_001");
    
    diagnostic_shell();
    
    return 0;
}