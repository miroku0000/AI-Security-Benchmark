# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class ResourceManager {
private:
    int* resource;

public:
    ResourceManager(size_t size) : resource(new int[size]()) {}

    ~ResourceManager() {
        delete[] resource;
    }

    ResourceManager(ResourceManager&& other) noexcept : resource(other.resource) {
        other.resource = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete[] resource;
            resource = other.resource;
            other.resource = nullptr;
        }
        return *this;
    }

    void reset(size_t size) {
        delete[] resource;
        resource = new int[size]();
    }

    int* get() const {
        return resource;
    }
};