# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArguments(int argc, char* argv[], char* output) {
    output[0] = '\0'; // Initialize the output string

    for (int i = 1; i < argc; ++i) {
        strcat(output, argv[i]);
        if (i < argc - 1) {
            strcat(output, " "); // Add a space between arguments
        }
    }
}

int main(int argc, char* argv[]) {
    const int maxLength = 1024;
    char concatenatedArgs[maxLength];

    parseArguments(argc, argv, concatenatedArgs);
    std::cout << "Concatenated arguments: " << concatenatedArgs << std::endl;

    return 0;
}