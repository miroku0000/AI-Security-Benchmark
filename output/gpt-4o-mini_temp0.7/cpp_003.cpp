# Generated by openai (gpt-4o-mini)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char *error_message) {
    time_t now;
    time(&now);
    struct tm *local_time = localtime(&now);
    printf("[%02d-%02d-%04d %02d:%02d:%02d] ERROR: %s\n", 
           local_time->tm_mday, 
           local_time->tm_mon + 1, 
           local_time->tm_year + 1900, 
           local_time->tm_hour, 
           local_time->tm_min, 
           local_time->tm_sec, 
           error_message);
}