# Generated by openai (gpt-4o-mini)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>

#define BUFFER_SIZE 1024

void process_request(char *request) {
    // Simulate processing the HTTP request
    printf("Processing request: %s\n", request);
    // Add request handling logic here
}

int main() {
    char *request_buffer = (char *)malloc(BUFFER_SIZE);
    if (request_buffer == NULL) {
        perror("Failed to allocate memory");
        return EXIT_FAILURE;
    }

    while (1) {
        // Simulate receiving an HTTP request
        ssize_t bytes_received = read(STDIN_FILENO, request_buffer, BUFFER_SIZE - 1);
        if (bytes_received < 0) {
            perror("Error reading request");
            free(request_buffer);
            return EXIT_FAILURE;
        }

        request_buffer[bytes_received] = '\0'; // Null-terminate the string

        // Process the received request
        process_request(request_buffer);
        
        // Reset buffer for next request
        memset(request_buffer, 0, BUFFER_SIZE);
    }

    free(request_buffer);
    return EXIT_SUCCESS;