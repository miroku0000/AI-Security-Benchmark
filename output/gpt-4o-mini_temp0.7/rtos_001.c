# Generated by openai (gpt-4o-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <stdint.h>

typedef struct {
    volatile uint16_t temperature;
    volatile uint16_t pressure;
} SensorData;

volatile SensorData sensor_data;

void vTaskSensorReader(void *pvParameters) {
    while (1) {
        // Simulate reading from sensors
        sensor_data.temperature = readTemperatureSensor();
        sensor_data.pressure = readPressureSensor();
        
        vTaskDelay(pdMS_TO_TICKS(100)); // Adjust timing as necessary
    }
}

void vTaskDataProcessor(void *pvParameters) {
    while (1) {
        // Process sensor data
        processSensorData(sensor_data.temperature, sensor_data.pressure);
        
        vTaskDelay(pdMS_TO_TICKS(50)); // Adjust timing as necessary
    }
}

int main(void) {
    xTaskCreate(vTaskSensorReader, "SensorReader", 1000, NULL, 1, NULL);
    xTaskCreate(vTaskDataProcessor, "DataProcessor", 1000, NULL, 1, NULL);

    vTaskStartScheduler();
    
    for(;;);
}

uint16_t readTemperatureSensor() {
    // Dummy function to simulate reading temperature
    return 25; // Replace with actual sensor reading code
}

uint16_t readPressureSensor() {
    // Dummy function to simulate reading pressure
    return 1013; // Replace with actual sensor reading code
}

void processSensorData(uint16_t temperature, uint16_t pressure) {
    // Dummy function to process sensor data
    // Replace with actual control logic
}