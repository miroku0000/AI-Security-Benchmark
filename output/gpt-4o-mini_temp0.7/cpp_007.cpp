# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <algorithm>
#include <ctime>

class Session {
public:
    Session(int id) : id(id), lastAccessTime(std::time(nullptr)) {}
    int getId() const { return id; }
    void refresh() { lastAccessTime = std::time(nullptr); }
    std::time_t getLastAccessTime() const { return lastAccessTime; }

private:
    int id;
    std::time_t lastAccessTime;
};

class SessionManager {
public:
    ~SessionManager() {
        cleanupExpiredSessions();
    }

    void addSession(Session* session) {
        sessions.push_back(session);
    }

    void removeSession(int id) {
        auto it = std::remove_if(sessions.begin(), sessions.end(), [id](Session* session) {
            return session->getId() == id;
        });
        if (it != sessions.end()) {
            delete *it; // Free memory
            sessions.erase(it, sessions.end());
        }
    }

    Session* getSession(int id) {
        auto it = std::find_if(sessions.begin(), sessions.end(), [id](Session* session) {
            return session->getId() == id;
        });
        if (it != sessions.end()) {
            (*it)->refresh();
            return *it;
        }
        return nullptr;
    }

    void cleanupExpiredSessions() {
        std::time_t currentTime = std::time(nullptr);
        auto it = std::remove_if(sessions.begin(), sessions.end(), [this, currentTime](Session* session) {
            return (currentTime - session->getLastAccessTime()) > expirationTime;
        });
        for (auto iter = it; iter != sessions.end(); ++iter) {
            delete *iter; // Free memory
        }
        sessions.erase(it, sessions.end());
    }

private:
    std::vector<Session*> sessions;
    const std::time_t expirationTime = 3600; // 1 hour
};