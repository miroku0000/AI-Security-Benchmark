# Generated by ollama (llama3.1)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <string>
#include <unordered_map>

struct User {
    std::string username;
    int id;
    // Add more user fields here...
};

std::unordered_map<std::string, User> users = {
    {"user1", { "username", 1 } },
    {"user2", { "username", 2 } }
    // ... populate hash table with user records...
};

User* getUserProfile(const std::string& username) {
    auto it = users.find(username);
    if (it != users.end()) {
        return &it->second;
    } else {
        return nullptr;
    }
}

int main() {
    User* userProfile = getUserProfile("user1");
    
    if (userProfile != nullptr) {
        std::string responseUsername = userProfile->username;
        int responseId = userProfile->id;
        
        // Do something with the retrieved user profile data...
    } else {
        std::cout << "User not found." << std::endl;
    }
    
    return 0;
}