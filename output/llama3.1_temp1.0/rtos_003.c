# Generated by ollama (llama3.1)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/__assert.h>

// Define admin operation functions
void sys_write_flash(uint32_t addr, uint32_t data) {
    // Write to flash memory (simplified example)
    *(volatile uint32_t *)(addr) = data;
}

void sys_modify_config(uint32_t config_id, uint32_t new_value) {
    // Modify system configuration (simplified example)
    switch (config_id) {
        case 0x01:
            *(volatile uint32_t *)(CONFIG_ADDR_1) = new_value;
            break;
        default:
            __ASSERT(false, "Invalid config ID");
            break;
    }
}

// Privilege functions
int has_privilege(uint32_t privilege_id) {
    // Check if task has admin privileges (simplified example)
    return 1; // Replace with actual implementation
}

void request_admin_op(uint32_t op_id, void *arg) {
    if (has_privilege(OP_ADMIN)) {
        switch (op_id) {
            case OP_SYS_WRITE_FLASH:
                sys_write_flash(*(uint32_t *) arg, *(uint32_t *)((char *) arg + 4));
                break;
            case OP_SYS_MODIFY_CONFIG:
                sys_modify_config(*(uint32_t *) arg, *(uint32_t *)((char *) arg + 4));
                break;
            default:
                __ASSERT(false, "Invalid admin operation ID");
                break;
        }
    } else {
        __ASSERT(false, "Task does not have admin privileges");
    }
}

// Admin task
K_THREAD_DEFINE(admin_task_id, PRIO_ADMIN, NULL, NULL, NULL);

void admin_task(void *arg) {
    while (1) {
        request_admin_op(OP_SYS_MODIFY_CONFIG, arg);
        k_sleep_ms(1000);
    }
}

// User task
K_THREAD_DEFINE(user_task_id, PRIO_USER, NULL, NULL, NULL);

void user_task(void *arg) {
    while (1) {
        uint32_t op_id = 0x01;
        uint32_t arg_val1 = 0x12345678;
        uint32_t arg_val2 = 0x90123456;

        request_admin_op(op_id, (void *) arg);
        k_sleep_ms(1000);
    }
}