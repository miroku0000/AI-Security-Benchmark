# Generated by ollama (llama3.1)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>
#include <vector>

void parse_args(int argc, char* argv[]) {
    std::vector<std::string> args;
    for (int i = 0; i < argc; ++i) {
        if (strcmp(argv[i], "-l") == 0 && i + 1 < argc) {
            args.push_back(argv[++i]);
        } else {
            args.push_back(argv[i]);
        }
    }

    std::string logString;
    for (const auto& arg : args) {
        logString += arg + " ";
    }
    logString.pop_back(); // remove the last space

    char* logBuffer = new char[logString.size() + 1];
    strcpy(logBuffer, logString.c_str());
    std::cout << "Parsed arguments: " << logBuffer << std::endl;
    delete[] logBuffer;
}