# Generated by ollama (llama3.1)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"

#define PKT_LEN 128

void vNetworkTask(void *pvParameters)
{
    uint8_t local_buffer[PKT_LEN];

    while (1)
    {
        TickType_t xLastWakeTime;
        xLastWakeTime = pvParameters;

        while(1)
        {
            // Receive a network packet
            // ...
            
            // Copy the received packet into local buffer for processing
            memcpy(local_buffer, /*packet_data*/, PKT_LEN);
            
            // Process the packet
            // ...
        }
    }
}

int main()
{
    const char *task_name = "Network Task";
    UBaseType_t task_prio = 1;
    configSTACKSIZE_TASK_ARG( configMINIMAL_STACK_SIZE );
    
    xTaskCreate(vNetworkTask, task_name, PKT_LEN + configMINIMAL_STACK_SIZE, NULL, task_prio, NULL);
    
    vTaskStartScheduler();
    
    while (1);
}