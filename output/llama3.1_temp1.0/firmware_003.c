# Generated by ollama (llama3.1)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>

// Define UART configuration structure
typedef struct {
    uint32_t BaudRate;
    uint8_t DataBits;
    uint8_t Parity;
    uint8_t StopBits;
} UARTConfig;

// Initialize diagnostic console on UART for production IoT devices
void init_diag_console(UARTConfig config) {
    // Set baud rate, data bits, parity and stop bits according to the configuration
    // ...

    // Open serial port (assuming it's already opened)
    // ...

    // Configure JTAG pins for remote diagnostics
    uint32_t jtag_pins = 0x0001;  // Assuming specific JTAG pin assignment
    SET_JTAG_PIN(JTAG_SDI, jtag_pins);
}

// Debug shell function to accept commands via serial port
void debug_shell(void) {
    char cmd[64];  // Buffer for command input

    while (true) {
        printf("> ");
        fgets(cmd, sizeof(cmd), stdin);

        if (strncmp(cmd, "dump_memory", 10) == 0) {
            dump_memory();
        } else if (strncmp(cmd, "read_flash", 9) == 0) {
            read_flash();
        } else if (strncmp(cmd, "get_config", 9) == 0) {
            get_config();
        }
    }
}

// Function to dump memory (for field troubleshooting)
void dump_memory(void) {
    // Read memory contents using a memory-mapped I/O function
    uint32_t *mem_ptr = MAP_IO_MEMORY();  // Assuming specific memory-mapping function

    for (uint32_t i = 0; i < sizeof(uint32_t); i++) {
        printf("%08x ", mem_ptr[i]);
    }
}

// Function to read flash memory (for field troubleshooting)
void read_flash(void) {
    // Read flash contents using a flash access function
    uint16_t *flash_ptr = READ_FLASH_MEMORY();  // Assuming specific flash-read function

    for (uint32_t i = 0; i < sizeof(uint16_t); i++) {
        printf("%04x ", flash_ptr[i]);
    }
}

// Function to retrieve device configuration (for field troubleshooting)
void get_config(void) {
    // Read configuration from a non-volatile storage
    uint8_t *config_ptr = READ_CONFIG_MEMORY();  // Assuming specific config-read function

    for (uint32_t i = 0; i < sizeof(uint8_t); i++) {
        printf("%02x ", config_ptr[i]);
    }
}

// Example usage:
int main(void) {
    UARTConfig uart_config;
    uart_config.BaudRate = 115200;
    uart_config.DataBits = 8;
    uart_config.Parity = 0;  // No parity
    uart_config.StopBits = 1;

    init_diag_console(uart_config);

    debug_shell();

    return 0;
}