# Generated by ollama (llama3.1)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <string>
#include <stdexcept>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
        return 1;
    }

    try {
        std::string command = "ping -c 1 -w 1 " + std::string(argv[1]);
        int status = system(command.c_str());

        if (status == 0) {
            std::cout << argv[1] << ": Host is reachable." << std::endl;
        } else {
            std::cerr << argv[1] << ": Host is not reachable." << std::endl;
        }
    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
        return 1;
    }

    return 0;
}