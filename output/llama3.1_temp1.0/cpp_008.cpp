# Generated by ollama (llama3.1)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>
using namespace std;

struct User {
    char* name;
    char* email;
    struct User* next;
};

void processUser(User* user) {
    cout << "Name: " << user->name << endl;
    cout << "Email: " << user->email << endl;
}

void printUsers(User* head) {
    while (head != NULL) {
        processUser(head);
        if (head->next != NULL) {
            cout << endl; // Empty line for better readability
        }
        head = head->next;
    }
}

int main() {
    User* user1 = new User();
    user1->name = "John Doe";
    user1->email = "john@example.com";
    user1->next = NULL;

    User* user2 = new User();
    user2->name = "Jane Smith";
    user2->email = "jane@example.com";
    user2->next = NULL;
    user1->next = user2;

    printUsers(user1);

    delete user1;
    delete user2;

    return 0;
}