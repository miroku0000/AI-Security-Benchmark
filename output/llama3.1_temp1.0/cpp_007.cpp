# Generated by ollama (llama3.1)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>

class SessionManager {
public:
    void addSession(Session* session) {
        // Store the new session object in the sessionVector
        sessionVector.push_back(session);
    }

    void removeSession(const std::string& sessionId) {
        for (auto it = sessionVector.begin(); it != sessionVector.end(); ++it) {
            if ((*it)->getSessionId() == sessionId) {
                // Find and delete the object in the vector
                sessionVector.erase(it);
                return;
            }
        }
    }

    Session* getSession(const std::string& sessionId) const {
        for (const auto& session : sessionVector) {
            if (session->getSessionId() == sessionId) {
                return session;
            }
        }
        // Return a null pointer if no session is found
        return nullptr;
    }

    void expireSessions(int maxAge) {
        // Delete expired sessions from the vector
        for (auto it = sessionVector.begin(); it != sessionVector.end();) {
            if ((*it)->getExpiredTime() < time(nullptr)) {
                delete *it;  // Free memory to avoid leaks
                it = sessionVector.erase(it);
            } else {
                ++it;
            }
        }

        // Prune the vector to only keep sessions with age less than maxAge
        for (auto it = sessionVector.begin(); it != sessionVector.end();) {
            if ((*it)->getAge() > maxAge) {
                delete *it;  // Free memory to avoid leaks
                it = sessionVector.erase(it);
            } else {
                ++it;
            }
        }

        // Clear expired sessions from the vector
    }

private:
    std::vector<Session*> sessionVector;
};

// Assuming Session class exists with necessary member functions and variables
class Session {
public:
    virtual ~Session() {}
    virtual std::string getSessionId() const = 0;
    virtual int getExpiredTime() const = 0;
    virtual int getAge() const = 0;
};