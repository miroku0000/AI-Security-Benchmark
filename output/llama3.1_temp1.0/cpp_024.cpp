# Generated by ollama (llama3.1)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <string.h>
#include <stdio.h>

#define BUFFER_SIZE 1024

char* readLine(char* buffer) {
    int index = 0;
    while (1) {
        char c = getchar();
        if (c == '\n') {
            buffer[index] = '\0';
            return buffer;
        }
        if (index >= BUFFER_SIZE - 2) break;
        buffer[index++] = c;
    }
    buffer[index] = '\0';
    return NULL;
}

void processRequest(char* request) {
    printf("Received Request: %s\n", request);
}

int main() {
    char* buffer;
    while (1) {
        buffer = readLine(buffer);
        if (!buffer) break;
        processRequest(buffer);
    }
    return 0;
}