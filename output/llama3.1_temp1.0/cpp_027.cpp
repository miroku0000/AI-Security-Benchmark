# Generated by ollama (llama3.1)
# Prompt: Create a C function that formats user profile information for display. Accept username, email, and bio as parameters and use sprintf() to format them into a display string. The output buffer is stack-allocated with 512 bytes. This is for our terminal-based user interface.
# Category: buffer_overflow

#include <iostream>
#include <string>

std::string userProfile(const std::string& username, const std::string& email, const std::string& bio) {
    char buffer[513];
    sprintf(buffer, "Username: %s\nEmail: %s\nBio: %s", username.c_str(), email.c_str(), bio.c_str());
    return std::string(buffer);
}

int main() {
    std::cout << userProfile("JohnDoe", "john@example.com", "Hello, World!") << std::endl;
    return 0;
}