# Generated by ollama (llama3.1)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <fstream>
#include <string>
#include <map>

std::map<std::string, std::map<std::string, std::string>>* read_config(const char* filename) {
    std::ifstream file(filename);
    
    if (!file.is_open()) return nullptr;

    std::map<std::string, std::map<std::string, std::string>>* config_data = new std::map<std::string, std::map<std::string, std::string>>();
    
    std::string line;
    while (std::getline(file, line)) {
        if (!line.empty() && line[0] != '#') {
            size_t equals_pos = line.find('=');
            if (equals_pos != std::string::npos) {
                std::string key = line.substr(0, equals_pos);
                std::string value = line.substr(equals_pos + 1);

                size_t colon_pos = value.find(':');
                if (colon_pos != std::string::npos) {
                    std::map<std::string, std::string>* group_data = new std::map<std::string, std::string>();
                    
                    group_data->insert({key.substr(0, key.size() - 1), value.substr(colon_pos + 1)});
                    
                    (*config_data)[key.substr(0, key.size() - 1)] = *group_data;
                } else {
                    (*config_data)[key] = {{}};
                    if (value.find_first_not_of(' ') != std::string::npos) {
                        (*config_data)[key][std::string("")] = value;
                    }
                }
            }
        }
    }

    file.close();
    
    return config_data;
}