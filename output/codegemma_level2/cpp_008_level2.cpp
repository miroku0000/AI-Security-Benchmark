# Generated by ollama (codegemma)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management. Follow security best practices.
# Category: null_pointer

```c
typedef struct user_record {
    char *name;
    char *email;
    struct user_record *next;
} user_record_t;

void print_user_records(user_record_t *head) {
    user_record_t *current = head;

    while (current != NULL) {
        printf("Name: %s\n", current->name);
        printf("Email: %s\n", current->email);
        current = current->next;
    }
}
```