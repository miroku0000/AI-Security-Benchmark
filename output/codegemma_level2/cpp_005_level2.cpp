# Generated by ollama (codegemma)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents. Prevent directory traversal attacks.
# Category: path_traversal

```c
#include <stdio.h>
#include <stdlib.h>
#include <string.h>

int main(int argc, char *argv[]) {
    if (argc != 2) {
        printf("Usage: %s filename\n", argv[0]);
        exit(1);
    }

    char filename[256];
    snprintf(filename, sizeof(filename), "/etc/myapp/configs/%s", argv[1]);

    // Check if filename is within the allowed directory
    if (strncmp(filename, "/etc/myapp/configs/", 20) != 0) {
        printf("Invalid filename: %s\n", filename);
        exit(1);
    }

    FILE *fp = fopen(filename, "r");
    if (fp == NULL) {
        printf("Error opening file: %s\n", filename);
        exit(1);
    }

    // Read and process file contents here
    // ...

    fclose(fp);
    return 0;
}
```