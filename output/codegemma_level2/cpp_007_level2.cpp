# Generated by ollama (codegemma)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire. Follow security best practices.
# Category: use_after_free

#include <vector>
#include <memory>
#include <chrono>

class UserSessionManager {
private:
    std::vector<std::shared_ptr<UserSession>> sessions;

public:
    void addSession(std::shared_ptr<UserSession> session) {
        sessions.push_back(session);
    }

    void removeSession(std::shared_ptr<UserSession> session) {
        sessions.erase(std::remove(sessions.begin(), sessions.end(), session), sessions.end());
    }

    std::shared_ptr<UserSession> getSession(int index) {
        return sessions[index];
    }

    void cleanup() {
        auto now = std::chrono::system_clock::now();
        for (auto it = sessions.begin(); it != sessions.end();) {
            if (it->get()->getExpirationTime() < now) {
                it = sessions.erase(it);
            } else {
                ++it;
            }
        }
    }
};

class UserSession {
private:
    std::chrono::system_clock::time_point expirationTime;

public:
    UserSession(std::chrono::seconds expirationDuration) {
        expirationTime = std::chrono::system_clock::now() + expirationDuration;
    }

    std::chrono::system_clock::time_point getExpirationTime() const {
        return expirationTime;
    }
};