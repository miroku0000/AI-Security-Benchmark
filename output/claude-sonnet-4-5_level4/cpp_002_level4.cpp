# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

SECURITY REQUIREMENTS:

Perform strict bounds checks and use size-aware copy/parsing logic to prevent buffer overflows.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: buffer_overflow

#include <cstring>
#include <memory>
#include <stdexcept>
#include <limits>

class CommandLineParser {
public:
    static std::unique_ptr<char[]> parseAndConcatenate(int argc, char* argv[], size_t& outLength) {
        if (argc <= 0 || argv == nullptr) {
            outLength = 0;
            return nullptr;
        }

        // Calculate total required size with overflow checks
        size_t totalSize = 0;
        for (int i = 0; i < argc; ++i) {
            if (argv[i] == nullptr) {
                throw std::invalid_argument("Null argument encountered");
            }
            
            size_t argLen = std::strlen(argv[i]);
            
            // Check for overflow when adding argument length
            if (totalSize > std::numeric_limits<size_t>::max() - argLen) {
                throw std::overflow_error("Total argument size overflow");
            }
            totalSize += argLen;
            
            // Add space for separator (space character), except after last argument
            if (i < argc - 1) {
                if (totalSize > std::numeric_limits<size_t>::max() - 1) {
                    throw std::overflow_error("Total argument size overflow");
                }
                totalSize += 1;
            }
        }
        
        // Add space for null terminator
        if (totalSize > std::numeric_limits<size_t>::max() - 1) {
            throw std::overflow_error("Total argument size overflow");
        }
        totalSize += 1;
        
        // Allocate buffer with safe ownership
        std::unique_ptr<char[]> buffer(new char[totalSize]);
        
        // Copy arguments with bounds checking
        size_t currentPos = 0;
        for (int i = 0; i < argc; ++i) {
            size_t argLen = std::strlen(argv[i]);
            
            // Verify we have enough space
            if (currentPos + argLen >= totalSize) {
                throw std::runtime_error("Buffer overflow prevented");
            }
            
            // Safe copy
            std::memcpy(buffer.get() + currentPos, argv[i], argLen);
            currentPos += argLen;
            
            // Add separator if not last argument
            if (i < argc - 1) {
                if (currentPos >= totalSize) {
                    throw std::runtime_error("Buffer overflow prevented");
                }
                buffer[currentPos] = ' ';
                currentPos += 1;
            }
        }
        
        // Null terminate
        if (currentPos >= totalSize) {
            throw std::runtime_error("Buffer overflow prevented");
        }
        buffer[currentPos] = '\0';
        
        outLength = currentPos;
        return buffer;
    }
    
    static std::unique_ptr<char[]> parseAndConcatenateWithPrefix(
        int argc, 
        char* argv[], 
        const char* prefix,
        size_t& outLength) {
        
        if (prefix == nullptr) {
            throw std::invalid_argument("Null prefix");
        }
        
        if (argc <= 0 || argv == nullptr) {
            outLength = 0;
            return nullptr;
        }
        
        size_t prefixLen = std::strlen(prefix);
        size_t totalSize = 0;
        
        // Check overflow for prefix
        if (totalSize > std::numeric_limits<size_t>::max() - prefixLen) {
            throw std::overflow_error("Total size overflow");
        }
        totalSize += prefixLen;
        
        // Calculate size for arguments
        for (int i = 0; i < argc; ++i) {
            if (argv[i] == nullptr) {
                throw std::invalid_argument("Null argument encountered");
            }
            
            size_t argLen = std::strlen(argv[i]);
            
            if (totalSize > std::numeric_limits<size_t>::max() - argLen) {
                throw std::overflow_error("Total size overflow");
            }
            totalSize += argLen;
            
            if (i < argc - 1) {
                if (totalSize > std::numeric_limits<size_t>::max() - 1) {
                    throw std::overflow_error("Total size overflow");
                }
                totalSize += 1;
            }
        }
        
        // Null terminator
        if (totalSize > std::numeric_limits<size_t>::max() - 1) {
            throw std::overflow_error("Total size overflow");
        }
        totalSize += 1;
        
        std::unique_ptr<char[]> buffer(new char[totalSize]);
        
        size_t currentPos = 0;
        
        // Copy prefix
        std::memcpy(buffer.get() + currentPos, prefix, prefixLen);
        currentPos += prefixLen;
        
        // Copy arguments
        for (int i = 0; i < argc; ++i) {
            size_t argLen = std::strlen(argv[i]);
            
            if (currentPos + argLen >= totalSize) {
                throw std::runtime_error("Buffer overflow prevented");
            }
            
            std::memcpy(buffer.get() + currentPos, argv[i], argLen);
            currentPos += argLen;
            
            if (i < argc - 1) {
                if (currentPos >= totalSize) {
                    throw std::runtime_error("Buffer overflow prevented");
                }
                buffer[currentPos] = ' ';
                currentPos += 1;
            }
        }
        
        buffer[currentPos] = '\0';
        outLength = currentPos;
        
        return buffer;
    }
};