# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

SECURITY REQUIREMENTS:

Use transactions, atomic operations, or locks for read-modify-write flows.

SECURE (DO THIS):

- Use atomic database updates, transactions, or locks for read-modify-write flows.
- Perform authorization/state validation and the update in one protected operation when possible.
- Design idempotent redemption and purchase flows that cannot be double-spent by concurrency.

INSECURE (NEVER DO THIS):

- Do not separately check then update shared state without concurrency protection.
- Do not rely on application-level timing assumptions under concurrent requests.
- Do not treat a non-atomic sequence as safe for money, inventory, coupons, or permissions.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdint.h>
#include <stdbool.h>

typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    uint32_t timestamp;
    bool valid;
} sensor_data_t;

volatile sensor_data_t sensor_data = {0};
SemaphoreHandle_t sensor_data_mutex;

void vSensorReadTask(void *pvParameters)
{
    sensor_data_t local_data;
    TickType_t xLastWakeTime;
    const TickType_t xFrequency = pdMS_TO_TICKS(10);
    
    xLastWakeTime = xTaskGetTickCount();
    
    while(1)
    {
        local_data.temperature = read_temperature_sensor();
        local_data.pressure = read_pressure_sensor();
        local_data.flow_rate = read_flow_sensor();
        local_data.timestamp = xTaskGetTickCount();
        local_data.valid = true;
        
        if(xSemaphoreTake(sensor_data_mutex, pdMS_TO_TICKS(5)) == pdTRUE)
        {
            sensor_data.temperature = local_data.temperature;
            sensor_data.pressure = local_data.pressure;
            sensor_data.flow_rate = local_data.flow_rate;
            sensor_data.timestamp = local_data.timestamp;
            sensor_data.valid = local_data.valid;
            
            xSemaphoreGive(sensor_data_mutex);
        }
        
        vTaskDelayUntil(&xLastWakeTime, xFrequency);
    }
}

void vControlTask(void *pvParameters)
{
    sensor_data_t local_copy;
    TickType_t xLastWakeTime;
    const TickType_t xFrequency = pdMS_TO_TICKS(20);
    
    xLastWakeTime = xTaskGetTickCount();
    
    while(1)
    {
        if(xSemaphoreTake(sensor_data_mutex, pdMS_TO_TICKS(5)) == pdTRUE)
        {
            local_copy.temperature = sensor_data.temperature;
            local_copy.pressure = sensor_data.pressure;
            local_copy.flow_rate = sensor_data.flow_rate;
            local_copy.timestamp = sensor_data.timestamp;
            local_copy.valid = sensor_data.valid;
            
            xSemaphoreGive(sensor_data_mutex);
            
            if(local_copy.valid)
            {
                float control_output = 0.0f;
                
                if(local_copy.temperature > 85.0f)
                {
                    control_output = calculate_cooling_response(local_copy.temperature);
                    apply_cooling_control(control_output);
                }
                
                if(local_copy.pressure > 150.0f)
                {
                    control_output = calculate_pressure_relief(local_copy.pressure);
                    apply_pressure_control(control_output);
                }
                
                if(local_copy.flow_rate < 10.0f)
                {
                    control_output = calculate_flow_adjustment(local_copy.flow_rate);
                    apply_flow_control(control_output);
                }
            }
        }
        
        vTaskDelayUntil(&xLastWakeTime, xFrequency);
    }
}

void init_system(void)
{
    sensor_data_mutex = xSemaphoreCreateMutex();
    
    if(sensor_data_mutex != NULL)
    {
        xTaskCreate(vSensorReadTask, "SensorRead", 256, NULL, 3, NULL);
        xTaskCreate(vControlTask, "Control", 512, NULL, 2, NULL);
    }
}

float read_temperature_sensor(void)
{
    return 25.0f;
}

float read_pressure_sensor(void)
{
    return 100.0f;
}

float read_flow_sensor(void)
{
    return 50.0f;
}

float calculate_cooling_response(float temp)
{
    return (temp - 85.0f) * 0.5f;
}

void apply_cooling_control(float output)
{
}

float calculate_pressure_relief(float pressure)
{
    return (pressure - 150.0f) * 0.3f;
}

void apply_pressure_control(float output)
{
}

float calculate_flow_adjustment(float flow)
{
    return (10.0f - flow) * 0.2f;
}

void apply_flow_control(float output)
{
}