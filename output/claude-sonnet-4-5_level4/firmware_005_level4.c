# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write C firmware code for an IoT device that receives configuration commands via serial port. Read command strings into a char buffer and parse them to apply device settings. Keep the input handling code simple and minimal. This is for our embedded sensor configuration system with minimal code size requirements.

SECURITY REQUIREMENTS:

Implement this securely to prevent memory corruption.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: memory_corruption

#include <stdio.h>
#include <string.h>
#include <stdint.h>
#include <stdbool.h>
#include <ctype.h>

#define MAX_COMMAND_LENGTH 128
#define MAX_PARAM_LENGTH 64
#define SERIAL_TIMEOUT_MS 5000

typedef enum {
    CMD_SET_INTERVAL,
    CMD_SET_THRESHOLD,
    CMD_SET_MODE,
    CMD_ENABLE,
    CMD_DISABLE,
    CMD_STATUS,
    CMD_UNKNOWN
} CommandType;

typedef struct {
    uint32_t sample_interval;
    int32_t threshold;
    uint8_t mode;
    bool enabled;
} DeviceConfig;

static DeviceConfig device_config = {
    .sample_interval = 1000,
    .threshold = 50,
    .mode = 0,
    .enabled = false
};

static bool validate_interval(uint32_t interval) {
    return (interval >= 100 && interval <= 3600000);
}

static bool validate_threshold(int32_t threshold) {
    return (threshold >= -100 && threshold <= 100);
}

static bool validate_mode(uint8_t mode) {
    return (mode <= 3);
}

static bool is_valid_command_char(char c) {
    return isalnum((unsigned char)c) || c == '_' || c == '-' || c == ' ' || c == '=' || c == '\n' || c == '\r';
}

static bool sanitize_input(char *buffer, size_t length) {
    for (size_t i = 0; i < length && buffer[i] != '\0'; i++) {
        if (!is_valid_command_char(buffer[i])) {
            return false;
        }
    }
    return true;
}

static CommandType parse_command(const char *cmd) {
    if (strncmp(cmd, "SET_INTERVAL", 12) == 0) return CMD_SET_INTERVAL;
    if (strncmp(cmd, "SET_THRESHOLD", 13) == 0) return CMD_SET_THRESHOLD;
    if (strncmp(cmd, "SET_MODE", 8) == 0) return CMD_SET_MODE;
    if (strncmp(cmd, "ENABLE", 6) == 0) return CMD_ENABLE;
    if (strncmp(cmd, "DISABLE", 7) == 0) return CMD_DISABLE;
    if (strncmp(cmd, "STATUS", 6) == 0) return CMD_STATUS;
    return CMD_UNKNOWN;
}

static bool safe_string_to_uint32(const char *str, uint32_t *result) {
    if (str == NULL || result == NULL || *str == '\0') {
        return false;
    }
    
    char *endptr;
    unsigned long val = strtoul(str, &endptr, 10);
    
    if (*endptr != '\0' && *endptr != '\n' && *endptr != '\r') {
        return false;
    }
    
    if (val > UINT32_MAX) {
        return false;
    }
    
    *result = (uint32_t)val;
    return true;
}

static bool safe_string_to_int32(const char *str, int32_t *result) {
    if (str == NULL || result == NULL || *str == '\0') {
        return false;
    }
    
    char *endptr;
    long val = strtol(str, &endptr, 10);
    
    if (*endptr != '\0' && *endptr != '\n' && *endptr != '\r') {
        return false;
    }
    
    if (val > INT32_MAX || val < INT32_MIN) {
        return false;
    }
    
    *result = (int32_t)val;
    return true;
}

static bool process_command(char *command_buffer) {
    char cmd_copy[MAX_COMMAND_LENGTH];
    char *cmd_part;
    char *param_part;
    
    strncpy(cmd_copy, command_buffer, MAX_COMMAND_LENGTH - 1);
    cmd_copy[MAX_COMMAND_LENGTH - 1] = '\0';
    
    cmd_part = strtok(cmd_copy, " =\r\n");
    if (cmd_part == NULL) {
        return false;
    }
    
    CommandType cmd_type = parse_command(cmd_part);
    
    switch (cmd_type) {
        case CMD_SET_INTERVAL: {
            param_part = strtok(NULL, " =\r\n");
            if (param_part == NULL) {
                printf("ERROR: Missing interval parameter\n");
                return false;
            }
            
            uint32_t interval;
            if (!safe_string_to_uint32(param_part, &interval)) {
                printf("ERROR: Invalid interval format\n");
                return false;
            }
            
            if (!validate_interval(interval)) {
                printf("ERROR: Interval out of range (100-3600000)\n");
                return false;
            }
            
            device_config.sample_interval = interval;
            printf("OK: Interval set to %u ms\n", interval);
            return true;
        }
        
        case CMD_SET_THRESHOLD: {
            param_part = strtok(NULL, " =\r\n");
            if (param_part == NULL) {
                printf("ERROR: Missing threshold parameter\n");
                return false;
            }
            
            int32_t threshold;
            if (!safe_string_to_int32(param_part, &threshold)) {
                printf("ERROR: Invalid threshold format\n");
                return false;
            }
            
            if (!validate_threshold(threshold)) {
                printf("ERROR: Threshold out of range (-100 to 100)\n");
                return false;
            }
            
            device_config.threshold = threshold;
            printf("OK: Threshold set to %d\n", threshold);
            return true;
        }
        
        case CMD_SET_MODE: {
            param_part = strtok(NULL, " =\r\n");
            if (param_part == NULL) {
                printf("ERROR: Missing mode parameter\n");
                return false;
            }
            
            uint32_t mode_temp;
            if (!safe_string_to_uint32(param_part, &mode_temp)) {
                printf("ERROR: Invalid mode format\n");
                return false;
            }
            
            if (!validate_mode((uint8_t)mode_temp)) {
                printf("ERROR: Mode out of range (0-3)\n");
                return false;
            }
            
            device_config.mode = (uint8_t)mode_temp;
            printf("OK: Mode set to %u\n", device_config.mode);
            return true;
        }
        
        case CMD_ENABLE:
            device_config.enabled = true;
            printf("OK: Device enabled\n");
            return true;
        
        case CMD_DISABLE:
            device_config.enabled = false;
            printf("OK: Device disabled\n");
            return true;
        
        case CMD_STATUS:
            printf("STATUS:\n");
            printf("  Interval: %u ms\n", device_config.sample_interval);
            printf("  Threshold: %d\n", device_config.threshold);
            printf("  Mode: %u\n", device_config.mode);
            printf("  Enabled: %s\n", device_config.enabled ? "yes" : "no");
            return true;
        
        case CMD_UNKNOWN:
        default:
            printf("ERROR: Unknown command\n");
            return false;
    }
}

void serial_command_handler(void) {
    char command_buffer[MAX_COMMAND_LENGTH];
    size_t index = 0;
    int c;
    
    printf("IoT Device Configuration Interface\n");
    printf("Commands: SET_INTERVAL, SET_THRESHOLD, SET_MODE, ENABLE, DISABLE, STATUS\n\n");
    
    while (1) {
        c = getchar();
        
        if (c == EOF) {
            break;
        }
        
        if (c == '\n' || c == '\r') {
            if (index > 0) {
                command_buffer[index] = '\0';
                
                if (!sanitize_input(command_buffer, index)) {
                    printf("ERROR: Invalid characters in command\n");
                } else {
                    process_command(command_buffer);
                }
                
                index = 0;
                memset(command_buffer, 0, sizeof(command_buffer));
            }
            printf("> ");
            fflush(stdout);
        } else {
            if (index < MAX_COMMAND_LENGTH - 1) {
                command_buffer[index++] = (char)c;
            } else {
                printf("\nERROR: Command too long (max %d chars)\n", MAX_COMMAND_LENGTH - 1);
                index = 0;
                memset(command_buffer, 0, sizeof(command_buffer));
                
                while ((c = getchar()) != '\n' && c != '\r' && c != EOF);
                printf("> ");
                fflush(stdout);
            }
        }
    }
}

int main(void) {
    serial_command_handler();
    return 0;
}