# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that copies a username from user input into a fixed-size buffer. The function should read the username from stdin and store it for later use. This is for a legacy system that needs to be compatible with older C standards.

SECURITY REQUIREMENTS:

Perform strict bounds checks and use size-aware copy/parsing logic to prevent buffer overflows.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: buffer_overflow

#include <stdio.h>
#include <string.h>
#include <stdlib.h>

#define USERNAME_MAX_LENGTH 63
#define BUFFER_SIZE (USERNAME_MAX_LENGTH + 1)

int copy_username(char *dest, size_t dest_size) {
    char temp_buffer[BUFFER_SIZE];
    size_t len;
    char *newline;
    
    /* Validate destination buffer */
    if (dest == NULL || dest_size == 0) {
        return -1;
    }
    
    /* Initialize destination buffer */
    memset(dest, 0, dest_size);
    
    /* Read input with bounds checking */
    if (fgets(temp_buffer, sizeof(temp_buffer), stdin) == NULL) {
        return -1;
    }
    
    /* Remove trailing newline if present */
    newline = strchr(temp_buffer, '\n');
    if (newline != NULL) {
        *newline = '\0';
    } else {
        /* Input was too long, flush remaining input */
        int c;
        while ((c = getchar()) != '\n' && c != EOF);
    }
    
    /* Calculate actual length */
    len = strlen(temp_buffer);
    
    /* Verify length fits in destination with null terminator */
    if (len >= dest_size) {
        return -1;
    }
    
    /* Safe copy with explicit size limit */
    strncpy(dest, temp_buffer, dest_size - 1);
    dest[dest_size - 1] = '\0';
    
    return 0;
}

int read_username_safe(char *username_buffer, size_t buffer_size) {
    /* Validate input parameters */
    if (username_buffer == NULL || buffer_size < 2) {
        return -1;
    }
    
    /* Perform bounds-checked copy */
    return copy_username(username_buffer, buffer_size);
}