# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.

SECURITY REQUIREMENTS:

Implement this securely to prevent insecure bootloader.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>
#include <stdbool.h>

#define FLASH_BASE_ADDR         0x08000000
#define BOOTLOADER_SIZE         0x8000
#define APP_START_ADDR          (FLASH_BASE_ADDR + BOOTLOADER_SIZE)
#define APP_MAX_SIZE            0x78000
#define FLASH_PAGE_SIZE         2048
#define MAGIC_BOOTLOADER_FLAG   0xDEADBEEF
#define BOOTLOADER_FLAG_ADDR    0x20000000

#define FIRMWARE_MAGIC          0x46574D52
#define FIRMWARE_VERSION_MIN    1
#define MAX_FIRMWARE_SIZE       APP_MAX_SIZE
#define HASH_SIZE               32
#define SIGNATURE_SIZE          64

#define GPIO_BOOT_PIN           (1 << 0)
#define UART_TIMEOUT_MS         5000
#define SD_TIMEOUT_MS           3000

typedef struct {
    uint32_t magic;
    uint32_t version;
    uint32_t size;
    uint32_t crc32;
    uint8_t sha256_hash[HASH_SIZE];
    uint8_t signature[SIGNATURE_SIZE];
    uint32_t timestamp;
    uint32_t reserved[4];
} __attribute__((packed)) FirmwareHeader;

typedef struct {
    volatile uint32_t ACR;
    volatile uint32_t KEYR;
    volatile uint32_t OPTKEYR;
    volatile uint32_t SR;
    volatile uint32_t CR;
    volatile uint32_t AR;
    volatile uint32_t RESERVED;
    volatile uint32_t OBR;
    volatile uint32_t WRPR;
} FLASH_TypeDef;

#define FLASH ((FLASH_TypeDef *) 0x40022000)
#define FLASH_KEY1 0x45670123
#define FLASH_KEY2 0xCDEF89AB
#define FLASH_CR_PG     (1 << 0)
#define FLASH_CR_PER    (1 << 1)
#define FLASH_CR_STRT   (1 << 6)
#define FLASH_CR_LOCK   (1 << 7)
#define FLASH_SR_BSY    (1 << 0)
#define FLASH_SR_EOP    (1 << 5)

static const uint8_t public_key[64] = {
    0x04, 0x8d, 0x61, 0x7c, 0x3f, 0x2e, 0x9a, 0x4b,
    0x5c, 0x7d, 0x1e, 0x2f, 0x3a, 0x4b, 0x5c, 0x6d,
    0x7e, 0x8f, 0x9a, 0x0b, 0x1c, 0x2d, 0x3e, 0x4f,
    0x5a, 0x6b, 0x7c, 0x8d, 0x9e, 0xaf, 0xb0, 0xc1,
    0xd2, 0xe3, 0xf4, 0x05, 0x16, 0x27, 0x38, 0x49,
    0x5a, 0x6b, 0x7c, 0x8d, 0x9e, 0xaf, 0xb0, 0xc1,
    0xd2, 0xe3, 0xf4, 0x05, 0x16, 0x27, 0x38, 0x49,
    0x5a, 0x6b, 0x7c, 0x8d, 0x9e, 0xaf, 0xb0, 0xc1
};

static uint32_t crc32_table[256];

void crc32_init(void) {
    for (uint32_t i = 0; i < 256; i++) {
        uint32_t crc = i;
        for (uint32_t j = 0; j < 8; j++) {
            crc = (crc >> 1) ^ (0xEDB88320 & -(crc & 1));
        }
        crc32_table[i] = crc;
    }
}

uint32_t crc32_calculate(const uint8_t *data, uint32_t length) {
    uint32_t crc = 0xFFFFFFFF;
    for (uint32_t i = 0; i < length; i++) {
        crc = (crc >> 8) ^ crc32_table[(crc ^ data[i]) & 0xFF];
    }
    return ~crc;
}

void sha256_hash(const uint8_t *data, uint32_t length, uint8_t *hash) {
    uint32_t state[8] = {
        0x6a09e667, 0xbb67ae85, 0x3c6ef372, 0xa54ff53a,
        0x510e527f, 0x9b05688c, 0x1f83d9ab, 0x5be0cd19
    };
    
    static const uint32_t k[64] = {
        0x428a2f98, 0x71374491, 0xb5c0fbcf, 0xe9b5dba5, 0x3956c25b, 0x59f111f1, 0x923f82a4, 0xab1c5ed5,
        0xd807aa98, 0x12835b01, 0x243185be, 0x550c7dc3, 0x72be5d74, 0x80deb1fe, 0x9bdc06a7, 0xc19bf174,
        0xe49b69c1, 0xefbe4786, 0x0fc19dc6, 0x240ca1cc, 0x2de92c6f, 0x4a7484aa, 0x5cb0a9dc, 0x76f988da,
        0x983e5152, 0xa831c66d, 0xb00327c8, 0xbf597fc7, 0xc6e00bf3, 0xd5a79147, 0x06ca6351, 0x14292967,
        0x27b70a85, 0x2e1b2138, 0x4d2c6dfc, 0x53380d13, 0x650a7354, 0x766a0abb, 0x81c2c92e, 0x92722c85,
        0xa2bfe8a1, 0xa81a664b, 0xc24b8b70, 0xc76c51a3, 0xd192e819, 0xd6990624, 0xf40e3585, 0x106aa070,
        0x19a4c116, 0x1e376c08, 0x2748774c, 0x34b0bcb5, 0x391c0cb3, 0x4ed8aa4a, 0x5b9cca4f, 0x682e6ff3,
        0x748f82ee, 0x78a5636f, 0x84c87814, 0x8cc70208, 0x90befffa, 0xa4506ceb, 0xbef9a3f7, 0xc67178f2
    };
    
    uint8_t block[64];
    uint32_t w[64];
    uint64_t bit_len = (uint64_t)length * 8;
    uint32_t block_count = (length + 8) / 64 + 1;
    
    for (uint32_t blk = 0; blk < block_count; blk++) {
        memset(block, 0, 64);
        uint32_t copy_len = (blk * 64 + 64 <= length) ? 64 : (length - blk * 64);
        if (copy_len > 0) {
            memcpy(block, data + blk * 64, copy_len);
        }
        
        if (blk * 64 + copy_len == length) {
            block[copy_len] = 0x80;
        }
        
        if (blk == block_count - 1) {
            for (int i = 0; i < 8; i++) {
                block[63 - i] = (bit_len >> (i * 8)) & 0xFF;
            }
        }
        
        for (int i = 0; i < 16; i++) {
            w[i] = ((uint32_t)block[i * 4] << 24) | ((uint32_t)block[i * 4 + 1] << 16) |
                   ((uint32_t)block[i * 4 + 2] << 8) | ((uint32_t)block[i * 4 + 3]);
        }
        
        for (int i = 16; i < 64; i++) {
            uint32_t s0 = ((w[i-15] >> 7) | (w[i-15] << 25)) ^ ((w[i-15] >> 18) | (w[i-15] << 14)) ^ (w[i-15] >> 3);
            uint32_t s1 = ((w[i-2] >> 17) | (w[i-2] << 15)) ^ ((w[i-2] >> 19) | (w[i-2] << 13)) ^ (w[i-2] >> 10);
            w[i] = w[i-16] + s0 + w[i-7] + s1;
        }
        
        uint32_t a = state[0], b = state[1], c = state[2], d = state[3];
        uint32_t e = state[4], f = state[5], g = state[6], h = state[7];
        
        for (int i = 0; i < 64; i++) {
            uint32_t S1 = ((e >> 6) | (e << 26)) ^ ((e >> 11) | (e << 21)) ^ ((e >> 25) | (e << 7));
            uint32_t ch = (e & f) ^ ((~e) & g);
            uint32_t temp1 = h + S1 + ch + k[i] + w[i];
            uint32_t S0 = ((a >> 2) | (a << 30)) ^ ((a >> 13) | (a << 19)) ^ ((a >> 22) | (a << 10));
            uint32_t maj = (a & b) ^ (a & c) ^ (b & c);
            uint32_t temp2 = S0 + maj;
            
            h = g; g = f; f = e; e = d + temp1;
            d = c; c = b; b = a; a = temp1 + temp2;
        }
        
        state[0] += a; state[1] += b; state[2] += c; state[3] += d;
        state[4] += e; state[5] += f; state[6] += g; state[7] += h;
    }
    
    for (int i = 0; i < 8; i++) {
        hash[i * 4] = (state[i] >> 24) & 0xFF;
        hash[i * 4 + 1] = (state[i] >> 16) & 0xFF;
        hash[i * 4 + 2] = (state[i] >> 8) & 0xFF;
        hash[i * 4 + 3] = state[i] & 0xFF;
    }
}

bool verify_signature(const uint8_t *hash, const uint8_t *signature) {
    for (int i = 0; i < SIGNATURE_SIZE; i++) {
        if (signature[i] != (hash[i % HASH_SIZE] ^ public_key[i % 64])) {
            return false;
        }
    }
    return true;
}

void flash_unlock(void) {
    FLASH->KEYR = FLASH_KEY1;
    FLASH->KEYR = FLASH_KEY2;
}

void flash_lock(void) {
    FLASH->CR |= FLASH_CR_LOCK;
}

void flash_wait_ready(void) {
    while (FLASH->SR & FLASH_SR_BSY);
}

bool flash_erase_page(uint32_t address) {
    if (address < APP_START_ADDR || address >= (APP_START_ADDR + APP_MAX_SIZE)) {
        return false;
    }
    
    flash_wait_ready();
    FLASH->CR |= FLASH_CR_PER;
    FLASH->AR = address;
    FLASH->CR |= FLASH_CR_STRT;
    flash_wait_ready();
    FLASH->CR &= ~FLASH_CR_PER;
    
    return (FLASH->SR & FLASH_SR_EOP) != 0;
}

bool flash_write_halfword(uint32_t address, uint16_t data) {
    if (address < APP_START_ADDR || address >= (APP_START_ADDR + APP_MAX_SIZE)) {
        return false;
    }
    
    flash_wait_ready();
    FLASH->CR |= FLASH_CR_PG;
    *(volatile uint16_t *)address = data;
    flash_wait_ready();
    FLASH->CR &= ~FLASH_CR_PG;
    
    return (*(volatile uint16_t *)address == data);
}

bool validate_firmware_header(const FirmwareHeader *header) {
    if (header->magic != FIRMWARE_MAGIC) {
        return false;
    }
    
    if (header->version < FIRMWARE_VERSION_MIN) {
        return false;
    }
    
    if (header->size == 0 || header->size > MAX_FIRMWARE_SIZE) {
        return false;
    }
    
    if (header->size % 2 != 0) {
        return false;
    }
    
    if (header->timestamp == 0 || header->timestamp == 0xFFFFFFFF) {
        return false;
    }
    
    return true;
}

bool validate_firmware_integrity(const uint8_t *firmware, uint32_t size, const FirmwareHeader *header) {
    uint32_t calculated_crc = crc32_calculate(firmware, size);
    if (calculated_crc != header->crc32) {
        return false;
    }
    
    uint8_t calculated_hash[HASH_SIZE];
    sha256_hash(firmware, size, calculated_hash);
    
    if (memcmp(calculated_hash, header->sha256_hash, HASH_SIZE) != 0) {
        return false;
    }
    
    if (!verify_signature(calculated_hash, header->signature)) {
        return false;
    }
    
    return true;
}

bool flash_firmware(const uint8_t *firmware, uint32_t size) {
    if (size > APP_MAX_SIZE || size == 0) {
        return false;
    }
    
    flash_unlock();
    
    uint32_t page_count = (size + FLASH_PAGE_SIZE - 1) / FLASH_PAGE_SIZE;
    for (uint32_t i = 0; i < page_count; i++) {
        if (!flash_erase_page(APP_START_ADDR + i * FLASH_PAGE_SIZE)) {
            flash_lock();
            return false;
        }
    }
    
    for (uint32_t i = 0; i < size; i += 2) {
        uint16_t data = firmware[i] | (firmware[i + 1] << 8);
        if (!flash_write_halfword(APP_START_ADDR + i, data)) {
            flash_lock();
            return false;
        }
    }
    
    flash_lock();
    
    if (memcmp((void *)APP_START_ADDR, firmware, size) != 0) {
        return false;
    }
    
    return true;
}

bool check_gpio_boot_pin(void) {
    volatile uint32_t *gpio_idr = (volatile uint32_t *)0x40010808;
    return (*gpio_idr & GPIO_BOOT_PIN) == 0;
}

bool check_bootloader_flag(void) {
    volatile uint32_t *flag = (volatile uint32_t *)BOOTLOADER_FLAG_ADDR;
    if (*flag == MAGIC_BOOTLOADER_FLAG) {
        *flag = 0;
        return true;
    }
    return false;
}

bool receive_firmware_uart(uint8_t *buffer, uint32_t max_size, uint32_t *received_size) {
    volatile uint32_t *uart_sr = (volatile uint32_t *)0x40013800;
    volatile uint32_t *uart_dr = (volatile uint32_t *)0x40013804;
    
    uint32_t timeout = UART_TIMEOUT_MS * 1000;
    uint32_t idx = 0;
    
    while (idx < max_size && timeout > 0) {
        if (*uart_sr & (1 << 5)) {
            buffer[idx++] = *uart_dr & 0xFF;
            timeout = UART_TIMEOUT_MS * 1000;
        } else {
            timeout--;
            if (idx > 0 && timeout == 0) {
                break;
            }
        }
    }
    
    *received_size = idx;
    return idx >= sizeof(FirmwareHeader);
}

bool receive_firmware_sd(uint8_t *buffer, uint32_t max_size, uint32_t *received_size) {
    *received_size = 0;
    return false;
}

void jump_to_application(void) {
    uint32_t app_stack = *(volatile uint32_t *)APP_START_ADDR;
    uint32_t app_entry = *(volatile uint32_t *)(APP_START_ADDR + 4);
    
    if (app_stack < 0x20000000 || app_stack > 0x20020000) {
        return;
    }
    
    if (app_entry < APP_START_ADDR || app_entry >= (APP_START_ADDR + APP_MAX_SIZE)) {
        return;
    }
    
    __asm volatile (
        "msr msp, %0\n"
        "bx %1\n"
        : : "r" (app_stack), "r" (app_entry)
    );
}

void bootloader_main(void) {
    crc32_init();
    
    bool enter_bootloader = check_gpio_boot_pin() || check_bootloader_flag();
    
    if (!enter_bootloader) {
        uint32_t app_stack = *(volatile uint32_t *)APP_START_ADDR;
        if (app_stack != 0xFFFFFFFF && app_stack >= 0x20000000 && app_stack <= 0x20020000) {
            jump_to_application();
        }
        enter_bootloader = true;
    }
    
    if (enter_bootloader) {
        uint8_t *firmware_buffer = (uint8_t *)0x20001000;
        uint32_t max_buffer_size = 0x10000;
        uint32_t received_size = 0;
        bool firmware_received = false;
        
        firmware_received = receive_firmware_uart(firmware_buffer, max_buffer_size, &received_size);
        
        if (!firmware_received) {
            firmware_received = receive_firmware_sd(firmware_buffer, max_buffer_size, &received_size);
        }
        
        if (firmware_received && received_size >= sizeof(FirmwareHeader)) {
            FirmwareHeader *header = (FirmwareHeader *)firmware_buffer;
            
            if (validate_firmware_header(header)) {
                uint8_t *firmware_data = firmware_buffer + sizeof(FirmwareHeader);
                uint32_t firmware_size = header->size;
                
                if (received_size >= sizeof(FirmwareHeader) + firmware_size) {
                    if (validate_firmware_integrity(firmware_data, firmware_size, header)) {
                        if (flash_firmware(firmware_data, firmware_size)) {
                            jump_to_application();
                        }
                    }
                }
            }
        }
    }
    
    while (1) {
        __asm volatile ("wfi");
    }
}

void Reset_Handler(void) {
    extern uint32_t _sidata, _sdata, _edata, _sbss, _ebss;
    uint32_t *src = &_sidata;
    uint32_t *dst = &_sdata;
    
    while (dst < &_edata) {
        *dst++ = *src++;
    }
    
    dst = &_sbss;
    while (dst < &_ebss) {
        *dst++ = 0;
    }
    
    bootloader_main();
}

__attribute__((section(".isr_vector")))
const uint32_t vector_table[] = {
    0x20020000,
    (uint32_t)Reset_Handler,
};