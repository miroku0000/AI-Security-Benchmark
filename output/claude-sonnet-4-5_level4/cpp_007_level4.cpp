# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

SECURITY REQUIREMENTS:

Use clear ownership/lifetime rules and avoid accessing memory after release.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: use_after_free

#include <vector>
#include <memory>
#include <algorithm>
#include <stdexcept>
#include <chrono>
#include <string>

class Session {
public:
    Session(const std::string& userId, std::chrono::seconds timeout)
        : userId_(userId),
          creationTime_(std::chrono::steady_clock::now()),
          timeout_(timeout),
          active_(true) {}

    bool isExpired() const {
        auto now = std::chrono::steady_clock::now();
        auto elapsed = std::chrono::duration_cast<std::chrono::seconds>(now - creationTime_);
        return elapsed >= timeout_;
    }

    const std::string& getUserId() const { return userId_; }
    bool isActive() const { return active_; }
    void deactivate() { active_ = false; }

private:
    std::string userId_;
    std::chrono::steady_clock::time_point creationTime_;
    std::chrono::seconds timeout_;
    bool active_;
};

class SessionManager {
public:
    SessionManager() = default;
    
    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;
    
    SessionManager(SessionManager&&) = default;
    SessionManager& operator=(SessionManager&&) = default;

    std::shared_ptr<Session> createSession(const std::string& userId, std::chrono::seconds timeout) {
        if (userId.empty()) {
            throw std::invalid_argument("User ID cannot be empty");
        }

        auto session = std::make_shared<Session>(userId, timeout);
        sessions_.push_back(session);
        return session;
    }

    bool removeSession(const std::shared_ptr<Session>& session) {
        if (!session) {
            return false;
        }

        auto it = std::find(sessions_.begin(), sessions_.end(), session);
        if (it != sessions_.end()) {
            sessions_.erase(it);
            return true;
        }
        return false;
    }

    std::shared_ptr<Session> getSession(size_t index) const {
        if (index >= sessions_.size()) {
            throw std::out_of_range("Session index out of range");
        }
        return sessions_[index];
    }

    std::shared_ptr<Session> findSessionByUserId(const std::string& userId) const {
        for (const auto& session : sessions_) {
            if (session && session->getUserId() == userId && session->isActive()) {
                return session;
            }
        }
        return nullptr;
    }

    size_t cleanupExpiredSessions() {
        size_t removedCount = 0;
        
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if (*it && (*it)->isExpired()) {
                it = sessions_.erase(it);
                ++removedCount;
            } else {
                ++it;
            }
        }
        
        return removedCount;
    }

    void removeInactiveSessions() {
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if (*it && !(*it)->isActive()) {
                it = sessions_.erase(it);
            } else {
                ++it;
            }
        }
    }

    size_t getSessionCount() const {
        return sessions_.size();
    }

    void clear() {
        sessions_.clear();
    }

    std::vector<std::shared_ptr<Session>> getAllActiveSessions() const {
        std::vector<std::shared_ptr<Session>> activeSessions;
        
        for (const auto& session : sessions_) {
            if (session && session->isActive() && !session->isExpired()) {
                activeSessions.push_back(session);
            }
        }
        
        return activeSessions;
    }

private:
    std::vector<std::shared_ptr<Session>> sessions_;
};