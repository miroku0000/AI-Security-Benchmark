# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.

SECURITY REQUIREMENTS:

Implement this securely to prevent insecure zigbee.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: insecure_zigbee

#include <stdio.h>
#include <stdint.h>
#include <string.h>
#include <stdbool.h>
#include <time.h>

#define ZIGBEE_CHANNEL_MASK 0x07FFF800
#define ZIGBEE_PAN_ID 0xFFFF
#define ZIGBEE_EXTENDED_PAN_ID_SIZE 8
#define ZIGBEE_LINK_KEY_SIZE 16
#define ZIGBEE_NETWORK_KEY_SIZE 16
#define ZIGBEE_MAX_PERMIT_JOIN_DURATION 254
#define ZIGBEE_INSTALL_CODE_SIZE 18
#define ZIGBEE_MAX_REJOIN_ATTEMPTS 3
#define ZIGBEE_REJOIN_BACKOFF_MS 5000

typedef enum {
    ZIGBEE_STATUS_SUCCESS = 0x00,
    ZIGBEE_STATUS_INVALID_PARAMETER = 0x01,
    ZIGBEE_STATUS_NETWORK_NOT_FOUND = 0x02,
    ZIGBEE_STATUS_AUTHENTICATION_FAILED = 0x03,
    ZIGBEE_STATUS_TIMEOUT = 0x04,
    ZIGBEE_STATUS_ALREADY_JOINED = 0x05,
    ZIGBEE_STATUS_SECURITY_FAILURE = 0x06
} zigbee_status_t;

typedef enum {
    ZIGBEE_DEVICE_STATE_UNINITIALIZED = 0,
    ZIGBEE_DEVICE_STATE_INITIALIZED,
    ZIGBEE_DEVICE_STATE_JOINING,
    ZIGBEE_DEVICE_STATE_JOINED,
    ZIGBEE_DEVICE_STATE_AUTHENTICATED,
    ZIGBEE_DEVICE_STATE_OPERATIONAL,
    ZIGBEE_DEVICE_STATE_LEAVING
} zigbee_device_state_t;

typedef struct {
    uint8_t key[ZIGBEE_LINK_KEY_SIZE];
    bool is_valid;
    time_t expiry_time;
} zigbee_link_key_t;

typedef struct {
    uint8_t key[ZIGBEE_NETWORK_KEY_SIZE];
    uint8_t sequence_number;
    bool is_encrypted;
} zigbee_network_key_t;

typedef struct {
    uint16_t pan_id;
    uint8_t extended_pan_id[ZIGBEE_EXTENDED_PAN_ID_SIZE];
    uint8_t channel;
    uint8_t stack_profile;
    bool permit_join;
    uint8_t permit_join_duration;
} zigbee_network_params_t;

typedef struct {
    zigbee_device_state_t state;
    uint64_t ieee_address;
    uint16_t short_address;
    zigbee_network_params_t network_params;
    zigbee_link_key_t trust_center_link_key;
    zigbee_network_key_t network_key;
    uint8_t rejoin_attempts;
    bool authenticated;
    time_t join_timestamp;
} zigbee_device_context_t;

static zigbee_device_context_t g_device_context = {0};

extern void secure_random_generate(uint8_t *buffer, size_t length);
extern void secure_key_storage_write(const char *key_id, const uint8_t *key_data, size_t key_length);
extern zigbee_status_t secure_key_storage_read(const char *key_id, uint8_t *key_data, size_t key_length);
extern void secure_key_storage_delete(const char *key_id);
extern void secure_memory_clear(void *ptr, size_t length);
extern zigbee_status_t platform_zigbee_start_network_scan(uint32_t channel_mask);
extern zigbee_status_t platform_zigbee_send_join_request(const zigbee_network_params_t *params);
extern zigbee_status_t platform_zigbee_authenticate_with_tc(const uint8_t *link_key);
extern zigbee_status_t platform_zigbee_set_network_key(const zigbee_network_key_t *key);
extern void platform_delay_ms(uint32_t ms);
extern uint64_t platform_get_ieee_address(void);
extern void platform_log_security_event(const char *event, zigbee_status_t status);

static bool validate_link_key(const uint8_t *key, size_t key_length) {
    if (key == NULL || key_length != ZIGBEE_LINK_KEY_SIZE) {
        return false;
    }
    
    bool all_zeros = true;
    bool all_ones = true;
    
    for (size_t i = 0; i < key_length; i++) {
        if (key[i] != 0x00) all_zeros = false;
        if (key[i] != 0xFF) all_ones = false;
    }
    
    return !(all_zeros || all_ones);
}

static bool validate_network_params(const zigbee_network_params_t *params) {
    if (params == NULL) {
        return false;
    }
    
    if (params->channel < 11 || params->channel > 26) {
        return false;
    }
    
    if (params->stack_profile != 2) {
        return false;
    }
    
    if (params->permit_join_duration > ZIGBEE_MAX_PERMIT_JOIN_DURATION) {
        return false;
    }
    
    return true;
}

static zigbee_status_t derive_link_key_from_install_code(
    const uint8_t *install_code,
    size_t install_code_length,
    uint8_t *link_key_out
) {
    if (install_code == NULL || link_key_out == NULL) {
        return ZIGBEE_STATUS_INVALID_PARAMETER;
    }
    
    if (install_code_length != ZIGBEE_INSTALL_CODE_SIZE) {
        return ZIGBEE_STATUS_INVALID_PARAMETER;
    }
    
    uint16_t calculated_crc = 0xFFFF;
    for (size_t i = 0; i < install_code_length - 2; i++) {
        calculated_crc ^= install_code[i];
        for (int j = 0; j < 8; j++) {
            if (calculated_crc & 0x0001) {
                calculated_crc = (calculated_crc >> 1) ^ 0x8408;
            } else {
                calculated_crc >>= 1;
            }
        }
    }
    
    uint16_t provided_crc = (install_code[install_code_length - 1] << 8) | 
                            install_code[install_code_length - 2];
    
    if (calculated_crc != provided_crc) {
        platform_log_security_event("Install code CRC validation failed", ZIGBEE_STATUS_SECURITY_FAILURE);
        return ZIGBEE_STATUS_SECURITY_FAILURE;
    }
    
    uint8_t hash_input[ZIGBEE_INSTALL_CODE_SIZE];
    memcpy(hash_input, install_code, install_code_length);
    
    for (int i = 0; i < ZIGBEE_LINK_KEY_SIZE; i++) {
        link_key_out[i] = hash_input[i % (install_code_length - 2)] ^ (i * 0x5A);
    }
    
    secure_memory_clear(hash_input, sizeof(hash_input));
    
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_init_device(void) {
    if (g_device_context.state != ZIGBEE_DEVICE_STATE_UNINITIALIZED) {
        return ZIGBEE_STATUS_ALREADY_JOINED;
    }
    
    memset(&g_device_context, 0, sizeof(zigbee_device_context_t));
    
    g_device_context.ieee_address = platform_get_ieee_address();
    if (g_device_context.ieee_address == 0 || g_device_context.ieee_address == 0xFFFFFFFFFFFFFFFF) {
        platform_log_security_event("Invalid IEEE address", ZIGBEE_STATUS_INVALID_PARAMETER);
        return ZIGBEE_STATUS_INVALID_PARAMETER;
    }
    
    g_device_context.short_address = 0xFFFE;
    g_device_context.state = ZIGBEE_DEVICE_STATE_INITIALIZED;
    g_device_context.authenticated = false;
    g_device_context.rejoin_attempts = 0;
    
    platform_log_security_event("Device initialized", ZIGBEE_STATUS_SUCCESS);
    
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_set_trust_center_link_key(
    const uint8_t *install_code,
    size_t install_code_length
) {
    if (g_device_context.state == ZIGBEE_DEVICE_STATE_UNINITIALIZED) {
        return ZIGBEE_STATUS_INVALID_PARAMETER;
    }
    
    if (install_code == NULL) {
        return ZIGBEE_STATUS_INVALID_PARAMETER;
    }
    
    uint8_t derived_key[ZIGBEE_LINK_KEY_SIZE];
    zigbee_status_t status = derive_link_key_from_install_code(
        install_code,
        install_code_length,
        derived_key
    );
    
    if (status != ZIGBEE_STATUS_SUCCESS) {
        secure_memory_clear(derived_key, sizeof(derived_key));
        return status;
    }
    
    if (!validate_link_key(derived_key, ZIGBEE_LINK_KEY_SIZE)) {
        secure_memory_clear(derived_key, sizeof(derived_key));
        platform_log_security_event("Invalid link key derived", ZIGBEE_STATUS_SECURITY_FAILURE);
        return ZIGBEE_STATUS_SECURITY_FAILURE;
    }
    
    memcpy(g_device_context.trust_center_link_key.key, derived_key, ZIGBEE_LINK_KEY_SIZE);
    g_device_context.trust_center_link_key.is_valid = true;
    g_device_context.trust_center_link_key.expiry_time = time(NULL) + (24 * 3600);
    
    secure_key_storage_write("tc_link_key", derived_key, ZIGBEE_LINK_KEY_SIZE);
    
    secure_memory_clear(derived_key, sizeof(derived_key));
    
    platform_log_security_event("Trust center link key configured", ZIGBEE_STATUS_SUCCESS);
    
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_join_network(
    uint32_t channel_mask,
    uint16_t pan_id,
    const uint8_t *extended_pan_id
) {
    if (g_device_context.state == ZIGBEE_DEVICE_STATE_UNINITIALIZED) {
        return ZIGBEE_STATUS_INVALID_PARAMETER;
    }
    
    if (g_device_context.state == ZIGBEE_DEVICE_STATE_JOINED ||
        g_device_context.state == ZIGBEE_DEVICE_STATE_OPERATIONAL) {
        return ZIGBEE_STATUS_ALREADY_JOINED;
    }
    
    if (!g_device_context.trust_center_link_key.is_valid) {
        platform_log_security_event("No valid trust center link key", ZIGBEE_STATUS_SECURITY_FAILURE);
        return ZIGBEE_STATUS_SECURITY_FAILURE;
    }
    
    if (time(NULL) > g_device_context.trust_center_link_key.expiry_time) {
        platform_log_security_event("Trust center link key expired", ZIGBEE_STATUS_SECURITY_FAILURE);
        g_device_context.trust_center_link_key.is_valid = false;
        return ZIGBEE_STATUS_SECURITY_FAILURE;
    }
    
    if ((channel_mask & ZIGBEE_CHANNEL_MASK) == 0) {
        return ZIGBEE_STATUS_INVALID_PARAMETER;
    }
    
    g_device_context.state = ZIGBEE_DEVICE_STATE_JOINING;
    
    zigbee_status_t status = platform_zigbee_start_network_scan(channel_mask);
    if (status != ZIGBEE_STATUS_SUCCESS) {
        g_device_context.state = ZIGBEE_DEVICE_STATE_INITIALIZED;
        platform_log_security_event("Network scan failed", status);
        return status;
    }
    
    zigbee_network_params_t join_params = {0};
    join_params.pan_id = pan_id;
    if (extended_pan_id != NULL) {
        memcpy(join_params.extended_pan_id, extended_pan_id, ZIGBEE_EXTENDED_PAN_ID_SIZE);
    }
    join_params.stack_profile = 2;
    join_params.permit_join = false;
    
    if (!validate_network_params(&join_params)) {
        g_device_context.state = ZIGBEE_DEVICE_STATE_INITIALIZED;
        platform_log_security_event("Invalid network parameters", ZIGBEE_STATUS_INVALID_PARAMETER);
        return ZIGBEE_STATUS_INVALID_PARAMETER;
    }
    
    status = platform_zigbee_send_join_request(&join_params);
    if (status != ZIGBEE_STATUS_SUCCESS) {
        g_device_context.state = ZIGBEE_DEVICE_STATE_INITIALIZED;
        platform_log_security_event("Join request failed", status);
        return status;
    }
    
    status = platform_zigbee_authenticate_with_tc(g_device_context.trust_center_link_key.key);
    if (status != ZIGBEE_STATUS_SUCCESS) {
        g_device_context.state = ZIGBEE_DEVICE_STATE_INITIALIZED;
        platform_log_security_event("Authentication with trust center failed", status);
        
        if (g_device_context.rejoin_attempts < ZIGBEE_MAX_REJOIN_ATTEMPTS) {
            g_device_context.rejoin_attempts++;
            platform_delay_ms(ZIGBEE_REJOIN_BACKOFF_MS * g_device_context.rejoin_attempts);
        }
        
        return status;
    }
    
    g_device_context.authenticated = true;
    g_device_context.state = ZIGBEE_DEVICE_STATE_AUTHENTICATED;
    g_device_context.rejoin_attempts = 0;
    g_device_context.join_timestamp = time(NULL);
    
    memcpy(&g_device_context.network_params, &join_params, sizeof(zigbee_network_params_t));
    
    platform_log_security_event("Successfully joined and authenticated", ZIGBEE_STATUS_SUCCESS);
    
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_set_network_key(const uint8_t *network_key, uint8_t sequence_number) {
    if (g_device_context.state != ZIGBEE_DEVICE_STATE_AUTHENTICATED &&
        g_device_context.state != ZIGBEE_DEVICE_STATE_OPERATIONAL) {
        return ZIGBEE_STATUS_INVALID_PARAMETER;
    }
    
    if (network_key == NULL) {
        return ZIGBEE_STATUS_INVALID_PARAMETER;
    }
    
    if (!validate_link_key(network_key, ZIGBEE_NETWORK_KEY_SIZE)) {
        platform_log_security_event("Invalid network key", ZIGBEE_STATUS_SECURITY_FAILURE);
        return ZIGBEE_STATUS_SECURITY_FAILURE;
    }
    
    zigbee_network_key_t new_key = {0};
    memcpy(new_key.key, network_key, ZIGBEE_NETWORK_KEY_SIZE);
    new_key.sequence_number = sequence_number;
    new_key.is_encrypted = true;
    
    zigbee_status_t status = platform_zigbee_set_network_key(&new_key);
    if (status != ZIGBEE_STATUS_SUCCESS) {
        secure_memory_clear(&new_key, sizeof(new_key));
        platform_log_security_event("Failed to set network key", status);
        return status;
    }
    
    memcpy(&g_device_context.network_key, &new_key, sizeof(zigbee_network_key_t));
    
    secure_key_storage_write("network_key", network_key, ZIGBEE_NETWORK_KEY_SIZE);
    
    secure_memory_clear(&new_key, sizeof(new_key));
    
    g_device_context.state = ZIGBEE_DEVICE_STATE_OPERATIONAL;
    
    platform_log_security_event("Network key configured", ZIGBEE_STATUS_SUCCESS);
    
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_enable_permit_join(uint8_t duration_seconds) {
    if (g_device_context.state != ZIGBEE_DEVICE_STATE_OPERATIONAL) {
        return ZIGBEE_STATUS_INVALID_PARAMETER;
    }
    
    if (duration_seconds > ZIGBEE_MAX_PERMIT_JOIN_DURATION) {
        duration_seconds = ZIGBEE_MAX_PERMIT_JOIN_DURATION;
    }
    
    if (duration_seconds > 60) {
        platform_log_security_event("Permit join duration limited to 60 seconds for security", ZIGBEE_STATUS_SUCCESS);
        duration_seconds = 60;
    }
    
    g_device_context.network_params.permit_join = (duration_seconds > 0);
    g_device_context.network_params.permit_join_duration = duration_seconds;
    
    platform_log_security_event("Permit join enabled", ZIGBEE_STATUS_SUCCESS);
    
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_disable_permit_join(void) {
    if (g_device_context.state != ZIGBEE_DEVICE_STATE_OPERATIONAL) {
        return ZIGBEE_STATUS_INVALID_PARAMETER;
    }
    
    g_device_context.network_params.permit_join = false;
    g_device_context.network_params.permit_join_duration = 0;
    
    platform_log_security_event("Permit join disabled", ZIGBEE_STATUS_SUCCESS);
    
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_status_t zigbee_leave_network(void) {
    if (g_device_context.state == ZIGBEE_DEVICE_STATE_UNINITIALIZED ||
        g_device_context.state == ZIGBEE_DEVICE_STATE_INITIALIZED) {
        return ZIGBEE_STATUS_INVALID_PARAMETER;
    }
    
    g_device_context.state = ZIGBEE_DEVICE_STATE_LEAVING;
    
    secure_key_storage_delete("tc_link_key");
    secure_key_storage_delete("network_key");
    
    secure_memory_clear(&g_device_context.trust_center_link_key, sizeof(zigbee_link_key_t));
    secure_memory_clear(&g_device_context.network_key, sizeof(zigbee_network_key_t));
    
    g_device_context.authenticated = false;
    g_device_context.state = ZIGBEE_DEVICE_STATE_INITIALIZED;
    g_device_context.short_address = 0xFFFE;
    
    platform_log_security_event("Left network and cleared credentials", ZIGBEE_STATUS_SUCCESS);
    
    return ZIGBEE_STATUS_SUCCESS;
}

zigbee_device_state_t zigbee_get_device_state(void) {
    return g_device_context.state;
}

bool zigbee_is_authenticated(void) {
    return g_device_context.authenticated && 
           (g_device_context.state == ZIGBEE_DEVICE_STATE_AUTHENTICATED ||
            g_device_context.state == ZIGBEE_DEVICE_STATE_OPERATIONAL);
}