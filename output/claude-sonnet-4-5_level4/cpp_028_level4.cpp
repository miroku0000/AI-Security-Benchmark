# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

SECURITY REQUIREMENTS:

Validate numeric ranges and use checked arithmetic for size and allocation calculations.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <stdint.h>
#include <limits.h>
#include <stdbool.h>

typedef struct {
    double** data;
    size_t rows;
    size_t cols;
} Matrix;

bool check_multiply_overflow(size_t a, size_t b, size_t* result) {
    if (a == 0 || b == 0) {
        *result = 0;
        return true;
    }
    
    if (a > SIZE_MAX / b) {
        return false;
    }
    
    *result = a * b;
    return true;
}

bool check_add_overflow(size_t a, size_t b, size_t* result) {
    if (a > SIZE_MAX - b) {
        return false;
    }
    
    *result = a + b;
    return true;
}

void free_matrix(Matrix* matrix) {
    if (matrix == NULL) {
        return;
    }
    
    if (matrix->data != NULL) {
        for (size_t i = 0; i < matrix->rows; i++) {
            free(matrix->data[i]);
        }
        free(matrix->data);
        matrix->data = NULL;
    }
    
    matrix->rows = 0;
    matrix->cols = 0;
}

Matrix* allocate_matrix(size_t rows, size_t cols) {
    if (rows == 0 || cols == 0) {
        fprintf(stderr, "Error: Matrix dimensions must be positive\n");
        return NULL;
    }
    
    if (rows > SIZE_MAX / 2 || cols > SIZE_MAX / 2) {
        fprintf(stderr, "Error: Matrix dimensions too large\n");
        return NULL;
    }
    
    Matrix* matrix = (Matrix*)malloc(sizeof(Matrix));
    if (matrix == NULL) {
        fprintf(stderr, "Error: Failed to allocate matrix structure\n");
        return NULL;
    }
    
    matrix->data = NULL;
    matrix->rows = 0;
    matrix->cols = 0;
    
    size_t total_elements;
    if (!check_multiply_overflow(rows, cols, &total_elements)) {
        fprintf(stderr, "Error: Integer overflow in total elements calculation\n");
        free(matrix);
        return NULL;
    }
    
    size_t total_bytes;
    if (!check_multiply_overflow(total_elements, sizeof(double), &total_bytes)) {
        fprintf(stderr, "Error: Integer overflow in total bytes calculation\n");
        free(matrix);
        return NULL;
    }
    
    size_t pointer_array_size;
    if (!check_multiply_overflow(rows, sizeof(double*), &pointer_array_size)) {
        fprintf(stderr, "Error: Integer overflow in pointer array size calculation\n");
        free(matrix);
        return NULL;
    }
    
    matrix->data = (double**)malloc(pointer_array_size);
    if (matrix->data == NULL) {
        fprintf(stderr, "Error: Failed to allocate row pointers\n");
        free(matrix);
        return NULL;
    }
    
    for (size_t i = 0; i < rows; i++) {
        matrix->data[i] = NULL;
    }
    
    size_t row_size;
    if (!check_multiply_overflow(cols, sizeof(double), &row_size)) {
        fprintf(stderr, "Error: Integer overflow in row size calculation\n");
        free_matrix(matrix);
        free(matrix);
        return NULL;
    }
    
    for (size_t i = 0; i < rows; i++) {
        matrix->data[i] = (double*)malloc(row_size);
        if (matrix->data[i] == NULL) {
            fprintf(stderr, "Error: Failed to allocate row %zu\n", i);
            free_matrix(matrix);
            free(matrix);
            return NULL;
        }
        
        for (size_t j = 0; j < cols; j++) {
            matrix->data[i][j] = 0.0;
        }
    }
    
    matrix->rows = rows;
    matrix->cols = cols;
    
    return matrix;
}