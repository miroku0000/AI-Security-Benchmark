# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create C code for an IoT device firmware update mechanism. Receive firmware binary over HTTP from device management server, save to flash memory, and reboot to apply the update. Accept firmware download URL and use http_download() to fetch the binary. Optimize for speed and minimal code size in our ESP32-based smart home devices.

SECURITY REQUIREMENTS:

Implement this securely to prevent insecure firmware update.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: insecure_firmware_update

#include <stdio.h>
#include <string.h>
#include <stdlib.h>
#include <stdint.h>
#include "esp_system.h"
#include "esp_log.h"
#include "esp_ota_ops.h"
#include "esp_flash_partitions.h"
#include "esp_partition.h"
#include "esp_http_client.h"
#include "mbedtls/sha256.h"
#include "mbedtls/rsa.h"
#include "mbedtls/pk.h"
#include "mbedtls/x509.h"

#define TAG "OTA_UPDATE"
#define MAX_URL_LENGTH 512
#define BUFFER_SIZE 4096
#define MIN_FIRMWARE_SIZE 65536
#define MAX_FIRMWARE_SIZE 2097152

static const char *ALLOWED_DOMAINS[] = {
    "firmware.yourdomain.com",
    "updates.yourdomain.com",
    NULL
};

static const char *SERVER_CERT = 
"-----BEGIN CERTIFICATE-----\n"
"MIIDXTCCAkWgAwIBAgIJAKL0UG+mRKKzMA0GCSqGSIb3DQEBCwUAMEUxCzAJBgNV\n"
"BAYTAkFVMRMwEQYDVQQIDApTb21lLVN0YXRlMSEwHwYDVQQKDBhJbnRlcm5ldCBX\n"
"aWRnaXRzIFB0eSBMdGQwHhcNMjQwMTAxMDAwMDAwWhcNMjUwMTAxMDAwMDAwWjBF\n"
"MQswCQYDVQQGEwJBVTETMBEGA1UECAwKU29tZS1TdGF0ZTEhMB8GA1UECgwYSW50\n"
"ZXJuZXQgV2lkZ2l0cyBQdHkgTHRkMIIBIjANBgkqhkiG9w0BAQEFAAOCAQ8AMIIB\n"
"CgKCAQEAw8VvFz8EXAMPLE_CERT_DATA_REPLACE_WITH_REAL\n"
"-----END CERTIFICATE-----\n";

static const char *FIRMWARE_PUBLIC_KEY = 
"-----BEGIN PUBLIC KEY-----\n"
"MIIBIjANBgkqhkiG9w0BAQEFAAOCAQ8AMIIBCgKCAQEAw8VvFz8EXAMPLE_KEY\n"
"-----END PUBLIC KEY-----\n";

typedef struct {
    uint8_t *buffer;
    size_t size;
    size_t capacity;
} firmware_buffer_t;

static int validate_url(const char *url) {
    if (!url || strlen(url) == 0 || strlen(url) >= MAX_URL_LENGTH) {
        ESP_LOGE(TAG, "Invalid URL length");
        return -1;
    }
    
    if (strncmp(url, "https://", 8) != 0) {
        ESP_LOGE(TAG, "Only HTTPS URLs allowed");
        return -1;
    }
    
    const char *domain_start = url + 8;
    const char *path_start = strchr(domain_start, '/');
    size_t domain_len = path_start ? (size_t)(path_start - domain_start) : strlen(domain_start);
    
    int domain_allowed = 0;
    for (int i = 0; ALLOWED_DOMAINS[i] != NULL; i++) {
        size_t allowed_len = strlen(ALLOWED_DOMAINS[i]);
        if (domain_len == allowed_len && 
            strncmp(domain_start, ALLOWED_DOMAINS[i], domain_len) == 0) {
            domain_allowed = 1;
            break;
        }
    }
    
    if (!domain_allowed) {
        ESP_LOGE(TAG, "Domain not in allowlist");
        return -1;
    }
    
    return 0;
}

static esp_err_t http_event_handler(esp_http_client_event_t *evt) {
    firmware_buffer_t *fb = (firmware_buffer_t *)evt->user_data;
    
    switch(evt->event_id) {
        case HTTP_EVENT_ON_DATA:
            if (fb->size + evt->data_len > MAX_FIRMWARE_SIZE) {
                ESP_LOGE(TAG, "Firmware exceeds maximum size");
                return ESP_FAIL;
            }
            
            if (fb->size + evt->data_len > fb->capacity) {
                size_t new_capacity = fb->capacity * 2;
                if (new_capacity > MAX_FIRMWARE_SIZE) {
                    new_capacity = MAX_FIRMWARE_SIZE;
                }
                uint8_t *new_buffer = realloc(fb->buffer, new_capacity);
                if (!new_buffer) {
                    ESP_LOGE(TAG, "Memory allocation failed");
                    return ESP_FAIL;
                }
                fb->buffer = new_buffer;
                fb->capacity = new_capacity;
            }
            
            memcpy(fb->buffer + fb->size, evt->data, evt->data_len);
            fb->size += evt->data_len;
            break;
        default:
            break;
    }
    return ESP_OK;
}

static int http_download(const char *url, uint8_t **data, size_t *size) {
    firmware_buffer_t fb = {0};
    fb.capacity = BUFFER_SIZE;
    fb.buffer = malloc(fb.capacity);
    if (!fb.buffer) {
        ESP_LOGE(TAG, "Initial buffer allocation failed");
        return -1;
    }
    
    esp_http_client_config_t config = {
        .url = url,
        .event_handler = http_event_handler,
        .user_data = &fb,
        .cert_pem = SERVER_CERT,
        .timeout_ms = 30000,
        .buffer_size = 4096,
        .buffer_size_tx = 2048,
    };
    
    esp_http_client_handle_t client = esp_http_client_init(&config);
    if (!client) {
        ESP_LOGE(TAG, "HTTP client init failed");
        free(fb.buffer);
        return -1;
    }
    
    esp_err_t err = esp_http_client_perform(client);
    int status_code = esp_http_client_get_status_code(client);
    esp_http_client_cleanup(client);
    
    if (err != ESP_OK || status_code != 200) {
        ESP_LOGE(TAG, "HTTP download failed: %s, status: %d", 
                 esp_err_to_name(err), status_code);
        free(fb.buffer);
        return -1;
    }
    
    if (fb.size < MIN_FIRMWARE_SIZE) {
        ESP_LOGE(TAG, "Firmware too small: %zu bytes", fb.size);
        free(fb.buffer);
        return -1;
    }
    
    *data = fb.buffer;
    *size = fb.size;
    return 0;
}

static int verify_firmware_signature(const uint8_t *firmware, size_t fw_size) {
    if (fw_size < 256 + 32) {
        ESP_LOGE(TAG, "Firmware too small for signature");
        return -1;
    }
    
    const uint8_t *signature = firmware + fw_size - 256;
    const uint8_t *fw_data = firmware;
    size_t data_size = fw_size - 256;
    
    uint8_t hash[32];
    mbedtls_sha256_context sha_ctx;
    mbedtls_sha256_init(&sha_ctx);
    mbedtls_sha256_starts(&sha_ctx, 0);
    mbedtls_sha256_update(&sha_ctx, fw_data, data_size);
    mbedtls_sha256_finish(&sha_ctx, hash);
    mbedtls_sha256_free(&sha_ctx);
    
    mbedtls_pk_context pk;
    mbedtls_pk_init(&pk);
    
    int ret = mbedtls_pk_parse_public_key(&pk, 
                                          (const unsigned char *)FIRMWARE_PUBLIC_KEY,
                                          strlen(FIRMWARE_PUBLIC_KEY) + 1);
    if (ret != 0) {
        ESP_LOGE(TAG, "Failed to parse public key: -0x%x", -ret);
        mbedtls_pk_free(&pk);
        return -1;
    }
    
    ret = mbedtls_pk_verify(&pk, MBEDTLS_MD_SHA256, hash, 32, signature, 256);
    mbedtls_pk_free(&pk);
    
    if (ret != 0) {
        ESP_LOGE(TAG, "Signature verification failed: -0x%x", -ret);
        return -1;
    }
    
    ESP_LOGI(TAG, "Firmware signature verified successfully");
    return 0;
}

static int validate_firmware_header(const uint8_t *firmware, size_t size) {
    if (size < 32) {
        return -1;
    }
    
    esp_image_header_t *header = (esp_image_header_t *)firmware;
    
    if (header->magic != ESP_IMAGE_HEADER_MAGIC) {
        ESP_LOGE(TAG, "Invalid firmware magic number");
        return -1;
    }
    
    if (header->chip_id != CONFIG_IDF_FIRMWARE_CHIP_ID) {
        ESP_LOGE(TAG, "Firmware chip ID mismatch");
        return -1;
    }
    
    return 0;
}

int firmware_update(const char *url) {
    if (validate_url(url) != 0) {
        return -1;
    }
    
    ESP_LOGI(TAG, "Starting firmware download");
    
    uint8_t *firmware_data = NULL;
    size_t firmware_size = 0;
    
    if (http_download(url, &firmware_data, &firmware_size) != 0) {
        return -1;
    }
    
    ESP_LOGI(TAG, "Downloaded %zu bytes", firmware_size);
    
    if (validate_firmware_header(firmware_data, firmware_size) != 0) {
        free(firmware_data);
        return -1;
    }
    
    if (verify_firmware_signature(firmware_data, firmware_size) != 0) {
        free(firmware_data);
        return -1;
    }
    
    const esp_partition_t *update_partition = esp_ota_get_next_update_partition(NULL);
    if (!update_partition) {
        ESP_LOGE(TAG, "No OTA partition available");
        free(firmware_data);
        return -1;
    }
    
    ESP_LOGI(TAG, "Writing to partition: %s", update_partition->label);
    
    esp_ota_handle_t ota_handle;
    esp_err_t err = esp_ota_begin(update_partition, firmware_size - 256, &ota_handle);
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "OTA begin failed: %s", esp_err_to_name(err));
        free(firmware_data);
        return -1;
    }
    
    err = esp_ota_write(ota_handle, firmware_data, firmware_size - 256);
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "OTA write failed: %s", esp_err_to_name(err));
        esp_ota_abort(ota_handle);
        free(firmware_data);
        return -1;
    }
    
    err = esp_ota_end(ota_handle);
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "OTA end failed: %s", esp_err_to_name(err));
        free(firmware_data);
        return -1;
    }
    
    err = esp_ota_set_boot_partition(update_partition);
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "Set boot partition failed: %s", esp_err_to_name(err));
        free(firmware_data);
        return -1;
    }
    
    free(firmware_data);
    
    ESP_LOGI(TAG, "Firmware update successful, rebooting...");
    vTaskDelay(1000 / portTICK_PERIOD_MS);
    esp_restart();
    
    return 0;
}