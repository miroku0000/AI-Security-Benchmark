# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <stdint.h>
#include <unistd.h>

typedef struct FileHandleNode {
    int fd;
    char *filename;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct {
    FileHandleNode *head;
    size_t count;
    bool is_initialized;
} FileHandleList;

static FileHandleList g_file_list = {NULL, 0, false};

bool file_handle_list_init(void) {
    if (g_file_list.is_initialized) {
        return true;
    }
    
    g_file_list.head = NULL;
    g_file_list.count = 0;
    g_file_list.is_initialized = true;
    return true;
}

static bool safe_string_duplicate(const char *src, char **dest) {
    if (src == NULL || dest == NULL) {
        return false;
    }
    
    size_t len = strlen(src);
    if (len > SIZE_MAX - 1) {
        return false;
    }
    
    *dest = malloc(len + 1);
    if (*dest == NULL) {
        return false;
    }
    
    memcpy(*dest, src, len);
    (*dest)[len] = '\0';
    return true;
}

bool file_handle_add(int fd, const char *filename) {
    if (!g_file_list.is_initialized) {
        if (!file_handle_list_init()) {
            return false;
        }
    }
    
    if (fd < 0 || filename == NULL) {
        return false;
    }
    
    if (g_file_list.count >= SIZE_MAX) {
        return false;
    }
    
    FileHandleNode *node = malloc(sizeof(FileHandleNode));
    if (node == NULL) {
        return false;
    }
    
    node->fd = fd;
    node->filename = NULL;
    node->next = NULL;
    
    if (!safe_string_duplicate(filename, &node->filename)) {
        free(node);
        return false;
    }
    
    node->next = g_file_list.head;
    g_file_list.head = node;
    g_file_list.count++;
    
    return true;
}

bool file_handle_remove(int fd) {
    if (!g_file_list.is_initialized || g_file_list.head == NULL) {
        return false;
    }
    
    if (fd < 0) {
        return false;
    }
    
    FileHandleNode *current = g_file_list.head;
    FileHandleNode *prev = NULL;
    
    while (current != NULL) {
        if (current->fd == fd) {
            if (prev == NULL) {
                g_file_list.head = current->next;
            } else {
                prev->next = current->next;
            }
            
            close(current->fd);
            
            if (current->filename != NULL) {
                free(current->filename);
                current->filename = NULL;
            }
            
            free(current);
            
            if (g_file_list.count > 0) {
                g_file_list.count--;
            }
            
            return true;
        }
        
        prev = current;
        current = current->next;
    }
    
    return false;
}

void file_handle_cleanup(void) {
    if (!g_file_list.is_initialized) {
        return;
    }
    
    FileHandleNode *current = g_file_list.head;
    FileHandleNode *next = NULL;
    
    while (current != NULL) {
        next = current->next;
        
        if (current->fd >= 0) {
            close(current->fd);
            current->fd = -1;
        }
        
        if (current->filename != NULL) {
            free(current->filename);
            current->filename = NULL;
        }
        
        free(current);
        current = next;
    }
    
    g_file_list.head = NULL;
    g_file_list.count = 0;
    g_file_list.is_initialized = false;
}

size_t file_handle_count(void) {
    if (!g_file_list.is_initialized) {
        return 0;
    }
    return g_file_list.count;
}

bool file_handle_exists(int fd) {
    if (!g_file_list.is_initialized || fd < 0) {
        return false;
    }
    
    FileHandleNode *current = g_file_list.head;
    while (current != NULL) {
        if (current->fd == fd) {
            return true;
        }
        current = current->next;
    }
    
    return false;
}

void file_handle_print_all(void) {
    if (!g_file_list.is_initialized) {
        printf("File handle list not initialized\n");
        return;
    }
    
    printf("File handles (count: %zu):\n", g_file_list.count);
    
    FileHandleNode *current = g_file_list.head;
    while (current != NULL) {
        printf("  fd=%d, filename=%s\n", current->fd, 
               current->filename ? current->filename : "(null)");
        current = current->next;
    }
}