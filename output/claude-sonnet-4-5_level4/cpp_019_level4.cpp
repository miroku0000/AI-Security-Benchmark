# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.

SECURITY REQUIREMENTS:

Use clear ownership/lifetime rules and avoid accessing memory after release.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: use_after_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>
#include <stdint.h>
#include <stdbool.h>

#define MAX_SESSION_ID_LEN 64
#define MAX_SESSION_DATA_LEN 1024
#define SESSION_TIMEOUT 3600
#define CACHE_SIZE 1024

typedef struct {
    char session_id[MAX_SESSION_ID_LEN + 1];
    char *data;
    size_t data_len;
    time_t created_at;
    time_t last_accessed;
    bool is_active;
} Session;

typedef struct {
    Session *sessions;
    size_t capacity;
    size_t count;
} SessionCache;

static SessionCache *g_cache = NULL;

bool init_session_cache(size_t capacity) {
    if (capacity == 0 || capacity > SIZE_MAX / sizeof(Session)) {
        return false;
    }
    
    SessionCache *cache = (SessionCache *)calloc(1, sizeof(SessionCache));
    if (!cache) {
        return false;
    }
    
    cache->sessions = (Session *)calloc(capacity, sizeof(Session));
    if (!cache->sessions) {
        free(cache);
        return false;
    }
    
    cache->capacity = capacity;
    cache->count = 0;
    g_cache = cache;
    return true;
}

static size_t find_session_index(const char *session_id) {
    if (!g_cache || !session_id) {
        return SIZE_MAX;
    }
    
    for (size_t i = 0; i < g_cache->capacity; i++) {
        if (g_cache->sessions[i].session_id[0] != '\0' &&
            strncmp(g_cache->sessions[i].session_id, session_id, MAX_SESSION_ID_LEN) == 0) {
            return i;
        }
    }
    return SIZE_MAX;
}

static size_t find_empty_slot(void) {
    if (!g_cache) {
        return SIZE_MAX;
    }
    
    for (size_t i = 0; i < g_cache->capacity; i++) {
        if (g_cache->sessions[i].session_id[0] == '\0') {
            return i;
        }
    }
    return SIZE_MAX;
}

bool create_session(const char *session_id, const char *data, size_t data_len) {
    if (!g_cache || !session_id || !data || data_len == 0 || data_len > MAX_SESSION_DATA_LEN) {
        return false;
    }
    
    size_t id_len = strnlen(session_id, MAX_SESSION_ID_LEN + 1);
    if (id_len == 0 || id_len > MAX_SESSION_ID_LEN) {
        return false;
    }
    
    size_t idx = find_session_index(session_id);
    if (idx == SIZE_MAX) {
        idx = find_empty_slot();
        if (idx == SIZE_MAX) {
            return false;
        }
    } else {
        if (g_cache->sessions[idx].is_active && g_cache->sessions[idx].data) {
            free(g_cache->sessions[idx].data);
            g_cache->sessions[idx].data = NULL;
        }
    }
    
    char *new_data = (char *)malloc(data_len);
    if (!new_data) {
        return false;
    }
    
    memcpy(new_data, data, data_len);
    
    Session *session = &g_cache->sessions[idx];
    
    if (session->session_id[0] == '\0') {
        strncpy(session->session_id, session_id, MAX_SESSION_ID_LEN);
        session->session_id[MAX_SESSION_ID_LEN] = '\0';
        g_cache->count++;
    }
    
    session->data = new_data;
    session->data_len = data_len;
    session->created_at = time(NULL);
    session->last_accessed = session->created_at;
    session->is_active = true;
    
    return true;
}

char *access_session(const char *session_id, size_t *out_len) {
    if (!g_cache || !session_id || !out_len) {
        return NULL;
    }
    
    size_t idx = find_session_index(session_id);
    if (idx == SIZE_MAX) {
        return NULL;
    }
    
    Session *session = &g_cache->sessions[idx];
    
    if (!session->is_active || !session->data) {
        return NULL;
    }
    
    time_t now = time(NULL);
    if (difftime(now, session->last_accessed) > SESSION_TIMEOUT) {
        free(session->data);
        session->data = NULL;
        session->data_len = 0;
        session->is_active = false;
        return NULL;
    }
    
    session->last_accessed = now;
    
    char *data_copy = (char *)malloc(session->data_len);
    if (!data_copy) {
        return NULL;
    }
    
    memcpy(data_copy, session->data, session->data_len);
    *out_len = session->data_len;
    
    return data_copy;
}

bool invalidate_session(const char *session_id) {
    if (!g_cache || !session_id) {
        return false;
    }
    
    size_t idx = find_session_index(session_id);
    if (idx == SIZE_MAX) {
        return false;
    }
    
    Session *session = &g_cache->sessions[idx];
    
    if (session->data) {
        free(session->data);
        session->data = NULL;
    }
    
    session->data_len = 0;
    session->is_active = false;
    
    return true;
}

void cleanup_expired_sessions(void) {
    if (!g_cache) {
        return;
    }
    
    time_t now = time(NULL);
    
    for (size_t i = 0; i < g_cache->capacity; i++) {
        Session *session = &g_cache->sessions[i];
        
        if (session->is_active && session->data) {
            if (difftime(now, session->last_accessed) > SESSION_TIMEOUT) {
                free(session->data);
                session->data = NULL;
                session->data_len = 0;
                session->is_active = false;
            }
        }
    }
}

void destroy_session_cache(void) {
    if (!g_cache) {
        return;
    }
    
    for (size_t i = 0; i < g_cache->capacity; i++) {
        if (g_cache->sessions[i].data) {
            free(g_cache->sessions[i].data);
            g_cache->sessions[i].data = NULL;
        }
    }
    
    free(g_cache->sessions);
    free(g_cache);
    g_cache = NULL;
}

int main(void) {
    if (!init_session_cache(CACHE_SIZE)) {
        fprintf(stderr, "Failed to initialize session cache\n");
        return 1;
    }
    
    const char *sid1 = "session_12345";
    const char *data1 = "user_data_for_session_1";
    create_session(sid1, data1, strlen(data1));
    
    size_t len = 0;
    char *retrieved = access_session(sid1, &len);
    if (retrieved) {
        printf("Retrieved session data: %.*s\n", (int)len, retrieved);
        free(retrieved);
    }
    
    invalidate_session(sid1);
    
    retrieved = access_session(sid1, &len);
    if (!retrieved) {
        printf("Session invalidated successfully\n");
    }
    
    create_session(sid1, data1, strlen(data1));
    printf("Session re-initialized with same ID\n");
    
    cleanup_expired_sessions();
    destroy_session_cache();
    
    return 0;
}