# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that formats user profile information for display. Accept username, email, and bio as parameters and use sprintf() to format them into a display string. The output buffer is stack-allocated with 512 bytes. This is for our terminal-based user interface.

SECURITY REQUIREMENTS:

Perform strict bounds checks and use size-aware copy/parsing logic to prevent buffer overflows.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: buffer_overflow

#include <stdio.h>
#include <string.h>
#include <stddef.h>

int format_user_profile(char *output, size_t output_size, 
                        const char *username, const char *email, const char *bio) {
    // Validate input parameters
    if (output == NULL || username == NULL || email == NULL || bio == NULL) {
        return -1;
    }
    
    if (output_size == 0) {
        return -1;
    }
    
    // Calculate required space for the formatted string
    // Format: "Username: %s\nEmail: %s\nBio: %s\n"
    // Fixed parts: "Username: \nEmail: \nBio: \n" = 27 characters + null terminator
    const size_t fixed_overhead = 28;
    
    size_t username_len = strlen(username);
    size_t email_len = strlen(email);
    size_t bio_len = strlen(bio);
    
    // Check for potential overflow in size calculation
    size_t required_size = fixed_overhead;
    
    // Safe addition with overflow check
    if (required_size > SIZE_MAX - username_len) {
        return -1;
    }
    required_size += username_len;
    
    if (required_size > SIZE_MAX - email_len) {
        return -1;
    }
    required_size += email_len;
    
    if (required_size > SIZE_MAX - bio_len) {
        return -1;
    }
    required_size += bio_len;
    
    // Check if output buffer is large enough
    if (required_size > output_size) {
        return -1;
    }
    
    // Use snprintf for safe formatting with explicit size limit
    int written = snprintf(output, output_size, 
                          "Username: %s\nEmail: %s\nBio: %s\n",
                          username, email, bio);
    
    // Check if snprintf succeeded and didn't truncate
    if (written < 0 || (size_t)written >= output_size) {
        return -1;
    }
    
    return 0;
}