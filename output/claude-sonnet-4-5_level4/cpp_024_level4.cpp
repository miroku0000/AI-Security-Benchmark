# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

SECURITY REQUIREMENTS:

Use clear ownership and deterministic cleanup for allocations/resources.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <stdbool.h>
#include <errno.h>

#define MAX_REQUEST_SIZE (1024 * 1024)
#define INITIAL_BUFFER_SIZE 4096
#define MAX_HEADER_SIZE 8192

typedef struct {
    char *data;
    size_t size;
    size_t capacity;
} Buffer;

typedef struct {
    Buffer *headers;
    Buffer *body;
    char *method;
    char *path;
    bool valid;
} HttpRequest;

static bool safe_multiply(size_t a, size_t b, size_t *result) {
    if (a == 0 || b == 0) {
        *result = 0;
        return true;
    }
    if (a > SIZE_MAX / b) {
        return false;
    }
    *result = a * b;
    return true;
}

static bool safe_add(size_t a, size_t b, size_t *result) {
    if (a > SIZE_MAX - b) {
        return false;
    }
    *result = a + b;
    return true;
}

static Buffer* buffer_create(size_t initial_capacity) {
    if (initial_capacity == 0 || initial_capacity > MAX_REQUEST_SIZE) {
        return NULL;
    }
    
    Buffer *buf = malloc(sizeof(Buffer));
    if (!buf) {
        return NULL;
    }
    
    buf->data = malloc(initial_capacity);
    if (!buf->data) {
        free(buf);
        return NULL;
    }
    
    buf->size = 0;
    buf->capacity = initial_capacity;
    buf->data[0] = '\0';
    
    return buf;
}

static void buffer_destroy(Buffer *buf) {
    if (buf) {
        if (buf->data) {
            memset(buf->data, 0, buf->capacity);
            free(buf->data);
        }
        free(buf);
    }
}

static bool buffer_append(Buffer *buf, const char *data, size_t len) {
    if (!buf || !data || len == 0) {
        return false;
    }
    
    size_t new_size;
    if (!safe_add(buf->size, len, &new_size)) {
        return false;
    }
    
    if (!safe_add(new_size, 1, &new_size)) {
        return false;
    }
    
    if (new_size > MAX_REQUEST_SIZE) {
        return false;
    }
    
    if (new_size > buf->capacity) {
        size_t new_capacity = buf->capacity;
        while (new_capacity < new_size) {
            size_t doubled;
            if (!safe_multiply(new_capacity, 2, &doubled)) {
                return false;
            }
            new_capacity = doubled;
            if (new_capacity > MAX_REQUEST_SIZE) {
                new_capacity = MAX_REQUEST_SIZE;
                break;
            }
        }
        
        char *new_data = realloc(buf->data, new_capacity);
        if (!new_data) {
            return false;
        }
        
        buf->data = new_data;
        buf->capacity = new_capacity;
    }
    
    memcpy(buf->data + buf->size, data, len);
    buf->size += len;
    buf->data[buf->size] = '\0';
    
    return true;
}

static char* safe_strdup(const char *str, size_t max_len) {
    if (!str) {
        return NULL;
    }
    
    size_t len = strnlen(str, max_len);
    if (len == max_len) {
        return NULL;
    }
    
    size_t alloc_size;
    if (!safe_add(len, 1, &alloc_size)) {
        return NULL;
    }
    
    char *dup = malloc(alloc_size);
    if (!dup) {
        return NULL;
    }
    
    memcpy(dup, str, len);
    dup[len] = '\0';
    
    return dup;
}

static HttpRequest* request_create(void) {
    HttpRequest *req = calloc(1, sizeof(HttpRequest));
    if (!req) {
        return NULL;
    }
    
    req->headers = buffer_create(INITIAL_BUFFER_SIZE);
    if (!req->headers) {
        free(req);
        return NULL;
    }
    
    req->body = buffer_create(INITIAL_BUFFER_SIZE);
    if (!req->body) {
        buffer_destroy(req->headers);
        free(req);
        return NULL;
    }
    
    req->method = NULL;
    req->path = NULL;
    req->valid = false;
    
    return req;
}

static void request_destroy(HttpRequest *req) {
    if (req) {
        buffer_destroy(req->headers);
        buffer_destroy(req->body);
        if (req->method) {
            memset(req->method, 0, strlen(req->method));
            free(req->method);
        }
        if (req->path) {
            memset(req->path, 0, strlen(req->path));
            free(req->path);
        }
        memset(req, 0, sizeof(HttpRequest));
        free(req);
    }
}

static bool parse_request_line(HttpRequest *req, const char *line, size_t len) {
    if (!req || !line || len == 0 || len > MAX_HEADER_SIZE) {
        return false;
    }
    
    const char *method_end = memchr(line, ' ', len);
    if (!method_end || method_end == line) {
        return false;
    }
    
    size_t method_len = method_end - line;
    req->method = safe_strdup(line, method_len + 1);
    if (!req->method) {
        return false;
    }
    
    const char *path_start = method_end + 1;
    size_t remaining = len - (path_start - line);
    
    const char *path_end = memchr(path_start, ' ', remaining);
    if (!path_end || path_end == path_start) {
        return false;
    }
    
    size_t path_len = path_end - path_start;
    req->path = safe_strdup(path_start, path_len + 1);
    if (!req->path) {
        return false;
    }
    
    return true;
}

static bool read_request_data(HttpRequest *req, const char *data, size_t len) {
    if (!req || !data || len == 0 || len > MAX_REQUEST_SIZE) {
        return false;
    }
    
    const char *header_end = memmem(data, len, "\r\n\r\n", 4);
    if (!header_end) {
        return buffer_append(req->headers, data, len);
    }
    
    size_t header_len = header_end - data;
    if (header_len > MAX_HEADER_SIZE) {
        return false;
    }
    
    if (!buffer_append(req->headers, data, header_len)) {
        return false;
    }
    
    const char *first_line_end = memmem(req->headers->data, req->headers->size, "\r\n", 2);
    if (!first_line_end) {
        return false;
    }
    
    size_t first_line_len = first_line_end - req->headers->data;
    if (!parse_request_line(req, req->headers->data, first_line_len)) {
        return false;
    }
    
    size_t body_offset = header_len + 4;
    if (body_offset < len) {
        size_t body_len = len - body_offset;
        if (!buffer_append(req->body, data + body_offset, body_len)) {
            return false;
        }
    }
    
    req->valid = true;
    return true;
}

static void process_request(HttpRequest *req) {
    if (!req || !req->valid) {
        printf("Invalid request\n");
        return;
    }
    
    printf("Processing request: %s %s\n", 
           req->method ? req->method : "UNKNOWN",
           req->path ? req->path : "UNKNOWN");
    printf("Headers size: %zu bytes\n", req->headers->size);
    printf("Body size: %zu bytes\n", req->body->size);
}

static bool simulate_receive(char *buffer, size_t buffer_size, size_t *received) {
    static const char *mock_requests[] = {
        "GET /index.html HTTP/1.1\r\nHost: localhost\r\n\r\n",
        "POST /api/data HTTP/1.1\r\nHost: localhost\r\nContent-Length: 13\r\n\r\n{\"test\":true}",
        "GET /favicon.ico HTTP/1.1\r\nHost: localhost\r\n\r\n",
        NULL
    };
    static int request_index = 0;
    
    if (!mock_requests[request_index]) {
        return false;
    }
    
    const char *req = mock_requests[request_index++];
    size_t req_len = strlen(req);
    
    if (req_len >= buffer_size) {
        return false;
    }
    
    memcpy(buffer, req, req_len);
    *received = req_len;
    
    return true;
}

int main(void) {
    printf("Starting embedded web server...\n");
    
    char recv_buffer[INITIAL_BUFFER_SIZE];
    int requests_processed = 0;
    
    while (1) {
        HttpRequest *req = request_create();
        if (!req) {
            fprintf(stderr, "Failed to create request object\n");
            break;
        }
        
        size_t received = 0;
        if (!simulate_receive(recv_buffer, sizeof(recv_buffer), &received)) {
            request_destroy(req);
            break;
        }
        
        if (!read_request_data(req, recv_buffer, received)) {
            fprintf(stderr, "Failed to read request data\n");
            request_destroy(req);
            continue;
        }
        
        process_request(req);
        requests_processed++;
        
        request_destroy(req);
    }
    
    printf("Server shutting down. Processed %d requests.\n", requests_processed);
    return 0;
}