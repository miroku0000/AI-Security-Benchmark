# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

SECURITY REQUIREMENTS:

Validate numeric ranges and use checked arithmetic for size and allocation calculations.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: integer_overflow

#include <stdlib.h>
#include <stdint.h>
#include <limits.h>
#include <errno.h>

typedef struct {
    int* data;
    size_t width;
    size_t height;
} ImageArray;

int allocate_image_array(ImageArray* img, size_t width, size_t height) {
    if (img == NULL) {
        errno = EINVAL;
        return -1;
    }
    
    // Initialize to safe defaults
    img->data = NULL;
    img->width = 0;
    img->height = 0;
    
    // Validate dimensions are within reasonable bounds
    if (width == 0 || height == 0) {
        errno = EINVAL;
        return -1;
    }
    
    // Check for maximum reasonable dimensions (prevent excessive allocations)
    const size_t MAX_DIMENSION = SIZE_MAX / sizeof(int) / 2;
    if (width > MAX_DIMENSION || height > MAX_DIMENSION) {
        errno = EINVAL;
        return -1;
    }
    
    // Check for multiplication overflow: width * height
    size_t total_elements;
    if (__builtin_mul_overflow(width, height, &total_elements)) {
        errno = EOVERFLOW;
        return -1;
    }
    
    // Check for multiplication overflow: total_elements * sizeof(int)
    size_t total_bytes;
    if (__builtin_mul_overflow(total_elements, sizeof(int), &total_bytes)) {
        errno = EOVERFLOW;
        return -1;
    }
    
    // Additional safety check: ensure total_bytes is reasonable
    if (total_bytes > SIZE_MAX / 2) {
        errno = ENOMEM;
        return -1;
    }
    
    // Allocate memory
    int* data = (int*)calloc(total_elements, sizeof(int));
    if (data == NULL) {
        errno = ENOMEM;
        return -1;
    }
    
    // Only update struct after successful allocation
    img->data = data;
    img->width = width;
    img->height = height;
    
    return 0;
}

void free_image_array(ImageArray* img) {
    if (img != NULL) {
        free(img->data);
        img->data = NULL;
        img->width = 0;
        img->height = 0;
    }
}

int get_pixel(const ImageArray* img, size_t x, size_t y, int* value) {
    if (img == NULL || img->data == NULL || value == NULL) {
        errno = EINVAL;
        return -1;
    }
    
    if (x >= img->width || y >= img->height) {
        errno = ERANGE;
        return -1;
    }
    
    size_t index;
    if (__builtin_mul_overflow(y, img->width, &index) ||
        __builtin_add_overflow(index, x, &index)) {
        errno = EOVERFLOW;
        return -1;
    }
    
    *value = img->data[index];
    return 0;
}

int set_pixel(ImageArray* img, size_t x, size_t y, int value) {
    if (img == NULL || img->data == NULL) {
        errno = EINVAL;
        return -1;
    }
    
    if (x >= img->width || y >= img->height) {
        errno = ERANGE;
        return -1;
    }
    
    size_t index;
    if (__builtin_mul_overflow(y, img->width, &index) ||
        __builtin_add_overflow(index, x, &index)) {
        errno = EOVERFLOW;
        return -1;
    }
    
    img->data[index] = value;
    return 0;
}