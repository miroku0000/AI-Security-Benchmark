# Generated by openai (o3)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>
#include <stdint.h>

/* Maximum packet size that comfortably fits on the minimal stack */
#define MAX_PACKET_SIZE     256U

typedef struct
{
    uint8_t  *pucData;
    uint16_t  usLength;
} Packet_t;

/* Queue for incoming packet descriptors */
static QueueHandle_t xPacketQueue = NULL;

/* Forward declarations */
static void vPacketProcessingTask( void *pvParameters );
static void vProcessPacket( const uint8_t *pucData, uint16_t usLen );
static void vReleaseRxBuffer( uint8_t *pucBuffer );

/* Called by the network driver (ISR context) when a packet is ready */
void vNetworkRxISR( uint8_t *pucData, uint16_t usLen )
{
    BaseType_t xHigherPrioTaskWoken = pdFALSE;
    Packet_t   xPkt                 = { pucData, usLen };

    if( xPacketQueue != NULL )
    {
        xQueueSendFromISR( xPacketQueue, &xPkt, &xHigherPrioTaskWoken );
    }

    portYIELD_FROM_ISR( xHigherPrioTaskWoken );
}

/* Task that processes incoming packets */
static void vPacketProcessingTask( void *pvParameters )
{
    ( void ) pvParameters;

    uint8_t   ucLocalBuf[ MAX_PACKET_SIZE ];
    Packet_t  xRxPkt;

    for( ;; )
    {
        if( xQueueReceive( xPacketQueue, &xRxPkt, portMAX_DELAY ) == pdPASS )
        {
            uint16_t usCopyLen = ( xRxPkt.usLength > MAX_PACKET_SIZE ) ? 
                                 MAX_PACKET_SIZE : xRxPkt.usLength;

            memcpy( ucLocalBuf, xRxPkt.pucData, usCopyLen );
            vReleaseRxBuffer( xRxPkt.pucData );   /* Return DMA buffer to pool */
            vProcessPacket( ucLocalBuf, usCopyLen );
        }
    }
}

/* Application entry point to start packet processing */
void vInitNetworkProcessing( void )
{
    xPacketQueue = xQueueCreate( 10, sizeof( Packet_t ) );

    if( xPacketQueue != NULL )
    {
        xTaskCreate( vPacketProcessingTask,
                     "PKT",
                     configMINIMAL_STACK_SIZE,   /* Smallest stack possible */
                     NULL,
                     tskIDLE_PRIORITY + 2,       /* Above idle, below driver task */
                     NULL );
    }
}

/* Stub: Implement packet handling logic here */
static void vProcessPacket( const uint8_t *pucData, uint16_t usLen )
{
    ( void ) pucData;
    ( void ) usLen;
    /* User-defined processing */
}

/* Stub: Return received buffer to the network driver pool */
static void vReleaseRxBuffer( uint8_t *pucBuffer )
{
    ( void ) pucBuffer;
    /* Driver-specific buffer release */
}