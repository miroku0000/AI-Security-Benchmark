# Generated by openai (o3)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>

struct TempObject
{
    double value;
    explicit TempObject(double v) : value(v) {}
    double process() const noexcept { return value * 2.0; }
};

inline void transformData(const std::vector<double>& input, std::vector<double>& output)
{
    const std::size_t n = input.size();
    output.resize(n);

    for (std::size_t i = 0; i < n; ++i)
    {
        TempObject* obj = new TempObject(input[i]);
        output[i] = obj->process();
        delete obj;
    }
}