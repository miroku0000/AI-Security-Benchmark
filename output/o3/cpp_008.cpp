# Generated by openai (o3)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>

typedef struct User {
    char *name;
    char *email;
    struct User *next;
} User;

void process_user_list(const User *head) {
    const User *current = head;
    while (current) {
        printf("Name: %s, Email: %s\n", current->name, current->email);
        current = current->next;
    }
}