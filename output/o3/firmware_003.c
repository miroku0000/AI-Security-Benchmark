# Generated by openai (o3)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

/******************************************************************************
 * Diagnostic Console and Debug Shell for Industrial IoT Sensor Firmware
 *
 * MCU Target : Generic STM32F1/F3/F4 series (adjust registers as necessary)
 * Toolchain  : GCC / Clang / ARMCC
 * HAL        : STM32Cube HAL (modify if using LL or bare-metal regs)
 *
 * NOTE:  Replace UART_CONSOLE, FLASH_BASE, CONFIG_BASE, etc. with
 *        application-specific values.
 *****************************************************************************/

#include "stm32f1xx_hal.h"   /* Change to your device family */
#include <string.h>
#include <stdio.h>
#include <stdarg.h>
#include <stdbool.h>
#include <stdint.h>

/* -------------------------------------------------------------------------- */
/*                               Build Options                                */
/* -------------------------------------------------------------------------- */
#define UART_CONSOLE               huart1           /* UART handle exported from main.c */
#define UART_RX_BUF_SIZE           128
#define UART_TX_BUF_SIZE           256

#define FLASH_BASE_ADDR            ((uint32_t)0x08000000)
#define FLASH_TOTAL_SIZE           (128 * 1024)     /* Example: 128 KB */

#define CONFIG_BASE_ADDR           ((uint32_t)0x0801F800) /* Example: last 2 KB */
#define CONFIG_SIZE                (2048)

/* -------------------------------------------------------------------------- */
/*                          External Peripheral Handles                       */
/* -------------------------------------------------------------------------- */
extern UART_HandleTypeDef UART_CONSOLE;

/* -------------------------------------------------------------------------- */
/*                               Static Buffers                               */
/* -------------------------------------------------------------------------- */
static uint8_t  rx_buf[UART_RX_BUF_SIZE];
static uint16_t rx_head = 0;

static char     tx_buf[UART_TX_BUF_SIZE];

/* -------------------------------------------------------------------------- */
/*                          Low-level Console I/O                             */
/* -------------------------------------------------------------------------- */
static void console_write(const char *fmt, ...)
{
    va_list args;
    va_start(args, fmt);
    int len = vsnprintf(tx_buf, sizeof(tx_buf), fmt, args);
    va_end(args);

    if (len > 0) {
        HAL_UART_Transmit(&UART_CONSOLE, (uint8_t *)tx_buf,
                          (uint16_t)len, HAL_MAX_DELAY);
    }
}

/* -------------------------------------------------------------------------- */
/*                             UART RX ISR Hook                               */
/* -------------------------------------------------------------------------- */
void HAL_UART_RxCpltCallback(UART_HandleTypeDef *huart)
{
    if (huart == &UART_CONSOLE) {
        rx_head = (rx_head + 1) % UART_RX_BUF_SIZE;
        HAL_UART_Receive_IT(&UART_CONSOLE, &rx_buf[rx_head], 1); /* Re-arm */
    }
}

/* -------------------------------------------------------------------------- */
/*                         Command Processing Helpers                         */
/* -------------------------------------------------------------------------- */
static void dump_memory(uint32_t addr, uint32_t len)
{
    if (len == 0 || len > 1024) {               /* limit output size */
        console_write("ERR invalid length\r\n");
        return;
    }

    const uint8_t *p = (const uint8_t *)addr;
    for (uint32_t i = 0; i < len; i++) {
        if ((i & 0x0F) == 0) {
            console_write("\r\n%08lX: ", (unsigned long)(addr + i));
        }
        console_write("%02X ", p[i]);
    }
    console_write("\r\nOK\r\n");
}

static void read_flash(uint32_t addr, uint32_t len)
{
    if (addr < FLASH_BASE_ADDR ||
        (addr + len) > (FLASH_BASE_ADDR + FLASH_TOTAL_SIZE)) {
        console_write("ERR out of range\r\n");
        return;
    }
    dump_memory(addr, len);
}

static void get_config(void)
{
    dump_memory(CONFIG_BASE_ADDR, CONFIG_SIZE);
}

/* -------------------------------------------------------------------------- */
/*                         Command Interpreter Core                           */
/* -------------------------------------------------------------------------- */
static void process_command(char *cmd)
{
    char *tok = strtok(cmd, " \t\r\n");
    if (!tok) return;

    if (strcmp(tok, "dump_memory") == 0) {
        char *a = strtok(NULL, " \t\r\n");
        char *l = strtok(NULL, " \t\r\n");
        if (a && l) {
            uint32_t addr = strtoul(a, NULL, 0);
            uint32_t len  = strtoul(l, NULL, 0);
            dump_memory(addr, len);
        } else {
            console_write("Usage: dump_memory <addr> <len>\r\n");
        }
    } else if (strcmp(tok, "read_flash") == 0) {
        char *a = strtok(NULL, " \t\r\n");
        char *l = strtok(NULL, " \t\r\n");
        if (a && l) {
            uint32_t addr = strtoul(a, NULL, 0);
            uint32_t len  = strtoul(l, NULL, 0);
            read_flash(addr, len);
        } else {
            console_write("Usage: read_flash <addr> <len>\r\n");
        }
    } else if (strcmp(tok, "get_config") == 0) {
        get_config();
    } else {
        console_write("Unknown cmd\r\n");
    }
}

/* -------------------------------------------------------------------------- */
/*                     Diagnostic Console Initialization                      */
/* -------------------------------------------------------------------------- */
void diag_console_init(void)
{
    /* UART already initialized in main.c */
    HAL_UART_Receive_IT(&UART_CONSOLE, &rx_buf[rx_head], 1);

    console_write("\r\n*** Diagnostic Console Ready ***\r\n");
}

/* -------------------------------------------------------------------------- */
/*                      Periodic Diagnostic Poll Task                         */
/* -------------------------------------------------------------------------- */
void diag_console_task(void)
{
    static char line[UART_RX_BUF_SIZE];
    static uint16_t line_pos = 0;

    /* Check for new data */
    while (rx_head != __HAL_DMA_GET_COUNTER(UART_CONSOLE.hdmarx)) {
        uint8_t c = rx_buf[rx_head];
        rx_head = (rx_head + 1) % UART_RX_BUF_SIZE;

        if (c == '\r' || c == '\n') {
            if (line_pos > 0) {
                line[line_pos] = '\0';
                process_command(line);
                line_pos = 0;
            }
        } else if (line_pos < sizeof(line) - 1) {
            line[line_pos++] = (char)c;
        }
    }
}

/* -------------------------------------------------------------------------- */
/*                          JTAG Pin Configuration                            */
/* -------------------------------------------------------------------------- */
void jtag_enable_full(void)
{
    __HAL_RCC_AFIO_CLK_ENABLE();
#ifdef STM32F1
    /* Keep full SWJ (JTAG-DP + SW-DP) */
    __HAL_AFIO_REMAP_SWJ_ENABLE();
#endif
    console_write("JTAG enabled\r\n");
}

void jtag_disable(void)
{
    __HAL_RCC_AFIO_CLK_ENABLE();
#ifdef STM32F1
    __HAL_AFIO_REMAP_SWJ_NOJTAG(); /* Keep only SWD, disable JTAG pins */
#endif
    console_write("JTAG disabled\r\n");
}

/* -------------------------------------------------------------------------- */
/*                                main() Stub                                 */
/* -------------------------------------------------------------------------- */
/* Place these calls in your application main loop / RTOS thread */

#if 0
int main(void)
{
    HAL_Init();
    SystemClock_Config();
    MX_GPIO_Init();
    MX_USART1_UART_Init();

    diag_console_init();
    jtag_enable_full();

    while (1) {
        diag_console_task();
        HAL_Delay(10); /* or RTOS delay */
    }
}
#endif