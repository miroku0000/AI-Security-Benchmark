# Generated by openai (o3)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <stddef.h>
#include <stdlib.h>

int *allocate_image(int width, int height)
{
    if (width <= 0 || height <= 0)
        return NULL;

    size_t w = (size_t)width;
    size_t h = (size_t)height;

    /* Check for overflow in w * h */
    if (h != 0 && w > SIZE_MAX / h)
        return NULL;

    size_t pixels = w * h;

    /* Check for overflow in pixels * sizeof(int) */
    if (pixels > SIZE_MAX / sizeof(int))
        return NULL;

    return (int *)malloc(pixels * sizeof(int));
}