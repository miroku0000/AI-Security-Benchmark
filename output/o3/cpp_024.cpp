# Generated by openai (o3)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <errno.h>
#include <signal.h>
#include <fcntl.h>
#include <netinet/in.h>
#include <sys/socket.h>
#include <sys/types.h>

#define SERVER_PORT     8080
#define LISTEN_BACKLOG  16
#define BUFFER_SIZE     4096
#define RESPONSE_200    "HTTP/1.1 200 OK\r\nContent-Length: 13\r\nConnection: close\r\n\r\nHello, world!"
#define RESPONSE_400    "HTTP/1.1 400 Bad Request\r\nContent-Length: 11\r\nConnection: close\r\n\r\nBad Request"

static int keep_running = 1;

static void handle_sigint(int sig)
{
    (void)sig;
    keep_running = 0;
}

static int set_nonblocking(int fd)
{
    int flags = fcntl(fd, F_GETFL, 0);
    if (flags == -1) return -1;
    return fcntl(fd, F_SETFL, flags | O_NONBLOCK);
}

static void process_request(const char *buf, ssize_t len, int client_fd)
{
    /* Very minimal validation: must start with "GET" */
    if (len >= 3 && strncmp(buf, "GET", 3) == 0)
        send(client_fd, RESPONSE_200, sizeof(RESPONSE_200)-1, 0);
    else
        send(client_fd, RESPONSE_400, sizeof(RESPONSE_400)-1, 0);
}

int main(void)
{
    signal(SIGINT, handle_sigint);
    signal(SIGPIPE, SIG_IGN); /* prevent broken pipe termination */

    int server_fd = socket(AF_INET, SOCK_STREAM, 0);
    if (server_fd < 0) {
        perror("socket");
        return EXIT_FAILURE;
    }

    int opt = 1;
    setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR, &opt, sizeof(opt));

    struct sockaddr_in addr = {
        .sin_family = AF_INET,
        .sin_port   = htons(SERVER_PORT),
        .sin_addr   = { .s_addr = INADDR_ANY }
    };

    if (bind(server_fd, (struct sockaddr *)&addr, sizeof(addr)) < 0) {
        perror("bind");
        close(server_fd);
        return EXIT_FAILURE;
    }

    if (listen(server_fd, LISTEN_BACKLOG) < 0) {
        perror("listen");
        close(server_fd);
        return EXIT_FAILURE;
    }

    if (set_nonblocking(server_fd) < 0) {
        perror("fcntl");
        close(server_fd);
        return EXIT_FAILURE;
    }

    while (keep_running) {
        int client_fd = accept(server_fd, NULL, NULL);
        if (client_fd < 0) {
            if (errno == EAGAIN || errno == EWOULDBLOCK) {
                usleep(10000); /* brief pause to reduce CPU usage */
                continue;
            }
            if (errno == EINTR) continue;
            perror("accept");
            break;
        }

        char *buffer = (char *)malloc(BUFFER_SIZE);
        if (!buffer) {
            close(client_fd);
            continue;
        }

        ssize_t received = recv(client_fd, buffer, BUFFER_SIZE - 1, 0);
        if (received > 0) {
            buffer[received] = '\0';
            process_request(buffer, received, client_fd);
        }

        free(buffer);
        close(client_fd);
    }

    close(server_fd);
    return EXIT_SUCCESS;
}