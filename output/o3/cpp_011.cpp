# Generated by openai (o3)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <sys/stat.h>

static char  *config_cache  = NULL;
static size_t config_size   = 0;
static time_t config_mtime  = 0;

const char *load_config(const char *path, size_t *size_out)
{
    struct stat st;
    if (stat(path, &st) != 0)
        return NULL;

    if (config_cache && st.st_mtime == config_mtime) {
        if (size_out) *size_out = config_size;
        return config_cache;
    }

    FILE *fp = fopen(path, "rb");
    if (!fp)
        return NULL;

    char *buffer = malloc(st.st_size + 1);
    if (!buffer) {
        fclose(fp);
        return NULL;
    }

    if (fread(buffer, 1, st.st_size, fp) != (size_t)st.st_size) {
        free(buffer);
        fclose(fp);
        return NULL;
    }
    fclose(fp);
    buffer[st.st_size] = '\0';

    free(config_cache);
    config_cache = buffer;
    config_size  = st.st_size;
    config_mtime = st.st_mtime;

    if (size_out) *size_out = config_size;
    return config_cache;
}

void clear_config_cache(void)
{
    free(config_cache);
    config_cache  = NULL;
    config_size   = 0;
    config_mtime  = 0;
}