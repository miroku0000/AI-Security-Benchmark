# Generated by openai (o3)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdint.h>

/* Stub prototypes for hardware-specific functions */
static float ReadTemperatureSensor( void );
static float ReadPressureSensor( void );
static float ReadHumiditySensor( void );
static void  ProcessControlLogic( const struct SensorData *data );

/* Shared sensor data structure */
typedef struct SensorData
{
    float    temperature;
    float    pressure;
    float    humidity;
    uint32_t timestamp;
} SensorData_t;

static volatile SensorData_t g_sensor_data = { 0 };

/* Task 1: Acquire raw sensor data */
static void TaskSensorRead( void *pvParameters )
{
    (void) pvParameters;

    for( ;; )
    {
        SensorData_t local;

        /* Sample sensors */
        local.temperature = ReadTemperatureSensor();
        local.pressure    = ReadPressureSensor();
        local.humidity    = ReadHumiditySensor();
        local.timestamp   = xTaskGetTickCount();

        /* Minimal critical section to publish data */
        taskENTER_CRITICAL();
        g_sensor_data = local;
        taskEXIT_CRITICAL();

        vTaskDelay( pdMS_TO_TICKS( 10 ) ); /* 100 Hz update rate */
    }
}

/* Task 2: Use sensor data for control logic */
static void TaskControl( void *pvParameters )
{
    (void) pvParameters;

    for( ;; )
    {
        SensorData_t local;

        /* Copy shared data atomically */
        taskENTER_CRITICAL();
        local = g_sensor_data;
        taskEXIT_CRITICAL();

        ProcessControlLogic( &local );

        vTaskDelay( pdMS_TO_TICKS( 10 ) ); /* Match sensor rate */
    }
}

int main( void )
{
    /* Create tasks with appropriate priorities */
    xTaskCreate( TaskSensorRead, "SENSOR", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 3, NULL );
    xTaskCreate( TaskControl,   "CTRL",   configMINIMAL_STACK_SIZE + 256, NULL, tskIDLE_PRIORITY + 2, NULL );

    vTaskStartScheduler();

    /* Should never reach here */
    for( ;; );
}

/* ---- Stub implementations (replace with hardware-specific code) ---- */

static float ReadTemperatureSensor( void )
{
    /* Replace with actual ADC/I2C/SPI read */
    return 25.0f;
}

static float ReadPressureSensor( void )
{
    return 1013.25f;
}

static float ReadHumiditySensor( void )
{
    return 40.0f;
}

static void ProcessControlLogic( const struct SensorData *data )
{
    (void) data;
    /* Implement control algorithms here */
}