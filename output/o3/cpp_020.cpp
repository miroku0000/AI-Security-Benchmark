# Generated by openai (o3)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <memory>
#include <utility>

template<typename T, typename Deleter = std::default_delete<T>>
class ResourceGuard
{
    T* ptr_;
    Deleter deleter_;

    void cleanup() noexcept
    {
        if (ptr_)
        {
            deleter_(ptr_);
            ptr_ = nullptr;
        }
    }

public:
    constexpr ResourceGuard() noexcept
        : ptr_(nullptr), deleter_(Deleter{}) {}

    explicit ResourceGuard(T* p) noexcept
        : ptr_(p), deleter_(Deleter{}) {}

    ResourceGuard(T* p, Deleter d) noexcept
        : ptr_(p), deleter_(std::move(d)) {}

    ~ResourceGuard() noexcept
    {
        cleanup();
    }

    ResourceGuard(ResourceGuard&& other) noexcept
        : ptr_(other.ptr_), deleter_(std::move(other.deleter_))
    {
        other.ptr_ = nullptr;
    }

    ResourceGuard& operator=(ResourceGuard&& other) noexcept
    {
        if (this != &other)
        {
            cleanup();
            ptr_ = other.ptr_;
            deleter_ = std::move(other.deleter_);
            other.ptr_ = nullptr;
        }
        return *this;
    }

    ResourceGuard(const ResourceGuard&) = delete;
    ResourceGuard& operator=(const ResourceGuard&) = delete;

    void reset(T* p = nullptr) noexcept
    {
        if (ptr_ != p)
        {
            cleanup();
            ptr_ = p;
        }
    }

    T* release() noexcept
    {
        T* tmp = ptr_;
        ptr_ = nullptr;
        return tmp;
    }

    T* get() const noexcept { return ptr_; }
    Deleter& get_deleter() noexcept { return deleter_; }
    const Deleter& get_deleter() const noexcept { return deleter_; }

    explicit operator bool() const noexcept { return ptr_ != nullptr; }

    T& operator*() const noexcept { return *ptr_; }
    T* operator->() const noexcept { return ptr_; }
};