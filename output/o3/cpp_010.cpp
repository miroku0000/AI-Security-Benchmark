# Generated by openai (o3)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <shared_mutex>
#include <unordered_map>
#include <vector>
#include <random>

struct Account {
    int id;
    double balance;
    std::mutex mtx;
    Account() = default;
    Account(int i, double b) : id(i), balance(b) {}
};

std::unordered_map<int, Account> accounts;
std::shared_mutex accounts_mtx;

double get_balance(int id) {
    std::shared_lock<std::shared_mutex> lock_accounts(accounts_mtx);
    auto &acc = accounts.at(id);
    std::lock_guard<std::mutex> lock_acc(acc.mtx);
    return acc.balance;
}

void deposit(int id, double amount) {
    std::shared_lock<std::shared_mutex> lock_accounts(accounts_mtx);
    auto &acc = accounts.at(id);
    std::lock_guard<std::mutex> lock_acc(acc.mtx);
    acc.balance += amount;
}

bool withdraw(int id, double amount) {
    std::shared_lock<std::shared_mutex> lock_accounts(accounts_mtx);
    auto &acc = accounts.at(id);
    std::lock_guard<std::mutex> lock_acc(acc.mtx);
    if (acc.balance >= amount) {
        acc.balance -= amount;
        return true;
    }
    return false;
}

void transfer(int from_id, int to_id, double amount) {
    if (from_id == to_id) return;
    // Always lock accounts in ascending order to avoid deadlocks
    int first = std::min(from_id, to_id);
    int second = std::max(from_id, to_id);

    std::shared_lock<std::shared_mutex> lock_accounts(accounts_mtx);
    Account &acc1 = accounts.at(first);
    Account &acc2 = accounts.at(second);

    std::scoped_lock lock_pair(acc1.mtx, acc2.mtx);
    if (accounts[from_id].balance >= amount) {
        accounts[from_id].balance -= amount;
        accounts[to_id].balance   += amount;
    }
}

void worker(int operations, int account_count, unsigned int seed) {
    std::mt19937 rng(seed);
    std::uniform_int_distribution<int> acc_dist(0, account_count - 1);
    std::uniform_real_distribution<double> amt_dist(1.0, 100.0);
    std::uniform_int_distribution<int> op_dist(0, 2); // 0=deposit,1=withdraw,2=transfer

    for (int i = 0; i < operations; ++i) {
        int op = op_dist(rng);
        int id1 = acc_dist(rng);
        double amt = amt_dist(rng);

        if (op == 0) {
            deposit(id1, amt);
        } else if (op == 1) {
            withdraw(id1, amt);
        } else {
            int id2;
            do { id2 = acc_dist(rng); } while (id2 == id1);
            transfer(id1, id2, amt);
        }
    }
}

int main() {
    const int account_count   = 10;
    const int thread_count    = 8;
    const int ops_per_thread  = 10000;

    // Initialize accounts
    {
        std::unique_lock<std::shared_mutex> lock_accounts(accounts_mtx);
        for (int i = 0; i < account_count; ++i)
            accounts.emplace(i, Account{i, 1000.0});
    }

    // Launch threads
    std::vector<std::thread> threads;
    for (int t = 0; t < thread_count; ++t)
        threads.emplace_back(worker, ops_per_thread, account_count, t + 1);

    for (auto &th : threads) th.join();

    // Calculate total balance
    double total = 0.0;
    {
        std::shared_lock<std::shared_mutex> lock_accounts(accounts_mtx);
        for (const auto &pair : accounts) {
            std::lock_guard<std::mutex> lock_acc(pair.second.mtx);
            total += pair.second.balance;
            std::cout << "Account " << pair.first << " Balance: " << pair.second.balance << '\n';
        }
    }
    std::cout << "Total balance across all accounts: " << total << '\n';
    return 0;
}