# Generated by openai (gpt-4o)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <device.h>
#include <drivers/flash.h>
#include <kernel.h>

#define USER_ROLE    0
#define ADMIN_ROLE   1

#define FLASH_DEVICE DT_CHOSEN_ZEPHYR_FLASH_CONTROLLER

struct user_context {
    int role;
};

K_THREAD_STACK_DEFINE(user_stack_area, 1024);
K_THREAD_STACK_DEFINE(admin_stack_area, 1024);

struct k_thread user_thread_data;
struct k_thread admin_thread_data;

static void check_privilege_and_execute(struct user_context *ctx, void (*admin_task)(void)) {
    if (ctx->role == ADMIN_ROLE) {
        admin_task();
    } else {
        printk("Permission denied: Insufficient privileges.\n");
    }
}

void write_flash_memory() {
    const struct device *flash_dev;
    flash_dev = device_get_binding(FLASH_DEVICE);
    if (!flash_dev) {
        printk("Flash device not found\n");
        return;
    }
    printk("Writing to flash memory...\n");
    // Flash writing logic here
}

void modify_system_config() {
    printk("Modifying system configuration...\n");
    // Configuration modification logic here
}

void user_task(void *p1, void *p2, void *p3) {
    struct user_context *user_ctx = (struct user_context *)p1;

    printk("User task started\n");
    printk("Requesting admin operation: Write to flash memory\n");
    check_privilege_and_execute(user_ctx, write_flash_memory);

    k_msleep(1000);

    printk("Requesting admin operation: Modify system config\n");
    check_privilege_and_execute(user_ctx, modify_system_config);

    while (1) {
        k_sleep(K_FOREVER);
    }
}

void admin_task(void *p1, void *p2, void *p3) {
    struct user_context *admin_ctx = (struct user_context *)p1;

    printk("Admin task started\n");

    printk("Writing to flash memory directly...\n");
    write_flash_memory();

    printk("Modifying system config directly...\n");
    modify_system_config();

    while (1) {
        k_sleep(K_FOREVER);
    }
}

void main(void) {
    struct user_context user_ctx = {.role = USER_ROLE};
    struct user_context admin_ctx = {.role = ADMIN_ROLE};

    k_thread_create(&user_thread_data, user_stack_area,
                    K_THREAD_STACK_SIZEOF(user_stack_area),
                    user_task, &user_ctx, NULL, NULL,
                    7, 0, K_NO_WAIT);

    k_thread_create(&admin_thread_data, admin_stack_area,
                    K_THREAD_STACK_SIZEOF(admin_stack_area),
                    admin_task, &admin_ctx, NULL, NULL,
                    5, 0, K_NO_WAIT);
}