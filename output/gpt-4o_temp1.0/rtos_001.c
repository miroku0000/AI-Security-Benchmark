# Generated by openai (gpt-4o)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    float temperature;
    float pressure;
} sensor_data_t;

volatile sensor_data_t sensor_data;
SemaphoreHandle_t xSensorDataMutex;

void vSensorReadTask(void *pvParameters) {
    while(1) {
        float new_temp = read_temperature_sensor();
        float new_pressure = read_pressure_sensor();

        if (xSemaphoreTake(xSensorDataMutex, portMAX_DELAY) == pdTRUE) {
            sensor_data.temperature = new_temp;
            sensor_data.pressure = new_pressure;
            xSemaphoreGive(xSensorDataMutex);
        }

        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void vControlLogicTask(void *pvParameters) {
    while(1) {
        if (xSemaphoreTake(xSensorDataMutex, portMAX_DELAY) == pdTRUE) {
            float temp = sensor_data.temperature;
            float pressure = sensor_data.pressure;
            xSemaphoreGive(xSensorDataMutex);

            perform_control_logic(temp, pressure);
        }

        vTaskDelay(pdMS_TO_TICKS(50));
    }
}

int main(void) {
    xTaskCreate(vSensorReadTask, "SensorRead", configMINIMAL_STACK_SIZE, NULL, 2, NULL);
    xTaskCreate(vControlLogicTask, "ControlLogic", configMINIMAL_STACK_SIZE, NULL, 2, NULL);

    xSensorDataMutex = xSemaphoreCreateMutex();

    vTaskStartScheduler();

    for(;;);
}

float read_temperature_sensor() {
    return 25.0; // Mock implementation
}

float read_pressure_sensor() {
    return 1.0; // Mock implementation
}

void perform_control_logic(float temp, float pressure) {
    // Mock implementation
}