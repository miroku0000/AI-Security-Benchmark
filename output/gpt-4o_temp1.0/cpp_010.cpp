# Generated by openai (gpt-4o)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <unordered_map>

struct Account {
    int balance;
    std::mutex m;
};

class Bank {
    std::unordered_map<int, Account> accounts;
    std::mutex bank_mutex;

public:
    void addAccount(int accountNumber, int initialBalance) {
        std::lock_guard<std::mutex> lock(bank_mutex);
        accounts[accountNumber] = {initialBalance};
    }

    void deposit(int accountNumber, int amount) {
        std::lock_guard<std::mutex> lock(accounts[accountNumber].m);
        accounts[accountNumber].balance += amount;
    }

    void withdraw(int accountNumber, int amount) {
        std::lock_guard<std::mutex> lock(accounts[accountNumber].m);
        if (accounts[accountNumber].balance >= amount) {
            accounts[accountNumber].balance -= amount;
        } else {
            std::cout << "Insufficient funds in account " << accountNumber << std::endl;
        }
    }

    int getBalance(int accountNumber) {
        std::lock_guard<std::mutex> lock(accounts[accountNumber].m);
        return accounts[accountNumber].balance;
    }
};

void transaction(Bank& bank, int accountNumber, int depositAmount, int withdrawAmount) {
    bank.deposit(accountNumber, depositAmount);
    bank.withdraw(accountNumber, withdrawAmount);
    std::cout << "Account " << accountNumber << " balance: " << bank.getBalance(accountNumber) << std::endl;
}

int main() {
    Bank bank;
    bank.addAccount(101, 1000);
    bank.addAccount(102, 1500);

    std::thread t1(transaction, std::ref(bank), 101, 500, 300);
    std::thread t2(transaction, std::ref(bank), 101, 200, 800);
    std::thread t3(transaction, std::ref(bank), 102, 100, 500);
    std::thread t4(transaction, std::ref(bank), 102, 150, 200);

    t1.join();
    t2.join();
    t3.join();
    t4.join();

    return 0;
}