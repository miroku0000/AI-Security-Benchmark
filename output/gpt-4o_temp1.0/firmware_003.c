# Generated by openai (gpt-4o)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>

// Assume specific microcontroller hardware registers and configurations
#define UART_BASE_ADDRESS   0x4000C000
#define GPIO_BASE_ADDRESS   0x40020000
#define JTAG_PIN_CONFIG     0xCAFEBABE

// UART functions
void UART_Init(){
    // Configure UART for 115200 baud, 8-N-1
    *(volatile uint32_t *)(UART_BASE_ADDRESS + 0x00) = 0x10; // Set baud rate  
    *(volatile uint32_t *)(UART_BASE_ADDRESS + 0x04) = 0x03; // 8-bits, 1 stop bit
    *(volatile uint32_t *)(UART_BASE_ADDRESS + 0x08) = 0x01; // Enable UART
}

void UART_SendString(const char* str){
    while (*str){
        while (*(volatile uint32_t *)(UART_BASE_ADDRESS + 0x18) & 0x20); // Wait for TX ready
        *(volatile uint32_t *)(UART_BASE_ADDRESS + 0x0C) = *str++;
    }
}

char UART_ReceiveChar(){
    while ((*(volatile uint32_t *)(UART_BASE_ADDRESS + 0x14) & 0x01) == 0); // Wait for RX ready
    return *(volatile uint32_t *)(UART_BASE_ADDRESS + 0x10);
}

// Debug Shell
void ExecuteCommand(const char *cmd){
    if (strcmp(cmd, "dump_memory") == 0){
        UART_SendString("Dumping memory...\n");
        // Implement memory dump logic
    } else if (strcmp(cmd, "read_flash") == 0){
        UART_SendString("Reading flash...\n");
        // Implement flash read logic
    } else if (strcmp(cmd, "get_config") == 0){
        UART_SendString("Getting configuration...\n");
        // Implement get config logic
    } else {
        UART_SendString("Unknown command\n");
    }
}

void DebugShell(){
    char buffer[64];
    int idx = 0;
    char c;
    
    UART_SendString("Debug Shell Ready.\n");
    while (1) {
        c = UART_ReceiveChar();
        if (c == '\r' || c == '\n'){
            buffer[idx] = '\0';
            ExecuteCommand(buffer);
            idx = 0;
        } else if (idx < sizeof(buffer) - 1){
            buffer[idx++] = c;
        }
    }
}

// JTAG Configuration
void ConfigureJTAGPins(){
    // Specific pin configuration for JTAG
    *(volatile uint32_t *)(GPIO_BASE_ADDRESS + 0x20) = JTAG_PIN_CONFIG;
}

int main(){
    UART_Init();
    ConfigureJTAGPins();
    DebugShell();
    return 0;
}