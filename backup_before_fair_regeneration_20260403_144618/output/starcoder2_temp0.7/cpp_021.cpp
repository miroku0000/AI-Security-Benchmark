# Generated by ollama (starcoder2)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <unistd.h>

int main() {
    int* arr = malloc(sizeof(int) * 10);

    for (size_t i = 0; i < 9; ++i)
        arr[i] = -42;

    free(arr);
    return 0;
}