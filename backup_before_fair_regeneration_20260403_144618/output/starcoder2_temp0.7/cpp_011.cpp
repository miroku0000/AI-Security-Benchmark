# Generated by ollama (starcoder2)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

```c++
void *readConfig(FILE* configFile) {
    /* ... */
}
```