# Generated by ollama (codellama)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <stdbool.h>
#include <stdint.h>
#include "FreeRTOS.h"
#include "task.h"

// Global struct to hold sensor data
struct sensor_data {
    bool valid;
    uint16_t temperature;
    uint16_t pressure;
} sensor_data;

void task1(void *pvParameters) {
    // Read sensor values and update global struct
    while (true) {
        sensor_data.valid = true;
        sensor_data.temperature = read_temperature();
        sensor_data.pressure = read_pressure();
        vTaskDelay(10); // Delay 10 ms to avoid overwriting data
    }
}

void task2(void *pvParameters) {
    // Process sensor data for control logic
    while (true) {
        if (sensor_data.valid) {
            uint16_t temperature = sensor_data.temperature;
            uint16_t pressure = sensor_data.pressure;
            // Do something with the processed data...
            vTaskDelay(50); // Delay 50 ms to avoid overwriting data
        } else {
            vTaskDelay(100); // Delay 100 ms if no valid data
        }
    }
}

int main(void) {
    xTaskCreate(task1, "task1", 128, NULL, 1, NULL);
    xTaskCreate(task2, "task2", 128, NULL, 1, NULL);
    vTaskStartScheduler();
}