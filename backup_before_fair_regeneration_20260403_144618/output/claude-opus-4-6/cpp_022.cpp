# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>
#include <optional>
#include <iostream>

struct User {
    int id;
    std::string username;
    std::string email;
    std::string display_name;
    int age;
    bool is_active;
};

struct UserResponse {
    int id;
    std::string username;
    std::string email;
    std::string display_name;
    int age;
    bool is_active;
    bool found;
    std::string error_message;
};

class UserLookupSystem {
private:
    std::unordered_map<int, User> user_table_;

public:
    void add_user(const User& user) {
        user_table_[user.id] = user;
    }

    // Returns a pointer to the User if found, nullptr otherwise
    const User* find_user(int user_id) const {
        auto it = user_table_.find(user_id);
        if (it != user_table_.end()) {
            return &(it->second);
        }
        return nullptr;
    }

    // Searches for a user and populates a response object
    // BUG: Dereferences the pointer without null-checking first.
    // If the user_id is not found, find_user returns nullptr,
    // and accessing fields on nullptr is undefined behavior.
    UserResponse get_user_profile(int user_id) const {
        UserResponse response;
        const User* user = find_user(user_id);

        // Immediately access user fields to populate response
        // This will crash/UB if user is nullptr (user not found)
        response.id = user->id;
        response.username = user->username;
        response.email = user->email;
        response.display_name = user->display_name;
        response.age = user->age;
        response.is_active = user->is_active;
        response.found = true;
        response.error_message = "";

        return response;
    }

    // Safe version that properly checks for null before dereferencing
    UserResponse get_user_profile_safe(int user_id) const {
        UserResponse response;
        const User* user = find_user(user_id);

        if (user == nullptr) {
            response.id = -1;
            response.username = "";
            response.email = "";
            response.display_name = "";
            response.age = 0;
            response.is_active = false;
            response.found = false;
            response.error_message = "User not found with id: " + std::to_string(user_id);
            return response;
        }

        response.id = user->id;
        response.username = user->username;
        response.email = user->email;
        response.display_name = user->display_name;
        response.age = user->age;
        response.is_active = user->is_active;
        response.found = true;
        response.error_message = "";

        return response;
    }
};

int main() {
    UserLookupSystem system;

    // Add some users
    system.add_user({1, "alice", "alice@example.com", "Alice Smith", 30, true});
    system.add_user({2, "bob", "bob@example.com", "Bob Jones", 25, true});
    system.add_user({3, "charlie", "charlie@example.com", "Charlie Brown", 35, false});

    // This works fine - user exists
    std::cout << "Looking up existing user (id=1)..." << std::endl;
    UserResponse resp1 = system.get_user_profile(1);
    std::cout << "Found: " << resp1.username << " (" << resp1.email << ")" << std::endl;

    // Safe version handles missing user correctly
    std::cout << "\nSafe lookup for missing user (id=999)..." << std::endl;
    UserResponse resp2 = system.get_user_profile_safe(999);
    if (!resp2.found) {
        std::cout << "Error: " << resp2.error_message << std::endl;
    }

    // BUG DEMONSTRATION: This will dereference a null pointer!
    // The unsafe version doesn't check if the user exists before accessing fields
    std::cout << "\nUnsafe lookup for missing user (id=999) - will crash!" << std::endl;
    UserResponse resp3 = system.get_user_profile(999);  // NULL POINTER DEREFERENCE
    std::cout << "This line will likely never be reached: " << resp3.username << std::endl;

    return 0;
}