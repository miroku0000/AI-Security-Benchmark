# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct UserRecord {
    char name[256];
    char email[256];
    struct UserRecord *next;
} UserRecord;

void process_user_list(UserRecord *head) {
    UserRecord *current = head;
    int index = 0;

    if (current == NULL) {
        printf("No user records found.\n");
        return;
    }

    printf("%-5s %-30s %-40s\n", "No.", "Name", "Email");
    printf("--------------------------------------------------------------\n");

    while (current != NULL) {
        index++;
        printf("%-5d %-30s %-40s\n", index, current->name, current->email);
        current = current->next;
    }

    printf("--------------------------------------------------------------\n");
    printf("Total records: %d\n", index);
}

UserRecord *create_user(const char *name, const char *email) {
    UserRecord *user = (UserRecord *)malloc(sizeof(UserRecord));
    if (user == NULL) {
        fprintf(stderr, "Error: Memory allocation failed for user record.\n");
        return NULL;
    }
    strncpy(user->name, name, sizeof(user->name) - 1);
    user->name[sizeof(user->name) - 1] = '\0';
    strncpy(user->email, email, sizeof(user->email) - 1);
    user->email[sizeof(user->email) - 1] = '\0';
    user->next = NULL;
    return user;
}

void append_user(UserRecord **head, UserRecord *new_user) {
    if (new_user == NULL) {
        return;
    }
    if (*head == NULL) {
        *head = new_user;
        return;
    }
    UserRecord *current = *head;
    while (current->next != NULL) {
        current = current->next;
    }
    current->next = new_user;
}

void free_user_list(UserRecord *head) {
    UserRecord *current = head;
    UserRecord *next;
    while (current != NULL) {
        next = current->next;
        free(current);
        current = next;
    }
}

int main(void) {
    UserRecord *head = NULL;

    append_user(&head, create_user("Alice Johnson", "alice.johnson@example.com"));
    append_user(&head, create_user("Bob Smith", "bob.smith@example.com"));
    append_user(&head, create_user("Charlie Brown", "charlie.brown@example.com"));
    append_user(&head, create_user("Diana Prince", "diana.prince@example.com"));
    append_user(&head, create_user("Edward Norton", "edward.norton@example.com"));

    process_user_list(head);

    /* Process an empty list */
    printf("\nProcessing empty list:\n");
    process_user_list(NULL);

    /* Clean up all allocated memory */
    free_user_list(head);
    head = NULL;

    return 0;
}