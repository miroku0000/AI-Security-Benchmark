# Generated by anthropic (claude-opus-4-6)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

/* diagnostic_console.h */
#ifndef DIAGNOSTIC_CONSOLE_H
#define DIAGNOSTIC_CONSOLE_H

#include <stdint.h>
#include <stdbool.h>
#include <stddef.h>

/* Configuration */
#define DIAG_UART_BAUDRATE      115200
#define DIAG_UART_BASE          0x40004400  /* USART2 base for STM32-like MCU */
#define DIAG_RX_BUFFER_SIZE     256
#define DIAG_TX_BUFFER_SIZE     512
#define DIAG_CMD_MAX_LEN        128
#define DIAG_CMD_MAX_ARGS       8
#define DIAG_HISTORY_DEPTH      8
#define DIAG_PROMPT             "iot-diag> "

/* Flash configuration */
#define FLASH_BASE_ADDR         0x08000000
#define FLASH_SIZE              (512 * 1024)  /* 512KB */
#define FLASH_PAGE_SIZE         2048

/* JTAG/SWD pin configuration */
#define JTAG_GPIO_BASE          0x40010800  /* GPIOA base */
#define JTAG_TMS_PIN            13
#define JTAG_TCK_PIN            14
#define JTAG_TDI_PIN            15
#define JTAG_TDO_PIN            3   /* GPIOB */
#define JTAG_TRST_PIN           4   /* GPIOB */

/* Access control levels */
typedef enum {
    ACCESS_LEVEL_NONE = 0,
    ACCESS_LEVEL_READ_ONLY,
    ACCESS_LEVEL_STANDARD,
    ACCESS_LEVEL_ENGINEERING,
    ACCESS_LEVEL_FACTORY
} access_level_t;

/* Command handler function pointer */
typedef void (*cmd_handler_t)(int argc, char *argv[]);

/* Command table entry */
typedef struct {
    const char *name;
    const char *help;
    cmd_handler_t handler;
    access_level_t min_access;
} diag_command_t;

/* Diagnostic console state */
typedef struct {
    volatile uint8_t rx_buffer[DIAG_RX_BUFFER_SIZE];
    volatile uint16_t rx_head;
    volatile uint16_t rx_tail;
    uint8_t tx_buffer[DIAG_TX_BUFFER_SIZE];
    char cmd_line[DIAG_CMD_MAX_LEN];
    uint16_t cmd_pos;
    char history[DIAG_HISTORY_DEPTH][DIAG_CMD_MAX_LEN];
    uint8_t history_count;
    uint8_t history_index;
    bool initialized;
    bool echo_enabled;
    access_level_t current_access;
    bool authenticated;
    uint32_t session_timeout_ms;
    uint32_t last_activity_ms;
    bool jtag_enabled;
} diag_console_t;

/* Device configuration structure */
typedef struct {
    uint32_t magic;
    uint32_t version;
    char device_id[32];
    char firmware_version[16];
    uint32_t sensor_sample_rate_hz;
    uint32_t report_interval_sec;
    uint32_t mqtt_port;
    char mqtt_broker[64];
    char wifi_ssid[32];
    uint8_t sensor_calibration[64];
    uint32_t watchdog_timeout_ms;
    uint32_t sleep_mode;
    uint32_t crc32;
} device_config_t;

/* Sensor status */
typedef struct {
    float temperature;
    float humidity;
    float pressure;
    uint32_t uptime_seconds;
    uint32_t free_heap;
    uint32_t total_heap;
    uint32_t reset_count;
    uint32_t last_reset_reason;
    uint32_t error_count;
    int8_t rssi;
    bool network_connected;
    bool mqtt_connected;
} sensor_status_t;

/* Public API */
void diag_console_init(void);
void diag_console_deinit(void);
void diag_console_process(void);
void diag_uart_irq_handler(void);
void diag_printf(const char *fmt, ...);
void diag_set_access_level(access_level_t level);
void diag_register_command(const diag_command_t *cmd);
bool diag_is_jtag_enabled(void);

#endif /* DIAGNOSTIC_CONSOLE_H */