# Generated by anthropic (claude-opus-4-6)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdio.h>
#include <string.h>

typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    float vibration;
    uint32_t timestamp;
    uint8_t sensor_status;
    uint8_t data_ready;
} SensorData_t;

volatile SensorData_t sensor_data = {0};

SemaphoreHandle_t xSensorMutex;

TaskHandle_t xSensorReadTaskHandle = NULL;
TaskHandle_t xControlLogicTaskHandle = NULL;

/* Simulated hardware sensor read functions */
static float read_temperature_sensor(void)
{
    /* Replace with actual hardware register read */
    static float temp = 25.0f;
    temp += 0.1f;
    if (temp > 100.0f) temp = 25.0f;
    return temp;
}

static float read_pressure_sensor(void)
{
    static float pressure = 101.3f;
    pressure += 0.05f;
    if (pressure > 200.0f) pressure = 101.3f;
    return pressure;
}

static float read_flow_rate_sensor(void)
{
    static float flow = 50.0f;
    flow += 0.2f;
    if (flow > 150.0f) flow = 50.0f;
    return flow;
}

static float read_vibration_sensor(void)
{
    static float vib = 0.0f;
    vib += 0.01f;
    if (vib > 10.0f) vib = 0.0f;
    return vib;
}

static uint8_t check_sensor_health(void)
{
    /* 0xFF = all sensors OK, individual bits represent each sensor */
    return 0xFF;
}

/* Task 1: Sensor Reading Task - Higher priority for real-time acquisition */
void vSensorReadTask(void *pvParameters)
{
    TickType_t xLastWakeTime;
    const TickType_t xReadPeriod = pdMS_TO_TICKS(10); /* 10ms sampling period */

    float temp_local;
    float pressure_local;
    float flow_local;
    float vibration_local;
    uint8_t status_local;
    uint32_t timestamp_local;

    xLastWakeTime = xTaskGetTickCount();

    for (;;)
    {
        /* Read all sensors into local variables first to minimize mutex hold time */
        temp_local = read_temperature_sensor();
        pressure_local = read_pressure_sensor();
        flow_local = read_flow_rate_sensor();
        vibration_local = read_vibration_sensor();
        status_local = check_sensor_health();
        timestamp_local = (uint32_t)xTaskGetTickCount();

        /* Acquire mutex with a bounded timeout to avoid indefinite blocking */
        if (xSemaphoreTake(xSensorMutex, pdMS_TO_TICKS(5)) == pdTRUE)
        {
            sensor_data.temperature = temp_local;
            sensor_data.pressure = pressure_local;
            sensor_data.flow_rate = flow_local;
            sensor_data.vibration = vibration_local;
            sensor_data.sensor_status = status_local;
            sensor_data.timestamp = timestamp_local;

            /* Memory barrier to ensure all writes are visible before setting flag */
            __asm volatile ("dmb" ::: "memory");

            sensor_data.data_ready = 1;

            xSemaphoreGive(xSensorMutex);

            /* Notify control task that new data is available */
            xTaskNotifyGive(xControlLogicTaskHandle);
        }
        else
        {
            /* Mutex timeout - log error for diagnostics */
            printf("[SENSOR] WARNING: Mutex acquisition timeout at tick %lu\n",
                   (unsigned long)xTaskGetTickCount());
        }

        /* Use vTaskDelayUntil for deterministic timing */
        vTaskDelayUntil(&xLastWakeTime, xReadPeriod);
    }
}

/* Control output action functions */
static void activate_cooling_system(float temperature)
{
    printf("[CONTROL] Activating cooling system - Temp: %.2f C\n", temperature);
}

static void deactivate_cooling_system(void)
{
    printf("[CONTROL] Deactivating cooling system\n");
}

static void trigger_pressure_relief_valve(float pressure)
{
    printf("[CONTROL] Opening pressure relief valve - Pressure: %.2f kPa\n", pressure);
}

static void close_pressure_relief_valve(void)
{
    printf("[CONTROL] Closing pressure relief valve\n");
}

static void adjust_flow_control_valve(float flow_rate)
{
    printf("[CONTROL] Adjusting flow control valve - Flow: %.2f L/min\n", flow_rate);
}

static void trigger_vibration_alarm(float vibration)
{
    printf("[CONTROL] ALARM: Excessive vibration detected - Level: %.2f mm/s\n", vibration);
}

static void trigger_emergency_shutdown(uint8_t reason)
{
    printf("[CONTROL] EMERGENCY SHUTDOWN initiated - Reason code: 0x%02X\n", reason);
}

static void report_sensor_failure(uint8_t status)
{
    printf("[CONTROL] SENSOR FAILURE detected - Status: 0x%02X\n", status);
}

/* Task 2: Control Logic Task - Processes sensor data and executes control actions */
void vControlLogicTask(void *pvParameters)
{
    SensorData_t local_copy;
    uint32_t notification_value;

    /* Control thresholds */
    const float TEMP_HIGH_THRESHOLD = 80.0f;
    const float TEMP_LOW_THRESHOLD = 70.0f;
    const float PRESSURE_HIGH_THRESHOLD = 180.0f;
    const float PRESSURE_LOW_THRESHOLD = 160.0f;
    const float FLOW_MIN_THRESHOLD = 30.0f;
    const float FLOW_MAX_THRESHOLD = 120.0f;
    const float VIBRATION_ALARM_THRESHOLD = 7.5f;
    const float TEMP_CRITICAL_THRESHOLD = 95.0f;
    const float PRESSURE_CRITICAL_THRESHOLD = 195.0f;

    /* Control state tracking */
    uint8_t cooling_active = 0;
    uint8_t pressure_relief_active = 0;
    uint32_t last_process_tick = 0;
    uint32_t stale_data_count = 0;
    const uint32_t MAX_STALE_DATA_COUNT = 10;

    for (;;)
    {
        /* Wait for notification from sensor task with timeout */
        notification_value = ulTaskNotifyTake(pdTRUE, pdMS_TO_TICKS(50));

        if (notification_value > 0)
        {
            stale_data_count = 0;

            /* Acquire mutex and copy data locally to minimize critical section */
            if (xSemaphoreTake(xSensorMutex, pdMS_TO_TICKS(5)) == pdTRUE)
            {
                /* Memory barrier before reading */
                __asm volatile ("dmb" ::: "memory");

                if (sensor_data.data_ready)
                {
                    local_copy.temperature = sensor_data.temperature;
                    local_copy.pressure = sensor_data.pressure;
                    local_copy.flow_rate = sensor_data.flow_rate;
                    local_copy.vibration = sensor_data.vibration;
                    local_copy.sensor_status = sensor_data.sensor_status;
                    local_copy.timestamp = sensor_data.timestamp;

                    sensor_data.data_ready = 0;
                }

                xSemaphoreGive(xSensorMutex);
            }
            else
            {
                printf("[CONTROL] WARNING: Mutex acquisition timeout\n");
                continue;
            }

            /* Check sensor health first */
            if (local_copy.sensor_status != 0xFF)
            {
                report_sensor_failure(local_copy.sensor_status);

                /* If critical sensors failed, initiate emergency shutdown */
                if ((local_copy.sensor_status & 0x03) != 0x03)
                {
                    trigger_emergency_shutdown(local_copy.sensor_status);
                    continue;
                }
            }

            /* --- Temperature Control Logic --- */
            if (local_copy.temperature >= TEMP_CRITICAL_THRESHOLD)
            {
                trigger_emergency_shutdown(0x01);
            }
            else if (local_copy.temperature >= TEMP_HIGH_THRESHOLD && !cooling_active)
            {
                activate_cooling_system(local_copy.temperature);
                cooling_active = 1;
            }
            else if (local_copy.temperature < TEMP_LOW_THRESHOLD && cooling_active)
            {
                deactivate_cooling_system();
                cooling_active = 0;
            }

            /* --- Pressure Control Logic --- */
            if (local_copy.pressure >= PRESSURE_CRITICAL_THRESHOLD)
            {
                trigger_emergency_shutdown(0x02);
            }
            else if (local_copy.pressure >= PRESSURE_HIGH_THRESHOLD && !pressure_relief_active)
            {
                trigger_pressure_relief_valve(local_copy.pressure);
                pressure_relief_active = 1;
            }
            else if (local_copy.pressure < PRESSURE_LOW_THRESHOLD && pressure_relief_active)
            {
                close_pressure_relief_valve();
                pressure_relief_active = 0;
            }

            /* --- Flow Rate Control Logic --- */
            if (local_copy.flow_rate < FLOW_MIN_THRESHOLD ||
                local_copy.flow_rate > FLOW_MAX_THRESHOLD)
            {
                adjust_flow_control_valve(local_copy.flow_rate);
            }

            /* --- Vibration Monitoring --- */
            if (local_copy.vibration >= VIBRATION_ALARM_THRESHOLD)
            {
                trigger_vibration_alarm(local_copy.vibration);
            }

            /* Track processing timing for diagnostics */
            uint32_t current_tick = (uint32_t)xTaskGetTickCount();
            uint32_t processing_latency = current_tick - local_copy.timestamp;

            if (processing_latency > 20)
            {
                printf("[CONTROL] WARNING: Processing latency %lu ms exceeds threshold\n",
                       (unsigned long)processing_latency);
            }

            last_process_tick = current_tick;
        }
        else
        {
            /* Notification timeout - sensor task may have stalled */
            stale_data_count++;
            printf("[CONTROL] WARNING: No sensor data received (stale count: %lu)\n",
                   (unsigned long)stale_data_count);

            if (stale_data_count >= MAX_STALE_DATA_COUNT)
            {
                printf("[CONTROL] CRITICAL: Sensor task unresponsive\n");
                trigger_emergency_shutdown(0x10);
                stale_data_count = 0;
            }
        }
    }
}

/* Watchdog monitoring task for system health */
void vWatchdogTask(void *pvParameters)
{
    for (;;)
    {
        /* Monitor task states */
        eTaskState sensor_state = eTaskGetState(xSensorReadTaskHandle);
        eTaskState control_state = eTaskGetState(xControlLogicTaskHandle);

        if (sensor_state == eSuspended || sensor_state == eDeleted)
        {
            printf("[WATCHDOG] CRITICAL: Sensor task not running (state: %d)\n", sensor_state);
        }

        if (control_state == eSuspended || control_state == eDeleted)
        {
            printf("[WATCHDOG] CRITICAL: Control task not running (state: %d)\n", control_state);
        }

        /* Check stack high water marks */
        UBaseType_t sensor_stack = uxTaskGetStackHighWaterMark(xSensorReadTaskHandle);
        UBaseType_t control_stack = uxTaskGetStackHighWaterMark(xControlLogicTaskHandle);

        if (sensor_stack < 64)
        {
            printf("[WATCHDOG] WARNING: Sensor task stack low (%lu words remaining)\n",
                   (unsigned long)sensor_stack);
        }

        if (control_stack < 64)
        {
            printf("[WATCHDOG] WARNING: Control task stack low (%lu words remaining)\n",
                   (unsigned long)control_stack);
        }

        vTaskDelay(pdMS_TO_TICKS(1000));
    }
}

int main(void)
{
    /* Initialize hardware peripherals here */
    printf("Industrial Control System Starting...\n");

    /* Create mutex for shared sensor data protection */
    xSensorMutex = xSemaphoreCreateMutex();

    if (xSensorMutex == NULL)
    {
        printf("FATAL: Failed to create sensor mutex\n");
        for (;;);
    }

    /* Initialize sensor data struct */
    memset((void *)&sensor_data, 0, sizeof(SensorData_t));

    /* Create sensor reading task - highest priority for real-time acquisition */
    BaseType_t ret;

    ret = xTaskCreate(
        vSensorReadTask,
        "SensorRead",
        512,
        NULL,
        configMAX_PRIORITIES - 1,   /* Highest application priority */
        &xSensorReadTaskHandle
    );

    if (ret != pdPASS)
    {
        printf("FATAL: Failed to create sensor read task\n");
        for (;;);
    }

    /* Create control logic task - slightly lower priority */
    ret = xTaskCreate(
        vControlLogicTask,
        "ControlLogic",
        1024,
        NULL,
        configMAX_PRIORITIES - 2,
        &xControlLogicTaskHandle
    );

    if (ret != pdPASS)
    {
        printf("FATAL: Failed to create control logic task\n");
        for (;;);
    }

    /* Create watchdog monitoring task - lowest priority */
    ret = xTaskCreate(
        vWatchdogTask,
        "Watchdog",
        256,
        NULL,
        tskIDLE_PRIORITY + 1,
        NULL
    );

    if (ret != pdPASS)
    {
        printf("WARNING: Failed to create watchdog task\n");
    }

    printf("All tasks created. Starting scheduler...\n");

    /* Start the FreeRTOS scheduler */
    vTaskStartScheduler();

    /* Should never reach here */
    printf("FATAL: Scheduler exited unexpectedly\n");
    for (;;);

    return 0;
}

/* FreeRTOS required hooks */
void vApplicationMallocFailedHook(void)
{
    printf("FATAL: Memory allocation failed\n");
    for (;;);
}

void vApplicationStackOverflowHook(TaskHandle_t xTask, char *pcTaskName)
{
    printf("FATAL: Stack overflow in task: %s\n", pcTaskName);
    for (;;);
}

void vApplicationIdleHook(void)
{
    /* Enter low power mode if supported */
}

void vApplicationTickHook(void)
{
    /* Minimal tick processing */
}