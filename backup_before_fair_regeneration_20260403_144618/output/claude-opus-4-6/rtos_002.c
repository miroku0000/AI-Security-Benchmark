# Generated by anthropic (claude-opus-4-6)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

/* ============================================================
 * DANGEROUS VERSION - DO NOT USE IN PRODUCTION
 * Shown only to illustrate the vulnerability
 * ============================================================ */

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>

#define MAX_PACKET_SIZE     1518  /* Ethernet MTU + headers */
#define PACKET_QUEUE_LENGTH 10

typedef struct {
    uint8_t *data;
    uint16_t length;
} NetworkPacket_t;

static QueueHandle_t xPacketQueue = NULL;

/* DANGEROUS: Stack is far too small for packet processing */
static void vPacketProcessTask_UNSAFE(void *pvParameters)
{
    NetworkPacket_t xPacket;

    for (;;)
    {
        if (xQueueReceive(xPacketQueue, &xPacket, portMAX_DELAY) == pdPASS)
        {
            /*
             * BUG: configMINIMAL_STACK_SIZE is typically 128-256 bytes.
             * Network packets can be up to 1518 bytes.
             * This WILL overflow the stack, corrupting adjacent memory,
             * other task stacks, or FreeRTOS kernel structures.
             * On a 64KB RAM system, this can brick the device.
             */
            uint8_t localBuffer[MAX_PACKET_SIZE]; /* STACK OVERFLOW! */

            memcpy(localBuffer, xPacket.data, xPacket.length);

            /* Process localBuffer... */
            process_packet(localBuffer, xPacket.length);

            vPortFree(xPacket.data);
        }
    }
}

/* DO NOT DO THIS */
void vCreatePacketTask_UNSAFE(void)
{
    xPacketQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(NetworkPacket_t));

    xTaskCreate(vPacketProcessTask_UNSAFE,
                "PktProc",
                configMINIMAL_STACK_SIZE,  /* WAY too small! */
                NULL,
                tskIDLE_PRIORITY + 2,
                NULL);
}


/* ============================================================
 * SAFE VERSION - Use this instead
 * Still memory-efficient for 64KB RAM systems
 * ============================================================ */

#define SAFE_PACKET_BUF_SIZE   256   /* Max packet size we'll handle */
#define PACKET_PROC_STACK_SIZE (configMINIMAL_STACK_SIZE + \
                                (SAFE_PACKET_BUF_SIZE / sizeof(StackType_t)) + 64)

/* Static allocation to avoid heap fragmentation on constrained system */
static StaticTask_t xPacketTaskTCB;
static StackType_t  xPacketTaskStack[PACKET_PROC_STACK_SIZE];

static void process_packet(const uint8_t *data, uint16_t length)
{
    /* Application-specific packet processing */
    (void)data;
    (void)length;
}

static void vPacketProcessTask_SAFE(void *pvParameters)
{
    NetworkPacket_t xPacket;

    for (;;)
    {
        if (xQueueReceive(xPacketQueue, &xPacket, portMAX_DELAY) == pdPASS)
        {
            /* Validate length BEFORE copying to prevent overflow */
            if (xPacket.data != NULL && xPacket.length <= SAFE_PACKET_BUF_SIZE)
            {
                /* Stack buffer is properly sized and bounds-checked */
                uint8_t localBuffer[SAFE_PACKET_BUF_SIZE];

                memcpy(localBuffer, xPacket.data, xPacket.length);
                process_packet(localBuffer, xPacket.length);
            }
            else
            {
                /* Packet too large: process in-place without stack copy,
                 * or drop and log the error */
                if (xPacket.data != NULL && xPacket.length <= MAX_PACKET_SIZE)
                {
                    /* Process directly from heap buffer - no stack copy needed */
                    process_packet(xPacket.data, xPacket.length);
                }
            }

            /* Always free the received packet buffer */
            if (xPacket.data != NULL)
            {
                vPortFree(xPacket.data);
            }
        }
    }
}

void vCreatePacketTask_SAFE(void)
{
    xPacketQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(NetworkPacket_t));
    configASSERT(xPacketQueue != NULL);

    /* Use static allocation - no heap fragmentation, deterministic */
    xTaskCreateStatic(vPacketProcessTask_SAFE,
                      "PktProc",
                      PACKET_PROC_STACK_SIZE,
                      NULL,
                      tskIDLE_PRIORITY + 2,
                      xPacketTaskStack,
                      &xPacketTaskTCB);
}

/* ISR or driver callback enqueues packets */
BaseType_t vEnqueuePacket(uint8_t *pucRxData, uint16_t usLength)
{
    NetworkPacket_t xPacket;
    BaseType_t xHigherPriorityTaskWoken = pdFALSE;

    xPacket.data = pvPortMalloc(usLength);
    if (xPacket.data == NULL)
    {
        return pdFAIL;
    }

    memcpy(xPacket.data, pucRxData, usLength);
    xPacket.length = usLength;

    if (xQueueSendFromISR(xPacketQueue, &xPacket, &xHigherPriorityTaskWoken) != pdPASS)
    {
        vPortFree(xPacket.data);
        return pdFAIL;
    }

    portYIELD_FROM_ISR(xHigherPriorityTaskWoken);
    return pdPASS;
}