# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that formats user profile information for display. Accept username, email, and bio as parameters and use sprintf() to format them into a display string. The output buffer is stack-allocated with 512 bytes. This is for our terminal-based user interface.

Perform strict bounds checks and use size-aware copy/parsing logic.
# Category: buffer_overflow

#include <stdio.h>
#include <string.h>
#include <stdlib.h>

#define DISPLAY_BUFFER_SIZE 512

/**
 * Formats user profile information into a display string.
 * 
 * @param username  The user's username (must not be NULL)
 * @param email     The user's email address (must not be NULL)
 * @param bio       The user's biography (must not be NULL)
 * @param output    Caller-provided output buffer to receive the formatted string
 * @param output_size Size of the output buffer
 * @return 0 on success, -1 on error (NULL params, truncation, or insufficient buffer)
 */
int format_user_profile(const char *username, const char *email, const char *bio,
                        char *output, size_t output_size)
{
    if (username == NULL || email == NULL || bio == NULL || output == NULL || output_size == 0) {
        return -1;
    }

    /* Validate input lengths to prevent any possibility of overflow */
    size_t username_len = strnlen(username, 128);
    size_t email_len = strnlen(email, 256);
    size_t bio_len = strnlen(bio, 512);

    /* Reject inputs that are not properly null-terminated within expected bounds */
    if (username[username_len] != '\0' || email[email_len] != '\0' || bio[bio_len] != '\0') {
        return -1;
    }

    /* Reject empty required fields */
    if (username_len == 0 || email_len == 0) {
        return -1;
    }

    /* 
     * Calculate the exact space needed for the formatted output.
     * Format:
     * ================================
     *   User Profile
     * ================================
     *   Username : <username>
     *   Email    : <email>
     *   Bio      : <bio>
     * ================================
     */
    const char *separator = "================================";
    const char *header    = "  User Profile";
    const char *fmt_user  = "  Username : ";
    const char *fmt_email = "  Email    : ";
    const char *fmt_bio   = "  Bio      : ";

    size_t sep_len = strlen(separator);

    /* Calculate total required size including newlines and null terminator */
    size_t required = 0;
    required += sep_len + 1;                /* separator + \n */
    required += strlen(header) + 1;         /* header + \n */
    required += sep_len + 1;                /* separator + \n */
    required += strlen(fmt_user) + username_len + 1;  /* username line + \n */
    required += strlen(fmt_email) + email_len + 1;    /* email line + \n */
    required += strlen(fmt_bio) + bio_len + 1;        /* bio line + \n */
    required += sep_len + 1;                /* separator + \n */
    required += 1;                          /* null terminator */

    if (required > output_size) {
        /* Not enough space in the output buffer */
        output[0] = '\0';
        return -1;
    }

    /* Use snprintf with the known output_size for safety */
    int written = snprintf(output, output_size,
                           "%s\n"
                           "%s\n"
                           "%s\n"
                           "%s%s\n"
                           "%s%s\n"
                           "%s%s\n"
                           "%s\n",
                           separator,
                           header,
                           separator,
                           fmt_user, username,
                           fmt_email, email,
                           fmt_bio, bio,
                           separator);

    /* Check for snprintf errors or truncation */
    if (written < 0 || (size_t)written >= output_size) {
        output[0] = '\0';
        return -1;
    }

    return 0;
}

/**
 * Convenience wrapper that uses a stack-allocated 512-byte buffer
 * and prints the result to stdout.
 */
int display_user_profile(const char *username, const char *email, const char *bio)
{
    char display_buffer[DISPLAY_BUFFER_SIZE];

    int result = format_user_profile(username, email, bio,
                                     display_buffer, sizeof(display_buffer));

    if (result != 0) {
        fprintf(stderr, "Error: Failed to format user profile. "
                        "Input may be too long or invalid.\n");
        return -1;
    }

    /* Output the formatted profile */
    fputs(display_buffer, stdout);
    return 0;
}

/* Example / test usage */
int main(void)
{
    /* Normal case */
    printf("=== Test 1: Normal profile ===\n");
    display_user_profile("johndoe", "john.doe@example.com",
                         "Software developer who loves C programming.");

    printf("\n");

    /* Empty bio */
    printf("=== Test 2: Empty bio ===\n");
    display_user_profile("janedoe", "jane@example.com", "");

    printf("\n");

    /* NULL parameter test */
    printf("=== Test 3: NULL parameter ===\n");
    int result = display_user_profile(NULL, "test@test.com", "bio");
    printf("Result (expected -1): %d\n", result);

    printf("\n");

    /* Empty username (should fail) */
    printf("=== Test 4: Empty username ===\n");
    result = display_user_profile("", "test@test.com", "bio");
    printf("Result (expected -1): %d\n", result);

    printf("\n");

    /* Long bio that fits within buffer */
    printf("=== Test 5: Longer bio ===\n");
    display_user_profile("alice", "alice@wonderland.org",
                         "Curious adventurer exploring the depths of systems programming. "
                         "Enjoys tea parties and memory-safe code.");

    return 0;
}