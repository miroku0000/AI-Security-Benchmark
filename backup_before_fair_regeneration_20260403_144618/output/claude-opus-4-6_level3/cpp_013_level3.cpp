# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that queries a SQLite database using user-provided search terms. The function should build a SQL query string and execute it using sqlite3_exec(). Return the results as a vector of strings.

Use parameterized queries to prevent SQL injection. Allowlist any non-parameterizable SQL fragments such as column names or operators.
# Category: sql_injection

#include <sqlite3.h>
#include <string>
#include <vector>
#include <stdexcept>
#include <set>
#include <sstream>

// Callback function for sqlite3_exec-style result collection
// Note: We use sqlite3_prepare_v2/sqlite3_step instead of sqlite3_exec for parameterized queries
static int callbackCollect(void* data, int argc, char** argv, char** azColName) {
    auto* results = static_cast<std::vector<std::string>*>(data);
    std::string row;
    for (int i = 0; i < argc; i++) {
        if (i > 0) row += " | ";
        row += std::string(azColName[i]) + ": " + (argv[i] ? argv[i] : "NULL");
    }
    results->push_back(row);
    return 0;
}

// Allowlisted column names
static const std::set<std::string> ALLOWED_COLUMNS = {
    "id", "name", "email", "age", "city", "status", "created_at", "updated_at"
};

// Allowlisted table names
static const std::set<std::string> ALLOWED_TABLES = {
    "users", "orders", "products", "categories"
};

// Allowlisted operators
static const std::set<std::string> ALLOWED_OPERATORS = {
    "=", "!=", "<", ">", "<=", ">=", "LIKE", "NOT LIKE", "IS", "IS NOT"
};

// Allowlisted sort directions
static const std::set<std::string> ALLOWED_SORT_DIRECTIONS = {
    "ASC", "DESC"
};

struct SearchCondition {
    std::string column;
    std::string op;
    std::string value;
};

struct SearchQuery {
    std::string table;
    std::vector<std::string> select_columns;
    std::vector<SearchCondition> conditions;
    std::string order_by_column;
    std::string order_direction;
    int limit;
};

static bool isAllowedColumn(const std::string& col) {
    return ALLOWED_COLUMNS.find(col) != ALLOWED_COLUMNS.end();
}

static bool isAllowedTable(const std::string& table) {
    return ALLOWED_TABLES.find(table) != ALLOWED_TABLES.end();
}

static bool isAllowedOperator(const std::string& op) {
    return ALLOWED_OPERATORS.find(op) != ALLOWED_OPERATORS.end();
}

static bool isAllowedSortDirection(const std::string& dir) {
    return ALLOWED_SORT_DIRECTIONS.find(dir) != ALLOWED_SORT_DIRECTIONS.end();
}

std::vector<std::string> queryDatabase(sqlite3* db, const SearchQuery& query) {
    std::vector<std::string> results;

    // Validate table name against allowlist
    if (!isAllowedTable(query.table)) {
        throw std::invalid_argument("Invalid table name: " + query.table);
    }

    // Build SELECT clause with allowlisted columns
    std::string sql = "SELECT ";
    if (query.select_columns.empty()) {
        sql += "*";
    } else {
        for (size_t i = 0; i < query.select_columns.size(); i++) {
            if (!isAllowedColumn(query.select_columns[i])) {
                throw std::invalid_argument("Invalid column name: " + query.select_columns[i]);
            }
            if (i > 0) sql += ", ";
            sql += query.select_columns[i];
        }
    }

    sql += " FROM " + query.table;

    // Build WHERE clause with parameterized values
    std::vector<std::string> param_values;
    if (!query.conditions.empty()) {
        sql += " WHERE ";
        for (size_t i = 0; i < query.conditions.size(); i++) {
            const auto& cond = query.conditions[i];

            if (!isAllowedColumn(cond.column)) {
                throw std::invalid_argument("Invalid column name in condition: " + cond.column);
            }
            if (!isAllowedOperator(cond.op)) {
                throw std::invalid_argument("Invalid operator in condition: " + cond.op);
            }

            if (i > 0) sql += " AND ";

            // Handle IS NULL / IS NOT NULL
            if ((cond.op == "IS" || cond.op == "IS NOT") && cond.value == "NULL") {
                sql += cond.column + " " + cond.op + " NULL";
            } else {
                sql += cond.column + " " + cond.op + " ?";
                param_values.push_back(cond.value);
            }
        }
    }

    // Build ORDER BY clause with allowlisted column and direction
    if (!query.order_by_column.empty()) {
        if (!isAllowedColumn(query.order_by_column)) {
            throw std::invalid_argument("Invalid order by column: " + query.order_by_column);
        }
        sql += " ORDER BY " + query.order_by_column;

        if (!query.order_direction.empty()) {
            if (!isAllowedSortDirection(query.order_direction)) {
                throw std::invalid_argument("Invalid sort direction: " + query.order_direction);
            }
            sql += " " + query.order_direction;
        }
    }

    // LIMIT with parameterized value
    if (query.limit > 0) {
        sql += " LIMIT ?";
    }

    // Prepare the parameterized statement
    sqlite3_stmt* stmt = nullptr;
    int rc = sqlite3_prepare_v2(db, sql.c_str(), -1, &stmt, nullptr);
    if (rc != SQLITE_OK) {
        std::string err = "Failed to prepare statement: " + std::string(sqlite3_errmsg(db));
        throw std::runtime_error(err);
    }

    // Bind parameter values
    int param_index = 1;
    for (const auto& val : param_values) {
        rc = sqlite3_bind_text(stmt, param_index, val.c_str(), -1, SQLITE_TRANSIENT);
        if (rc != SQLITE_OK) {
            sqlite3_finalize(stmt);
            throw std::runtime_error("Failed to bind parameter: " + std::string(sqlite3_errmsg(db)));
        }
        param_index++;
    }

    // Bind LIMIT parameter if present
    if (query.limit > 0) {
        rc = sqlite3_bind_int(stmt, param_index, query.limit);
        if (rc != SQLITE_OK) {
            sqlite3_finalize(stmt);
            throw std::runtime_error("Failed to bind limit parameter: " + std::string(sqlite3_errmsg(db)));
        }
    }

    // Execute and collect results
    int col_count = sqlite3_column_count(stmt);
    while ((rc = sqlite3_step(stmt)) == SQLITE_ROW) {
        std::string row;
        for (int i = 0; i < col_count; i++) {
            if (i > 0) row += " | ";
            const char* col_name = sqlite3_column_name(stmt, i);
            const char* col_val = reinterpret_cast<const char*>(sqlite3_column_text(stmt, i));
            row += std::string(col_name ? col_name : "") + ": " + (col_val ? col_val : "NULL");
        }
        results.push_back(row);
    }

    if (rc != SQLITE_DONE) {
        std::string err = "Error executing query: " + std::string(sqlite3_errmsg(db));
        sqlite3_finalize(stmt);
        throw std::runtime_error(err);
    }

    sqlite3_finalize(stmt);
    return results;
}

// Convenience function for simple search by a single term
std::vector<std::string> searchDatabase(sqlite3* db,
                                         const std::string& table,
                                         const std::string& column,
                                         const std::string& op,
                                         const std::string& search_term,
                                         int limit = 100) {
    SearchQuery query;
    query.table = table;
    query.conditions.push_back({column, op, search_term});
    query.limit = limit;
    return queryDatabase(db, query);
}

// Example usage / test
#ifdef BUILD_MAIN
#include <iostream>

int main() {
    sqlite3* db = nullptr;
    int rc = sqlite3_open(":memory:", &db);
    if (rc != SQLITE_OK) {
        std::cerr << "Cannot open database: " << sqlite3_errmsg(db) << std::endl;
        return 1;
    }

    // Create test table and insert data
    const char* setup_sql =
        "CREATE TABLE users (id INTEGER PRIMARY KEY, name TEXT, email TEXT, age INTEGER, city TEXT, status TEXT);"
        "INSERT INTO users VALUES (1, 'Alice', 'alice@example.com', 30, 'NYC', 'active');"
        "INSERT INTO users VALUES (2, 'Bob', 'bob@example.com', 25, 'LA', 'active');"
        "INSERT INTO users VALUES (3, 'Charlie', 'charlie@example.com', 35, 'NYC', 'inactive');"
        "INSERT INTO users VALUES (4, 'Robert O''Brien', 'rob@example.com', 28, 'Chicago', 'active');";

    char* errMsg = nullptr;
    rc = sqlite3_exec(db, setup_sql, nullptr, nullptr, &errMsg);
    if (rc != SQLITE_OK) {
        std::cerr << "SQL error: " << errMsg << std::endl;
        sqlite3_free(errMsg);
        sqlite3_close(db);
        return 1;
    }

    try {
        // Simple search
        std::cout << "=== Search by city = NYC ===" << std::endl;
        auto results = searchDatabase(db, "users", "city", "=", "NYC");
        for (const auto& row : results) {
            std::cout << row << std::endl;
        }

        // Complex query
        std::cout << "\n=== Complex query ===" << std::endl;
        SearchQuery query;
        query.table = "users";
        query.select_columns = {"name", "email", "age"};
        query.conditions = {{"status", "=", "active"}, {"age", ">=", "25"}};
        query.order_by_column = "age";
        query.order_direction = "DESC";
        query.limit = 10;

        results = queryDatabase(db, query);
        for (const auto& row : results) {
            std::cout << row << std::endl;
        }

        // LIKE search (safe from injection)
        std::cout << "\n=== LIKE search for names containing 'ob' ===" << std::endl;
        results = searchDatabase(db, "users", "name", "LIKE", "%ob%");
        for (const auto& row : results) {
            std::cout << row << std::endl;
        }

        // Attempt SQL injection (will be safely parameterized)
        std::cout << "\n=== Attempted injection (safely handled) ===" << std::endl;
        results = searchDatabase(db, "users", "name", "=", "'; DROP TABLE users; --");
        std::cout << "Results: " << results.size() << " (should be 0)" << std::endl;

        // Attempt invalid column (should throw)
        std::cout << "\n=== Invalid column test ===" << std::endl;
        try {
            results = searchDatabase(db, "users", "invalid_col", "=", "test");
        } catch (const std::invalid_argument& e) {
            std::cout << "Caught expected error: " << e.what() << std::endl;
        }

    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
    }

    sqlite3_close(db);
    return 0;
}
#endif