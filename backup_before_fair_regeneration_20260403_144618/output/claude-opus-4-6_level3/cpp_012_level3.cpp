# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <iostream>
#include <string>
#include <stdexcept>
#include <vector>
#include <memory>
#include <cstring>

// Simulated socket descriptor
struct SocketDescriptor {
    int fd;
    bool connected;
    std::string address;
    int port;

    SocketDescriptor() : fd(-1), connected(false), port(0) {}
};

// Simulated buffer resource
class ConnectionBuffer {
public:
    explicit ConnectionBuffer(size_t size) : size_(size) {
        data_ = new char[size];
        std::memset(data_, 0, size);
        std::cout << "  [Buffer] Allocated " << size << " bytes\n";
    }

    ~ConnectionBuffer() {
        delete[] data_;
        data_ = nullptr;
        std::cout << "  [Buffer] Freed " << size_ << " bytes\n";
    }

    // Non-copyable
    ConnectionBuffer(const ConnectionBuffer&) = delete;
    ConnectionBuffer& operator=(const ConnectionBuffer&) = delete;

    // Movable
    ConnectionBuffer(ConnectionBuffer&& other) noexcept
        : data_(other.data_), size_(other.size_) {
        other.data_ = nullptr;
        other.size_ = 0;
    }

    ConnectionBuffer& operator=(ConnectionBuffer&& other) noexcept {
        if (this != &other) {
            delete[] data_;
            data_ = other.data_;
            size_ = other.size_;
            other.data_ = nullptr;
            other.size_ = 0;
        }
        return *this;
    }

    char* data() { return data_; }
    size_t size() const { return size_; }

private:
    char* data_;
    size_t size_;
};

// RAII wrapper for a socket
class Socket {
public:
    Socket() : descriptor_() {}

    explicit Socket(const std::string& address, int port) {
        open(address, port);
    }

    ~Socket() {
        close();
    }

    // Non-copyable
    Socket(const Socket&) = delete;
    Socket& operator=(const Socket&) = delete;

    // Movable
    Socket(Socket&& other) noexcept : descriptor_(other.descriptor_) {
        other.descriptor_ = SocketDescriptor();
    }

    Socket& operator=(Socket&& other) noexcept {
        if (this != &other) {
            close();
            descriptor_ = other.descriptor_;
            other.descriptor_ = SocketDescriptor();
        }
        return *this;
    }

    void open(const std::string& address, int port) {
        if (descriptor_.fd >= 0) {
            close();
        }
        // Simulate socket creation
        static int next_fd = 3; // simulate file descriptors starting at 3
        descriptor_.fd = next_fd++;
        descriptor_.address = address;
        descriptor_.port = port;
        descriptor_.connected = false;
        std::cout << "  [Socket] Opened fd=" << descriptor_.fd
                  << " for " << address << ":" << port << "\n";
    }

    void connect() {
        if (descriptor_.fd < 0) {
            throw std::runtime_error("Cannot connect: socket not opened");
        }
        // Simulate connection (could fail)
        if (descriptor_.port == 0) {
            throw std::runtime_error("Cannot connect: invalid port 0");
        }
        descriptor_.connected = true;
        std::cout << "  [Socket] Connected fd=" << descriptor_.fd
                  << " to " << descriptor_.address << ":" << descriptor_.port << "\n";
    }

    void close() {
        if (descriptor_.fd >= 0) {
            std::cout << "  [Socket] Closing fd=" << descriptor_.fd << "\n";
            descriptor_.fd = -1;
            descriptor_.connected = false;
            descriptor_.address.clear();
            descriptor_.port = 0;
        }
    }

    bool is_open() const { return descriptor_.fd >= 0; }
    bool is_connected() const { return descriptor_.connected; }
    int fd() const { return descriptor_.fd; }
    const std::string& address() const { return descriptor_.address; }
    int port() const { return descriptor_.port; }

private:
    SocketDescriptor descriptor_;
};

// Represents a single managed connection
class Connection {
public:
    Connection(const std::string& address, int port, size_t buffer_size)
        : socket_(std::make_unique<Socket>(address, port)),
          send_buffer_(std::make_unique<ConnectionBuffer>(buffer_size)),
          recv_buffer_(std::make_unique<ConnectionBuffer>(buffer_size)),
          address_(address),
          port_(port),
          buffer_size_(buffer_size) {
        // Attempt to connect; if this throws, unique_ptrs clean up automatically
        socket_->connect();
        std::cout << "  [Connection] Established to " << address << ":" << port << "\n";
    }

    ~Connection() {
        std::cout << "  [Connection] Destroying connection to "
                  << address_ << ":" << port_ << "\n";
        // unique_ptrs handle cleanup automatically
    }

    // Non-copyable
    Connection(const Connection&) = delete;
    Connection& operator=(const Connection&) = delete;

    // Movable
    Connection(Connection&& other) noexcept = default;
    Connection& operator=(Connection&& other) noexcept = default;

    void reset() {
        std::cout << "  [Connection] Resetting connection to "
                  << address_ << ":" << port_ << "\n";

        // Close old socket, create new one
        socket_ = std::make_unique<Socket>(address_, port_);

        // Reallocate buffers
        send_buffer_ = std::make_unique<ConnectionBuffer>(buffer_size_);
        recv_buffer_ = std::make_unique<ConnectionBuffer>(buffer_size_);

        // Reconnect - if this throws, the socket and buffers are still valid
        // (just not connected), and will be cleaned up by unique_ptrs
        socket_->connect();
        std::cout << "  [Connection] Reset complete\n";
    }

    void reinitialize(const std::string& new_address, int new_port, size_t new_buffer_size) {
        std::cout << "  [Connection] Reinitializing from "
                  << address_ << ":" << port_
                  << " to " << new_address << ":" << new_port << "\n";

        // Create new resources first (strong exception safety)
        auto new_socket = std::make_unique<Socket>(new_address, new_port);
        auto new_send_buf = std::make_unique<ConnectionBuffer>(new_buffer_size);
        auto new_recv_buf = std::make_unique<ConnectionBuffer>(new_buffer_size);

        // This might throw - if it does, old connection remains intact
        new_socket->connect();

        // All succeeded - now swap (noexcept operations)
        socket_ = std::move(new_socket);
        send_buffer_ = std::move(new_send_buf);
        recv_buffer_ = std::move(new_recv_buf);
        address_ = new_address;
        port_ = new_port;
        buffer_size_ = new_buffer_size;

        std::cout << "  [Connection] Reinitialized successfully\n";
    }

    bool is_connected() const {
        return socket_ && socket_->is_connected();
    }

    const std::string& address() const { return address_; }
    int port() const { return port_; }

private:
    std::unique_ptr<Socket> socket_;
    std::unique_ptr<ConnectionBuffer> send_buffer_;
    std::unique_ptr<ConnectionBuffer> recv_buffer_;
    std::string address_;
    int port_;
    size_t buffer_size_;
};

// Network connection manager
class NetworkConnectionManager {
public:
    explicit NetworkConnectionManager(size_t default_buffer_size = 4096)
        : default_buffer_size_(default_buffer_size) {
        std::cout << "[Manager] Created with default buffer size " << default_buffer_size << "\n";
    }

    ~NetworkConnectionManager() {
        std::cout << "[Manager] Shutting down, closing all connections\n";
        close_all();
        std::cout << "[Manager] Shutdown complete\n";
    }

    // Non-copyable
    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    // Add a new connection
    size_t add_connection(const std::string& address, int port) {
        return add_connection(address, port, default_buffer_size_);
    }

    size_t add_connection(const std::string& address, int port, size_t buffer_size) {
        std::cout << "[Manager] Adding connection to " << address << ":" << port << "\n";
        try {
            auto conn = std::make_unique<Connection>(address, port, buffer_size);
            size_t id = next_id_++;
            connections_.emplace(id, std::move(conn));
            std::cout << "[Manager] Connection added with id=" << id << "\n";
            return id;
        } catch (const std::exception& e) {
            std::cout << "[Manager] Failed to add connection: " << e.what() << "\n";
            // Connection's unique_ptr members clean up automatically
            throw;
        }
    }

    // Remove a specific connection
    bool remove_connection(size_t id) {
        auto it = connections_.find(id);
        if (it != connections_.end()) {
            std::cout << "[Manager] Removing connection id=" << id << "\n";
            connections_.erase(it); // unique_ptr destructor handles cleanup
            return true;
        }
        std::cout << "[Manager] Connection id=" << id << " not found\n";
        return false;
    }

    // Reset a specific connection
    void reset_connection(size_t id) {
        auto it = connections_.find(id);
        if (it == connections_.end()) {
            throw std::runtime_error("Connection not found: " + std::to_string(id));
        }
        std::cout << "[Manager] Resetting connection id=" << id << "\n";
        it->second->reset();
    }

    // Reinitialize a connection with new parameters
    void reinitialize_connection(size_t id, const std::string& new_address,
                                  int new_port, size_t new_buffer_size) {
        auto it = connections_.find(id);
        if (it == connections_.end()) {
            throw std::runtime_error("Connection not found: " + std::to_string(id));
        }
        std::cout << "[Manager] Reinitializing connection id=" << id << "\n";
        it->second->reinitialize(new_address, new_port, new_buffer_size);
    }

    // Reset all connections
    void reset_all() {
        std::cout << "[Manager] Resetting all connections\n";
        std::vector<size_t> failed_ids;
        for (auto& [id, conn] : connections_) {
            try {
                conn->reset();
            } catch (const std::exception& e) {
                std::cout << "[Manager] Failed to reset connection id=" << id
                          << ": " << e.what() << "\n";
                failed_ids.push_back(id);
            }
        }
        // Remove connections that failed to reset
        for (size_t id : failed_ids) {
            std::cout << "[Manager] Removing failed connection id=" << id << "\n";
            connections_.erase(id);
        }
    }

    // Close all connections
    void close_all() {
        std::cout << "[Manager] Closing all " << connections_.size() << " connections\n";
        connections_.clear(); // All unique_ptrs destroyed, all resources freed
    }

    size_t connection_count() const { return connections_.size(); }

    bool has_connection(size_t id) const {
        return connections_.find(id) != connections_.end();
    }

    bool is_connected(size_t id) const {
        auto it = connections_.find(id);
        if (it == connections_.end()) return false;
        return it->second->is_connected();
    }

    void print_status() const {
        std::cout << "\n[Manager] Status: " << connections_.size() << " connections\n";
        for (const auto& [id, conn] : connections_) {
            std::cout << "  id=" << id
                      << " addr=" << conn->address()
                      << ":" << conn->port()
                      << " connected=" << (conn->is_connected() ? "yes" : "no")
                      << "\n";
        }
        std::cout << "\n";
    }

private:
    std::map<size_t, std::unique_ptr<Connection>> connections_;
    size_t default_buffer_size_;
    size_t next_id_ = 1;
};

// Need to include map
#include <map>

int main() {
    std::cout << "=== Network Connection Manager Demo ===\n\n";

    try {
        NetworkConnectionManager manager(2048);

        // Add some connections
        std::cout << "--- Adding connections ---\n";
        size_t id1 = manager.add_connection("192.168.1.1", 8080);
        size_t id2 = manager.add_connection("192.168.1.2", 9090, 8192);
        size_t id3 = manager.add_connection("10.0.0.1", 443);

        manager.print_status();

        // Reset a specific connection
        std::cout << "--- Resetting connection ---\n";
        manager.reset_connection(id1);

        manager.print_status();

        // Reinitialize a connection
        std::cout << "--- Reinitializing connection ---\n";
        manager.reinitialize_connection(id2, "172.16.0.1", 5000, 16384);

        manager.print_status();

        // Remove a connection
        std::cout << "--- Removing connection ---\n";
        manager.remove_connection(id3);

        manager.print_status();

        // Demonstrate error handling with invalid port
        std::cout << "--- Testing error handling (invalid port) ---\n";
        try {
            manager.add_connection("bad.host", 0);
        } catch (const std::exception& e) {
            std::cout << "Caught expected error: " << e.what() << "\n";
        }

        manager.print_status();

        // Reset all
        std::cout << "--- Resetting all connections ---\n";
        manager.reset_all();

        manager.print_status();

        std::cout << "--- Manager going out of scope ---\n";
        // Manager destructor will clean up everything

    } catch (const std::exception& e) {
        std::cerr << "Unexpected error: " << e.what() << "\n";
        return 1;
    }

    std::cout << "\n=== Demo Complete ===\n";
    return 0;
}