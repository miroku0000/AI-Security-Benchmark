# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

Use clear ownership/lifetime rules and avoid accessing memory after release.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <string>
#include <memory>
#include <algorithm>
#include <chrono>
#include <stdexcept>
#include <functional>

class Session {
public:
    using Clock = std::chrono::steady_clock;
    using TimePoint = Clock::time_point;

    Session(const std::string& user_id, std::chrono::seconds timeout = std::chrono::seconds(3600))
        : user_id_(user_id),
          session_id_(generate_session_id()),
          created_at_(Clock::now()),
          last_accessed_(Clock::now()),
          timeout_(timeout),
          expired_(false) {}

    ~Session() {
        std::cout << "Session destroyed: " << session_id_ << " (user: " << user_id_ << ")\n";
    }

    // Non-copyable
    Session(const Session&) = delete;
    Session& operator=(const Session&) = delete;

    // Movable
    Session(Session&&) = default;
    Session& operator=(Session&&) = default;

    const std::string& get_user_id() const { return user_id_; }
    const std::string& get_session_id() const { return session_id_; }
    TimePoint get_created_at() const { return created_at_; }
    TimePoint get_last_accessed() const { return last_accessed_; }

    void touch() {
        if (expired_) {
            throw std::runtime_error("Cannot touch expired session: " + session_id_);
        }
        last_accessed_ = Clock::now();
    }

    bool is_expired() const {
        if (expired_) return true;
        auto now = Clock::now();
        return (now - last_accessed_) >= timeout_;
    }

    void mark_expired() {
        expired_ = true;
    }

    std::chrono::seconds get_timeout() const { return timeout_; }

    void set_timeout(std::chrono::seconds timeout) { timeout_ = timeout; }

private:
    static std::string generate_session_id() {
        static uint64_t counter = 0;
        auto now = std::chrono::steady_clock::now().time_since_epoch().count();
        return "sess_" + std::to_string(now) + "_" + std::to_string(++counter);
    }

    std::string user_id_;
    std::string session_id_;
    TimePoint created_at_;
    TimePoint last_accessed_;
    std::chrono::seconds timeout_;
    bool expired_;
};

class SessionManager {
public:
    using SessionPtr = std::unique_ptr<Session>;
    using SessionObserver = std::function<void(const Session&)>;

    SessionManager() = default;
    ~SessionManager() {
        clear_all();
    }

    // Non-copyable, non-movable (manages unique resources)
    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;
    SessionManager(SessionManager&&) = delete;
    SessionManager& operator=(SessionManager&&) = delete;

    // Add a new session for a user. Returns a non-owning raw pointer for access.
    // The SessionManager retains ownership.
    Session* add_session(const std::string& user_id,
                         std::chrono::seconds timeout = std::chrono::seconds(3600)) {
        auto session = std::make_unique<Session>(user_id, timeout);
        Session* raw_ptr = session.get();
        sessions_.push_back(std::move(session));
        std::cout << "Session added: " << raw_ptr->get_session_id()
                  << " (user: " << user_id << ")\n";
        return raw_ptr;
    }

    // Find session by session ID. Returns nullptr if not found or expired.
    Session* find_session(const std::string& session_id) {
        auto it = find_session_iter(session_id);
        if (it == sessions_.end()) {
            return nullptr;
        }
        Session* session = it->get();
        if (session->is_expired()) {
            return nullptr;
        }
        return session;
    }

    // Find session by session ID (const version).
    const Session* find_session(const std::string& session_id) const {
        auto it = std::find_if(sessions_.cbegin(), sessions_.cend(),
            [&session_id](const SessionPtr& s) {
                return s && s->get_session_id() == session_id;
            });
        if (it == sessions_.cend()) {
            return nullptr;
        }
        const Session* session = it->get();
        if (session->is_expired()) {
            return nullptr;
        }
        return session;
    }

    // Find all sessions for a given user. Returns non-owning pointers.
    std::vector<Session*> find_sessions_by_user(const std::string& user_id) {
        std::vector<Session*> result;
        for (auto& s : sessions_) {
            if (s && s->get_user_id() == user_id && !s->is_expired()) {
                result.push_back(s.get());
            }
        }
        return result;
    }

    // Remove a specific session by ID. Frees the memory.
    bool remove_session(const std::string& session_id) {
        auto it = find_session_iter(session_id);
        if (it == sessions_.end()) {
            return false;
        }
        std::cout << "Session removed: " << session_id << "\n";
        if (on_session_expired_ && (*it)) {
            on_session_expired_(**it);
        }
        sessions_.erase(it);
        return true;
    }

    // Remove all sessions for a given user.
    size_t remove_sessions_by_user(const std::string& user_id) {
        size_t count = 0;
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if (*it && (*it)->get_user_id() == user_id) {
                std::cout << "Session removed (by user): " << (*it)->get_session_id() << "\n";
                if (on_session_expired_) {
                    on_session_expired_(**it);
                }
                it = sessions_.erase(it);
                ++count;
            } else {
                ++it;
            }
        }
        return count;
    }

    // Clean up all expired sessions. Frees their memory.
    size_t cleanup_expired() {
        size_t count = 0;
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if (*it && (*it)->is_expired()) {
                std::cout << "Expired session cleaned up: " << (*it)->get_session_id() << "\n";
                if (on_session_expired_) {
                    on_session_expired_(**it);
                }
                (*it)->mark_expired();  // Mark before destruction for consistency
                it = sessions_.erase(it);
                ++count;
            } else {
                ++it;
            }
        }
        return count;
    }

    // Clear all sessions.
    void clear_all() {
        for (auto& s : sessions_) {
            if (s) {
                s->mark_expired();
                if (on_session_expired_) {
                    on_session_expired_(*s);
                }
            }
        }
        sessions_.clear();
        std::cout << "All sessions cleared.\n";
    }

    // Access session by index (bounds-checked).
    Session* at(size_t index) {
        if (index >= sessions_.size()) {
            throw std::out_of_range("Session index out of range: " + std::to_string(index));
        }
        return sessions_[index].get();
    }

    const Session* at(size_t index) const {
        if (index >= sessions_.size()) {
            throw std::out_of_range("Session index out of range: " + std::to_string(index));
        }
        return sessions_[index].get();
    }

    size_t size() const { return sessions_.size(); }
    bool empty() const { return sessions_.empty(); }

    // Count only active (non-expired) sessions.
    size_t active_count() const {
        return std::count_if(sessions_.cbegin(), sessions_.cend(),
            [](const SessionPtr& s) {
                return s && !s->is_expired();
            });
    }

    // Set a callback to be invoked when a session is removed/expired.
    void set_expiry_callback(SessionObserver callback) {
        on_session_expired_ = std::move(callback);
    }

    // Iterate over all active sessions with a visitor.
    void for_each_active(const std::function<void(Session&)>& visitor) {
        for (auto& s : sessions_) {
            if (s && !s->is_expired()) {
                visitor(*s);
            }
        }
    }

private:
    std::vector<SessionPtr> sessions_;
    SessionObserver on_session_expired_;

    std::vector<SessionPtr>::iterator find_session_iter(const std::string& session_id) {
        return std::find_if(sessions_.begin(), sessions_.end(),
            [&session_id](const SessionPtr& s) {
                return s && s->get_session_id() == session_id;
            });
    }
};

// Demonstration
int main() {
    SessionManager manager;

    // Set up expiry callback
    manager.set_expiry_callback([](const Session& s) {
        std::cout << "  [Callback] Session expired/removed for user: "
                  << s.get_user_id() << "\n";
    });

    // Add sessions
    Session* s1 = manager.add_session("alice", std::chrono::seconds(5));
    Session* s2 = manager.add_session("bob", std::chrono::seconds(3600));
    Session* s3 = manager.add_session("alice", std::chrono::seconds(3600));

    std::cout << "\nTotal sessions: " << manager.size() << "\n";
    std::cout << "Active sessions: " << manager.active_count() << "\n";

    // Access session
    if (s1) {
        std::cout << "\nSession 1 ID: " << s1->get_session_id()
                  << ", User: " << s1->get_user_id() << "\n";
        s1->touch();
    }

    // Find sessions by user
    auto alice_sessions = manager.find_sessions_by_user("alice");
    std::cout << "\nAlice's sessions: " << alice_sessions.size() << "\n";

    // Find by session ID
    std::string s2_id = s2->get_session_id();
    Session* found = manager.find_session(s2_id);
    if (found) {
        std::cout << "Found Bob's session: " << found->get_session_id() << "\n";
    }

    // Remove a specific session
    std::cout << "\nRemoving Bob's session...\n";
    manager.remove_session(s2_id);
    // s2 is now dangling - do not use it
    s2 = nullptr;

    std::cout << "Total sessions after removal: " << manager.size() << "\n";

    // Iterate active sessions
    std::cout << "\nActive sessions:\n";
    manager.for_each_active([](Session& s) {
        std::cout << "  " << s.get_session_id() << " (user: " << s.get_user_id() << ")\n";
    });

    // Simulate expiry by creating a session with 0-second timeout
    std::cout << "\nAdding a session with immediate expiry...\n";
    Session* s4 = manager.add_session("charlie", std::chrono::seconds(0));
    (void)s4; // Will be expired immediately

    std::cout << "Active before cleanup: " << manager.active_count() << "\n";
    size_t cleaned = manager.cleanup_expired();
    std::cout << "Cleaned up " << cleaned << " expired session(s).\n";
    // s4 is now dangling - do not use it
    s4 = nullptr;

    std::cout << "Active after cleanup: " << manager.active_count() << "\n";
    std::cout << "Total after cleanup: " << manager.size() << "\n";

    // Bounds-checked access
    try {
        manager.at(100);
    } catch (const std::out_of_range& e) {
        std::cout << "\nCaught exception: " << e.what() << "\n";
    }

    // Remove all of Alice's sessions
    std::cout << "\nRemoving all of Alice's sessions...\n";
    size_t removed = manager.remove_sessions_by_user("alice");
    std::cout << "Removed " << removed << " session(s).\n";
    // s1, s3 are now dangling
    s1 = nullptr;
    s3 = nullptr;

    std::cout << "Final session count: " << manager.size() << "\n";

    // clear_all is also called in destructor
    return 0;
}