# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

Validate pointers/references before use and preserve clear ownership/initialization rules.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_NAME_LEN 128
#define MAX_EMAIL_LEN 256

typedef struct UserRecord {
    char name[MAX_NAME_LEN];
    char email[MAX_EMAIL_LEN];
    struct UserRecord *next;
} UserRecord;

/* Creates a new user record node. Caller takes ownership of the returned pointer. */
UserRecord *create_user_record(const char *name, const char *email) {
    if (name == NULL || email == NULL) {
        fprintf(stderr, "Error: name and email must not be NULL\n");
        return NULL;
    }

    UserRecord *record = (UserRecord *)calloc(1, sizeof(UserRecord));
    if (record == NULL) {
        fprintf(stderr, "Error: failed to allocate memory for UserRecord\n");
        return NULL;
    }

    strncpy(record->name, name, MAX_NAME_LEN - 1);
    record->name[MAX_NAME_LEN - 1] = '\0';

    strncpy(record->email, email, MAX_EMAIL_LEN - 1);
    record->email[MAX_EMAIL_LEN - 1] = '\0';

    record->next = NULL;

    return record;
}

/* Appends a user record to the end of the list.
 * head_ref: pointer to the head pointer (must not be NULL).
 * new_record: the record to append (ownership transferred to the list). */
int append_user_record(UserRecord **head_ref, UserRecord *new_record) {
    if (head_ref == NULL) {
        fprintf(stderr, "Error: head_ref must not be NULL\n");
        return -1;
    }
    if (new_record == NULL) {
        fprintf(stderr, "Error: new_record must not be NULL\n");
        return -1;
    }

    /* Ensure the new record's next is NULL to avoid dangling chains */
    new_record->next = NULL;

    if (*head_ref == NULL) {
        *head_ref = new_record;
        return 0;
    }

    UserRecord *current = *head_ref;
    while (current->next != NULL) {
        current = current->next;
    }
    current->next = new_record;

    return 0;
}

/* Traverses the linked list and prints each user's name and email.
 * Validates each node pointer before accessing fields. */
void print_user_records(const UserRecord *head) {
    if (head == NULL) {
        printf("(empty user list)\n");
        return;
    }

    const UserRecord *current = head;
    int index = 0;

    while (current != NULL) {
        printf("User #%d:\n", index);
        printf("  Name:  %s\n", current->name);
        printf("  Email: %s\n", current->email);
        printf("\n");

        current = current->next;
        index++;
    }

    printf("Total users: %d\n", index);
}

/* Frees all nodes in the linked list. Sets *head_ref to NULL after freeing.
 * Caller must pass a valid pointer to the head pointer. */
void free_user_records(UserRecord **head_ref) {
    if (head_ref == NULL) {
        fprintf(stderr, "Error: head_ref must not be NULL in free_user_records\n");
        return;
    }

    UserRecord *current = *head_ref;
    while (current != NULL) {
        UserRecord *next = current->next;
        current->next = NULL;  /* Clear before freeing to avoid dangling pointers */
        free(current);
        current = next;
    }

    *head_ref = NULL;  /* Prevent use-after-free via the original head pointer */
}

/* Demo / test driver */
int main(void) {
    UserRecord *user_list = NULL;  /* Initialize head to NULL (empty list) */

    /* Create and append user records */
    UserRecord *u1 = create_user_record("Alice Johnson", "alice@example.com");
    if (u1 != NULL) {
        append_user_record(&user_list, u1);
    }

    UserRecord *u2 = create_user_record("Bob Smith", "bob@example.com");
    if (u2 != NULL) {
        append_user_record(&user_list, u2);
    }

    UserRecord *u3 = create_user_record("Charlie Brown", "charlie@example.com");
    if (u3 != NULL) {
        append_user_record(&user_list, u3);
    }

    /* Test with NULL inputs */
    UserRecord *u_invalid = create_user_record(NULL, "test@example.com");
    if (u_invalid != NULL) {
        append_user_record(&user_list, u_invalid);
    }

    /* Print all user records */
    printf("=== User Records ===\n\n");
    print_user_records(user_list);

    /* Test printing an empty list */
    printf("\n=== Empty List Test ===\n");
    print_user_records(NULL);

    /* Clean up: free all records and nullify head */
    free_user_records(&user_list);

    /* Verify head is NULL after cleanup */
    printf("\nAfter cleanup, user_list is %s\n",
           user_list == NULL ? "NULL (safe)" : "NOT NULL (error!)");

    return 0;
}