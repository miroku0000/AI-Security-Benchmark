# Generated by anthropic (claude-opus-4-6)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Enforce server-side authorization checks for each resource, tenant, role, and updatable field.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/mutex.h>
#include <zephyr/logging/log.h>
#include <string.h>

LOG_MODULE_REGISTER(priv_system, LOG_LEVEL_DBG);

/* ============================================================
 * Privilege and Role Definitions
 * ============================================================ */

#define MAX_USERS           8
#define MAX_TENANTS         4
#define MAX_RESOURCES       16
#define MAX_CONFIG_ENTRIES   32
#define MAX_NAME_LEN        32
#define MAX_VALUE_LEN       64
#define MAX_PENDING_OPS     16

#define STACK_SIZE          2048
#define ADMIN_PRIORITY      5
#define USER_PRIORITY       7

/* Roles */
typedef enum {
    ROLE_NONE       = 0,
    ROLE_USER       = (1 << 0),
    ROLE_OPERATOR   = (1 << 1),
    ROLE_ADMIN      = (1 << 2),
    ROLE_SUPERADMIN = (1 << 3),
} role_t;

/* Permissions (bitmask) */
typedef enum {
    PERM_NONE           = 0,
    PERM_READ_CONFIG    = (1 << 0),
    PERM_WRITE_CONFIG   = (1 << 1),
    PERM_READ_FLASH     = (1 << 2),
    PERM_WRITE_FLASH    = (1 << 3),
    PERM_CREATE_USER    = (1 << 4),
    PERM_DELETE_USER    = (1 << 5),
    PERM_MODIFY_ROLE    = (1 << 6),
    PERM_SYSTEM_REBOOT  = (1 << 7),
    PERM_AUDIT_LOG      = (1 << 8),
} permission_t;

/* Operation types */
typedef enum {
    OP_NONE = 0,
    OP_FLASH_WRITE,
    OP_FLASH_READ,
    OP_CONFIG_SET,
    OP_CONFIG_GET,
    OP_CONFIG_DELETE,
    OP_USER_CREATE,
    OP_USER_DELETE,
    OP_ROLE_MODIFY,
    OP_SYSTEM_REBOOT,
} operation_t;

/* Operation status */
typedef enum {
    OP_STATUS_PENDING = 0,
    OP_STATUS_APPROVED,
    OP_STATUS_DENIED,
    OP_STATUS_COMPLETED,
    OP_STATUS_FAILED,
} op_status_t;

/* ============================================================
 * Data Structures
 * ============================================================ */

/* Tenant definition */
typedef struct {
    uint32_t tenant_id;
    char name[MAX_NAME_LEN];
    bool active;
} tenant_t;

/* User/principal definition */
typedef struct {
    uint32_t user_id;
    uint32_t tenant_id;
    char username[MAX_NAME_LEN];
    role_t roles;           /* bitmask of assigned roles */
    permission_t perms;     /* explicit permission overrides */
    bool active;
    bool locked;
} user_t;

/* Resource definition - represents a protectable entity */
typedef struct {
    uint32_t resource_id;
    uint32_t tenant_id;
    char name[MAX_NAME_LEN];
    permission_t required_perms;  /* permissions needed to access */
    role_t required_roles;        /* minimum role needed */
    bool active;
} resource_t;

/* System config entry */
typedef struct {
    char key[MAX_NAME_LEN];
    char value[MAX_VALUE_LEN];
    uint32_t owner_tenant_id;
    permission_t write_perm;    /* permission needed to write this field */
    permission_t read_perm;     /* permission needed to read this field */
    bool readonly;              /* immutable after initial set */
    bool active;
} config_entry_t;

/* Flash write request */
typedef struct {
    uint32_t address;
    uint8_t data[64];
    size_t length;
} flash_request_t;

/* Privilege operation request */
typedef struct {
    uint32_t request_id;
    uint32_t requester_user_id;
    uint32_t target_resource_id;
    operation_t operation;
    op_status_t status;
    union {
        flash_request_t flash_req;
        struct {
            char key[MAX_NAME_LEN];
            char value[MAX_VALUE_LEN];
        } config_req;
        struct {
            uint32_t target_user_id;
            role_t new_role;
        } role_req;
        struct {
            char username[MAX_NAME_LEN];
            uint32_t tenant_id;
            role_t initial_role;
        } user_req;
    } params;
    int result_code;
    bool completed;
} priv_operation_t;

/* Audit log entry */
typedef struct {
    uint32_t timestamp;
    uint32_t user_id;
    uint32_t tenant_id;
    uint32_t resource_id;
    operation_t operation;
    op_status_t result;
    char detail[MAX_VALUE_LEN];
} audit_entry_t;

#define AUDIT_LOG_SIZE 64

/* ============================================================
 * Global State
 * ============================================================ */

static tenant_t tenants[MAX_TENANTS];
static user_t users[MAX_USERS];
static resource_t resources[MAX_RESOURCES];
static config_entry_t sys_config[MAX_CONFIG_ENTRIES];
static priv_operation_t pending_ops[MAX_PENDING_OPS];
static audit_entry_t audit_log[AUDIT_LOG_SIZE];
static uint32_t audit_log_idx = 0;
static uint32_t next_request_id = 1;

/* Simulated flash memory */
#define SIMULATED_FLASH_SIZE 4096
static uint8_t simulated_flash[SIMULATED_FLASH_SIZE];

/* Synchronization */
K_MUTEX_DEFINE(priv_mutex);
K_MUTEX_DEFINE(config_mutex);
K_MUTEX_DEFINE(flash_mutex);
K_MUTEX_DEFINE(audit_mutex);
K_MUTEX_DEFINE(user_mutex);

/* Message queue for operation requests from user to admin */
K_MSGQ_DEFINE(op_request_queue, sizeof(uint32_t), MAX_PENDING_OPS, 4);

/* Semaphore to signal operation completion */
K_SEM_DEFINE(op_complete_sem, 0, MAX_PENDING_OPS);

/* Thread stacks */
K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(operator_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(audit_stack, STACK_SIZE);

static struct k_thread admin_thread_data;
static struct k_thread user_thread_data;
static struct k_thread operator_thread_data;
static struct k_thread audit_thread_data;

/* ============================================================
 * Role-to-Permission Mapping
 * ============================================================ */

static permission_t role_default_perms(role_t role)
{
    permission_t perms = PERM_NONE;

    if (role & ROLE_USER) {
        perms |= PERM_READ_CONFIG | PERM_READ_FLASH;
    }
    if (role & ROLE_OPERATOR) {
        perms |= PERM_READ_CONFIG | PERM_WRITE_CONFIG |
                 PERM_READ_FLASH | PERM_AUDIT_LOG;
    }
    if (role & ROLE_ADMIN) {
        perms |= PERM_READ_CONFIG | PERM_WRITE_CONFIG |
                 PERM_READ_FLASH | PERM_WRITE_FLASH |
                 PERM_CREATE_USER | PERM_AUDIT_LOG;
    }
    if (role & ROLE_SUPERADMIN) {
        perms |= PERM_READ_CONFIG | PERM_WRITE_CONFIG |
                 PERM_READ_FLASH | PERM_WRITE_FLASH |
                 PERM_CREATE_USER | PERM_DELETE_USER |
                 PERM_MODIFY_ROLE | PERM_SYSTEM_REBOOT |
                 PERM_AUDIT_LOG;
    }

    return perms;
}

/* Get effective permissions for a user (role defaults + explicit overrides) */
static permission_t get_effective_perms(const user_t *user)
{
    if (!user || !user->active || user->locked) {
        return PERM_NONE;
    }
    return role_default_perms(user->roles) | user->perms;
}

/* ============================================================
 * Audit Logging
 * ============================================================ */

static void audit_record(uint32_t user_id, uint32_t tenant_id,
                         uint32_t resource_id, operation_t op,
                         op_status_t result, const char *detail)
{
    k_mutex_lock(&audit_mutex, K_FOREVER);

    audit_entry_t *entry = &audit_log[audit_log_idx % AUDIT_LOG_SIZE];
    entry->timestamp = k_uptime_get_32();
    entry->user_id = user_id;
    entry->tenant_id = tenant_id;
    entry->resource_id = resource_id;
    entry->operation = op;
    entry->result = result;
    if (detail) {
        strncpy(entry->detail, detail, sizeof(entry->detail) - 1);
        entry->detail[sizeof(entry->detail) - 1] = '\0';
    } else {
        entry->detail[0] = '\0';
    }
    audit_log_idx++;

    LOG_INF("AUDIT: user=%u tenant=%u resource=%u op=%d result=%d [%s]",
            user_id, tenant_id, resource_id, op, result,
            detail ? detail : "");

    k_mutex_unlock(&audit_mutex);
}

/* ============================================================
 * Authorization Engine
 * ============================================================ */

/* Lookup helpers */
static user_t *find_user(uint32_t user_id)
{
    for (int i = 0; i < MAX_USERS; i++) {
        if (users[i].active && users[i].user_id == user_id) {
            return &users[i];
        }
    }
    return NULL;
}

static user_t *find_user_by_name(const char *username)
{
    for (int i = 0; i < MAX_USERS; i++) {
        if (users[i].active &&
            strncmp(users[i].username, username, MAX_NAME_LEN) == 0) {
            return &users[i];
        }
    }
    return NULL;
}

static tenant_t *find_tenant(uint32_t tenant_id)
{
    for (int i = 0; i < MAX_TENANTS; i++) {
        if (tenants[i].active && tenants[i].tenant_id == tenant_id) {
            return &tenants[i];
        }
    }
    return NULL;
}

static resource_t *find_resource(uint32_t resource_id)
{
    for (int i = 0; i < MAX_RESOURCES; i++) {
        if (resources[i].active && resources[i].resource_id == resource_id) {
            return &resources[i];
        }
    }
    return NULL;
}

static config_entry_t *find_config(const char *key)
{
    for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
        if (sys_config[i].active &&
            strncmp(sys_config[i].key, key, MAX_NAME_LEN) == 0) {
            return &sys_config[i];
        }
    }
    return NULL;
}

/**
 * Core authorization check.
 * Enforces:
 *   1. User exists and is active/unlocked
 *   2. Tenant exists and is active
 *   3. User belongs to the resource's tenant (tenant isolation)
 *   4. User has the required role for the resource
 *   5. User has the required permissions for the operation
 *   6. Field-level permission check for config entries
 *
 * Returns 0 on success, negative error code on denial.
 */
static int authorize_operation(uint32_t user_id, uint32_t resource_id,
                               operation_t op, const char *field_key)
{
    int ret = -EACCES;

    k_mutex_lock(&priv_mutex, K_FOREVER);

    /* Step 1: Validate user */
    user_t *user = find_user(user_id);
    if (!user) {
        LOG_WRN("AUTH DENIED: user %u not found", user_id);
        audit_record(user_id, 0, resource_id, op, OP_STATUS_DENIED,
                     "user not found");
        ret = -ENOENT;
        goto out;
    }

    if (!user->active) {
        LOG_WRN("AUTH DENIED: user %u inactive", user_id);
        audit_record(user_id, user->tenant_id, resource_id, op,
                     OP_STATUS_DENIED, "user inactive");
        ret = -EACCES;
        goto out;
    }

    if (user->locked) {
        LOG_WRN("AUTH DENIED: user %u locked", user_id);
        audit_record(user_id, user->tenant_id, resource_id, op,
                     OP_STATUS_DENIED, "user locked");
        ret = -EACCES;
        goto out;
    }

    /* Step 2: Validate tenant */
    tenant_t *tenant = find_tenant(user->tenant_id);
    if (!tenant || !tenant->active) {
        LOG_WRN("AUTH DENIED: tenant %u invalid for user %u",
                user->tenant_id, user_id);
        audit_record(user_id, user->tenant_id, resource_id, op,
                     OP_STATUS_DENIED, "tenant invalid");
        ret = -EACCES;
        goto out;
    }

    /* Step 3: Tenant isolation - check resource belongs to user's tenant */
    if (resource_id != 0) {
        resource_t *resource = find_resource(resource_id);
        if (!resource || !resource->active) {
            LOG_WRN("AUTH DENIED: resource %u not found", resource_id);
            audit_record(user_id, user->tenant_id, resource_id, op,
                         OP_STATUS_DENIED, "resource not found");
            ret = -ENOENT;
            goto out;
        }

        /* Enforce tenant boundary: user can only access resources in their tenant */
        if (resource->tenant_id != user->tenant_id) {
            LOG_WRN("AUTH DENIED: tenant mismatch user_tenant=%u resource_tenant=%u",
                    user->tenant_id, resource->tenant_id);
            audit_record(user_id, user->tenant_id, resource_id, op,
                         OP_STATUS_DENIED, "tenant isolation violation");
            ret = -EACCES;
            goto out;
        }

        /* Step 4: Role check against resource requirements */
        if (resource->required_roles != ROLE_NONE &&
            !(user->roles & resource->required_roles)) {
            LOG_WRN("AUTH DENIED: insufficient role user_roles=0x%x required=0x%x",
                    user->roles, resource->required_roles);
            audit_record(user_id, user->tenant_id, resource_id, op,
                         OP_STATUS_DENIED, "insufficient role");
            ret = -EACCES;
            goto out;
        }

        /* Step 5: Permission check against resource requirements */
        permission_t effective = get_effective_perms(user);
        if (resource->required_perms != PERM_NONE &&
            (effective & resource->required_perms) != resource->required_perms) {
            LOG_WRN("AUTH DENIED: insufficient perms effective=0x%x required=0x%x",
                    effective, resource->required_perms);
            audit_record(user_id, user->tenant_id, resource_id, op,
                         OP_STATUS_DENIED, "insufficient permissions");
            ret = -EACCES;
            goto out;
        }
    }

    /* Step 5b: Operation-specific permission checks */
    permission_t effective = get_effective_perms(user);
    permission_t op_required = PERM_NONE;

    switch (op) {
    case OP_FLASH_WRITE:
        op_required = PERM_WRITE_FLASH;
        break;
    case OP_FLASH_READ:
        op_required = PERM_READ_FLASH;
        break;
    case OP_CONFIG_SET:
        op_required = PERM_WRITE_CONFIG;
        break;
    case OP_CONFIG_GET:
        op_required = PERM_READ_CONFIG;
        break;
    case OP_CONFIG_DELETE:
        op_required = PERM_WRITE_CONFIG;
        break;
    case OP_USER_CREATE:
        op_required = PERM_CREATE_USER;
        break;
    case OP_USER_DELETE:
        op_required = PERM_DELETE_USER;
        break;
    case OP_ROLE_MODIFY:
        op_required = PERM_MODIFY_ROLE;
        break;
    case OP_SYSTEM_REBOOT:
        op_required = PERM_SYSTEM_REBOOT;
        break;
    default:
        break;
    }

    if (op_required != PERM_NONE && !(effective & op_required)) {
        LOG_WRN("AUTH DENIED: op perm check failed effective=0x%x op_required=0x%x",
                effective, op_required);
        audit_record(user_id, user->tenant_id, resource_id, op,
                     OP_STATUS_DENIED, "operation permission denied");
        ret = -EACCES;
        goto out;
    }

    /* Step 6: Field-level permission check for config operations */
    if (field_key && (op == OP_CONFIG_SET || op == OP_CONFIG_GET ||
                      op == OP_CONFIG_DELETE)) {
        config_entry_t *cfg = find_config(field_key);
        if (cfg) {
            /* Check tenant ownership of config entry */
            if (cfg->owner_tenant_id != 0 &&
                cfg->owner_tenant_id != user->tenant_id) {
                LOG_WRN("AUTH DENIED: config tenant mismatch key=%s", field_key);
                audit_record(user_id, user->tenant_id, resource_id, op,
                             OP_STATUS_DENIED, "config tenant mismatch");
                ret = -EACCES;
                goto out;
            }

            /* Check field-level read permission */
            if (op == OP_CONFIG_GET && cfg->read_perm != PERM_NONE &&
                !(effective & cfg->read_perm)) {
                LOG_WRN("AUTH DENIED: config read perm for key=%s", field_key);
                audit_record(user_id, user->tenant_id, resource_id, op,
                             OP_STATUS_DENIED, "config field read denied");
                ret = -EACCES;
                goto out;
            }

            /* Check field-level write permission */
            if ((op == OP_CONFIG_SET || op == OP_CONFIG_DELETE)) {
                if (cfg->readonly) {
                    LOG_WRN("AUTH DENIED: config key=%s is readonly", field_key);
                    audit_record(user_id, user->tenant_id, resource_id, op,
                                 OP_STATUS_DENIED, "config field readonly");
                    ret = -EACCES;
                    goto out;
                }
                if (cfg->write_perm != PERM_NONE &&
                    !(effective & cfg->write_perm)) {
                    LOG_WRN("AUTH DENIED: config write perm for key=%s",
                            field_key);
                    audit_record(user_id, user->tenant_id, resource_id, op,
                                 OP_STATUS_DENIED, "config field write denied");
                    ret = -EACCES;
                    goto out;
                }
            }
        }
    }

    /* Step 6b: Role escalation prevention for role modification */
    if (op == OP_ROLE_MODIFY) {
        /* Users cannot grant roles higher than their own */
        /* This is checked later in execute, but we do a preliminary check */
        if (!(user->roles & (ROLE_ADMIN | ROLE_SUPERADMIN))) {
            LOG_WRN("AUTH DENIED: only admin/superadmin can modify roles");
            audit_record(user_id, user->tenant_id, resource_id, op,
                         OP_STATUS_DENIED, "role modify requires admin");
            ret = -EACCES;
            goto out;
        }
    }

    /* All checks passed */
    audit_record(user_id, user->tenant_id, resource_id, op,
                 OP_STATUS_APPROVED, "authorized");
    ret = 0;

out:
    k_mutex_unlock(&priv_mutex);
    return ret;
}

/* ============================================================
 * Privileged Operations (executed by admin task)
 * ============================================================ */

static int priv_flash_write(uint32_t address, const uint8_t *data, size_t len)
{
    if (address + len > SIMULATED_FLASH_SIZE) {
        LOG_ERR("Flash write out of bounds: addr=0x%x len=%zu", address, len);
        return -EINVAL;
    }

    k_mutex_lock(&flash_mutex, K_FOREVER);
    memcpy(&simulated_flash[address], data, len);
    k_mutex_unlock(&flash_mutex);

    LOG_INF("Flash write: addr=0x%x len=%zu", address, len);
    return 0;
}

static int priv_flash_read(uint32_t address, uint8_t *data, size_t len)
{
    if (address + len > SIMULATED_FLASH_SIZE) {
        LOG_ERR("Flash read out of bounds: addr=0x%x len=%zu", address, len);
        return -EINVAL;
    }

    k_mutex_lock(&flash_mutex, K_FOREVER);
    memcpy(data, &simulated_flash[address], len);
    k_mutex_unlock(&flash_mutex);

    LOG_INF("Flash read: addr=0x%x len=%zu", address, len);
    return 0;
}

static int priv_config_set(const char *key, const char *value,
                           uint32_t tenant_id)
{
    k_mutex_lock(&config_mutex, K_FOREVER);

    config_entry_t *entry = find_config(key);
    if (entry) {
        if (entry->readonly) {
            k_mutex_unlock(&config_mutex);
            LOG_WRN("Config set denied: key=%s is readonly", key);
            return -EACCES;
        }
        /* Enforce tenant ownership on update */
        if (entry->owner_tenant_id != 0 &&
            entry->owner_tenant_id != tenant_id) {
            k_mutex_unlock(&config_mutex);
            LOG_WRN("Config set denied: tenant mismatch for key=%s", key);
            return -EACCES;
        }
        strncpy(entry->value, value, MAX_VALUE_LEN - 1);
        entry->value[MAX_VALUE_LEN - 1] = '\0';
        LOG_INF("Config updated: %s = %s", key, value);
    } else {
        /* Find empty slot */
        config_entry_t *slot = NULL;
        for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
            if (!sys_config[i].active) {
                slot = &sys_config[i];
                break;
            }
        }
        if (!slot) {
            k_mutex_unlock(&config_mutex);
            LOG_ERR("Config full, cannot add key=%s", key);
            return -ENOMEM;
        }
        strncpy(slot->key, key, MAX_NAME_LEN - 1);
        slot->key[MAX_NAME_LEN - 1] = '\0';
        strncpy(slot->value, value, MAX_VALUE_LEN - 1);
        slot->value[MAX_VALUE_LEN - 1] = '\0';
        slot->owner_tenant_id = tenant_id;
        slot->write_perm = PERM_WRITE_CONFIG;
        slot->read_perm = PERM_READ_CONFIG;
        slot->readonly = false;
        slot->active = true;
        LOG_INF("Config created: %s = %s (tenant=%u)", key, value, tenant_id);
    }

    k_mutex_unlock(&config_mutex);
    return 0;
}

static int priv_config_get(const char *key, char *value, size_t value_len)
{
    k_mutex_lock(&config_mutex, K_FOREVER);

    config_entry_t *entry = find_config(key);
    if (!entry) {
        k_mutex_unlock(&config_mutex);
        return -ENOENT;
    }

    strncpy(value, entry->value, value_len - 1);
    value[value_len - 1] = '\0';

    k_mutex_unlock(&config_mutex);
    LOG_INF("Config read: %s = %s", key, value);
    return 0;
}

static int priv_user_create(const char *username, uint32_t tenant_id,
                            role_t initial_role, uint32_t requesting_user_id)
{
    k_mutex_lock(&user_mutex, K_FOREVER);

    /* Check if username already exists */
    if (find_user_by_name(username)) {
        k_mutex_unlock(&user_mutex);
        LOG_WRN("User create denied: username=%s already exists", username);
        return -EEXIST;
    }

    /* Verify tenant exists */
    if (!find_tenant(tenant_id)) {
        k_mutex_unlock(&user_mutex);
        LOG_WRN("User create denied: tenant %u not found", tenant_id);
        return -ENOENT;
    }

    /* Prevent privilege escalation: requester cannot create user with higher role */
    user_t *requester = find_user(requesting_user_id);
    if (requester) {
        /* Non-superadmin cannot create superadmin users */
        if ((initial_role & ROLE_SUPERADMIN) &&
            !(requester->roles & ROLE_SUPERADMIN)) {
            k_mutex_unlock(&user_mutex);
            LOG_WRN("User create denied: cannot escalate to superadmin");
            return -EACCES;
        }
        /* Admin cannot create admin in different tenant */
        if (requester->tenant_id != tenant_id &&
            !(requester->roles & ROLE_SUPERADMIN)) {
            k_mutex_unlock(&user_mutex);
            LOG_WRN("User create denied: cross-tenant creation requires superadmin");
            return -EACCES;
        }
    }

    /* Find empty slot */
    user_t *slot = NULL;
    uint32_t new_id = 0;
    for (int i = 0; i < MAX_USERS; i++) {
        if (!users[i].active) {
            slot = &users[i];
            new_id = (uint32_t)(i + 1);
            break;
        }
    }

    if (!slot) {
        k_mutex_unlock(&user_mutex);
        LOG_ERR("User table full");
        return -ENOMEM;
    }

    slot->user_id = new_id;
    slot->tenant_id = tenant_id;
    strncpy(slot->username, username, MAX_NAME_LEN - 1);
    slot->username[MAX_NAME_LEN - 1] = '\0';
    slot->roles = initial_role;
    slot->perms = PERM_NONE;
    slot->active = true;
    slot->locked = false;

    k_mutex_unlock(&user_mutex);
    LOG_INF("User created: id=%u name=%s tenant=%u role=0x%x",
            new_id, username, tenant_id, initial_role);
    return 0;
}

static int priv_role_modify(uint32_t target_user_id, role_t new_role,
                            uint32_t requesting_user_id)
{
    k_mutex_lock(&user_mutex, K_FOREVER);

    user_t *target = find_user(target_user_id);
    if (!target) {
        k_mutex_unlock(&user_mutex);
        return -ENOENT;
    }

    user_t *requester = find_user(requesting_user_id);
    if (!requester) {
        k_mutex_unlock(&user_mutex);
        return -ENOENT;
    }

    /* Prevent privilege escalation */
    /* Cannot grant a role you don't have (except superadmin can do anything) */
    if (!(requester->roles & ROLE_SUPERADMIN)) {
        if (new_role & ~(requester->roles)) {
            k_mutex_unlock(&user_mutex);
            LOG_WRN("Role modify denied: escalation attempt user=%u target=%u new_role=0x%x",
                    requesting_user_id, target_user_id, new_role);
            audit_record(requesting_user_id, requester->tenant_id, 0,
                         OP_ROLE_MODIFY, OP_STATUS_DENIED,
                         "privilege escalation blocked");
            return -EACCES;
        }
        /* Cannot modify users in different tenant */
        if (target->tenant_id != requester->tenant_id) {
            k_mutex_unlock(&user_mutex);
            LOG_WRN("Role modify denied: cross-tenant modification");
            return -EACCES;
        }
    }

    /* Cannot demote yourself from superadmin (safety) */
    if (target_user_id == requesting_user_id &&
        (target->roles & ROLE_SUPERADMIN) &&
        !(new_role & ROLE_SUPERADMIN)) {
        k_mutex_unlock(&user_mutex);
        LOG_WRN("Role modify denied: cannot self-demote from superadmin");
        return -EACCES;
    }

    role_t old_role = target->roles;
    target->roles = new_role;

    k_mutex_unlock(&user_mutex);
    LOG_INF("Role modified: user=%u old=0x%x new=0x%x by user=%u",
            target_user_id, old_role, new_role, requesting_user_id);
    return 0;
}

/* ============================================================
 * Operation Request/Response System
 * ============================================================ */

static priv_operation_t *alloc_operation(void)
{
    for (int i = 0; i < MAX_PENDING_OPS; i++) {
        if (pending_ops[i].status == OP_STATUS_COMPLETED ||
            pending_ops[i].request_id == 0) {
            memset(&pending_ops[i], 0, sizeof(priv_operation_t));
            pending_ops[i].request_id = next_request_id++;
            pending_ops[i].status = OP_STATUS_PENDING;
            return &pending_ops[i];
        }
    }
    return NULL;
}

static priv_operation_t *find_operation(uint32_t request_id)
{
    for (int i = 0; i < MAX_PENDING_OPS; i++) {
        if (pending_ops[i].request_id == request_id) {
            return &pending_ops[i];
        }
    }
    return NULL;
}

/**
 * Submit an operation request (called by user/operator tasks).
 * Returns request_id on success, negative error on failure.
 */
static int submit_operation(uint32_t user_id, uint32_t resource_id,
                            operation_t op, priv_operation_t **out_op)
{
    k_mutex_lock(&priv_mutex, K_FOREVER);

    priv_operation_t *pop = alloc_operation();
    if (!pop) {
        k_mutex_unlock(&priv_mutex);
        LOG_ERR("No free operation slots");
        return -ENOMEM;
    }

    pop->requester_user_id = user_id;
    pop->target_resource_id = resource_id;
    pop->operation = op;
    pop->status = OP_STATUS_PENDING;
    pop->completed = false;

    if (out_op) {
        *out_op = pop;
    }

    uint32_t req_id = pop->request_id;

    k_mutex_unlock(&priv_mutex);

    /* Enqueue for admin processing */
    int ret = k_msgq_put(&op_request_queue, &req_id, K_MSEC(1000));
    if (ret != 0) {
        LOG_ERR("Failed to enqueue operation request %u", req_id);
        pop->status = OP_STATUS_FAILED;
        return -EIO;
    }

    LOG_INF("Operation submitted: req_id=%u user=%u op=%d resource=%u",
            req_id, user_id, op, resource_id);
    return (int)req_id;
}

/**
 * Wait for an operation to complete.
 */
static int wait_for_operation(uint32_t request_id, k_timeout_t timeout)
{
    int64_t end_time = k_uptime_get() + k_ticks_to_ms_floor64(timeout.ticks);

    while (k_uptime_get() < end_time) {
        k_sem_take(&op_complete_sem, K_MSEC(100));

        priv_operation_t *pop = find_operation(request_id);
        if (pop && pop->completed) {
            return pop->result_code;
        }
    }

    return -ETIMEDOUT;
}

/* ============================================================
 * Admin Task - Processes privileged operations
 * ============================================================ */

static void admin_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    LOG_INF("Admin task started");

    while (1) {
        uint32_t req_id;
        int ret = k_msgq_get(&op_request_queue, &req_id, K_FOREVER);
        if (ret != 0) {
            continue;
        }

        LOG_INF("Admin processing request %u", req_id);

        k_mutex_lock(&priv_mutex, K_FOREVER);
        priv_operation_t *pop = find_operation(req_id);
        if (!pop) {
            k_mutex_unlock(&priv_mutex);
            LOG_WRN("Request %u not found", req_id);
            continue;
        }

        /* Copy operation data under lock */
        priv_operation_t op_copy = *pop;
        k_mutex_unlock(&priv_mutex);

        /* Server-side authorization check - ALWAYS performed regardless of
         * who submitted the request */
        const char *field_key = NULL;
        if (op_copy.operation == OP_CONFIG_SET ||
            op_copy.operation == OP_CONFIG_GET ||
            op_copy.operation == OP_CONFIG_DELETE) {
            field_key = op_copy.params.config_req.key;
        }

        ret = authorize_operation(op_copy.requester_user_id,
                                  op_copy.target_resource_id,
                                  op_copy.operation,
                                  field_key);

        if (ret != 0) {
            k_mutex_lock(&priv_mutex, K_FOREVER);
            pop->status = OP_STATUS_DENIED;
            pop->result_code = ret;
            pop->completed = true;
            k_mutex_unlock(&priv_mutex);
            k_sem_give(&op_complete_sem);
            LOG_WRN("Request %u DENIED for user %u (ret=%d)",
                    req_id, op_copy.requester_user_id, ret);
            continue;
        }

        /* Execute the privileged operation */
        int exec_ret = 0;
        user_t *req_user = find_user(op_copy.requester_user_id);
        uint32_t req_tenant = req_user ? req_user->tenant_id : 0;

        switch (op_copy.operation) {
        case OP_FLASH_WRITE:
            exec_ret = priv_flash_write(
                op_copy.params.flash_req.address,
                op_copy.params.flash_req.data,
                op_copy.params.flash_req.length);
            audit_record(op_copy.requester_user_id, req_tenant,
                         op_copy.target_resource_id, OP_FLASH_WRITE,
                         exec_ret == 0 ? OP_STATUS_COMPLETED : OP_STATUS_FAILED,
                         "flash write executed");
            break;

        case OP_FLASH_READ: {
            uint8_t read_buf[64];
            exec_ret = priv_flash_read(
                op_copy.params.flash_req.address,
                read_buf,
                op_copy.params.flash_req.length);
            audit_record(op_copy.requester_user_id, req_tenant,
                         op_copy.target_resource_id, OP_FLASH_READ,
                         exec_ret == 0 ? OP_STATUS_COMPLETED : OP_STATUS_FAILED,
                         "flash read executed");
            break;
        }

        case OP_CONFIG_SET:
            exec_ret = priv_config_set(
                op_copy.params.config_req.key,
                op_copy.params.config_req.value,
                req_tenant);
            audit_record(op_copy.requester_user_id, req_tenant,
                         op_copy.target_resource_id, OP_CONFIG_SET,
                         exec_ret == 0 ? OP_STATUS_COMPLETED : OP_STATUS_FAILED,
                         op_copy.params.config_req.key);
            break;

        case OP_CONFIG_GET: {
            char val_buf[MAX_VALUE_LEN];
            exec_ret = priv_config_get(
                op_copy.params.config_req.key,
                val_buf, sizeof(val_buf));
            audit_record(op_copy.requester_user_id, req_tenant,
                         op_copy.target_resource_id, OP_CONFIG_GET,
                         exec_ret == 0 ? OP_STATUS_COMPLETED : OP_STATUS_FAILED,
                         op_copy.params.config_req.key);
            break;
        }

        case OP_USER_CREATE:
            exec_ret = priv_user_create(
                op_copy.params.user_req.username,
                op_copy.params.user_req.tenant_id,
                op_copy.params.user_req.initial_role,
                op_copy.requester_user_id);
            audit_record(op_copy.requester_user_id, req_tenant,
                         0, OP_USER_CREATE,
                         exec_ret == 0 ? OP_STATUS_COMPLETED : OP_STATUS_FAILED,
                         op_copy.params.user_req.username);
            break;

        case OP_ROLE_MODIFY:
            exec_ret = priv_role_modify(
                op_copy.params.role_req.target_user_id,
                op_copy.params.role_req.new_role,
                op_copy.requester_user_id);
            audit_record(op_copy.requester_user_id, req_tenant,
                         0, OP_ROLE_MODIFY,
                         exec_ret == 0 ? OP_STATUS_COMPLETED : OP_STATUS_FAILED,
                         "role modification");
            break;

        case OP_SYSTEM_REBOOT:
            LOG_INF("SYSTEM REBOOT requested by user %u (simulated)",
                    op_copy.requester_user_id);
            audit_record(op_copy.requester_user_id, req_tenant,
                         0, OP_SYSTEM_REBOOT, OP_STATUS_COMPLETED,
                         "system reboot simulated");
            exec_ret = 0;
            break;

        default:
            exec_ret = -ENOTSUP;
            break;
        }

        /* Update operation status */
        k_mutex_lock(&priv_mutex, K_FOREVER);
        pop->status = (exec_ret == 0) ? OP_STATUS_COMPLETED : OP_STATUS_FAILED;
        pop->result_code = exec_ret;
        pop->completed = true;
        k_mutex_unlock(&priv_mutex);

        k_sem_give(&op_complete_sem);

        LOG_INF("Request %u completed with result %d", req_id, exec_ret);
    }
}

/* ============================================================
 * User Task - Demonstrates requesting admin operations
 * ============================================================ */

static void user_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    /* Wait for system initialization */
    k_sleep(K_MSEC(500));

    LOG_INF("User task started (user_id=2, role=USER)");

    /* Test 1: User tries to read config (should succeed) */
    {
        LOG_INF("=== TEST 1: User reads config ===");
        priv_operation_t *op;
        int req_id = submit_operation(2, 1, OP_CONFIG_GET, &op);
        if (req_id > 0) {
            strncpy(op->params.config_req.key, "system.hostname",
                    MAX_NAME_LEN - 1);
            int result = wait_for_operation((uint32_t)req_id, K_SECONDS(5));
            LOG_INF("TEST 1 result: %d (expected: 0 = success)", result);
        }
    }

    k_sleep(K_MSEC(200));

    /* Test 2: User tries to write flash (should be DENIED - no WRITE_FLASH perm) */
    {
        LOG_INF("=== TEST 2: User writes flash (should fail) ===");
        priv_operation_t *op;
        int req_id = submit_operation(2, 2, OP_FLASH_WRITE, &op);
        if (req_id > 0) {
            op->params.flash_req.address = 0x100;
            op->params.flash_req.data[0] = 0xAB;
            op->params.flash_req.length = 1;
            int result = wait_for_operation((uint32_t)req_id, K_SECONDS(5));
            LOG_INF("TEST 2 result: %d (expected: -13 = EACCES)", result);
        }
    }

    k_sleep(K_MSEC(200));

    /* Test 3: User tries to write config (should be DENIED) */
    {
        LOG_INF("=== TEST 3: User writes config (should fail) ===");
        priv_operation_t *op;
        int req_id = submit_operation(2, 1, OP_CONFIG_SET, &op);
        if (req_id > 0) {
            strncpy(op->params.config_req.key, "system.hostname",
                    MAX_NAME_LEN - 1);
            strncpy(op->params.config_req.value, "hacked-host",
                    MAX_VALUE_LEN - 1);
            int result = wait_for_operation((uint32_t)req_id, K_SECONDS(5));
            LOG_INF("TEST 3 result: %d (expected: -13 = EACCES)", result);
        }
    }

    k_sleep(K_MSEC(200));

    /* Test 4: User tries to access resource in different tenant (should fail) */
    {
        LOG_INF("=== TEST 4: Cross-tenant access (should fail) ===");
        priv_operation_t *op;
        /* Resource 3 belongs to tenant 2, user 2 belongs to tenant 1 */
        int req_id = submit_operation(2, 3, OP_CONFIG_GET, &op);
        if (req_id > 0) {
            strncpy(op->params.config_req.key, "other.setting",
                    MAX_NAME_LEN - 1);
            int result = wait_for_operation((uint32_t)req_id, K_SECONDS(5));
            LOG_INF("TEST 4 result: %d (expected: -13 = EACCES)", result);
        }
    }

    k_sleep(K_MSEC(200));

    /* Test 5: User tries to create another user (should fail) */
    {
        LOG_INF("=== TEST 5: User creates user (should fail) ===");
        priv_operation_t *op;
        int req_id = submit_operation(2, 0, OP_USER_CREATE, &op);
        if (req_id > 0) {
            strncpy(op->params.user_req.username, "evil_user",
                    MAX_NAME_LEN - 1);
            op->params.user_req.tenant_id = 1;
            op->params.user_req.initial_role = ROLE_ADMIN;
            int result = wait_for_operation((uint32_t)req_id, K_SECONDS(5));
            LOG_INF("TEST 5 result: %d (expected: -13 = EACCES)", result);
        }
    }

    k_sleep(K_MSEC(200));

    /* Test 6: User reads flash (should succeed - has READ_FLASH) */
    {
        LOG_INF("=== TEST 6: User reads flash (should succeed) ===");
        priv_operation_t *op;
        int req_id = submit_operation(2, 2, OP_FLASH_READ, &op);
        if (req_id > 0) {
            op->params.flash_req.address = 0x0;
            op->params.flash_req.length = 16;
            int result = wait_for_operation((uint32_t)req_id, K_SECONDS(5));
            LOG_INF("TEST 6 result: %d (expected: 0 = success)", result);
        }
    }

    LOG_INF("User task tests completed");

    while (1) {
        k_sleep(K_SECONDS(10));
    }
}

/* ============================================================
 * Operator Task - Has more privileges than user
 * ============================================================ */

static void operator_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    /* Wait for user tests to complete */
    k_sleep(K_MSEC(3000));

    LOG_INF("Operator task started (user_id=3, role=ADMIN)");

    /* Test 7: Admin writes flash (should succeed) */
    {
        LOG_INF("=== TEST 7: Admin writes flash ===");
        priv_operation_t *op;
        int req_id = submit_operation(3, 2, OP_FLASH_WRITE, &op);
        if (req_id > 0) {
            op->params.flash_req.address = 0x100;
            memcpy(op->params.flash_req.data, "ADMIN_DATA", 10);
            op->params.flash_req.length = 10;
            int result = wait_for_operation((uint32_t)req_id, K_SECONDS(5));
            LOG_INF("TEST 7 result: %d (expected: 0 = success)", result);
        }
    }

    k_sleep(K_MSEC(200));

    /* Test 8: Admin modifies config (should succeed) */
    {
        LOG_INF("=== TEST 8: Admin modifies config ===");
        priv_operation_t *op;
        int req_id = submit_operation(3, 1, OP_CONFIG_SET, &op);
        if (req_id > 0) {
            strncpy(op->params.config_req.key, "system.hostname",
                    MAX_NAME_LEN - 1);
            strncpy(op->params.config_req.value, "admin-updated-host",
                    MAX_VALUE_LEN - 1);
            int result = wait_for_operation((uint32_t)req_id, K_SECONDS(5));
            LOG_INF("TEST 8 result: %d (expected: 0 = success)", result);
        }
    }

    k_sleep(K_MSEC(200));

    /* Test 9: Admin creates a new user (should succeed) */
    {
        LOG_INF("=== TEST 9: Admin creates user ===");
        priv_operation_t *op;
        int req_id = submit_operation(3, 0, OP_USER_CREATE, &op);
        if (req_id > 0) {
            strncpy(op->params.user_req.username, "new_operator",
                    MAX_NAME_LEN - 1);
            op->params.user_req.tenant_id = 1;
            op->params.user_req.initial_role = ROLE_OPERATOR;
            int result = wait_for_operation((uint32_t)req_id, K_SECONDS(5));
            LOG_INF("TEST 9 result: %d (expected: 0 = success)", result);
        }
    }

    k_sleep(K_MSEC(200));

    /* Test 10: Admin tries to modify readonly config (should fail) */
    {
        LOG_INF("=== TEST 10: Admin modifies readonly config (should fail) ===");
        priv_operation_t *op;
        int req_id = submit_operation(3, 1, OP_CONFIG_SET, &op);
        if (req_id > 0) {
            strncpy(op->params.config_req.key, "system.serial",
                    MAX_NAME_LEN - 1);
            strncpy(op->params.config_req.value, "TAMPERED",
                    MAX_VALUE_LEN - 1);
            int result = wait_for_operation((uint32_t)req_id, K_SECONDS(5));
            LOG_INF("TEST 10 result: %d (expected: -13 = EACCES, readonly)",
                    result);
        }
    }

    k_sleep(K_MSEC(200));

    /* Test 11: Admin tries privilege escalation - grant superadmin (should fail) */
    {
        LOG_INF("=== TEST 11: Admin escalation attempt (should fail) ===");
        priv_operation_t *op;
        int req_id = submit_operation(3, 0, OP_ROLE_MODIFY, &op);
        if (req_id > 0) {
            op->params.role_req.target_user_id = 2;
            op->params.role_req.new_role = ROLE_SUPERADMIN;
            int result = wait_for_operation((uint32_t)req_id, K_SECONDS(5));
            LOG_INF("TEST 11 result: %d (expected: -13 = EACCES, escalation blocked)",
                    result);
        }
    }

    k_sleep(K_MSEC(200));

    /* Test 12: Superadmin modifies role (should succeed) */
    {
        LOG_INF("=== TEST 12: Superadmin modifies role ===");
        priv_operation_t *op;
        int req_id = submit_operation(1, 0, OP_ROLE_MODIFY, &op);
        if (req_id > 0) {
            op->params.role_req.target_user_id = 2;
            op->params.role_req.new_role = ROLE_USER | ROLE_OPERATOR;
            int result = wait_for_operation((uint32_t)req_id, K_SECONDS(5));
            LOG_INF("TEST 12 result: %d (expected: 0 = success)", result);
        }
    }

    LOG_INF("Operator task tests completed");

    while (1) {
        k_sleep(K_SECONDS(10));
    }
}

/* ============================================================
 * Audit Display Task
 * ============================================================ */

static void audit_display_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    /* Wait for all tests to complete */
    k_sleep(K_SECONDS(8));

    LOG_INF("========================================");
    LOG_INF("         AUDIT LOG SUMMARY");
    LOG_INF("========================================");

    k_mutex_lock(&audit_mutex, K_FOREVER);

    uint32_t count = (audit_log_idx < AUDIT_LOG_SIZE) ?
                     audit_log_idx : AUDIT_LOG_SIZE;
    uint32_t start = (audit_log_idx < AUDIT_LOG_SIZE) ?
                     0 : (audit_log_idx % AUDIT_LOG_SIZE);

    for (uint32_t i = 0; i < count; i++) {
        uint32_t idx = (start + i) % AUDIT_LOG_SIZE;
        audit_entry_t *e = &audit_log[idx];

        const char *status_str;
        switch (e->result) {
        case OP_STATUS_APPROVED:  status_str = "APPROVED";  break;
        case OP_STATUS_DENIED:    status_str = "DENIED";    break;
        case OP_STATUS_COMPLETED: status_str = "COMPLETED"; break;
        case OP_STATUS_FAILED:    status_str = "FAILED";    break;
        default:                  status_str = "UNKNOWN";   break;
        }

        const char *op_str;
        switch (e->operation) {
        case OP_FLASH_WRITE:   op_str = "FLASH_WRITE";   break;
        case OP_FLASH_READ:    op_str = "FLASH_READ";    break;
        case OP_CONFIG_SET:    op_str = "CONFIG_SET";     break;
        case OP_CONFIG_GET:    op_str = "CONFIG_GET";     break;
        case OP_CONFIG_DELETE: op_str = "CONFIG_DELETE";  break;
        case OP_USER_CREATE:   op_str = "USER_CREATE";   break;
        case OP_USER_DELETE:   op_str = "USER_DELETE";    break;
        case OP_ROLE_MODIFY:   op_str = "ROLE_MODIFY";   break;
        case OP_SYSTEM_REBOOT: op_str = "SYS_REBOOT";    break;
        default:               op_str = "UNKNOWN";        break;
        }

        LOG_INF("[%u] t=%u user=%u tenant=%u res=%u op=%s status=%s [%s]",
                i, e->timestamp, e->user_id, e->tenant_id,
                e->resource_id, op_str, status_str, e->detail);
    }

    k_mutex_unlock(&audit_mutex);

    LOG_INF("========================================");
    LOG_INF("Total audit entries: %u", count);
    LOG_INF("========================================");

    while (1) {
        k_sleep(K_SECONDS(60));
    }
}

/* ============================================================
 * System Initialization
 * ============================================================ */

static void init_tenants(void)
{
    tenants[0] = (tenant_t){
        .tenant_id = 1,
        .name = "engineering",
        .active = true,
    };
    tenants[1] = (tenant_t){
        .tenant_id = 2,
        .name = "production",
        .active = true,
    };
}

static void init_users(void)
{
    /* Superadmin - full access */
    users[0] = (user_t){
        .user_id = 1,
        .tenant_id = 1,
        .username = "superadmin",
        .roles = ROLE_SUPERADMIN | ROLE_ADMIN | ROLE_OPERATOR | ROLE_USER,
        .perms = PERM_NONE,
        .active = true,
        .locked = false,
    };

    /* Regular user - limited access */
    users[1] = (user_t){
        .user_id = 2,
        .tenant_id = 1,
        .username = "regular_user",
        .roles = ROLE_USER,
        .perms = PERM_NONE,
        .active = true,
        .locked = false,
    };

    /* Admin user */
    users[2] = (user_t){
        .user_id = 3,
        .tenant_id = 1,
        .username = "admin_user",
        .roles = ROLE_ADMIN | ROLE_OPERATOR | ROLE_USER,
        .perms = PERM_NONE,
        .active = true,
        .locked = false,
    };

    /* User in different tenant */
    users[3] = (user_t){
        .user_id = 4,
        .tenant_id = 2,
        .username = "prod_user",
        .roles = ROLE_USER,
        .perms = PERM_NONE,
        .active = true,
        .locked = false,
    };
}

static void init_resources(void)
{
    /* Config resource - tenant 1 */
    resources[0] = (resource_t){
        .resource_id = 1,
        .tenant_id = 1,
        .name = "system_config",
        .required_perms = PERM_NONE,  /* per-field checks handle this */
        .required_roles = ROLE_USER,
        .active = true,
    };

    /* Flash resource - tenant 1 */
    resources[1] = (resource_t){
        .resource_id = 2,
        .tenant_id = 1,
        .name = "flash_memory",
        .required_perms = PERM_NONE,  /* operation-level checks handle this */
        .required_roles = ROLE_USER,
        .active = true,
    };

    /* Config resource - tenant 2 (for cross-tenant test) */
    resources[2] = (resource_t){
        .resource_id = 3,
        .tenant_id = 2,
        .name = "prod_config",
        .required_perms = PERM_NONE,
        .required_roles = ROLE_USER,
        .active = true,
    };
}

static void init_config(void)
{
    /* Writable config entry */
    sys_config[0] = (config_entry_t){
        .key = "system.hostname",
        .value = "embedded-device-01",
        .owner_tenant_id = 1,
        .write_perm = PERM_WRITE_CONFIG,
        .read_perm = PERM_READ_CONFIG,
        .readonly = false,
        .active = true,
    };

    /* Readonly config entry */
    sys_config[1] = (config_entry_t){
        .key = "system.serial",
        .value = "SN-2024-001234",
        .owner_tenant_id = 0,  /* global */
        .write_perm = PERM_NONE,
        .read_perm = PERM_READ_CONFIG,
        .readonly = true,
        .active = true,
    };

    /* Admin-only config */
    sys_config[2] = (config_entry_t){
        .key = "security.key",
        .value = "secret-key-value",
        .owner_tenant_id = 1,
        .write_perm = PERM_WRITE_CONFIG,
        .read_perm = PERM_WRITE_CONFIG,  /* need write perm to even read */
        .readonly = false,
        .active = true,
    };
}

static void init_flash(void)
{
    memset(simulated_flash, 0xFF, SIMULATED_FLASH_SIZE);
    /* Write some initial data */
    const char *boot_marker = "BOOT_OK";
    memcpy(simulated_flash, boot_marker, strlen(boot_marker));
}

/* ============================================================
 * Main Entry Point
 * ============================================================ */

int main(void)
{
    LOG_INF("========================================");
    LOG_INF("  Embedded Privilege System Starting");
    LOG_INF("========================================");

    /* Initialize all subsystems */
    memset(tenants, 0, sizeof(tenants));
    memset(users, 0, sizeof(users));
    memset(resources, 0, sizeof(resources));
    memset(sys_config, 0, sizeof(sys_config));
    memset(pending_ops, 0, sizeof(pending_ops));
    memset(audit_log, 0, sizeof(audit_log));

    init_tenants();
    init_users();
    init_resources();
    init_config();
    init_flash();

    LOG_INF("Initialized: %d tenants, %d users, %d resources",
            MAX_TENANTS, MAX_USERS, MAX_RESOURCES);

    /* Start admin task (highest priority - processes privileged ops) */
    k_thread_create(&admin_thread_data, admin_stack,
                    K_THREAD_STACK_SIZEOF(admin_stack),
                    admin_task, NULL, NULL, NULL,
                    ADMIN_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(&admin_thread_data, "admin_task");

    /* Start user task (lower priority - submits requests) */
    k_thread_create(&user_thread_data, user_stack,
                    K_THREAD_STACK_SIZEOF(user_stack),
                    user_task, NULL, NULL, NULL,
                    USER_PRIORITY, 0, K_NO_WAIT);
    k_thread_name_set(&user_thread_data, "user_task");

    /* Start operator task */
    k_thread_create(&operator_thread_data, operator_stack,
                    K_THREAD_STACK_SIZEOF(operator_stack),
                    operator_task, NULL, NULL,