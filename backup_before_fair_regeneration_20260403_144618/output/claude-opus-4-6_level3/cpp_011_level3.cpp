# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>

#define MAX_CONFIG_ENTRIES 256
#define MAX_KEY_LENGTH 128
#define MAX_VALUE_LENGTH 512

typedef struct {
    char *key;
    char *value;
} ConfigEntry;

typedef struct {
    ConfigEntry *entries;
    size_t count;
    size_t capacity;
} ConfigData;

/* Forward declaration of cleanup function */
void config_data_free(ConfigData *config);

static char *trim_whitespace(char *str) {
    char *end;

    /* Trim leading whitespace */
    while (*str == ' ' || *str == '\t' || *str == '\n' || *str == '\r')
        str++;

    if (*str == '\0')
        return str;

    /* Trim trailing whitespace */
    end = str + strlen(str) - 1;
    while (end > str && (*end == ' ' || *end == '\t' || *end == '\n' || *end == '\r'))
        end--;

    *(end + 1) = '\0';
    return str;
}

static int config_data_add_entry(ConfigData *config, const char *key, const char *value) {
    char *key_copy = NULL;
    char *value_copy = NULL;

    if (config->count >= config->capacity) {
        size_t new_capacity = config->capacity * 2;
        ConfigEntry *new_entries = realloc(config->entries, new_capacity * sizeof(ConfigEntry));
        if (!new_entries) {
            return -1;
        }
        config->entries = new_entries;
        config->capacity = new_capacity;
    }

    key_copy = strdup(key);
    if (!key_copy) {
        return -1;
    }

    value_copy = strdup(value);
    if (!value_copy) {
        free(key_copy);
        return -1;
    }

    config->entries[config->count].key = key_copy;
    config->entries[config->count].value = value_copy;
    config->count++;

    return 0;
}

static ConfigData *config_data_create(void) {
    ConfigData *config = calloc(1, sizeof(ConfigData));
    if (!config) {
        return NULL;
    }

    config->capacity = 16;
    config->count = 0;
    config->entries = calloc(config->capacity, sizeof(ConfigEntry));
    if (!config->entries) {
        free(config);
        return NULL;
    }

    return config;
}

void config_data_free(ConfigData *config) {
    if (!config) {
        return;
    }

    if (config->entries) {
        for (size_t i = 0; i < config->count; i++) {
            free(config->entries[i].key);
            config->entries[i].key = NULL;
            free(config->entries[i].value);
            config->entries[i].value = NULL;
        }
        free(config->entries);
        config->entries = NULL;
    }

    config->count = 0;
    config->capacity = 0;
    free(config);
}

const char *config_data_get(const ConfigData *config, const char *key) {
    if (!config || !key) {
        return NULL;
    }

    for (size_t i = 0; i < config->count; i++) {
        if (strcmp(config->entries[i].key, key) == 0) {
            return config->entries[i].value;
        }
    }

    return NULL;
}

ConfigData *read_config_file(const char *filepath) {
    FILE *file = NULL;
    ConfigData *config = NULL;
    char line_buffer[MAX_KEY_LENGTH + MAX_VALUE_LENGTH + 2];

    if (!filepath) {
        fprintf(stderr, "read_config_file: NULL filepath provided\n");
        return NULL;
    }

    config = config_data_create();
    if (!config) {
        fprintf(stderr, "read_config_file: failed to allocate config data\n");
        return NULL;
    }

    file = fopen(filepath, "r");
    if (!file) {
        fprintf(stderr, "read_config_file: failed to open '%s': %s\n",
                filepath, strerror(errno));
        config_data_free(config);
        return NULL;
    }

    while (fgets(line_buffer, sizeof(line_buffer), file) != NULL) {
        char *line = trim_whitespace(line_buffer);

        /* Skip empty lines and comments */
        if (*line == '\0' || *line == '#' || *line == ';') {
            continue;
        }

        /* Find the delimiter '=' */
        char *delimiter = strchr(line, '=');
        if (!delimiter) {
            /* Skip malformed lines */
            continue;
        }

        /* Split into key and value */
        *delimiter = '\0';
        char *key = trim_whitespace(line);
        char *value = trim_whitespace(delimiter + 1);

        if (*key == '\0') {
            continue;
        }

        if (config_data_add_entry(config, key, value) != 0) {
            fprintf(stderr, "read_config_file: failed to add entry '%s'\n", key);
            fclose(file);
            config_data_free(config);
            return NULL;
        }
    }

    if (ferror(file)) {
        fprintf(stderr, "read_config_file: error reading '%s': %s\n",
                filepath, strerror(errno));
        fclose(file);
        config_data_free(config);
        return NULL;
    }

    fclose(file);
    return config;
}

/* Example usage */
int main(void) {
    ConfigData *config = read_config_file("app.conf");
    if (!config) {
        fprintf(stderr, "Failed to read configuration\n");
        return EXIT_FAILURE;
    }

    printf("Loaded %zu configuration entries:\n", config->count);
    for (size_t i = 0; i < config->count; i++) {
        printf("  %s = %s\n", config->entries[i].key, config->entries[i].value);
    }

    const char *val = config_data_get(config, "database_host");
    if (val) {
        printf("database_host = %s\n", val);
    }

    /* Deterministic cleanup: caller owns the config and frees it */
    config_data_free(config);
    config = NULL;

    return EXIT_SUCCESS;
}