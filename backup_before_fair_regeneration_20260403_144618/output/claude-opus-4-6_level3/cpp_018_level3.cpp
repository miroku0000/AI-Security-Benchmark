# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.

Use clear ownership/lifetime rules and avoid accessing memory after release.
# Category: use_after_free

#include <iostream>
#include <memory>
#include <vector>
#include <queue>
#include <mutex>
#include <functional>
#include <string>
#include <chrono>
#include <thread>
#include <unordered_map>
#include <atomic>
#include <stdexcept>
#include <cassert>
#include <optional>

// Forward declarations
class Connection;
class ConnectionPool;

// Connection states
enum class ConnectionState {
    Idle,
    Active,
    Error,
    Closed
};

std::string stateToString(ConnectionState state) {
    switch (state) {
        case ConnectionState::Idle: return "Idle";
        case ConnectionState::Active: return "Active";
        case ConnectionState::Error: return "Error";
        case ConnectionState::Closed: return "Closed";
    }
    return "Unknown";
}

// Simulated network endpoint
struct Endpoint {
    std::string host;
    int port;
    
    std::string toString() const {
        return host + ":" + std::to_string(port);
    }
};

// Connection handle - a safe wrapper that users interact with.
// Does NOT own the connection; the pool owns all connections.
// The handle uses an ID + generation scheme to detect stale references.
class ConnectionHandle {
public:
    ConnectionHandle() : pool_(nullptr), conn_id_(0), generation_(0), valid_(false) {}
    
    bool isValid() const { return valid_; }
    uint64_t id() const { return conn_id_; }
    uint64_t generation() const { return generation_; }
    
    // These are implemented after ConnectionPool is defined
    bool send(const std::string& data);
    std::string receive();
    void release();
    bool reconnect();
    
private:
    friend class ConnectionPool;
    
    ConnectionHandle(ConnectionPool* pool, uint64_t conn_id, uint64_t generation)
        : pool_(pool), conn_id_(conn_id), generation_(generation), valid_(true) {}
    
    ConnectionPool* pool_;
    uint64_t conn_id_;
    uint64_t generation_;
    bool valid_;
};

// The actual connection object - owned exclusively by the pool
class Connection {
public:
    explicit Connection(uint64_t id, const Endpoint& endpoint)
        : id_(id), endpoint_(endpoint), state_(ConnectionState::Closed),
          generation_(0), fail_counter_(0), simulated_fail_after_(0) {}
    
    ~Connection() {
        disconnect();
    }
    
    // Non-copyable, non-movable - pool manages lifetime
    Connection(const Connection&) = delete;
    Connection& operator=(const Connection&) = delete;
    Connection(Connection&&) = delete;
    Connection& operator=(Connection&&) = delete;
    
    bool connect() {
        if (state_ == ConnectionState::Active || state_ == ConnectionState::Idle) {
            return true;
        }
        
        // Simulate connection attempt
        std::cout << "[Connection " << id_ << "] Connecting to " << endpoint_.toString() << "...\n";
        std::this_thread::sleep_for(std::chrono::milliseconds(10));
        
        state_ = ConnectionState::Idle;
        generation_++;
        fail_counter_ = 0;
        std::cout << "[Connection " << id_ << "] Connected (generation=" << generation_ << ")\n";
        return true;
    }
    
    void disconnect() {
        if (state_ != ConnectionState::Closed) {
            std::cout << "[Connection " << id_ << "] Disconnecting\n";
            state_ = ConnectionState::Closed;
        }
    }
    
    bool send(const std::string& data) {
        if (state_ != ConnectionState::Active && state_ != ConnectionState::Idle) {
            std::cerr << "[Connection " << id_ << "] Cannot send: not connected (state="
                      << stateToString(state_) << ")\n";
            return false;
        }
        
        state_ = ConnectionState::Active;
        fail_counter_++;
        
        // Simulate occasional failures
        if (simulated_fail_after_ > 0 && fail_counter_ >= simulated_fail_after_) {
            std::cerr << "[Connection " << id_ << "] Simulated send failure!\n";
            state_ = ConnectionState::Error;
            return false;
        }
        
        std::cout << "[Connection " << id_ << "] Sent " << data.size() << " bytes\n";
        return true;
    }
    
    std::string receive() {
        if (state_ != ConnectionState::Active) {
            if (state_ == ConnectionState::Error) {
                return "";
            }
            // Allow receive on idle connections too
            if (state_ != ConnectionState::Idle) {
                return "";
            }
        }
        
        // Simulate receiving data
        return "response_from_" + endpoint_.toString();
    }
    
    void setSimulatedFailAfter(int n) { simulated_fail_after_ = n; }
    
    uint64_t id() const { return id_; }
    uint64_t generation() const { return generation_; }
    ConnectionState state() const { return state_; }
    const Endpoint& endpoint() const { return endpoint_; }
    
    void markIdle() {
        if (state_ == ConnectionState::Active) {
            state_ = ConnectionState::Idle;
        }
    }
    
    void markError() {
        state_ = ConnectionState::Error;
    }
    
private:
    uint64_t id_;
    Endpoint endpoint_;
    ConnectionState state_;
    uint64_t generation_;
    int fail_counter_;
    int simulated_fail_after_;
};

// Configuration for the connection pool
struct PoolConfig {
    Endpoint endpoint;
    size_t max_connections = 10;
    size_t min_connections = 2;
    int max_retries = 3;
    std::chrono::milliseconds retry_delay{100};
    std::chrono::milliseconds connection_timeout{5000};
};

// The connection pool - sole owner of all Connection objects
class ConnectionPool {
public:
    explicit ConnectionPool(const PoolConfig& config)
        : config_(config), next_id_(1), shutdown_(false) {
        // Pre-create minimum connections
        for (size_t i = 0; i < config_.min_connections; ++i) {
            auto conn = createConnection();
            if (conn && conn->connect()) {
                uint64_t id = conn->id();
                idle_ids_.push(id);
                all_connections_[id] = std::move(conn);
            }
        }
        std::cout << "[Pool] Initialized with " << idle_ids_.size() << " connections\n";
    }
    
    ~ConnectionPool() {
        shutdown();
    }
    
    // Non-copyable
    ConnectionPool(const ConnectionPool&) = delete;
    ConnectionPool& operator=(const ConnectionPool&) = delete;
    
    void shutdown() {
        std::lock_guard<std::mutex> lock(mutex_);
        if (shutdown_) return;
        shutdown_ = true;
        
        std::cout << "[Pool] Shutting down, closing " << all_connections_.size() << " connections\n";
        
        // Clear idle queue
        while (!idle_ids_.empty()) idle_ids_.pop();
        active_handles_.clear();
        
        // Disconnect and destroy all connections
        for (auto& [id, conn] : all_connections_) {
            if (conn) {
                conn->disconnect();
            }
        }
        all_connections_.clear();
    }
    
    // Acquire a connection handle from the pool
    std::optional<ConnectionHandle> acquire() {
        std::lock_guard<std::mutex> lock(mutex_);
        
        if (shutdown_) {
            std::cerr << "[Pool] Cannot acquire: pool is shut down\n";
            return std::nullopt;
        }
        
        Connection* conn = nullptr;
        uint64_t conn_id = 0;
        
        // Try to get an idle connection
        while (!idle_ids_.empty()) {
            conn_id = idle_ids_.front();
            idle_ids_.pop();
            
            auto it = all_connections_.find(conn_id);
            if (it != all_connections_.end() && it->second &&
                it->second->state() == ConnectionState::Idle) {
                conn = it->second.get();
                break;
            }
            // Stale entry, skip
            conn = nullptr;
        }
        
        // If no idle connection, create a new one if under limit
        if (!conn) {
            if (all_connections_.size() >= config_.max_connections) {
                std::cerr << "[Pool] Connection limit reached (" << config_.max_connections << ")\n";
                return std::nullopt;
            }
            
            auto new_conn = createConnection();
            if (!new_conn || !new_conn->connect()) {
                std::cerr << "[Pool] Failed to create new connection\n";
                return std::nullopt;
            }
            
            conn_id = new_conn->id();
            conn = new_conn.get();
            all_connections_[conn_id] = std::move(new_conn);
        }
        
        // Create handle with current generation
        ConnectionHandle handle(this, conn_id, conn->generation());
        active_handles_.insert(conn_id);
        
        std::cout << "[Pool] Acquired connection " << conn_id
                  << " (active=" << active_handles_.size()
                  << ", idle=" << idle_ids_.size() << ")\n";
        
        return handle;
    }
    
    // Release a connection back to the pool
    void release(const ConnectionHandle& handle) {
        std::lock_guard<std::mutex> lock(mutex_);
        releaseInternal(handle);
    }
    
    // Send data through a handle - validates handle is still valid
    bool send(const ConnectionHandle& handle, const std::string& data) {
        std::lock_guard<std::mutex> lock(mutex_);
        
        Connection* conn = resolveHandle(handle);
        if (!conn) {
            std::cerr << "[Pool] Send failed: invalid handle (id=" << handle.id()
                      << ", gen=" << handle.generation() << ")\n";
            return false;
        }
        
        bool result = conn->send(data);
        if (!result && conn->state() == ConnectionState::Error) {
            handleErrorInternal(handle.id());
        }
        return result;
    }
    
    // Receive data through a handle
    std::string receive(const ConnectionHandle& handle) {
        std::lock_guard<std::mutex> lock(mutex_);
        
        Connection* conn = resolveHandle(handle);
        if (!conn) {
            return "";
        }
        
        return conn->receive();
    }
    
    // Reconnect a connection associated with a handle.
    // Returns true if reconnection succeeded. The handle remains valid
    // with an updated generation if the pool reassigns the same slot.
    bool reconnect(ConnectionHandle& handle) {
        std::lock_guard<std::mutex> lock(mutex_);
        
        if (shutdown_) return false;
        
        uint64_t conn_id = handle.id();
        auto it = all_connections_.find(conn_id);
        
        if (it == all_connections_.end() || !it->second) {
            // Connection was destroyed, create a new one in its place
            auto new_conn = createConnectionWithId(conn_id);
            if (!new_conn) return false;
            
            for (int attempt = 0; attempt <= config_.max_retries; ++attempt) {
                if (new_conn->connect()) {
                    handle = ConnectionHandle(this, conn_id, new_conn->generation());
                    active_handles_.insert(conn_id);
                    all_connections_[conn_id] = std::move(new_conn);
                    std::cout << "[Pool] Reconnected (new) connection " << conn_id << "\n";
                    return true;
                }
                if (attempt < config_.max_retries) {
                    std::cout << "[Pool] Reconnect attempt " << (attempt + 1) << " failed, retrying...\n";
                    // Unlock during sleep to avoid holding the lock
                    // In production, use condition variable or async retry
                }
            }
            return false;
        }
        
        Connection* conn = it->second.get();
        
        // Disconnect first
        conn->disconnect();
        
        // Retry connection
        for (int attempt = 0; attempt <= config_.max_retries; ++attempt) {
            if (conn->connect()) {
                // Update handle with new generation
                handle = ConnectionHandle(this, conn_id, conn->generation());
                active_handles_.insert(conn_id);
                std::cout << "[Pool] Reconnected connection " << conn_id
                          << " (generation=" << conn->generation() << ")\n";
                return true;
            }
            
            if (attempt < config_.max_retries) {
                std::cout << "[Pool] Reconnect attempt " << (attempt + 1)
                          << "/" << config_.max_retries << " failed, retrying...\n";
            }
        }
        
        std::cerr << "[Pool] Failed to reconnect connection " << conn_id
                  << " after " << config_.max_retries << " retries\n";
        
        // Destroy the failed connection
        destroyConnectionInternal(conn_id);
        handle = ConnectionHandle(); // Invalidate
        return false;
    }
    
    // Send with automatic retry on failure
    bool sendWithRetry(ConnectionHandle& handle, const std::string& data, int max_retries = -1) {
        if (max_retries < 0) max_retries = config_.max_retries;
        
        for (int attempt = 0; attempt <= max_retries; ++attempt) {
            if (send(handle, data)) {
                return true;
            }
            
            std::cout << "[Pool] Send failed on attempt " << (attempt + 1)
                      << ", attempting reconnect...\n";
            
            if (attempt < max_retries) {
                if (!reconnect(handle)) {
                    std::cerr << "[Pool] Reconnect failed during retry\n";
                    return false;
                }
            }
        }
        return false;
    }
    
    // Pool statistics
    struct Stats {
        size_t total_connections;
        size_t active_connections;
        size_t idle_connections;
    };
    
    Stats stats() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return Stats{
            all_connections_.size(),
            active_handles_.size(),
            idle_ids_.size()
        };
    }
    
private:
    std::unique_ptr<Connection> createConnection() {
        uint64_t id = next_id_++;
        return std::make_unique<Connection>(id, config_.endpoint);
    }
    
    std::unique_ptr<Connection> createConnectionWithId(uint64_t id) {
        return std::make_unique<Connection>(id, config_.endpoint);
    }
    
    // Resolve a handle to a raw pointer. Returns nullptr if handle is stale.
    // Caller must hold mutex_.
    Connection* resolveHandle(const ConnectionHandle& handle) {
        if (!handle.isValid() || shutdown_) return nullptr;
        
        auto it = all_connections_.find(handle.id());
        if (it == all_connections_.end() || !it->second) {
            return nullptr;
        }
        
        Connection* conn = it->second.get();
        
        // Check generation to detect use-after-free scenarios
        if (conn->generation() != handle.generation()) {
            std::cerr << "[Pool] Stale handle detected: handle gen=" << handle.generation()
                      << ", conn gen=" << conn->generation() << "\n";
            return nullptr;
        }
        
        // Verify the handle is in the active set
        if (active_handles_.find(handle.id()) == active_handles_.end()) {
            std::cerr << "[Pool] Handle " << handle.id() << " is not active\n";
            return nullptr;
        }
        
        return conn;
    }
    
    // Release connection back to idle pool. Caller must hold mutex_.
    void releaseInternal(const ConnectionHandle& handle) {
        if (shutdown_) return;
        
        uint64_t conn_id = handle.id();
        active_handles_.erase(conn_id);
        
        auto it = all_connections_.find(conn_id);
        if (it != all_connections_.end() && it->second) {
            Connection* conn = it->second.get();
            
            if (conn->generation() != handle.generation()) {
                // Stale handle, don't return to pool
                return;
            }
            
            if (conn->state() == ConnectionState::Error) {
                // Error state - destroy the connection
                std::cout << "[Pool] Destroying errored connection " << conn_id << "\n";
                destroyConnectionInternal(conn_id);
                return;
            }
            
            conn->markIdle();
            idle_ids_.push(conn_id);
            std::cout << "[Pool] Released connection " << conn_id << " back to pool\n";
        }
    }
    
    // Handle connection error. Caller must hold mutex_.
    void handleErrorInternal(uint64_t conn_id) {
        std::cout << "[Pool] Handling error for connection " << conn_id << "\n";
        // Don't destroy immediately - let the user decide to reconnect or release
        // The connection is marked as Error state
    }
    
    // Destroy a connection. Caller must hold mutex_.
    void destroyConnectionInternal(uint64_t conn_id) {
        active_handles_.erase(conn_id);
        auto it = all_connections_.find(conn_id);
        if (it != all_connections_.end()) {
            if (it->second) {
                it->second->disconnect();
            }
            all_connections_.erase(it);
            std::cout << "[Pool] Destroyed connection " << conn_id << "\n";
        }
    }
    
    PoolConfig config_;
    std::atomic<uint64_t> next_id_;
    bool shutdown_;
    
    mutable std::mutex mutex_;
    
    // The pool owns all connections via unique_ptr
    std::unordered_map<uint64_t, std::unique_ptr<Connection>> all_connections_;
    
    // IDs of idle connections available for reuse
    std::queue<uint64_t> idle_ids_;
    
    // IDs of connections currently checked out
    std::unordered_set<uint64_t> active_handles_;
};

// ConnectionHandle method implementations (need ConnectionPool to be complete)
bool ConnectionHandle::send(const std::string& data) {
    if (!valid_ || !pool_) return false;
    return pool_->send(*this, data);
}

std::string ConnectionHandle::receive() {
    if (!valid_ || !pool_) return "";
    return pool_->receive(*this);
}

void ConnectionHandle::release() {
    if (valid_ && pool_) {
        pool_->release(*this);
        valid_ = false;
        pool_ = nullptr;
    }
}

bool ConnectionHandle::reconnect() {
    if (!pool_) return false;
    bool result = pool_->reconnect(*this);
    if (result) valid_ = true;
    return result;
}

// RAII wrapper for connection handles - ensures release on scope exit
class ScopedConnection {
public:
    explicit ScopedConnection(std::optional<ConnectionHandle> handle)
        : handle_(handle ? std::move(*handle) : ConnectionHandle()) {}
    
    ~ScopedConnection() {
        if (handle_.isValid()) {
            handle_.release();
        }
    }
    
    ScopedConnection(const ScopedConnection&) = delete;
    ScopedConnection& operator=(const ScopedConnection&) = delete;
    
    ScopedConnection(ScopedConnection&& other) noexcept
        : handle_(std::move(other.handle_)) {
        other.handle_ = ConnectionHandle();
    }
    
    ScopedConnection& operator=(ScopedConnection&& other) noexcept {
        if (this != &other) {
            if (handle_.isValid()) handle_.release();
            handle_ = std::move(other.handle_);
            other.handle_ = ConnectionHandle();
        }
        return *this;
    }
    
    ConnectionHandle& get() { return handle_; }
    const ConnectionHandle& get() const { return handle_; }
    bool isValid() const { return handle_.isValid(); }
    
    ConnectionHandle* operator->() { return &handle_; }
    
private:
    ConnectionHandle handle_;
};

// High-level network client that uses the connection pool
class NetworkClient {
public:
    explicit NetworkClient(const PoolConfig& config)
        : pool_(std::make_unique<ConnectionPool>(config)), config_(config) {}
    
    ~NetworkClient() {
        pool_->shutdown();
    }
    
    // Simple request-response pattern with automatic retry
    std::optional<std::string> request(const std::string& data) {
        auto maybe_handle = pool_->acquire();
        if (!maybe_handle) {
            std::cerr << "[Client] Failed to acquire connection\n";
            return std::nullopt;
        }
        
        // Use RAII to ensure the connection is released
        ScopedConnection conn(std::move(maybe_handle));
        
        // Send with retry
        if (!pool_->sendWithRetry(conn.get(), data)) {
            std::cerr << "[Client] Failed to send after retries\n";
            return std::nullopt;
        }
        
        std::string response = conn->receive();
        if (response.empty()) {
            std::cerr << "[Client] Empty response\n";
            return std::nullopt;
        }
        
        return response;
    }
    
    // Batch operations reusing the same connection
    std::vector<std::string> batchRequest(const std::vector<std::string>& requests) {
        std::vector<std::string> responses;
        responses.reserve(requests.size());
        
        auto maybe_handle = pool_->acquire();
        if (!maybe_handle) {
            std::cerr << "[Client] Failed to acquire connection for batch\n";
            return responses;
        }
        
        ScopedConnection conn(std::move(maybe_handle));
        
        for (const auto& req : requests) {
            if (!pool_->sendWithRetry(conn.get(), req)) {
                std::cerr << "[Client] Batch send failed at request: " << req << "\n";
                break;
            }
            
            std::string resp = conn->receive();
            responses.push_back(std::move(resp));
        }
        
        return responses;
    }
    
    ConnectionPool::Stats stats() const {
        return pool_->stats();
    }
    
private:
    std::unique_ptr<ConnectionPool> pool_;
    PoolConfig config_;
};

// ============================================================================
// Demo / Test
// ============================================================================

int main() {
    std::cout << "=== Network Client Connection Pool Demo ===\n\n";
    
    PoolConfig config;
    config.endpoint = {"example.com", 8080};
    config.max_connections = 5;
    config.min_connections = 2;
    config.max_retries = 3;
    
    // Test 1: Basic acquire/send/receive/release
    {
        std::cout << "--- Test 1: Basic Operations ---\n";
        ConnectionPool pool(config);
        
        auto handle = pool.acquire();
        assert(handle.has_value());
        
        bool sent = handle->send("Hello, server!");
        assert(sent);
        
        std::string response = handle->receive();
        std::cout << "Received: " << response << "\n";
        
        handle->release();
        
        auto s = pool.stats();
        std::cout << "Pool stats: total=" << s.total_connections
                  << " active=" << s.active_connections
                  << " idle=" << s.idle_connections << "\n\n";
    }
    
    // Test 2: RAII scoped connection
    {
        std::cout << "--- Test 2: RAII Scoped Connection ---\n";
        ConnectionPool pool(config);
        
        {
            ScopedConnection conn(pool.acquire());
            assert(conn.isValid());
            conn->send("Scoped message");
            std::string resp = conn->receive();
            std::cout << "Scoped received: " << resp << "\n";
            // Auto-released here
        }
        
        auto s = pool.stats();
        std::cout << "After scope exit - active=" << s.active_connections
                  << " idle=" << s.idle_connections << "\n\n";
    }
    
    // Test 3: Connection reuse
    {
        std::cout << "--- Test 3: Connection Reuse ---\n";
        ConnectionPool pool(config);
        
        uint64_t first_id;
        {
            auto h = pool.acquire();
            first_id = h->id();
            h->send("First use");
            h->release();
        }
        
        {
            auto h = pool.acquire();
            std::cout << "Reused same connection: " << (h->id() == first_id ? "YES" : "NO") << "\n";
            h->send("Second use");
            h->release();
        }
        std::cout << "\n";
    }
    
    // Test 4: Reconnection on failure
    {
        std::cout << "--- Test 4: Reconnection ---\n";
        ConnectionPool pool(config);
        
        auto handle = pool.acquire();
        assert(handle.has_value());
        
        // Simulate that the connection will fail
        // We'll manually trigger a reconnect scenario
        std::cout << "Handle id=" << handle->id() << " gen=" << handle->generation() << "\n";
        
        // Force reconnect
        bool reconnected = handle->reconnect();
        std::cout << "Reconnected: " << (reconnected ? "YES" : "NO") << "\n";
        std::cout << "After reconnect - id=" << handle->id() << " gen=" << handle->generation() << "\n";
        
        if (reconnected) {
            handle->send("After reconnect");
            handle->release();
        }
        std::cout << "\n";
    }
    
    // Test 5: High-level client with retry
    {
        std::cout << "--- Test 5: NetworkClient ---\n";
        NetworkClient client(config);
        
        auto response = client.request("GET /api/data");
        if (response) {
            std::cout << "Client response: " << *response << "\n";
        }
        
        auto s = client.stats();
        std::cout << "Client pool stats: total=" << s.total_connections
                  << " active=" << s.active_connections
                  << " idle=" << s.idle_connections << "\n\n";
    }
    
    // Test 6: Batch operations
    {
        std::cout << "--- Test 6: Batch Operations ---\n";
        NetworkClient client(config);
        
        std::vector<std::string> requests = {
            "GET /api/item/1",
            "GET /api/item/2",
            "GET /api/item/3"
        };
        
        auto responses = client.batchRequest(requests);
        std::cout << "Batch responses (" << responses.size() << "):\n";
        for (const auto& r : responses) {
            std::cout << "  " << r << "\n";
        }
        std::cout << "\n";
    }
    
    // Test 7: Stale handle detection
    {
        std::cout << "--- Test 7: Stale Handle Detection ---\n";
        ConnectionPool pool(config);
        
        auto handle1 = pool.acquire();
        assert(handle1.has_value());
        
        // Save a copy of the handle info
        ConnectionHandle stale_handle = *handle1;
        
        // Release and re-acquire (the connection gets a new generation on reconnect)
        handle1->release();
        
        // The stale handle should still technically work since the connection
        // wasn't reconnected (same generation). But if we reconnect...
        auto handle2 = pool.acquire();
        // Force reconnect to bump generation
        handle2->reconnect();
        
        // Now try using the stale handle - should fail gracefully
        bool sent = stale_handle.send("stale data");
        std::cout << "Stale handle send result: " << (sent ? "SUCCESS (unexpected)" : "FAILED (expected)") << "\n";
        
        handle2->release();
        std::cout << "\n";
    }
    
    // Test 8: Pool exhaustion
    {
        std::cout << "--- Test 8: Pool Exhaustion ---\n";
        PoolConfig small_config = config;
        small_config.max_connections = 3;
        small_config.min_connections = 1;
        ConnectionPool pool(small_config);
        
        std::vector<ConnectionHandle> handles;
        for (int i = 0; i < 5; ++i) {
            auto h = pool.acquire();
            if (h) {
                std::cout << "Acquired connection " << h->id() << "\n";
                handles.push_back(std::move(*h));
            } else {
                std::cout << "Failed to acquire connection (pool exhausted)\n";
            }
        }
        
        // Release all
        for (auto& h : handles) {
            h.release();
        }
        
        auto s = pool.stats();
        std::cout << "After release - total=" << s.total_connections
                  << " active=" << s.active_connections
                  << " idle=" << s.idle_connections << "\n\n";
    }
    
    std::cout << "=== All tests completed ===\n";
    return 0;
}