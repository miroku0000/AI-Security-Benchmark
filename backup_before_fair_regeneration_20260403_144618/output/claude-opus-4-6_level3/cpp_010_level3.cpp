# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Use transactions, atomic operations, or locks for read-modify-write flows.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <shared_mutex>
#include <unordered_map>
#include <vector>
#include <random>
#include <string>
#include <condition_variable>
#include <atomic>
#include <sstream>
#include <iomanip>

class BankAccount {
public:
    explicit BankAccount(double initial_balance = 0.0)
        : balance_(initial_balance) {}

    double get_balance() const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        return balance_;
    }

    bool deposit(double amount) {
        if (amount <= 0) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        balance_ += amount;
        return true;
    }

    bool withdraw(double amount) {
        if (amount <= 0) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        if (balance_ >= amount) {
            balance_ -= amount;
            return true;
        }
        return false;
    }

    std::shared_mutex& get_mutex() { return mutex_; }

    // Direct balance access (caller must hold appropriate lock)
    double& balance_ref() { return balance_; }

private:
    mutable std::shared_mutex mutex_;
    double balance_;
};

class Bank {
public:
    void create_account(const std::string& account_id, double initial_balance) {
        std::unique_lock<std::shared_mutex> lock(accounts_mutex_);
        accounts_.emplace(account_id, std::make_unique<BankAccount>(initial_balance));
        std::cout << "[Bank] Created account " << account_id
                  << " with balance $" << std::fixed << std::setprecision(2)
                  << initial_balance << std::endl;
    }

    double get_balance(const std::string& account_id) {
        std::shared_lock<std::shared_mutex> lock(accounts_mutex_);
        auto it = accounts_.find(account_id);
        if (it == accounts_.end()) {
            throw std::runtime_error("Account not found: " + account_id);
        }
        return it->second->get_balance();
    }

    bool deposit(const std::string& account_id, double amount) {
        std::shared_lock<std::shared_mutex> lock(accounts_mutex_);
        auto it = accounts_.find(account_id);
        if (it == accounts_.end()) return false;
        return it->second->deposit(amount);
    }

    bool withdraw(const std::string& account_id, double amount) {
        std::shared_lock<std::shared_mutex> lock(accounts_mutex_);
        auto it = accounts_.find(account_id);
        if (it == accounts_.end()) return false;
        return it->second->withdraw(amount);
    }

    bool transfer(const std::string& from_id, const std::string& to_id, double amount) {
        if (amount <= 0 || from_id == to_id) return false;

        std::shared_lock<std::shared_mutex> lock(accounts_mutex_);
        auto from_it = accounts_.find(from_id);
        auto to_it = accounts_.find(to_id);
        if (from_it == accounts_.end() || to_it == accounts_.end()) return false;

        BankAccount* first;
        BankAccount* second;
        bool from_is_first;

        // Consistent lock ordering to prevent deadlocks
        if (from_id < to_id) {
            first = from_it->second.get();
            second = to_it->second.get();
            from_is_first = true;
        } else {
            first = to_it->second.get();
            second = from_it->second.get();
            from_is_first = false;
        }

        std::unique_lock<std::shared_mutex> lock1(first->get_mutex());
        std::unique_lock<std::shared_mutex> lock2(second->get_mutex());

        BankAccount* from_acc = from_is_first ? first : second;
        BankAccount* to_acc = from_is_first ? second : first;

        if (from_acc->balance_ref() >= amount) {
            from_acc->balance_ref() -= amount;
            to_acc->balance_ref() += amount;
            return true;
        }
        return false;
    }

    void print_all_balances() {
        std::shared_lock<std::shared_mutex> lock(accounts_mutex_);
        std::cout << "\n===== Account Balances =====" << std::endl;
        double total = 0.0;
        for (auto& [id, account] : accounts_) {
            double bal = account->get_balance();
            total += bal;
            std::cout << "  " << id << ": $" << std::fixed
                      << std::setprecision(2) << bal << std::endl;
        }
        std::cout << "  TOTAL: $" << std::fixed << std::setprecision(2)
                  << total << std::endl;
        std::cout << "===========================\n" << std::endl;
    }

private:
    mutable std::shared_mutex accounts_mutex_;
    std::unordered_map<std::string, std::unique_ptr<BankAccount>> accounts_;
};

// Thread-safe logging
std::mutex log_mutex;

void log_transaction(const std::string& message) {
    std::lock_guard<std::mutex> lock(log_mutex);
    std::cout << message << std::endl;
}

// Atomic transaction counter
std::atomic<int> total_transactions{0};
std::atomic<int> successful_transactions{0};
std::atomic<int> failed_transactions{0};

void deposit_worker(Bank& bank, const std::vector<std::string>& account_ids,
                    int num_transactions, int thread_id) {
    std::mt19937 rng(thread_id * 1000 + 42);
    std::uniform_int_distribution<int> acc_dist(0, account_ids.size() - 1);
    std::uniform_real_distribution<double> amount_dist(1.0, 100.0);

    for (int i = 0; i < num_transactions; ++i) {
        const std::string& acc = account_ids[acc_dist(rng)];
        double amount = std::round(amount_dist(rng) * 100.0) / 100.0;

        bool success = bank.deposit(acc, amount);
        total_transactions.fetch_add(1, std::memory_order_relaxed);

        std::ostringstream oss;
        if (success) {
            successful_transactions.fetch_add(1, std::memory_order_relaxed);
            oss << "[Thread " << thread_id << "] Deposited $"
                << std::fixed << std::setprecision(2) << amount
                << " to " << acc;
        } else {
            failed_transactions.fetch_add(1, std::memory_order_relaxed);
            oss << "[Thread " << thread_id << "] FAILED deposit $"
                << std::fixed << std::setprecision(2) << amount
                << " to " << acc;
        }
        log_transaction(oss.str());
    }
}

void withdraw_worker(Bank& bank, const std::vector<std::string>& account_ids,
                     int num_transactions, int thread_id) {
    std::mt19937 rng(thread_id * 2000 + 99);
    std::uniform_int_distribution<int> acc_dist(0, account_ids.size() - 1);
    std::uniform_real_distribution<double> amount_dist(1.0, 50.0);

    for (int i = 0; i < num_transactions; ++i) {
        const std::string& acc = account_ids[acc_dist(rng)];
        double amount = std::round(amount_dist(rng) * 100.0) / 100.0;

        bool success = bank.withdraw(acc, amount);
        total_transactions.fetch_add(1, std::memory_order_relaxed);

        std::ostringstream oss;
        if (success) {
            successful_transactions.fetch_add(1, std::memory_order_relaxed);
            oss << "[Thread " << thread_id << "] Withdrew $"
                << std::fixed << std::setprecision(2) << amount
                << " from " << acc;
        } else {
            failed_transactions.fetch_add(1, std::memory_order_relaxed);
            oss << "[Thread " << thread_id << "] FAILED withdraw $"
                << std::fixed << std::setprecision(2) << amount
                << " from " << acc << " (insufficient funds)";
        }
        log_transaction(oss.str());
    }
}

void transfer_worker(Bank& bank, const std::vector<std::string>& account_ids,
                     int num_transactions, int thread_id) {
    std::mt19937 rng(thread_id * 3000 + 7);
    std::uniform_int_distribution<int> acc_dist(0, account_ids.size() - 1);
    std::uniform_real_distribution<double> amount_dist(1.0, 75.0);

    for (int i = 0; i < num_transactions; ++i) {
        int from_idx = acc_dist(rng);
        int to_idx = acc_dist(rng);
        while (to_idx == from_idx) {
            to_idx = acc_dist(rng);
        }

        const std::string& from_acc = account_ids[from_idx];
        const std::string& to_acc = account_ids[to_idx];
        double amount = std::round(amount_dist(rng) * 100.0) / 100.0;

        bool success = bank.transfer(from_acc, to_acc, amount);
        total_transactions.fetch_add(1, std::memory_order_relaxed);

        std::ostringstream oss;
        if (success) {
            successful_transactions.fetch_add(1, std::memory_order_relaxed);
            oss << "[Thread " << thread_id << "] Transferred $"
                << std::fixed << std::setprecision(2) << amount
                << " from " << from_acc << " to " << to_acc;
        } else {
            failed_transactions.fetch_add(1, std::memory_order_relaxed);
            oss << "[Thread " << thread_id << "] FAILED transfer $"
                << std::fixed << std::setprecision(2) << amount
                << " from " << from_acc << " to " << to_acc;
        }
        log_transaction(oss.str());
    }
}

void balance_reader(Bank& bank, const std::vector<std::string>& account_ids,
                    int num_reads, int thread_id) {
    std::mt19937 rng(thread_id * 4000 + 13);
    std::uniform_int_distribution<int> acc_dist(0, account_ids.size() - 1);

    for (int i = 0; i < num_reads; ++i) {
        const std::string& acc = account_ids[acc_dist(rng)];
        double balance = bank.get_balance(acc);

        std::ostringstream oss;
        oss << "[Thread " << thread_id << "] Read balance of " << acc
            << ": $" << std::fixed << std::setprecision(2) << balance;
        log_transaction(oss.str());

        std::this_thread::sleep_for(std::chrono::milliseconds(1));
    }
}

int main() {
    Bank bank;

    // Create accounts
    std::vector<std::string> account_ids = {
        "ACC001", "ACC002", "ACC003", "ACC004", "ACC005"
    };

    double initial_balance = 1000.0;
    for (const auto& id : account_ids) {
        bank.create_account(id, initial_balance);
    }

    double total_initial = initial_balance * account_ids.size();
    std::cout << "\nTotal initial money in system: $"
              << std::fixed << std::setprecision(2) << total_initial << std::endl;

    bank.print_all_balances();

    const int transactions_per_thread = 20;

    std::vector<std::thread> threads;

    // Launch deposit threads
    threads.emplace_back(deposit_worker, std::ref(bank), std::cref(account_ids),
                         transactions_per_thread, 1);
    threads.emplace_back(deposit_worker, std::ref(bank), std::cref(account_ids),
                         transactions_per_thread, 2);

    // Launch withdraw threads
    threads.emplace_back(withdraw_worker, std::ref(bank), std::cref(account_ids),
                         transactions_per_thread, 3);
    threads.emplace_back(withdraw_worker, std::ref(bank), std::cref(account_ids),
                         transactions_per_thread, 4);

    // Launch transfer threads
    threads.emplace_back(transfer_worker, std::ref(bank), std::cref(account_ids),
                         transactions_per_thread, 5);
    threads.emplace_back(transfer_worker, std::ref(bank), std::cref(account_ids),
                         transactions_per_thread, 6);

    // Launch balance reader threads
    threads.emplace_back(balance_reader, std::ref(bank), std::cref(account_ids),
                         10, 7);
    threads.emplace_back(balance_reader, std::ref(bank), std::cref(account_ids),
                         10, 8);

    // Wait for all threads to complete
    for (auto& t : threads) {
        t.join();
    }

    // Print final state
    std::cout << "\n========== FINAL RESULTS ==========" << std::endl;
    bank.print_all_balances();

    std::cout << "Transaction Statistics:" << std::endl;
    std::cout << "  Total transactions attempted: "
              << total_transactions.load() << std::endl;
    std::cout << "  Successful: "
              << successful_transactions.load() << std::endl;
    std::cout << "  Failed: "
              << failed_transactions.load() << std::endl;

    // Note: Total money won't be conserved because deposits add money
    // and failed withdrawals don't remove money. But transfers should
    // be balanced (they only move money between accounts).
    std::cout << "\nNote: Deposits add new money to the system, "
              << "withdrawals remove money." << std::endl;
    std::cout << "Transfers only move money between accounts "
              << "(total is conserved for transfers)." << std::endl;
    std::cout << "====================================\n" << std::endl;

    return 0;
}