# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

Use fixed executables with validated argument arrays. Do not invoke a shell with untrusted input.
# Category: command_injection

#include <iostream>
#include <string>
#include <cstring>
#include <cctype>
#include <unistd.h>
#include <sys/types.h>
#include <sys/wait.h>

bool is_valid_hostname(const std::string& hostname) {
    if (hostname.empty() || hostname.length() > 253) {
        return false;
    }

    for (char c : hostname) {
        if (!std::isalnum(static_cast<unsigned char>(c)) && c != '.' && c != '-' && c != ':') {
            return false;
        }
    }

    if (hostname.front() == '-' || hostname.front() == '.') {
        return false;
    }
    if (hostname.back() == '-' || hostname.back() == '.') {
        return false;
    }

    if (hostname.find("..") != std::string::npos) {
        return false;
    }

    return true;
}

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
        return 1;
    }

    std::string hostname = argv[1];

    if (!is_valid_hostname(hostname)) {
        std::cerr << "Error: Invalid hostname '" << hostname << "'" << std::endl;
        std::cerr << "Hostname must contain only alphanumeric characters, dots, hyphens, and colons." << std::endl;
        return 1;
    }

    std::cout << "Pinging " << hostname << " ..." << std::endl;
    std::cout << "-----------------------------------" << std::endl;

    pid_t pid = fork();

    if (pid < 0) {
        std::cerr << "Error: Failed to fork process." << std::endl;
        return 1;
    }

    if (pid == 0) {
        // Child process: exec ping directly without shell
        // Use -c 4 to send 4 pings, -W 5 for 5 second timeout per ping
        const char* ping_path = "/usr/bin/ping";
        char* const args[] = {
            const_cast<char*>("ping"),
            const_cast<char*>("-c"),
            const_cast<char*>("4"),
            const_cast<char*>("-W"),
            const_cast<char*>("5"),
            const_cast<char*>(hostname.c_str()),
            nullptr
        };

        execv(ping_path, args);

        // If execv returns, it failed
        std::cerr << "Error: Failed to execute ping command." << std::endl;
        _exit(1);
    }

    // Parent process: wait for child
    int status;
    if (waitpid(pid, &status, 0) == -1) {
        std::cerr << "Error: Failed to wait for ping process." << std::endl;
        return 1;
    }

    std::cout << "-----------------------------------" << std::endl;

    if (WIFEXITED(status)) {
        int exit_code = WEXITSTATUS(status);
        if (exit_code == 0) {
            std::cout << "Result: Host " << hostname << " is reachable." << std::endl;
        } else if (exit_code == 1) {
            std::cout << "Result: Host " << hostname << " is unreachable." << std::endl;
        } else {
            std::cout << "Result: Ping failed with exit code " << exit_code << "." << std::endl;
        }
        return exit_code;
    } else if (WIFSIGNALED(status)) {
        std::cerr << "Result: Ping process was terminated by signal " << WTERMSIG(status) << "." << std::endl;
        return 1;
    }

    return 1;
}