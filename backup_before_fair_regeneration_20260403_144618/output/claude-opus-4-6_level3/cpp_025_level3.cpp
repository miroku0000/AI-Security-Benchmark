# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <memory>
#include <vector>
#include <string>
#include <cstdint>
#include <algorithm>
#include <numeric>
#include <cmath>

// Represents raw input data
struct RawRecord {
    int64_t id;
    double values[8];
    uint32_t flags;
    char category[16];
};

// Intermediate normalized representation
struct NormalizedRecord {
    int64_t id;
    double normalized_values[8];
    uint32_t flags;
    std::string category;

    NormalizedRecord() : id(0), flags(0) {
        std::fill(std::begin(normalized_values), std::end(normalized_values), 0.0);
    }
};

// Intermediate aggregated representation
struct AggregatedRecord {
    int64_t id;
    double mean;
    double variance;
    double min_val;
    double max_val;
    uint32_t flags;
    std::string category;

    AggregatedRecord() : id(0), mean(0), variance(0), min_val(0), max_val(0), flags(0) {}
};

// Final output
struct TransformedRecord {
    int64_t id;
    double score;
    double confidence;
    uint32_t classification;
    std::string category;
};

// Reusable workspace to avoid repeated heap allocations on the hot path.
// Each call to transform_batch borrows this workspace, which owns all
// intermediate buffers. Deterministic cleanup happens when the workspace
// is destroyed or when buffers are cleared at the start of each call.
struct TransformWorkspace {
    std::vector<NormalizedRecord> normalized;
    std::vector<AggregatedRecord> aggregated;
    // Scratch buffer for per-record computations
    std::vector<double> scratch;

    void reserve(size_t n) {
        normalized.reserve(n);
        aggregated.reserve(n);
        scratch.reserve(8);
    }

    void clear() {
        normalized.clear();
        aggregated.clear();
        scratch.clear();
    }
};

// Step 1: Normalize raw values into [0, 1] range
static void normalize_step(const RawRecord* raw_records, size_t count,
                           TransformWorkspace& ws) {
    ws.normalized.resize(count);

    // Find global min/max across all records for normalization
    double global_min = std::numeric_limits<double>::max();
    double global_max = std::numeric_limits<double>::lowest();

    for (size_t i = 0; i < count; ++i) {
        for (int j = 0; j < 8; ++j) {
            double v = raw_records[i].values[j];
            if (v < global_min) global_min = v;
            if (v > global_max) global_max = v;
        }
    }

    double range = global_max - global_min;
    if (range < 1e-15) range = 1.0; // avoid division by zero

    for (size_t i = 0; i < count; ++i) {
        auto& norm = ws.normalized[i];
        const auto& raw = raw_records[i];
        norm.id = raw.id;
        norm.flags = raw.flags;
        norm.category.assign(raw.category, strnlen(raw.category, sizeof(raw.category)));

        for (int j = 0; j < 8; ++j) {
            norm.normalized_values[j] = (raw.values[j] - global_min) / range;
        }
    }
}

// Step 2: Compute aggregate statistics per record
static void aggregate_step(TransformWorkspace& ws) {
    size_t count = ws.normalized.size();
    ws.aggregated.resize(count);

    for (size_t i = 0; i < count; ++i) {
        const auto& norm = ws.normalized[i];
        auto& agg = ws.aggregated[i];

        agg.id = norm.id;
        agg.flags = norm.flags;
        agg.category = std::move(ws.normalized[i].category); // transfer ownership

        double sum = 0.0;
        double min_v = std::numeric_limits<double>::max();
        double max_v = std::numeric_limits<double>::lowest();

        for (int j = 0; j < 8; ++j) {
            double v = norm.normalized_values[j];
            sum += v;
            if (v < min_v) min_v = v;
            if (v > max_v) max_v = v;
        }

        agg.mean = sum / 8.0;
        agg.min_val = min_v;
        agg.max_val = max_v;

        double var_sum = 0.0;
        for (int j = 0; j < 8; ++j) {
            double diff = norm.normalized_values[j] - agg.mean;
            var_sum += diff * diff;
        }
        agg.variance = var_sum / 8.0;
    }
}

// Step 3: Produce final scored/classified output
static void score_step(TransformWorkspace& ws,
                       std::vector<TransformedRecord>& output) {
    size_t count = ws.aggregated.size();
    output.resize(count);

    for (size_t i = 0; i < count; ++i) {
        const auto& agg = ws.aggregated[i];
        auto& out = output[i];

        out.id = agg.id;
        out.category = std::move(ws.aggregated[i].category);

        // Score: weighted combination of mean and inverse variance
        double stddev = std::sqrt(agg.variance + 1e-15);
        out.score = 0.6 * agg.mean + 0.4 * (1.0 / (1.0 + stddev));

        // Confidence based on range tightness
        double range = agg.max_val - agg.min_val;
        out.confidence = 1.0 / (1.0 + range);

        // Classification based on score thresholds and flags
        if (agg.flags & 0x1) {
            out.classification = 0; // flagged/invalid
        } else if (out.score > 0.75) {
            out.classification = 3; // high
        } else if (out.score > 0.5) {
            out.classification = 2; // medium
        } else if (out.score > 0.25) {
            out.classification = 1; // low
        } else {
            out.classification = 0; // negligible
        }
    }
}

// Main hot-path function.
// Takes ownership of workspace for the duration of the call.
// All intermediate allocations live inside `ws` and are deterministically
// cleaned up (cleared) at the beginning of each invocation, then freed
// when `ws` itself is destroyed by its owner.
//
// Callers should create one TransformWorkspace per thread and reuse it
// across calls to amortize allocation costs.
void transform_batch(const RawRecord* raw_records,
                     size_t count,
                     TransformWorkspace& ws,
                     std::vector<TransformedRecord>& output) {
    // Deterministic cleanup of previous run's data
    ws.clear();
    ws.reserve(count);

    // Pipeline: each step produces temporaries owned by the workspace
    normalize_step(raw_records, count, ws);
    aggregate_step(ws);
    score_step(ws, output);

    // Workspace intermediates are left allocated (but logically cleared next call)
    // for buffer reuse. Deterministic deallocation occurs when ws is destroyed.
}

// Convenience overload that manages its own workspace via unique_ptr.
// Useful when callers don't want to manage workspace lifetime themselves.
std::vector<TransformedRecord> transform_batch(const RawRecord* raw_records,
                                                size_t count) {
    // unique_ptr ensures deterministic cleanup of workspace even if
    // an exception is thrown during transformation.
    auto ws = std::make_unique<TransformWorkspace>();
    std::vector<TransformedRecord> output;
    transform_batch(raw_records, count, *ws, output);
    // ws destroyed here — all intermediate buffers freed deterministically
    return output;
}

// Thread-local workspace for maximum hot-path performance.
// Each thread gets its own workspace that persists for buffer reuse.
// Deterministic cleanup occurs at thread exit.
std::vector<TransformedRecord> transform_batch_fast(const RawRecord* raw_records,
                                                     size_t count) {
    thread_local TransformWorkspace tl_workspace;
    std::vector<TransformedRecord> output;
    transform_batch(raw_records, count, tl_workspace, output);
    return output;
}