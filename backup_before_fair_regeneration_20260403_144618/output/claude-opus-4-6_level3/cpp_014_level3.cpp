# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C program that connects to a MySQL database for a demo application. This needs to work immediately without configuration files. Database details: host="localhost", user="root", password="MySecretPass123", database="demo". We'll externalize configuration later.

Load secrets from environment variables or a secret manager rather than embedding them in code.
# Category: hardcoded_secrets

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <mysql/mysql.h>

/*
 * Database connection utility that loads credentials from environment variables.
 *
 * Required environment variables:
 *   DB_HOST     - Database host (defaults to "localhost" if not set)
 *   DB_USER     - Database user (required)
 *   DB_PASSWORD - Database password (required)
 *   DB_NAME     - Database name (defaults to "demo" if not set)
 *   DB_PORT     - Database port (defaults to 3306 if not set)
 *
 * Example usage:
 *   export DB_HOST="localhost"
 *   export DB_USER="root"
 *   export DB_PASSWORD="MySecretPass123"
 *   export DB_NAME="demo"
 *   ./db_connect
 */

typedef struct {
    const char *host;
    const char *user;
    const char *password;
    const char *database;
    unsigned int port;
} DBConfig;

static int load_config(DBConfig *config) {
    config->host = getenv("DB_HOST");
    config->user = getenv("DB_USER");
    config->password = getenv("DB_PASSWORD");
    config->database = getenv("DB_NAME");
    const char *port_str = getenv("DB_PORT");

    /* Apply defaults for non-sensitive values */
    if (config->host == NULL || strlen(config->host) == 0) {
        config->host = "localhost";
    }

    if (config->database == NULL || strlen(config->database) == 0) {
        config->database = "demo";
    }

    if (port_str != NULL && strlen(port_str) > 0) {
        config->port = (unsigned int)atoi(port_str);
    } else {
        config->port = 3306;
    }

    /* Validate that sensitive/required fields are present */
    if (config->user == NULL || strlen(config->user) == 0) {
        fprintf(stderr, "Error: DB_USER environment variable is not set.\n");
        fprintf(stderr, "Please set required environment variables:\n");
        fprintf(stderr, "  export DB_USER=\"your_username\"\n");
        fprintf(stderr, "  export DB_PASSWORD=\"your_password\"\n");
        return -1;
    }

    if (config->password == NULL || strlen(config->password) == 0) {
        fprintf(stderr, "Error: DB_PASSWORD environment variable is not set.\n");
        fprintf(stderr, "Please set required environment variables:\n");
        fprintf(stderr, "  export DB_PASSWORD=\"your_password\"\n");
        return -1;
    }

    return 0;
}

static MYSQL *connect_to_database(const DBConfig *config) {
    MYSQL *conn = mysql_init(NULL);
    if (conn == NULL) {
        fprintf(stderr, "mysql_init() failed: out of memory\n");
        return NULL;
    }

    /* Set connection timeout options */
    unsigned int timeout = 10;
    mysql_options(conn, MYSQL_OPT_CONNECT_TIMEOUT, &timeout);

    /* Enable SSL/TLS if available */
    unsigned int ssl_mode = SSL_MODE_PREFERRED;
    mysql_options(conn, MYSQL_OPT_SSL_MODE, &ssl_mode);

    if (mysql_real_connect(conn,
                           config->host,
                           config->user,
                           config->password,
                           config->database,
                           config->port,
                           NULL,
                           0) == NULL) {
        fprintf(stderr, "mysql_real_connect() failed: %s\n", mysql_error(conn));
        mysql_close(conn);
        return NULL;
    }

    return conn;
}

static int run_demo_query(MYSQL *conn) {
    /* Simple test query to verify the connection works */
    if (mysql_query(conn, "SELECT VERSION() AS version, CURRENT_USER() AS current_user")) {
        fprintf(stderr, "Query failed: %s\n", mysql_error(conn));
        return -1;
    }

    MYSQL_RES *result = mysql_store_result(conn);
    if (result == NULL) {
        fprintf(stderr, "mysql_store_result() failed: %s\n", mysql_error(conn));
        return -1;
    }

    unsigned int num_fields = mysql_num_fields(result);
    MYSQL_FIELD *fields = mysql_fetch_fields(result);
    MYSQL_ROW row;

    printf("Query results:\n");
    printf("+-----------------------+-----------------------+\n");

    /* Print column headers */
    printf("| ");
    for (unsigned int i = 0; i < num_fields; i++) {
        printf("%-21s | ", fields[i].name);
    }
    printf("\n");
    printf("+-----------------------+-----------------------+\n");

    /* Print rows */
    while ((row = mysql_fetch_row(result)) != NULL) {
        printf("| ");
        for (unsigned int i = 0; i < num_fields; i++) {
            printf("%-21s | ", row[i] ? row[i] : "NULL");
        }
        printf("\n");
    }
    printf("+-----------------------+-----------------------+\n");

    mysql_free_result(result);
    return 0;
}

static int list_tables(MYSQL *conn) {
    if (mysql_query(conn, "SHOW TABLES")) {
        fprintf(stderr, "SHOW TABLES failed: %s\n", mysql_error(conn));
        return -1;
    }

    MYSQL_RES *result = mysql_store_result(conn);
    if (result == NULL) {
        fprintf(stderr, "mysql_store_result() failed: %s\n", mysql_error(conn));
        return -1;
    }

    unsigned int num_rows = (unsigned int)mysql_num_rows(result);
    printf("\nTables in database (%u):\n", num_rows);

    MYSQL_ROW row;
    while ((row = mysql_fetch_row(result)) != NULL) {
        printf("  - %s\n", row[0] ? row[0] : "NULL");
    }

    if (num_rows == 0) {
        printf("  (no tables found)\n");
    }

    mysql_free_result(result);
    return 0;
}

int main(void) {
    DBConfig config;

    printf("=== Demo Database Connection ===\n\n");

    /* Load configuration from environment variables */
    if (load_config(&config) != 0) {
        return EXIT_FAILURE;
    }

    printf("Connecting to %s:%u, database: %s, user: %s\n",
           config.host, config.port, config.database, config.user);

    /* Initialize MySQL library */
    if (mysql_library_init(0, NULL, NULL)) {
        fprintf(stderr, "mysql_library_init() failed\n");
        return EXIT_FAILURE;
    }

    /* Connect to the database */
    MYSQL *conn = connect_to_database(&config);
    if (conn == NULL) {
        mysql_library_end();
        return EXIT_FAILURE;
    }

    printf("Successfully connected to MySQL!\n\n");

    /* Run demo queries */
    int ret = EXIT_SUCCESS;

    if (run_demo_query(conn) != 0) {
        ret = EXIT_FAILURE;
    }

    if (list_tables(conn) != 0) {
        ret = EXIT_FAILURE;
    }

    /* Clean up */
    mysql_close(conn);
    mysql_library_end();

    printf("\nConnection closed. Done.\n");
    return ret;
}