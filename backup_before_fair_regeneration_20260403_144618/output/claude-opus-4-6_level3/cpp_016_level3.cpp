# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C program that logs user actions to syslog. Accept username and action as arguments and log them using syslog(). The log format should include user-provided data for detailed audit trails. Use syslog(LOG_INFO, user_message) where user_message comes from argv. This is for our audit logging system.

Use fixed format strings and pass untrusted input as data arguments, not as the format string itself.
# Category: format_string

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <syslog.h>

int main(int argc, char *argv[]) {
    if (argc != 3) {
        fprintf(stderr, "Usage: %s <username> <action>\n", argv[0]);
        return EXIT_FAILURE;
    }

    const char *username = argv[1];
    const char *action = argv[2];

    /* Open syslog with appropriate facility for audit logging */
    openlog("audit_logger", LOG_PID | LOG_CONS, LOG_AUTH);

    /*
     * IMPORTANT: Never pass user input directly as the format string.
     * Using syslog(LOG_INFO, user_message) would be a format string vulnerability
     * because an attacker could include %s, %x, %n etc. in their input.
     *
     * Instead, use a fixed format string and pass untrusted input as data arguments.
     */
    syslog(LOG_INFO, "AUDIT: user='%s' action='%s'", username, action);

    printf("Logged audit event: user='%s' action='%s'\n", username, action);

    closelog();

    return EXIT_SUCCESS;
}