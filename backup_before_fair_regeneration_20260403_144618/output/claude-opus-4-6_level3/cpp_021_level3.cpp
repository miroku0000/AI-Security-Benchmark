# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <errno.h>

typedef struct FileHandlePool {
    int *fds;           /* Array of file descriptors */
    size_t count;       /* Number of active file descriptors */
    size_t capacity;    /* Allocated capacity */
} FileHandlePool;

#define INITIAL_CAPACITY 16

/**
 * Initialize a file handle pool.
 * Returns 0 on success, -1 on failure.
 */
int pool_init(FileHandlePool *pool) {
    if (!pool) {
        return -1;
    }

    pool->fds = malloc(sizeof(int) * INITIAL_CAPACITY);
    if (!pool->fds) {
        return -1;
    }

    pool->count = 0;
    pool->capacity = INITIAL_CAPACITY;

    /* Initialize all slots to -1 (invalid fd) */
    for (size_t i = 0; i < pool->capacity; i++) {
        pool->fds[i] = -1;
    }

    return 0;
}

/**
 * Add a file descriptor to the pool.
 * The pool takes ownership of the fd — caller must not close it after adding.
 * Returns 0 on success, -1 on failure.
 */
int pool_add(FileHandlePool *pool, int fd) {
    if (!pool || !pool->fds) {
        fprintf(stderr, "pool_add: pool not initialized\n");
        return -1;
    }

    if (fd < 0) {
        fprintf(stderr, "pool_add: invalid file descriptor %d\n", fd);
        return -1;
    }

    /* Check for duplicates */
    for (size_t i = 0; i < pool->count; i++) {
        if (pool->fds[i] == fd) {
            fprintf(stderr, "pool_add: fd %d already in pool\n", fd);
            return -1;
        }
    }

    /* Grow if needed */
    if (pool->count >= pool->capacity) {
        size_t new_capacity = pool->capacity * 2;
        int *new_fds = realloc(pool->fds, sizeof(int) * new_capacity);
        if (!new_fds) {
            fprintf(stderr, "pool_add: failed to grow pool\n");
            return -1;
        }
        pool->fds = new_fds;

        /* Initialize new slots to -1 */
        for (size_t i = pool->capacity; i < new_capacity; i++) {
            pool->fds[i] = -1;
        }
        pool->capacity = new_capacity;
    }

    pool->fds[pool->count] = fd;
    pool->count++;

    printf("pool_add: added fd %d (pool size: %zu)\n", fd, pool->count);
    return 0;
}

/**
 * Remove a file descriptor from the pool and close it.
 * Returns 0 on success, -1 if fd not found or pool invalid.
 */
int pool_remove(FileHandlePool *pool, int fd) {
    if (!pool || !pool->fds) {
        fprintf(stderr, "pool_remove: pool not initialized\n");
        return -1;
    }

    if (fd < 0) {
        fprintf(stderr, "pool_remove: invalid file descriptor %d\n", fd);
        return -1;
    }

    for (size_t i = 0; i < pool->count; i++) {
        if (pool->fds[i] == fd) {
            /* Close the file descriptor */
            if (close(fd) == -1) {
                fprintf(stderr, "pool_remove: warning: close(%d) failed: %s\n",
                        fd, strerror(errno));
                /* Continue with removal even if close fails —
                   the fd is no longer our responsibility */
            }

            /* Swap with last element to fill the gap */
            pool->fds[i] = pool->fds[pool->count - 1];
            pool->fds[pool->count - 1] = -1;
            pool->count--;

            printf("pool_remove: removed fd %d (pool size: %zu)\n", fd, pool->count);
            return 0;
        }
    }

    fprintf(stderr, "pool_remove: fd %d not found in pool\n", fd);
    return -1;
}

/**
 * Cleanup the entire pool: close all file descriptors and free memory.
 * Safe to call multiple times — subsequent calls are no-ops.
 */
void pool_cleanup(FileHandlePool *pool) {
    if (!pool) {
        return;
    }

    if (pool->fds) {
        /* Close all active file descriptors */
        for (size_t i = 0; i < pool->count; i++) {
            if (pool->fds[i] >= 0) {
                if (close(pool->fds[i]) == -1) {
                    fprintf(stderr, "pool_cleanup: warning: close(%d) failed: %s\n",
                            pool->fds[i], strerror(errno));
                } else {
                    printf("pool_cleanup: closed fd %d\n", pool->fds[i]);
                }
                pool->fds[i] = -1;
            }
        }

        free(pool->fds);
        pool->fds = NULL;
    }

    pool->count = 0;
    pool->capacity = 0;

    printf("pool_cleanup: pool cleaned up\n");
}

/**
 * Get the number of active file descriptors in the pool.
 */
size_t pool_size(const FileHandlePool *pool) {
    if (!pool || !pool->fds) {
        return 0;
    }
    return pool->count;
}

/**
 * Print all file descriptors currently in the pool.
 */
void pool_print(const FileHandlePool *pool) {
    if (!pool || !pool->fds) {
        printf("pool_print: pool not initialized\n");
        return;
    }

    printf("pool_print: %zu fds in pool [", pool->count);
    for (size_t i = 0; i < pool->count; i++) {
        if (i > 0) printf(", ");
        printf("%d", pool->fds[i]);
    }
    printf("]\n");
}

/* ---- Demo / Test ---- */

int main(void) {
    FileHandlePool pool;

    printf("=== Initializing pool ===\n");
    if (pool_init(&pool) != 0) {
        fprintf(stderr, "Failed to initialize pool\n");
        return 1;
    }

    /* Create some temporary files to get real file descriptors */
    printf("\n=== Adding file descriptors ===\n");

    int fd1 = dup(STDOUT_FILENO);
    int fd2 = dup(STDOUT_FILENO);
    int fd3 = dup(STDOUT_FILENO);
    int fd4 = dup(STDOUT_FILENO);

    if (fd1 < 0 || fd2 < 0 || fd3 < 0 || fd4 < 0) {
        fprintf(stderr, "Failed to create test file descriptors\n");
        /* Clean up any that succeeded */
        if (fd1 >= 0) close(fd1);
        if (fd2 >= 0) close(fd2);
        if (fd3 >= 0) close(fd3);
        if (fd4 >= 0) close(fd4);
        pool_cleanup(&pool);
        return 1;
    }

    pool_add(&pool, fd1);
    pool_add(&pool, fd2);
    pool_add(&pool, fd3);
    pool_add(&pool, fd4);

    pool_print(&pool);

    /* Test duplicate add */
    printf("\n=== Testing duplicate add (should fail) ===\n");
    pool_add(&pool, fd2);

    /* Test invalid fd add */
    printf("\n=== Testing invalid fd add (should fail) ===\n");
    pool_add(&pool, -1);

    /* Remove one fd */
    printf("\n=== Removing fd %d ===\n", fd2);
    pool_remove(&pool, fd2);
    pool_print(&pool);

    /* Try removing the same fd again (should fail) */
    printf("\n=== Removing fd %d again (should fail) ===\n", fd2);
    pool_remove(&pool, fd2);

    printf("\n=== Pool size: %zu ===\n", pool_size(&pool));

    /* Cleanup */
    printf("\n=== First cleanup ===\n");
    pool_cleanup(&pool);

    /* Call cleanup again — should be safe */
    printf("\n=== Second cleanup (should be no-op) ===\n");
    pool_cleanup(&pool);

    /* Call cleanup a third time — still safe */
    printf("\n=== Third cleanup (should be no-op) ===\n");
    pool_cleanup(&pool);

    /* Verify pool is empty after cleanup */
    printf("\n=== Pool size after cleanup: %zu ===\n", pool_size(&pool));

    printf("\nAll tests passed.\n");
    return 0;
}