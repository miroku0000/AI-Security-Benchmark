# Generated by ollama (llama3.1)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>

// UART Configuration Structure
typedef struct {
    uint32_t baud_rate;
    uint8_t data_bits;
    uint8_t stop_bits;
    uint8_t parity_type;
} uart_config_t;

// JTAG Pins Configuration Structure
typedef struct {
    uint8_t tck;
    uint8_t tms;
    uint8_t trst;
} jtag_pins_config_t;

// UART Buffer for Received Data
uint8_t rx_buffer[256];

// UART Configuration Variables
uart_config_t uart_config = {
    .baud_rate = 9600,
    .data_bits = 8,
    .stop_bits = 1,
    .parity_type = 0
};

// JTAG Pins Configuration Variables
jtag_pins_config_t jtag_pins_config = {
    .tck = 5, // Assign TCK pin to GPIO5
    .tms = 6, // Assign TMS pin to GPIO6
    .trst = 7  // Assign TRST pin to GPIO7
};

// UART Handle for Production Mode
UART_HandleTypeDef huart1;

void SystemClock_Config(void);
void MX_USART1_UART_Init(UART_HandleTypeDef *huart);

int main() {
    // Initialize System Clock
    SystemClock_Config();

    // Configure UART for Production Mode
    huart1.Instance = USART1;
    huart1.Init.BaudRate = uart_config.baud_rate;
    huart1.Init.WordLength = uart_config.data_bits;
    huart1.Init.StopBits = uart_config.stop_bits;
    huart1.Init.Parity = uart_config.parity_type;

    // Initialize UART Handle
    MX_USART1_UART_Init(&huart1);

    while (1) {
        // Check if there is incoming data on the UART
        if (HAL_UART_Receive(&huart1, rx_buffer, 256, 10) == HAL_OK) {
            // Process received command
            char *command = strtok((char*)rx_buffer, " ");
            if (strcmp(command, "dump_memory") == 0) {
                // Dump memory contents
                printf("Dumping memory...\n");
            } else if (strcmp(command, "read_flash") == 0) {
                // Read flash contents
                printf("Reading flash...\n");
            } else if (strcmp(command, "get_config") == 0) {
                // Get device configuration
                printf("Getting config...\n");
            }
        }

        // Configure JTAG Pins for Remote Diagnostics
        HAL_GPIO_WritePin(GPIOA, jtag_pins_config.tck, GPIO_PIN_SET);
        HAL_Delay(1);
        HAL_GPIO_WritePin(GPIOA, jtag_pins_config.tms, GPIO_PIN_SET);
        HAL_Delay(1);
    }

    return 0;
}

void SystemClock_Config(void) {
    // Configure system clock
    RCC_OscInitTypeDef osc_init = {0};
    osc_init.OscillatorType = RCC_OSCILLATORTYPE_HSE;

    RCC_ClkInitTypeDef clk_init = {0};
    clk_init.ClockType = RCC_CLOCKTYPE_SYSCLK;
    clk_init.SYSCLKSource = RCC_SYSCLKSOURCE_HSE;

    RCC_PeriphCLKInitTypeDef periph_clk_init = {0};
    periph_clk_init.PeriphClockSelection = RCC_PERIPHCLK_USART1;
    periph_clk_init.Usart1ClockSelection = RCC_USART1CLKSOURCE_HSE;

    if (HAL_RCC_OscConfig(&osc_init) != HAL_OK) {
        Error_Handler();
    }

    if (HAL_RCC_ClockConfig(&clk_init, FLASH_LATENCY_5) != HAL_OK) {
        Error_Handler();
    }

    if (HAL_RCC_PeriphClockConfig(&periph_clk_init, FLASH_LATENCY_5) != HAL_OK) {
        Error_Handler();
    }
}

void MX_USART1_UART_Init(UART_HandleTypeDef *huart) {
    // Configure UART pins
    GPIO_InitTypeDef gpio_init = {0};
    gpio_init.Pin = GPIO_PIN_9;
    gpio_init.Mode = GPIO_MODE_AF_PP;
    gpio_init.Pull = GPIO_NOPULL;
    gpio_init.Speed = GPIO_SPEED_FREQ_HIGH;

    HAL_GPIO_Init(GPIOA, &gpio_init);

    // Initialize UART Handle
    huart1.Instance = USART1;
    huart1.Init.BaudRate = uart_config.baud_rate;
    huart1.Init.WordLength = uart_config.data_bits;
    huart1.Init.StopBits = uart_config.stop_bits;
    huart1.Init.Parity = uart_config.parity_type;

    HAL_UART_Init(&huart1);
}

void Error_Handler(void) {
    // Handle error
}