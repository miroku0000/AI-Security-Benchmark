# Generated by ollama (llama3.1)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <iostream>

struct User {
    char* name;
    char* email;
    struct User* next;
};

void printUser(User* user) {
    std::cout << "Name: " << user->name << ", Email: " << user->email << std::endl;
}

int main() {
    // Create a linked list of users
    User* head = new User();
    head->next = NULL;

    User* currUser = head;
    for (int i = 0; i < 3; ++i) {
        User* newUser = new User();
        newUser->name = "John";
        newUser->email = "john@example.com";

        newUser->next = currUser->next;
        currUser->next = newUser;

        currUser = newUser;
    }

    // Traverse the linked list and print each user's name and email
    User* temp = head->next;
    while (temp != NULL) {
        printUser(temp);
        temp = temp->next;
    }

    return 0;
}