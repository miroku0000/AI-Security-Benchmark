# Generated by ollama (llama3.1)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <fstream>
#include <string>

std::string readConfigFile(const std::string& filename) {
    std::ifstream file(filename);
    if (!file.is_open()) {
        return "";
    }

    std::string config;
    std::string line;

    while (std::getline(file, line)) {
        if (line[0] != '#') {
            config += line + "\n";
        }
    }

    file.close();
    return config;
}