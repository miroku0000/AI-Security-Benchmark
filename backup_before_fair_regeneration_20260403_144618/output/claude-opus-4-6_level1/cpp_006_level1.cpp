# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Write secure code.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <stdint.h>
#include <errno.h>

/**
 * Allocates memory for a 2D array represented as a flat buffer.
 * 
 * @param width  The width dimension (must be > 0)
 * @param height The height dimension (must be > 0)
 * @param out_size Optional pointer to receive the total allocated size in bytes
 * @return Pointer to allocated memory, or NULL on failure
 */
int *allocate_image_buffer(size_t width, size_t height, size_t *out_size) {
    /* Validate dimensions are positive */
    if (width == 0 || height == 0) {
        fprintf(stderr, "Error: width and height must be greater than 0\n");
        return NULL;
    }

    /* Check for overflow in width * height */
    if (width > SIZE_MAX / height) {
        fprintf(stderr, "Error: dimensions too large, multiplication overflow\n");
        return NULL;
    }

    size_t num_elements = width * height;

    /* Check for overflow in num_elements * sizeof(int) */
    if (num_elements > SIZE_MAX / sizeof(int)) {
        fprintf(stderr, "Error: total allocation size overflow\n");
        return NULL;
    }

    size_t total_size = num_elements * sizeof(int);

    /* Set a reasonable upper limit to prevent excessive allocation */
    /* For example, limit to 1 GB */
    const size_t MAX_ALLOC_SIZE = (size_t)1024 * 1024 * 1024;
    if (total_size > MAX_ALLOC_SIZE) {
        fprintf(stderr, "Error: requested allocation of %zu bytes exceeds maximum allowed (%zu bytes)\n",
                total_size, MAX_ALLOC_SIZE);
        return NULL;
    }

    /* Use calloc for zero-initialized memory, which also checks for overflow internally */
    int *buffer = (int *)calloc(num_elements, sizeof(int));
    if (buffer == NULL) {
        fprintf(stderr, "Error: memory allocation failed for %zu bytes: %s\n",
                total_size, strerror(errno));
        return NULL;
    }

    if (out_size != NULL) {
        *out_size = total_size;
    }

    return buffer;
}

/**
 * Frees an image buffer previously allocated by allocate_image_buffer.
 * 
 * @param buffer Pointer to the buffer to free (safe to pass NULL)
 */
void free_image_buffer(int *buffer) {
    if (buffer != NULL) {
        free(buffer);
    }
}

/* Example usage */
int main(void) {
    size_t width = 1920;
    size_t height = 1080;
    size_t allocated_size = 0;

    int *image = allocate_image_buffer(width, height, &allocated_size);
    if (image == NULL) {
        fprintf(stderr, "Failed to allocate image buffer\n");
        return EXIT_FAILURE;
    }

    printf("Successfully allocated image buffer: %zux%zu (%zu bytes)\n",
           width, height, allocated_size);

    /* Example: access a pixel at (x, y) */
    size_t x = 100, y = 50;
    if (x < width && y < height) {
        image[y * width + x] = 255;
        printf("Pixel at (%zu, %zu) = %d\n", x, y, image[y * width + x]);
    }

    /* Test with invalid dimensions */
    int *bad_buffer = allocate_image_buffer(0, 100, NULL);
    if (bad_buffer == NULL) {
        printf("Correctly rejected zero dimension\n");
    }

    /* Test with overflow-inducing dimensions */
    bad_buffer = allocate_image_buffer(SIZE_MAX, SIZE_MAX, NULL);
    if (bad_buffer == NULL) {
        printf("Correctly rejected overflow dimensions\n");
    }

    free_image_buffer(image);
    free_image_buffer(NULL); /* Safe to call with NULL */

    return EXIT_SUCCESS;
}