# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

Write secure code.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <errno.h>
#include <stdbool.h>

typedef struct FileHandleNode {
    int fd;
    char *description;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct FileHandlePool {
    FileHandleNode *head;
    size_t count;
    bool initialized;
} FileHandlePool;

static FileHandlePool *pool_init(void) {
    FileHandlePool *pool = calloc(1, sizeof(FileHandlePool));
    if (pool == NULL) {
        fprintf(stderr, "Failed to allocate file handle pool\n");
        return NULL;
    }
    pool->head = NULL;
    pool->count = 0;
    pool->initialized = true;
    return pool;
}

static int pool_add(FileHandlePool *pool, int fd, const char *description) {
    if (pool == NULL || !pool->initialized) {
        fprintf(stderr, "Pool is not initialized\n");
        return -1;
    }

    if (fd < 0) {
        fprintf(stderr, "Invalid file descriptor: %d\n", fd);
        return -1;
    }

    /* Check for duplicate fd */
    FileHandleNode *current = pool->head;
    while (current != NULL) {
        if (current->fd == fd) {
            fprintf(stderr, "File descriptor %d already in pool\n", fd);
            return -1;
        }
        current = current->next;
    }

    FileHandleNode *node = calloc(1, sizeof(FileHandleNode));
    if (node == NULL) {
        fprintf(stderr, "Failed to allocate file handle node\n");
        return -1;
    }

    node->fd = fd;
    node->description = NULL;

    if (description != NULL) {
        size_t desc_len = strnlen(description, 256);
        node->description = calloc(desc_len + 1, sizeof(char));
        if (node->description == NULL) {
            fprintf(stderr, "Failed to allocate description\n");
            free(node);
            return -1;
        }
        memcpy(node->description, description, desc_len);
        node->description[desc_len] = '\0';
    }

    node->next = pool->head;
    pool->head = node;
    pool->count++;

    return 0;
}

static int pool_remove(FileHandlePool *pool, int fd) {
    if (pool == NULL || !pool->initialized) {
        fprintf(stderr, "Pool is not initialized\n");
        return -1;
    }

    if (fd < 0) {
        fprintf(stderr, "Invalid file descriptor: %d\n", fd);
        return -1;
    }

    FileHandleNode *current = pool->head;
    FileHandleNode *prev = NULL;

    while (current != NULL) {
        if (current->fd == fd) {
            if (prev == NULL) {
                pool->head = current->next;
            } else {
                prev->next = current->next;
            }

            /* Close the file descriptor */
            int ret;
            do {
                ret = close(current->fd);
            } while (ret == -1 && errno == EINTR);

            if (ret == -1) {
                fprintf(stderr, "Warning: failed to close fd %d: %s\n",
                        current->fd, strerror(errno));
            }

            free(current->description);
            current->description = NULL;
            current->fd = -1;
            current->next = NULL;
            free(current);

            pool->count--;
            return 0;
        }
        prev = current;
        current = current->next;
    }

    fprintf(stderr, "File descriptor %d not found in pool\n", fd);
    return -1;
}

static void pool_cleanup(FileHandlePool **pool_ptr) {
    if (pool_ptr == NULL || *pool_ptr == NULL) {
        return;
    }

    FileHandlePool *pool = *pool_ptr;

    if (!pool->initialized) {
        free(pool);
        *pool_ptr = NULL;
        return;
    }

    FileHandleNode *current = pool->head;
    while (current != NULL) {
        FileHandleNode *next = current->next;

        int ret;
        do {
            ret = close(current->fd);
        } while (ret == -1 && errno == EINTR);

        if (ret == -1) {
            fprintf(stderr, "Warning: failed to close fd %d during cleanup: %s\n",
                    current->fd, strerror(errno));
        }

        free(current->description);
        current->description = NULL;
        current->fd = -1;
        current->next = NULL;
        free(current);

        current = next;
    }

    pool->head = NULL;
    pool->count = 0;
    pool->initialized = false;

    free(pool);
    *pool_ptr = NULL;
}

static void pool_print(const FileHandlePool *pool) {
    if (pool == NULL || !pool->initialized) {
        printf("Pool is not initialized\n");
        return;
    }

    printf("File Handle Pool (%zu entries):\n", pool->count);
    FileHandleNode *current = pool->head;
    while (current != NULL) {
        printf("  fd=%d, description=\"%s\"\n",
               current->fd,
               current->description ? current->description : "(none)");
        current = current->next;
    }
}

int main(void) {
    FileHandlePool *pool = pool_init();
    if (pool == NULL) {
        return EXIT_FAILURE;
    }

    /* Create some pipe file descriptors for demonstration */
    int pipefd1[2], pipefd2[2], pipefd3[2];

    if (pipe(pipefd1) == -1) {
        perror("pipe");
        pool_cleanup(&pool);
        return EXIT_FAILURE;
    }
    if (pipe(pipefd2) == -1) {
        perror("pipe");
        close(pipefd1[0]);
        close(pipefd1[1]);
        pool_cleanup(&pool);
        return EXIT_FAILURE;
    }
    if (pipe(pipefd3) == -1) {
        perror("pipe");
        close(pipefd1[0]);
        close(pipefd1[1]);
        close(pipefd2[0]);
        close(pipefd2[1]);
        pool_cleanup(&pool);
        return EXIT_FAILURE;
    }

    /* Add file descriptors to the pool */
    pool_add(pool, pipefd1[0], "client-connection-read-1");
    pool_add(pool, pipefd1[1], "client-connection-write-1");
    pool_add(pool, pipefd2[0], "client-connection-read-2");
    pool_add(pool, pipefd2[1], "client-connection-write-2");
    pool_add(pool, pipefd3[0], "client-connection-read-3");
    pool_add(pool, pipefd3[1], "client-connection-write-3");

    printf("After adding 6 file descriptors:\n");
    pool_print(pool);

    /* Test duplicate detection */
    printf("\nAttempting to add duplicate fd %d:\n", pipefd1[0]);
    int ret = pool_add(pool, pipefd1[0], "duplicate");
    printf("Result: %s\n", ret == -1 ? "rejected (correct)" : "accepted (error)");

    /* Remove one */
    printf("\nRemoving fd %d:\n", pipefd2[0]);
    pool_remove(pool, pipefd2[0]);
    pool_print(pool);

    /* Test removing non-existent fd */
    printf("\nAttempting to remove non-existent fd 9999:\n");
    ret = pool_remove(pool, 9999);
    printf("Result: %s\n", ret == -1 ? "not found (correct)" : "found (error)");

    /* Cleanup all remaining */
    printf("\nCleaning up pool...\n");
    pool_cleanup(&pool);
    printf("Pool pointer after cleanup: %p\n", (void *)pool);

    /* Safe to call cleanup again */
    printf("Calling cleanup again (should be safe)...\n");
    pool_cleanup(&pool);
    printf("Pool pointer after second cleanup: %p\n", (void *)pool);

    printf("\nAll tests passed.\n");
    return EXIT_SUCCESS;
}