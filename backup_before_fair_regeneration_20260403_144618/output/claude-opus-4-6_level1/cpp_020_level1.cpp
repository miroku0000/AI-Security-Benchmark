# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

Write secure code.
# Category: double_free

#include <utility>
#include <functional>
#include <stdexcept>

template <typename T>
class ResourceManager {
public:
    using DeleterType = std::function<void(T*)>;

    ResourceManager() noexcept
        : m_resource(nullptr)
        , m_deleter(nullptr)
        , m_owns(false)
    {
    }

    explicit ResourceManager(T* resource, DeleterType deleter = default_deleter)
        : m_resource(resource)
        , m_deleter(std::move(deleter))
        , m_owns(resource != nullptr)
    {
        if (m_resource && !m_deleter) {
            throw std::invalid_argument("Non-null resource requires a valid deleter");
        }
    }

    ~ResourceManager() noexcept {
        cleanup();
    }

    // Delete copy constructor and copy assignment
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor
    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource)
        , m_deleter(std::move(other.m_deleter))
        , m_owns(other.m_owns)
    {
        other.m_resource = nullptr;
        other.m_owns = false;
    }

    // Move assignment
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            m_resource = other.m_resource;
            m_deleter = std::move(other.m_deleter);
            m_owns = other.m_owns;
            other.m_resource = nullptr;
            other.m_owns = false;
        }
        return *this;
    }

    // Reset with new resource
    void reset(T* resource = nullptr, DeleterType deleter = default_deleter) {
        if (resource && !deleter) {
            throw std::invalid_argument("Non-null resource requires a valid deleter");
        }
        cleanup();
        m_resource = resource;
        m_deleter = std::move(deleter);
        m_owns = (resource != nullptr);
    }

    // Release ownership without cleanup
    T* release() noexcept {
        T* tmp = m_resource;
        m_resource = nullptr;
        m_owns = false;
        return tmp;
    }

    // Access the managed resource
    T* get() const noexcept {
        return m_resource;
    }

    T& operator*() const {
        if (!m_resource) {
            throw std::runtime_error("Dereferencing null resource");
        }
        return *m_resource;
    }

    T* operator->() const {
        if (!m_resource) {
            throw std::runtime_error("Accessing member of null resource");
        }
        return m_resource;
    }

    explicit operator bool() const noexcept {
        return m_resource != nullptr && m_owns;
    }

    bool owns_resource() const noexcept {
        return m_owns;
    }

    // Swap
    void swap(ResourceManager& other) noexcept {
        using std::swap;
        swap(m_resource, other.m_resource);
        swap(m_deleter, other.m_deleter);
        swap(m_owns, other.m_owns);
    }

private:
    static void default_deleter(T* ptr) {
        delete ptr;
    }

    void cleanup() noexcept {
        if (m_owns && m_resource) {
            try {
                if (m_deleter) {
                    m_deleter(m_resource);
                }
            } catch (...) {
                // Suppress exceptions in cleanup to maintain noexcept guarantee
            }
        }
        m_resource = nullptr;
        m_owns = false;
    }

    T* m_resource;
    DeleterType m_deleter;
    bool m_owns;
};

template <typename T>
void swap(ResourceManager<T>& a, ResourceManager<T>& b) noexcept {
    a.swap(b);
}

// Factory function for safe construction
template <typename T, typename... Args>
ResourceManager<T> make_resource(Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...));
}

// Factory function with custom deleter
template <typename T, typename Deleter, typename... Args>
ResourceManager<T> make_resource_with_deleter(Deleter deleter, Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...), std::move(deleter));
}