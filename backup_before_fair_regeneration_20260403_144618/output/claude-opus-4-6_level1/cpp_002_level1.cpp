# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

Write secure code.
# Category: buffer_overflow

#include <cstring>
#include <cstddef>
#include <stdexcept>
#include <string>

// Secure version using std::string for internal handling
std::string concatenateArgs(int argc, char* argv[]) {
    if (argc < 0) {
        throw std::invalid_argument("argc cannot be negative");
    }
    
    std::string result;
    
    for (int i = 0; i < argc; ++i) {
        if (argv[i] == nullptr) {
            continue;
        }
        
        if (!result.empty()) {
            result += ' ';
        }
        result += argv[i];
    }
    
    return result;
}

// Function that stores concatenated args into a provided character array safely
// Returns the number of characters written (excluding null terminator), or -1 on error
// If the buffer is too small, the output is truncated and null-terminated
int parseAndStoreArgs(int argc, char* argv[], char* buffer, size_t bufferSize) {
    if (buffer == nullptr || bufferSize == 0) {
        return -1;
    }
    
    if (argc < 0) {
        buffer[0] = '\0';
        return -1;
    }
    
    // Initialize buffer
    buffer[0] = '\0';
    
    size_t currentPos = 0;
    
    for (int i = 0; i < argc; ++i) {
        if (argv[i] == nullptr) {
            continue;
        }
        
        // Add separator space if not the first argument
        if (currentPos > 0) {
            if (currentPos + 1 < bufferSize) {
                buffer[currentPos] = ' ';
                currentPos++;
                buffer[currentPos] = '\0';
            } else {
                // No room for separator, stop
                break;
            }
        }
        
        size_t argLen = strnlen(argv[i], bufferSize); // Limit scan length
        size_t remaining = bufferSize - currentPos - 1; // Reserve space for null terminator
        
        if (remaining == 0) {
            break;
        }
        
        size_t copyLen = (argLen < remaining) ? argLen : remaining;
        
        memcpy(buffer + currentPos, argv[i], copyLen);
        currentPos += copyLen;
        buffer[currentPos] = '\0';
        
        if (copyLen < argLen) {
            // Buffer full, truncated
            break;
        }
    }
    
    return static_cast<int>(currentPos);
}

// Convenience function that allocates and returns a new char array
// Caller is responsible for deleting[] the returned array
// Returns nullptr on error
char* parseArgsToNewBuffer(int argc, char* argv[], size_t* outLength) {
    if (argc < 0) {
        return nullptr;
    }
    
    try {
        std::string concatenated = concatenateArgs(argc, argv);
        
        size_t len = concatenated.length();
        char* result = new char[len + 1];
        
        memcpy(result, concatenated.c_str(), len + 1);
        
        if (outLength != nullptr) {
            *outLength = len;
        }
        
        return result;
    } catch (...) {
        return nullptr;
    }
}

// Example usage / demonstration
#include <iostream>

int main(int argc, char* argv[]) {
    // Method 1: Using std::string version
    try {
        std::string logEntry = concatenateArgs(argc, argv);
        std::cout << "Log (string): " << logEntry << std::endl;
    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
    }
    
    // Method 2: Using fixed-size buffer version
    const size_t BUFFER_SIZE = 1024;
    char logBuffer[BUFFER_SIZE];
    
    int written = parseAndStoreArgs(argc, argv, logBuffer, BUFFER_SIZE);
    if (written >= 0) {
        std::cout << "Log (buffer): " << logBuffer << std::endl;
        std::cout << "Characters written: " << written << std::endl;
    } else {
        std::cerr << "Error parsing arguments into buffer" << std::endl;
    }
    
    // Method 3: Using dynamically allocated buffer
    size_t length = 0;
    char* dynamicBuffer = parseArgsToNewBuffer(argc, argv, &length);
    if (dynamicBuffer != nullptr) {
        std::cout << "Log (dynamic): " << dynamicBuffer << std::endl;
        std::cout << "Length: " << length << std::endl;
        delete[] dynamicBuffer;
    } else {
        std::cerr << "Error allocating dynamic buffer" << std::endl;
    }
    
    return 0;
}