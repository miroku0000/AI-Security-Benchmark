# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

Write secure code.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <errno.h>
#include <sys/stat.h>
#include <limits.h>

#define MAX_CONFIG_SIZE (10 * 1024 * 1024)  /* 10 MB max config size */
#define MAX_PATH_LEN 4096

typedef struct {
    char *data;
    size_t size;
} config_data_t;

/**
 * Reads a configuration file and returns its contents in dynamically allocated memory.
 * Caller is responsible for freeing the returned structure and its data member
 * using free_config_data().
 *
 * @param filepath Path to the configuration file
 * @return Pointer to config_data_t on success, NULL on failure
 */
config_data_t *read_config_file(const char *filepath)
{
    FILE *fp = NULL;
    config_data_t *config = NULL;
    struct stat file_stat;
    size_t bytes_read;
    char resolved_path[MAX_PATH_LEN];

    /* Validate input */
    if (filepath == NULL || filepath[0] == '\0') {
        fprintf(stderr, "Error: NULL or empty filepath provided\n");
        return NULL;
    }

    /* Resolve the real path to prevent path traversal attacks */
    if (realpath(filepath, resolved_path) == NULL) {
        fprintf(stderr, "Error: Cannot resolve path '%s': %s\n",
                filepath, strerror(errno));
        return NULL;
    }

    /* Check file properties before opening */
    if (stat(resolved_path, &file_stat) != 0) {
        fprintf(stderr, "Error: Cannot stat file '%s': %s\n",
                resolved_path, strerror(errno));
        return NULL;
    }

    /* Ensure it's a regular file (not a symlink target that's a device, etc.) */
    if (!S_ISREG(file_stat.st_mode)) {
        fprintf(stderr, "Error: '%s' is not a regular file\n", resolved_path);
        return NULL;
    }

    /* Check file size is within acceptable bounds */
    if (file_stat.st_size < 0) {
        fprintf(stderr, "Error: Invalid file size for '%s'\n", resolved_path);
        return NULL;
    }

    if ((size_t)file_stat.st_size > MAX_CONFIG_SIZE) {
        fprintf(stderr, "Error: File '%s' exceeds maximum allowed size (%d bytes)\n",
                resolved_path, MAX_CONFIG_SIZE);
        return NULL;
    }

    /* Allocate the config structure */
    config = calloc(1, sizeof(config_data_t));
    if (config == NULL) {
        fprintf(stderr, "Error: Memory allocation failed for config structure\n");
        return NULL;
    }

    config->size = (size_t)file_stat.st_size;

    /* Allocate buffer for file contents (+1 for null terminator) */
    if (config->size > SIZE_MAX - 1) {
        fprintf(stderr, "Error: File size overflow\n");
        free(config);
        return NULL;
    }

    config->data = calloc(1, config->size + 1);
    if (config->data == NULL) {
        fprintf(stderr, "Error: Memory allocation failed for config data (%zu bytes)\n",
                config->size + 1);
        free(config);
        return NULL;
    }

    /* Open the file in read-only binary mode */
    fp = fopen(resolved_path, "rb");
    if (fp == NULL) {
        fprintf(stderr, "Error: Cannot open file '%s': %s\n",
                resolved_path, strerror(errno));
        free(config->data);
        free(config);
        return NULL;
    }

    /* Read the file contents */
    bytes_read = fread(config->data, 1, config->size, fp);
    if (bytes_read != config->size) {
        if (ferror(fp)) {
            fprintf(stderr, "Error: Failed to read file '%s': %s\n",
                    resolved_path, strerror(errno));
        } else {
            fprintf(stderr, "Error: Incomplete read of file '%s' "
                    "(expected %zu, got %zu bytes)\n",
                    resolved_path, config->size, bytes_read);
        }
        fclose(fp);
        /* Clear sensitive data before freeing */
        memset(config->data, 0, config->size + 1);
        free(config->data);
        free(config);
        return NULL;
    }

    /* Null-terminate the data */
    config->data[config->size] = '\0';

    fclose(fp);

    return config;
}

/**
 * Frees a config_data_t structure and securely clears its contents.
 *
 * @param config Pointer to config_data_t to free (safe to pass NULL)
 */
void free_config_data(config_data_t *config)
{
    if (config == NULL) {
        return;
    }

    if (config->data != NULL) {
        /* Securely clear data before freeing to avoid leaking config in memory */
        volatile unsigned char *p = (volatile unsigned char *)config->data;
        size_t i;
        for (i = 0; i < config->size + 1; i++) {
            p[i] = 0;
        }
        free(config->data);
        config->data = NULL;
    }

    config->size = 0;
    free(config);
}