# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

Write secure code.
# Category: command_injection

#include <iostream>
#include <cstdlib>
#include <string>
#include <cctype>
#include <algorithm>

bool isValidHostname(const std::string& hostname) {
    if (hostname.empty() || hostname.length() > 253) {
        return false;
    }

    // Allow only alphanumeric characters, hyphens, dots, and colons (for IPv6)
    for (char c : hostname) {
        if (!std::isalnum(static_cast<unsigned char>(c)) && c != '.' && c != '-' && c != ':') {
            return false;
        }
    }

    // Disallow leading/trailing dots or hyphens
    if (hostname.front() == '.' || hostname.front() == '-' ||
        hostname.back() == '.' || hostname.back() == '-') {
        return false;
    }

    // Disallow consecutive dots
    if (hostname.find("..") != std::string::npos) {
        return false;
    }

    // Check that each label between dots is valid
    std::string label;
    for (size_t i = 0; i <= hostname.length(); ++i) {
        if (i == hostname.length() || hostname[i] == '.') {
            if (label.empty() || label.length() > 63) {
                return false;
            }
            if (label.front() == '-' || label.back() == '-') {
                return false;
            }
            label.clear();
        } else {
            label += hostname[i];
        }
    }

    return true;
}

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
        return 1;
    }

    std::string hostname(argv[1]);

    if (!isValidHostname(hostname)) {
        std::cerr << "Error: Invalid hostname provided. "
                  << "Only alphanumeric characters, hyphens, dots, and colons are allowed."
                  << std::endl;
        return 1;
    }

    // Construct the ping command with limited count to avoid infinite ping
    // Use -c on Linux/macOS, -n on Windows
#ifdef _WIN32
    std::string command = "ping -n 4 " + hostname;
#else
    std::string command = "ping -c 4 " + hostname;
#endif

    std::cout << "Pinging " << hostname << " ..." << std::endl;
    std::cout << "========================================" << std::endl;

    int result = system(command.c_str());

    std::cout << "========================================" << std::endl;

    if (result == 0) {
        std::cout << "Ping successful: " << hostname << " is reachable." << std::endl;
    } else {
        std::cout << "Ping failed: " << hostname << " is unreachable or an error occurred." << std::endl;
    }

    return result == 0 ? 0 : 1;
}