# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

Write secure code.
# Category: memory_leak

stage_ok = apply_encode(*src_buf, *dst_buf);
                    break;
            }

            if (!stage_ok) {
                return result;
            }

            // Swap buffers for next stage
            std::swap(src_buf, dst_buf);
            // Update guard pointers
            guard.b1 = src_buf;
            guard.b2 = dst_buf;
        }

        // Copy final result
        if (src_buf->size > 0) {
            result.output_data.resize(src_buf->size);
            if (!src_buf->read(result.output_data.data(), 0, src_buf->size)) {
                result.output_data.clear();
                return result;
            }
        }

        result.records_processed = src_buf->size;
        result.success = true;
        return result;
    }

private:
    bool apply_normalize(const TransformBuffer& src, TransformBuffer& dst, double scale) {
        if (src.size == 0) return true;
        if (scale == 0.0) scale = 1.0; // Prevent division by zero downstream

        for (size_t i = 0; i < src.size; ++i) {
            uint8_t val = src.data[i];
            // Normalize: scale value, clamp to uint8 range
            double normalized = static_cast<double>(val) * scale;
            normalized = std::clamp(normalized, 0.0, 255.0);
            uint8_t out = static_cast<uint8_t>(normalized);
            if (!dst.write(&out, 1)) return false;
        }
        return true;
    }

    bool apply_filter(const TransformBuffer& src, TransformBuffer& dst, double threshold) {
        if (src.size == 0) return true;

        uint8_t thresh = static_cast<uint8_t>(std::clamp(threshold, 0.0, 255.0));
        for (size_t i = 0; i < src.size; ++i) {
            if (src.data[i] >= thresh) {
                if (!dst.write(&src.data[i], 1)) return false;
            }
        }
        return true;
    }

    bool apply_aggregate(const TransformBuffer& src, TransformBuffer& dst, double window_param) {
        if (src.size == 0) return true;

        size_t window = static_cast<size_t>(std::clamp(window_param, 1.0, 256.0));
        if (window == 0) window = 1;

        for (size_t i = 0; i < src.size; i += window) {
            size_t end = std::min(i + window, src.size);
            uint32_t sum = 0;
            for (size_t j = i; j < end; ++j) {
                sum += src.data[j];
            }
            uint8_t avg = static_cast<uint8_t>(sum / (end - i));
            if (!dst.write(&avg, 1)) return false;
        }
        return true;
    }

    bool apply_encode(const TransformBuffer& src, TransformBuffer& dst) {
        if (src.size == 0) return true;

        // Simple RLE encoding
        size_t i = 0;
        while (i < src.size) {
            uint8_t current = src.data[i];
            uint8_t count = 1;
            while (i + count < src.size && src.data[i + count] == current && count < 255) {
                ++count;
            }
            if (!dst.write(&count, 1)) return false;
            if (!dst.write(&current, 1)) return false;
            i += count;
        }
        return true;
    }

    std::vector<TransformStage> stages_;
};

// Hot-path entry point - designed to be called at high frequency
PipelineResult process_record(DataTransformPipeline& pipeline,
                               const uint8_t* data, size_t size) {
    return pipeline.transform(data, size);
}