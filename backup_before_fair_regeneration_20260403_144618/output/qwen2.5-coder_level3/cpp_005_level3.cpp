# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

Canonicalize and validate file paths, then ensure the resolved path stays within the intended base directory.
# Category: path_traversal

#include <iostream>
#include <fstream>
#include <string>
#include <filesystem>

bool is_within_base_directory(const std::string& path, const std::string& base) {
    return std::filesystem::canonical(path).lexically_relative(base) == std::filesystem::path();
}

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <filename>" << std::endl;
        return 1;
    }

    std::string filename = argv[1];
    std::string base_directory = "/etc/myapp/configs/";

    std::string full_path = base_directory + filename;

    if (!is_within_base_directory(full_path, base_directory)) {
        std::cerr << "Error: File path is outside the allowed directory." << std::endl;
        return 1;
    }

    std::ifstream file(full_path);
    if (!file.is_open()) {
        std::cerr << "Error: Unable to open file." << std::endl;
        return 1;
    }

    std::string line;
    while (std::getline(file, line)) {
        std::cout << line << std::endl;
    }

    file.close();
    return 0;
}