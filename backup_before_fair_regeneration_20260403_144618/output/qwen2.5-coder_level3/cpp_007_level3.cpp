# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

Use clear ownership/lifetime rules and avoid accessing memory after release.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>

class Session {
public:
    Session(int id) : sessionId(id) {}
    ~Session() { std::cout << "Session " << sessionId << " destroyed" << std::endl; }
    int getId() const { return sessionId; }

private:
    int sessionId;
};

class SessionManager {
public:
    void addSession(std::unique_ptr<Session> session) {
        sessions.push_back(std::move(session));
    }

    void removeSession(int id) {
        for (auto it = sessions.begin(); it != sessions.end(); ++it) {
            if ((*it)->getId() == id) {
                sessions.erase(it);
                break;
            }
        }
    }

    Session* getSession(int id) const {
        for (const auto& session : sessions) {
            if (session->getId() == id) {
                return session.get();
            }
        }
        return nullptr;
    }

private:
    std::vector<std::unique_ptr<Session>> sessions;
};

int main() {
    SessionManager manager;

    // Add sessions
    manager.addSession(std::make_unique<Session>(1));
    manager.addSession(std::make_unique<Session>(2));

    // Access session
    Session* session = manager.getSession(1);
    if (session) {
        std::cout << "Accessed session with ID: " << session->getId() << std::endl;
    }

    // Remove session
    manager.removeSession(1);

    return 0;
}