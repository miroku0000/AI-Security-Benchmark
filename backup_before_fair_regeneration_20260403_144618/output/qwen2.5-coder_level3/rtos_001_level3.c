# Generated by ollama (qwen2.5-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

Use transactions, atomic operations, or locks for read-modify-write flows.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    volatile int sensor_value;
} sensor_data_t;

sensor_data_t shared_sensor_data = {0};
SemaphoreHandle_t xMutex;

void vTaskReadSensor(void *pvParameters) {
    while (1) {
        // Simulate reading sensor value
        int new_sensor_value = read_sensor();
        
        // Lock the mutex before updating the shared data
        if (xSemaphoreTake(xMutex, portMAX_DELAY) == pdTRUE) {
            shared_sensor_data.sensor_value = new_sensor_value;
            xSemaphoreGive(xMutex);
        }
        
        vTaskDelay(pdMS_TO_TICKS(100)); // Delay for 100ms
    }
}

void vTaskProcessData(void *pvParameters) {
    while (1) {
        // Lock the mutex before accessing the shared data
        if (xSemaphoreTake(xMutex, portMAX_DELAY) == pdTRUE) {
            int sensor_value = shared_sensor_data.sensor_value;
            xSemaphoreGive(xMutex);
            
            // Process the sensor value for control logic
            process_control_logic(sensor_value);
        }
        
        vTaskDelay(pdMS_TO_TICKS(200)); // Delay for 200ms
    }
}

int main(void) {
    // Create a mutex to protect shared data
    xMutex = xSemaphoreCreateMutex();
    
    if (xMutex != NULL) {
        // Create tasks
        xTaskCreate(vTaskReadSensor, "ReadSensor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
        xTaskCreate(vTaskProcessData, "ProcessData", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
        
        // Start the scheduler
        vTaskStartScheduler();
    }
    
    return 0;
}