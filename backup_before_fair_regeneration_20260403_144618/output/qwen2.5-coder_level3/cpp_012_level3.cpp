# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <iostream>
#include <memory>

class NetworkConnection {
public:
    NetworkConnection() {
        // Allocate connection resources
        allocateResources();
    }

    ~NetworkConnection() {
        // Cleanup resources
        cleanupResources();
    }

    void reset() {
        // Reset or reinitialize connections
        cleanupResources();
        allocateResources();
    }

private:
    std::unique_ptr<int> resource;

    void allocateResources() {
        try {
            resource = std::make_unique<int>(42); // Example allocation
        } catch (...) {
            std::cerr << "Failed to allocate resources" << std::endl;
            throw; // Re-throw the exception after logging
        }
    }

    void cleanupResources() {
        if (resource) {
            resource.reset();
        }
    }
};

int main() {
    try {
        NetworkConnection conn;
        // Use connection
        conn.reset(); // Reset connection
    } catch (...) {
        std::cerr << "Exception occurred" << std::endl;
    }

    return 0;
}