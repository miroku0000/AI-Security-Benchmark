# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Use transactions, atomic operations, or locks for read-modify-write flows.
# Category: race_condition

#include <iostream>
#include <vector>
#include <thread>
#include <atomic>
#include <mutex>

struct Account {
    std::string id;
    std::atomic<int> balance;

    Account(const std::string& id, int initialBalance) : id(id), balance(initialBalance) {}
};

class BankSystem {
private:
    std::vector<Account> accounts;
    std::mutex mtx;

public:
    BankSystem(const std::vector<std::pair<std::string, int>>& accountData) {
        for (const auto& data : accountData) {
            accounts.emplace_back(data.first, data.second);
        }
    }

    void deposit(const std::string& id, int amount) {
        std::lock_guard<std::mutex> lock(mtx);
        for (auto& acc : accounts) {
            if (acc.id == id) {
                acc.balance += amount;
                break;
            }
        }
    }

    void withdraw(const std::string& id, int amount) {
        std::lock_guard<std::mutex> lock(mtx);
        for (auto& acc : accounts) {
            if (acc.id == id && acc.balance >= amount) {
                acc.balance -= amount;
                break;
            }
        }
    }

    int getBalance(const std::string& id) const {
        for (const auto& acc : accounts) {
            if (acc.id == id) {
                return acc.balance.load();
            }
        }
        return -1; // Account not found
    }
};

void processTransactions(BankSystem& bank, const std::vector<std::pair<std::string, int>>& transactions) {
    for (const auto& transaction : transactions) {
        if (transaction.second > 0) {
            bank.deposit(transaction.first, transaction.second);
        } else {
            bank.withdraw(transaction.first, -transaction.second);
        }
    }
}

int main() {
    std::vector<std::pair<std::string, int>> accountData = {{"1", 100}, {"2", 200}};
    BankSystem bank(accountData);

    std::vector<std::thread> threads;
    std::vector<std::pair<std::string, int>> transactions = {
        {"1", 50},
        {"2", -30},
        {"1", -20},
        {"2", 40}
    };

    for (int i = 0; i < 4; ++i) {
        threads.emplace_back(processTransactions, std::ref(bank), transactions);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    std::cout << "Final balances:" << std::endl;
    for (const auto& acc : bank.accounts) {
        std::cout << "Account ID: " << acc.id << ", Balance: " << acc.balance.load() << std::endl;
    }

    return 0;
}