# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <errno.h>

#define REQUEST_BUFFER_SIZE 8192
#define RESPONSE_BUFFER_SIZE 4096

typedef struct {
    char *buffer;
    size_t capacity;
    size_t length;
} RequestBuffer;

static int init_request_buffer(RequestBuffer *rb, size_t capacity) {
    rb->buffer = (char *)malloc(capacity);
    if (!rb->buffer) return -1;
    rb->capacity = capacity;
    rb->length = 0;
    return 0;
}

static void free_request_buffer(RequestBuffer *rb) {
    if (rb->buffer) free(rb->buffer);
    rb->buffer = NULL;
    rb->capacity = 0;
    rb->length = 0;
}

static ssize_t read_request(int fd, RequestBuffer *rb) {
    rb->length = 0;
    ssize_t n = read(fd, rb->buffer, rb->capacity - 1);
    if (n > 0) {
        rb->length = (size_t)n;
        rb->buffer[rb->length] = '\0';
    }
    return n;
}

static void process_request(const char *request, size_t request_len, char *response, size_t response_cap) {
    (void)request_len;
    const char *body = "OK";
    int written = snprintf(response, response_cap,
                           "HTTP/1.1 200 OK\r\n"
                           "Content-Length: %zu\r\n"
                           "Connection: keep-alive\r\n"
                           "Content-Type: text/plain\r\n"
                           "\r\n"
                           "%s",
                           strlen(body), body);
    if (written < 0 || (size_t)written >= response_cap) {
        if (response_cap > 0) response[0] = '\0';
    }
    (void)request;
}

static int handle_client(int fd) {
    RequestBuffer rb;
    char response[RESPONSE_BUFFER_SIZE];

    if (init_request_buffer(&rb, REQUEST_BUFFER_SIZE) != 0) {
        return -1;
    }

    for (;;) {
        ssize_t n = read_request(fd, &rb);
        if (n == 0) {
            break;
        }
        if (n < 0) {
            if (errno == EINTR) continue;
            break;
        }

        process_request(rb.buffer, rb.length, response, sizeof(response));

        size_t to_write = strnlen(response, sizeof(response));
        size_t total = 0;
        while (total < to_write) {
            ssize_t w = write(fd, response + total, to_write - total);
            if (w < 0) {
                if (errno == EINTR) continue;
                free_request_buffer(&rb);
                return -1;
            }
            total += (size_t)w;
        }
    }

    free_request_buffer(&rb);
    return 0;
}

int main(void) {
    int stdin_fd = STDIN_FILENO;
    (void)handle_client(stdin_fd);
    return 0;
}