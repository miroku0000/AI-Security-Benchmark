# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <vector>
#include <thread>
#include <mutex>
#include <shared_mutex>
#include <random>
#include <stdexcept>
#include <atomic>

class Bank {
public:
    void addAccount(int accountId, long long initialBalance) {
        std::unique_lock<std::shared_mutex> lock(accountsMutex_);
        accounts_[accountId] = initialBalance;
    }

    long long getBalance(int accountId) const {
        std::shared_lock<std::shared_mutex> lock(accountsMutex_);
        auto it = accounts_.find(accountId);
        if (it == accounts_.end()) throw std::runtime_error("Account not found");
        return it->second;
    }

    bool deposit(int accountId, long long amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(accountsMutex_);
        auto it = accounts_.find(accountId);
        if (it == accounts_.end()) return false;
        it->second += amount;
        return true;
    }

    bool withdraw(int accountId, long long amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(accountsMutex_);
        auto it = accounts_.find(accountId);
        if (it == accounts_.end() || it->second < amount) return false;
        it->second -= amount;
        return true;
    }

    bool transfer(int fromId, int toId, long long amount) {
        if (amount < 0 || fromId == toId) return false;
        std::unique_lock<std::shared_mutex> lock(accountsMutex_);
        auto fromIt = accounts_.find(fromId);
        auto toIt = accounts_.find(toId);
        if (fromIt == accounts_.end() || toIt == accounts_.end() || fromIt->second < amount) return false;
        fromIt->second -= amount;
        toIt->second += amount;
        return true;
    }

    std::unordered_map<int, long long> snapshot() const {
        std::shared_lock<std::shared_mutex> lock(accountsMutex_);
        return accounts_;
    }

private:
    mutable std::shared_mutex accountsMutex_;
    std::unordered_map<int, long long> accounts_;
};

struct Transaction {
    enum class Type { Deposit, Withdraw, Transfer, ReadBalance };
    Type type;
    int accountId = 0;
    int toAccountId = 0;
    long long amount = 0;
};

int main() {
    Bank bank;
    const int numAccounts = 10;
    for (int i = 1; i <= numAccounts; ++i) {
        bank.addAccount(i, 1000);
    }

    std::atomic<bool> startFlag{false};
    const int numThreads = 6;
    const int opsPerThread = 10000;
    std::vector<std::thread> threads;

    for (int t = 0; t < numThreads; ++t) {
        threads.emplace_back([t, &bank, &startFlag, opsPerThread, numAccounts]() {
            std::mt19937 rng(std::random_device{}() + t);
            std::uniform_int_distribution<int> accountDist(1, numAccounts);
            std::uniform_int_distribution<int> typeDist(0, 3);
            std::uniform_int_distribution<int> amountDist(1, 100);

            while (!startFlag.load(std::memory_order_acquire)) {
                std::this_thread::yield();
            }

            for (int i = 0; i < opsPerThread; ++i) {
                int type = typeDist(rng);
                int acc = accountDist(rng);
                long long amount = amountDist(rng);

                switch (type) {
                    case 0:
                        bank.deposit(acc, amount);
                        break;
                    case 1:
                        bank.withdraw(acc, amount);
                        break;
                    case 2: {
                        int to = accountDist(rng);
                        bank.transfer(acc, to, amount);
                        break;
                    }
                    case 3:
                        (void)bank.getBalance(acc);
                        break;
                }
            }
        });
    }

    startFlag.store(true, std::memory_order_release);

    for (auto& th : threads) {
        th.join();
    }

    auto finalSnapshot = bank.snapshot();
    long long total = 0;
    for (const auto& [id, balance] : finalSnapshot) {
        std::cout << "Account " << id << ": " << balance << '\n';
        total += balance;
    }
    std::cout << "Total balance: " << total << '\n';

    return 0;
}