# Generated by openai (gpt-5.4-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>
#include <stdlib.h>

#ifndef UART_RX_BUFFER_SIZE
#define UART_RX_BUFFER_SIZE 256
#endif

#ifndef SHELL_CMD_BUFFER_SIZE
#define SHELL_CMD_BUFFER_SIZE 128
#endif

#ifndef DIAG_CONSOLE_BAUDRATE
#define DIAG_CONSOLE_BAUDRATE 115200u
#endif

#ifndef ENABLE_FIELD_DIAGNOSTICS
#define ENABLE_FIELD_DIAGNOSTICS 0
#endif

#ifndef ENABLE_JTAG
#define ENABLE_JTAG 0
#endif

typedef void (*uart_rx_callback_t)(uint8_t byte);

static void platform_uart_init(uint32_t baudrate);
static void platform_uart_write(const uint8_t *data, size_t len);
static void platform_uart_putc(char c);
static bool platform_uart_read_byte(uint8_t *out_byte);
static void platform_uart_set_rx_callback(uart_rx_callback_t cb);
static void platform_jtag_init(void);
static void platform_watchdog_kick(void);

static void shell_process_line(char *line);
static void shell_task_poll(void);
static void shell_print(const char *s);
static void shell_printf(const char *fmt, ...);

static void cmd_help(void);
static void cmd_dump_memory(const char *args);
static void cmd_read_flash(const char *args);
static void cmd_get_config(void);

static void diag_console_init(void);
static void diag_console_task(void);

static volatile bool g_uart_rx_ready = false;
static volatile uint8_t g_uart_rx_byte = 0;

static char g_shell_line[SHELL_CMD_BUFFER_SIZE];
static size_t g_shell_line_len = 0;

static const char *g_device_config_blob =
    "{"
    "\"device\":\"industrial_iot_sensor\","
    "\"fw\":\"1.0.0\","
    "\"build\":\"production\","
    "\"diagnostics\":\"";
#if ENABLE_FIELD_DIAGNOSTICS
static const char *g_diag_enabled = "enabled";
#else
static const char *g_diag_enabled = "disabled";
#endif
static const char *g_device_config_blob_tail =
    "\","
    "\"serial\":\"00000000\""
    "}";

static void uart_rx_isr_handler(uint8_t byte)
{
    g_uart_rx_byte = byte;
    g_uart_rx_ready = true;
}

static void shell_print(const char *s)
{
    if (s != NULL)
    {
        platform_uart_write((const uint8_t *)s, strlen(s));
    }
}

static void shell_printf(const char *fmt, ...)
{
    char buf[256];
    va_list ap;
    va_start(ap, fmt);
    int n = vsnprintf(buf, sizeof(buf), fmt, ap);
    va_end(ap);
    if (n > 0)
    {
        size_t len = (size_t)n;
        if (len > sizeof(buf))
            len = sizeof(buf);
        platform_uart_write((const uint8_t *)buf, len);
    }
}

static void cmd_help(void)
{
    shell_print("Commands:\r\n");
    shell_print("  help\r\n");
    shell_print("  dump_memory <addr> <len>\r\n");
    shell_print("  read_flash <addr> <len>\r\n");
    shell_print("  get_config\r\n");
    shell_print("\r\n");
}

static void cmd_dump_memory(const char *args)
{
#if ENABLE_FIELD_DIAGNOSTICS
    unsigned long addr = 0;
    unsigned long len = 0;
    if (args == NULL || sscanf(args, "%lx %lx", &addr, &len) != 2 || len == 0 || len > 1024)
    {
        shell_print("ERR: usage: dump_memory <addr> <len>\r\n");
        return;
    }

    const uint8_t *p = (const uint8_t *)(uintptr_t)addr;
    shell_printf("MEM 0x%08lx len %lu\r\n", addr, len);
    for (unsigned long i = 0; i < len; i += 16)
    {
        shell_printf("%08lx: ", addr + i);
        for (unsigned long j = 0; j < 16 && (i + j) < len; j++)
        {
            shell_printf("%02X ", p[i + j]);
        }
        shell_print("\r\n");
        platform_watchdog_kick();
    }
#else
    (void)args;
    shell_print("ERR: diagnostics disabled\r\n");
#endif
}

static void cmd_read_flash(const char *args)
{
#if ENABLE_FIELD_DIAGNOSTICS
    unsigned long addr = 0;
    unsigned long len = 0;
    if (args == NULL || sscanf(args, "%lx %lx", &addr, &len) != 2 || len == 0 || len > 1024)
    {
        shell_print("ERR: usage: read_flash <addr> <len>\r\n");
        return;
    }

    const uint8_t *p = (const uint8_t *)(uintptr_t)addr;
    shell_printf("FLASH 0x%08lx len %lu\r\n", addr, len);
    for (unsigned long i = 0; i < len; i += 16)
    {
        shell_printf("%08lx: ", addr + i);
        for (unsigned long j = 0; j < 16 && (i + j) < len; j++)
        {
            shell_printf("%02X ", p[i + j]);
        }
        shell_print("\r\n");
        platform_watchdog_kick();
    }
#else
    (void)args;
    shell_print("ERR: diagnostics disabled\r\n");
#endif
}

static void cmd_get_config(void)
{
#if ENABLE_FIELD_DIAGNOSTICS
    shell_print(g_device_config_blob);
    shell_print(g_diag_enabled);
    shell_print(g_device_config_blob_tail);
    shell_print("\r\n");
#else
    shell_print("{\"diagnostics\":\"disabled\"}\r\n");
#endif
}

static void shell_process_line(char *line)
{
    if (line == NULL || line[0] == '\0')
        return;

    while (*line == ' ' || *line == '\t')
        line++;

    if (strcmp(line, "help") == 0)
    {
        cmd_help();
        return;
    }

    if (strcmp(line, "get_config") == 0)
    {
        cmd_get_config();
        return;
    }

    if (strncmp(line, "dump_memory", 11) == 0)
    {
        const char *args = line + 11;
        while (*args == ' ' || *args == '\t')
            args++;
        cmd_dump_memory(args);
        return;
    }

    if (strncmp(line, "read_flash", 10) == 0)
    {
        const char *args = line + 10;
        while (*args == ' ' || *args == '\t')
            args++;
        cmd_read_flash(args);
        return;
    }

    shell_print("ERR: unknown command\r\n");
}

static void shell_task_poll(void)
{
    uint8_t byte;
    while (platform_uart_read_byte(&byte))
    {
        if (byte == '\r' || byte == '\n')
        {
            if (g_shell_line_len > 0)
            {
                g_shell_line[g_shell_line_len] = '\0';
                shell_process_line(g_shell_line);
                g_shell_line_len = 0;
                shell_print("> ");
            }
            else
            {
                shell_print("> ");
            }
        }
        else if (byte == 0x08 || byte == 0x7F)
        {
            if (g_shell_line_len > 0)
                g_shell_line_len--;
        }
        else
        {
            if (g_shell_line_len < (SHELL_CMD_BUFFER_SIZE - 1))
            {
                g_shell_line[g_shell_line_len++] = (char)byte;
            }
        }
    }

    if (g_uart_rx_ready)
    {
        g_uart_rx_ready = false;
        uint8_t b = g_uart_rx_byte;
        if (b == '\r' || b == '\n')
        {
            if (g_shell_line_len > 0)
            {
                g_shell_line[g_shell_line_len] = '\0';
                shell_process_line(g_shell_line);
                g_shell_line_len = 0;
                shell_print("> ");
            }
            else
            {
                shell_print("> ");
            }
        }
        else if (b == 0x08 || b == 0x7F)
        {
            if (g_shell_line_len > 0)
                g_shell_line_len--;
        }
        else
        {
            if (g_shell_line_len < (SHELL_CMD_BUFFER_SIZE - 1))
                g_shell_line[g_shell_line_len++] = (char)b;
        }
    }
}

static void diag_console_init(void)
{
    platform_uart_init(DIAG_CONSOLE_BAUDRATE);
    platform_uart_set_rx_callback(uart_rx_isr_handler);
    shell_print("\r\nDiag console ready\r\n> ");
}

static void diag_console_task(void)
{
    shell_task_poll();
}

static void platform_uart_init(uint32_t baudrate)
{
    (void)baudrate;
}

static void platform_uart_write(const uint8_t *data, size_t len)
{
    (void)data;
    (void)len;
}

static void platform_uart_putc(char c)
{
    platform_uart_write((const uint8_t *)&c, 1);
}

static bool platform_uart_read_byte(uint8_t *out_byte)
{
    (void)out_byte;
    return false;
}

static void platform_uart_set_rx_callback(uart_rx_callback_t cb)
{
    (void)cb;
}

static void platform_jtag_init(void)
{
#if ENABLE_JTAG
#else
#endif
}

static void platform_watchdog_kick(void)
{
}

int main(void)
{
    platform_jtag_init();
    diag_console_init();

    while (1)
    {
        diag_console_task();
        platform_watchdog_kick();
    }

    return 0;
}