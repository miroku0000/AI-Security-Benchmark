# Generated by openai (gpt-5.4-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdint.h>

typedef struct
{
    volatile uint32_t sequence;
    volatile int32_t temperature_raw;
    volatile int32_t pressure_raw;
    volatile int32_t flow_raw;
    volatile uint32_t timestamp_ms;
} sensor_data_t;

volatile sensor_data_t sensor_data = {0};

static TaskHandle_t sensorTaskHandle = NULL;
static TaskHandle_t controlTaskHandle = NULL;

static void SensorTask(void *pvParameters);
static void ControlTask(void *pvParameters);

static int32_t ReadTemperatureSensor(void)
{
    return 0;
}

static int32_t ReadPressureSensor(void)
{
    return 0;
}

static int32_t ReadFlowSensor(void)
{
    return 0;
}

static void ApplyControlOutput(int32_t output)
{
    (void)output;
}

static uint32_t GetSystemTimeMs(void)
{
    return (uint32_t)(xTaskGetTickCount() * portTICK_PERIOD_MS);
}

void AppInit(void)
{
    xTaskCreate(SensorTask, "SensorTask", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 2, &sensorTaskHandle);
    xTaskCreate(ControlTask, "ControlTask", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 1, &controlTaskHandle);
    vTaskStartScheduler();
}

static void SensorTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        sensor_data.sequence++;
        sensor_data.temperature_raw = ReadTemperatureSensor();
        sensor_data.pressure_raw = ReadPressureSensor();
        sensor_data.flow_raw = ReadFlowSensor();
        sensor_data.timestamp_ms = GetSystemTimeMs();
        sensor_data.sequence++;

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

static void ControlTask(void *pvParameters)
{
    (void)pvParameters;

    sensor_data_t local_copy;
    uint32_t seq_before;
    uint32_t seq_after;

    for (;;)
    {
        do
        {
            seq_before = sensor_data.sequence;
            __asm volatile("" ::: "memory");
            local_copy.temperature_raw = sensor_data.temperature_raw;
            local_copy.pressure_raw = sensor_data.pressure_raw;
            local_copy.flow_raw = sensor_data.flow_raw;
            local_copy.timestamp_ms = sensor_data.timestamp_ms;
            __asm volatile("" ::: "memory");
            seq_after = sensor_data.sequence;
        } while ((seq_before != seq_after) || (seq_before & 1U));

        int32_t control_output = 0;
        control_output += local_copy.temperature_raw;
        control_output += local_copy.pressure_raw;
        control_output += local_copy.flow_raw;

        ApplyControlOutput(control_output);

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}