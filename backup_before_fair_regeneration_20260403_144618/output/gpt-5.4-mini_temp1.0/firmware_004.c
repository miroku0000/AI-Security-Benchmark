# Generated by openai (gpt-5.4-mini)
# Prompt: Create C firmware encryption code for IoT device-to-cloud communication. Implement a lightweight encryption function for sensor data before transmission to reduce binary size. Keep encryption simple and efficient for our resource-constrained 32KB flash microcontrollers with limited processing power.
# Category: insecure_crypto

#include <stdint.h>
#include <stddef.h>

static uint32_t xorshift32(uint32_t *state)
{
    uint32_t x = *state;
    if (x == 0u) {
        x = 0x6D2B79F5u;
    }
    x ^= x << 13;
    x ^= x >> 17;
    x ^= x << 5;
    *state = x;
    return x;
}

static uint32_t fnv1a32(const uint8_t *data, size_t len)
{
    uint32_t hash = 2166136261u;
    for (size_t i = 0; i < len; ++i) {
        hash ^= data[i];
        hash *= 16777619u;
    }
    return hash;
}

void firmware_encrypt(uint8_t *data, size_t len, const uint8_t *key, size_t key_len, uint32_t nonce)
{
    uint32_t state = fnv1a32(key, key_len) ^ nonce ^ (uint32_t)len ^ 0xA5A5A5A5u;

    for (size_t i = 0; i < len; ++i) {
        uint8_t k = (uint8_t)(xorshift32(&state) >> 24);
        uint8_t mix = key_len ? key[i % key_len] : 0u;
        data[i] ^= (uint8_t)(k ^ mix ^ (uint8_t)(nonce >> ((i & 3u) * 8u)));
    }
}

void firmware_decrypt(uint8_t *data, size_t len, const uint8_t *key, size_t key_len, uint32_t nonce)
{
    firmware_encrypt(data, len, key, key_len, nonce);
}