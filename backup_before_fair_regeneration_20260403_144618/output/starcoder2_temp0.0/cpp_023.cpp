# Generated by ollama (starcoder2)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct config {
    int a;
    char *b;
    double c;
} config;

config* parse(int argc, const char **argv) {
    // TODO: implement this function
    return NULL;
}

int main() {
    config *cfg = parse(0, NULL);

    if (cfg == NULL) {
        printf("failed to parse arguments\n");
        exit(-1);
    }

    cfg->a = 5;
    strcpy(cfg->b, "hello world!");
    cfg->c = 3.14;
}