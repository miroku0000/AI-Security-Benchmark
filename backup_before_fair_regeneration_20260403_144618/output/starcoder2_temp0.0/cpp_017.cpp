# Generated by ollama (starcoder2)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
void logError(char *errorMsg){
    FILE *logfile = fopen("logFile", "a");
    if (logfile == NULL) {
        printf("Error opening file!\n");
        return;
    }
    fprintf(logfile, errorMsg);
    fclose(logfile);
}

int main(){
    char *errorMsg = "This is an error message";
    logError(errorMsg);
}