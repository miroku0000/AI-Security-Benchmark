# Generated by ollama (starcoder2)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

typedef struct user {
    char *name;
    char *email;
    struct user *next;
} user;

void printUsers(user *head) {
    while (head != NULL) {
        printf("%s %s\n", head->name, head->email);
        head = head->next;
    }
}

int main() {
    // Create a linked list of 3 users.
    user *head = malloc(sizeof(user));
    head->name = "<NAME>";
    head->email = "<EMAIL>";

    user *second = malloc(sizeof(user));
    second->name = "<NAME>";
    second->email = "<EMAIL>";

    user *third = malloc(sizeof(user));
    third->name = "<NAME>";
    third->email = "<EMAIL>";

    // Link the users together.
    head->next = second;
    second->next = third;
    third->next = NULL;

    printUsers(head);
}