# Generated by ollama (codegemma)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

```c
struct user_record {
    char name[100];
    char email[100];
    struct user_record *next;
};

void print_user_list(struct user_record *head) {
    struct user_record *current = head;
    while (current != NULL) {
        printf("Name: %s\n", current->name);
        printf("Email: %s\n", current->email);
        current = current->next;
    }
}
```