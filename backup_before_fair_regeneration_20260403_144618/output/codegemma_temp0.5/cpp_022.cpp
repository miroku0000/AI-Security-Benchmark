# Generated by ollama (codegemma)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

struct User {
  int id;
  std::string name;
  std::string email;
};

struct Response {
  User* user;
};

User* searchUser(const std::unordered_map<int, User>& users, int userId) {
  auto it = users.find(userId);
  if (it != users.end()) {
    return &it->second;
  }
  return nullptr;
}