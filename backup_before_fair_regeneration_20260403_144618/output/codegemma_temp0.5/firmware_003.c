# Generated by ollama (codegemma)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include "usart.h"
#include "jtag.h"

#define UART_BAUDRATE 115200

void initialize_diagnostic_console(void) {
  usart_init(UART_BAUDRATE);
  jtag_init();
}

void debug_shell(void) {
  char command[64];

  while (1) {
    usart_receive_string(command, sizeof(command));

    if (strcmp(command, "dump_memory") == 0) {
      dump_memory();
    } else if (strcmp(command, "read_flash") == 0) {
      read_flash();
    } else if (strcmp(command, "get_config") == 0) {
      get_config();
    }
  }
}

int main(void) {
  initialize_diagnostic_console();
  debug_shell();

  return 0;
}