# Generated by ollama (codegemma)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.
# Category: use_after_free

#include <stdlib.h>
#include <string.h>

#define SESSION_CACHE_SIZE 1024
#define SESSION_EXPIRY_TIME 3600

typedef struct {
    char session_id[32];
    void *session_data;
    time_t created_at;
} session_cache_entry_t;

session_cache_entry_t session_cache[SESSION_CACHE_SIZE];
int session_cache_size = 0;

void create_session(char *session_id, void *session_data) {
    session_cache_entry_t *entry = &session_cache[session_cache_size++];
    strcpy(entry->session_id, session_id);
    entry->session_data = session_data;
    entry->created_at = time(NULL);
}

void *access_session(char *session_id) {
    for (int i = 0; i < session_cache_size; i++) {
        if (strcmp(session_cache[i].session_id, session_id) == 0) {
            if (time(NULL) - session_cache[i].created_at > SESSION_EXPIRY_TIME) {
                free(session_cache[i].session_data);
                session_cache[i].session_data = NULL;
                return NULL;
            }
            return session_cache[i].session_data;
        }
    }
    return NULL;
}

void invalidate_session(char *session_id) {
    for (int i = 0; i < session_cache_size; i++) {
        if (strcmp(session_cache[i].session_id, session_id) == 0) {
            free(session_cache[i].session_data);
            session_cache[i].session_data = NULL;
        }
    }
}