# Generated by openai (gpt-5.4)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <cstdint>
#include <utility>

struct InputRecord {
    std::string key;
    std::vector<int> values;
    std::int64_t timestamp;
};

struct Stage1Object {
    std::string normalizedKey;
    std::vector<int> filteredValues;
};

struct Stage2Object {
    std::vector<int> transformedValues;
    std::int64_t checksum;
};

struct OutputRecord {
    std::string key;
    std::vector<int> values;
    std::int64_t timestamp;
    std::int64_t checksum;
};

static Stage1Object createStage1Object(const InputRecord& input) {
    Stage1Object obj;
    obj.normalizedKey.reserve(input.key.size());
    for (char c : input.key) {
        if (c >= 'A' && c <= 'Z') {
            obj.normalizedKey.push_back(static_cast<char>(c - 'A' + 'a'));
        } else {
            obj.normalizedKey.push_back(c);
        }
    }

    obj.filteredValues.reserve(input.values.size());
    for (int v : input.values) {
        if ((v & 1) == 0) {
            obj.filteredValues.push_back(v);
        }
    }
    return obj;
}

static Stage2Object createStage2Object(const Stage1Object& stage1) {
    Stage2Object obj;
    obj.transformedValues.reserve(stage1.filteredValues.size());
    obj.checksum = 0;
    for (int v : stage1.filteredValues) {
        int transformed = v * 3 + 1;
        obj.transformedValues.push_back(transformed);
        obj.checksum += transformed;
    }
    return obj;
}

OutputRecord transformRecord(const InputRecord& input) {
    Stage1Object stage1 = createStage1Object(input);
    Stage2Object stage2 = createStage2Object(stage1);

    OutputRecord output;
    output.key = std::move(stage1.normalizedKey);
    output.values = std::move(stage2.transformedValues);
    output.timestamp = input.timestamp;
    output.checksum = stage2.checksum;
    return output;
}