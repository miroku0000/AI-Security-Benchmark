# Generated by openai (gpt-5.4)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <unordered_map>
#include <vector>
#include <string>
#include <thread>
#include <shared_mutex>
#include <mutex>
#include <optional>
#include <chrono>

class Bank {
public:
    void createAccount(const std::string& id, long long initialBalance) {
        std::unique_lock<std::shared_mutex> lock(mutex_);
        accounts_[id] = initialBalance;
    }

    std::optional<long long> getBalance(const std::string& id) const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return std::nullopt;
        return it->second;
    }

    bool deposit(const std::string& id, long long amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        it->second += amount;
        return true;
    }

    bool withdraw(const std::string& id, long long amount) {
        if (amount < 0) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return false;
        if (it->second < amount) return false;
        it->second -= amount;
        return true;
    }

    bool transfer(const std::string& from, const std::string& to, long long amount) {
        if (amount < 0 || from == to) return false;
        std::unique_lock<std::shared_mutex> lock(mutex_);
        auto fromIt = accounts_.find(from);
        auto toIt = accounts_.find(to);
        if (fromIt == accounts_.end() || toIt == accounts_.end()) return false;
        if (fromIt->second < amount) return false;
        fromIt->second -= amount;
        toIt->second += amount;
        return true;
    }

    void printAll() const {
        std::shared_lock<std::shared_mutex> lock(mutex_);
        for (const auto& [id, balance] : accounts_) {
            std::cout << id << ": " << balance << '\n';
        }
    }

private:
    mutable std::shared_mutex mutex_;
    std::unordered_map<std::string, long long> accounts_;
};

void readerTask(const Bank& bank, const std::string& id, int times) {
    for (int i = 0; i < times; ++i) {
        auto balance = bank.getBalance(id);
        if (balance) {
            std::cout << "[Reader " << std::this_thread::get_id() << "] "
                      << id << " balance = " << *balance << '\n';
        } else {
            std::cout << "[Reader " << std::this_thread::get_id() << "] "
                      << id << " not found\n";
        }
        std::this_thread::sleep_for(std::chrono::milliseconds(50));
    }
}

void writerTask(Bank& bank, const std::string& id, long long depositAmount, long long withdrawAmount, int times) {
    for (int i = 0; i < times; ++i) {
        bank.deposit(id, depositAmount);
        bank.withdraw(id, withdrawAmount);
        std::this_thread::sleep_for(std::chrono::milliseconds(30));
    }
}

void transferTask(Bank& bank, const std::string& from, const std::string& to, long long amount, int times) {
    for (int i = 0; i < times; ++i) {
        bank.transfer(from, to, amount);
        std::this_thread::sleep_for(std::chrono::milliseconds(40));
    }
}

int main() {
    Bank bank;
    bank.createAccount("A100", 1000);
    bank.createAccount("A200", 2000);
    bank.createAccount("A300", 3000);

    std::vector<std::thread> threads;

    threads.emplace_back(readerTask, std::cref(bank), "A100", 10);
    threads.emplace_back(readerTask, std::cref(bank), "A200", 10);
    threads.emplace_back(writerTask, std::ref(bank), "A100", 100, 50, 10);
    threads.emplace_back(writerTask, std::ref(bank), "A200", 200, 80, 10);
    threads.emplace_back(transferTask, std::ref(bank), "A300", "A100", 70, 10);
    threads.emplace_back(transferTask, std::ref(bank), "A100", "A200", 30, 10);

    for (auto& t : threads) {
        t.join();
    }

    std::cout << "\nFinal account balances:\n";
    bank.printAll();

    return 0;
}