# Generated by openai (gpt-5.4)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <string.h>

#ifndef FLASH_BASE
#define FLASH_BASE                 0x08000000UL
#endif
#ifndef FLASH_SIZE
#define FLASH_SIZE                 (512UL * 1024UL)
#endif
#ifndef APP_OFFSET
#define APP_OFFSET                 (32UL * 1024UL)
#endif
#ifndef APP_BASE
#define APP_BASE                   (FLASH_BASE + APP_OFFSET)
#endif
#ifndef SRAM_BASE
#define SRAM_BASE                  0x20000000UL
#endif
#ifndef SRAM_SIZE
#define SRAM_SIZE                  (128UL * 1024UL)
#endif
#ifndef SYS_CLOCK_HZ
#define SYS_CLOCK_HZ               48000000UL
#endif

#define FLASH_END                  (FLASH_BASE + FLASH_SIZE)
#define APP_MAX_SIZE               (FLASH_SIZE - APP_OFFSET)

#define BL_FLAG_ADDR               (FLASH_BASE + 0x000003F0UL)
#define BL_FLAG_VALUE              0xB00720ADUL

#define FW_MAGIC                   0x46574D47UL
#define FW_MAX_SIZE                APP_MAX_SIZE
#define FW_CHUNK_SIZE              256U
#define UART_RX_TIMEOUT_MS         3000U
#define UART_BYTE_TIMEOUT_MS       100U
#define SD_INIT_TIMEOUT_MS         500U
#define UPDATE_FILENAME            "firmware.bin"

#define SCB_VTOR                   (*(volatile uint32_t *)0xE000ED08UL)
#define SCB_AIRCR                  (*(volatile uint32_t *)0xE000ED0CUL)
#define SCB_AIRCR_VECTKEY          (0x5FAUL << 16)
#define SCB_AIRCR_SYSRESETREQ      (1UL << 2)
#define SYST_CSR                   (*(volatile uint32_t *)0xE000E010UL)
#define SYST_RVR                   (*(volatile uint32_t *)0xE000E014UL)
#define SYST_CVR                   (*(volatile uint32_t *)0xE000E018UL)

typedef struct
{
    uint32_t magic;
    uint32_t size;
    uint32_t crc32;
    uint32_t version;
} fw_header_t;

typedef struct
{
    uint32_t stack;
    uint32_t reset;
} vector_table_t;

static volatile uint32_t g_ms_ticks = 0;

void SysTick_Handler(void)
{
    g_ms_ticks++;
}

static void systick_init(void)
{
    SYST_RVR = (SYS_CLOCK_HZ / 1000UL) - 1UL;
    SYST_CVR = 0;
    SYST_CSR = 7UL;
}

static uint32_t millis(void)
{
    return g_ms_ticks;
}

static void delay_ms(uint32_t ms)
{
    uint32_t start = millis();
    while ((millis() - start) < ms) { }
}

__attribute__((noreturn)) static void system_reset(void)
{
    SCB_AIRCR = SCB_AIRCR_VECTKEY | SCB_AIRCR_SYSRESETREQ;
    while (1) { }
}

static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t len)
{
    crc = ~crc;
    for (uint32_t i = 0; i < len; i++)
    {
        crc ^= data[i];
        for (uint32_t j = 0; j < 8; j++)
        {
            uint32_t mask = -(crc & 1U);
            crc = (crc >> 1) ^ (0xEDB88320UL & mask);
        }
    }
    return ~crc;
}

static int addr_in_sram(uint32_t addr)
{
    return (addr >= SRAM_BASE) && (addr < (SRAM_BASE + SRAM_SIZE));
}

static int addr_in_flash(uint32_t addr)
{
    return (addr >= APP_BASE) && (addr < FLASH_END);
}

static int app_is_valid(void)
{
    const vector_table_t *vt = (const vector_table_t *)APP_BASE;
    if (!addr_in_sram(vt->stack))
        return 0;
    if (!addr_in_flash(vt->reset))
        return 0;
    return 1;
}

static void irq_disable(void)
{
    __asm volatile ("cpsid i" : : : "memory");
}

static void irq_enable(void)
{
    __asm volatile ("cpsie i" : : : "memory");
}

__attribute__((noreturn)) static void jump_to_app(void)
{
    const vector_table_t *vt = (const vector_table_t *)APP_BASE;
    uint32_t app_sp = vt->stack;
    uint32_t app_reset = vt->reset;

    irq_disable();
    SYST_CSR = 0;
    SCB_VTOR = APP_BASE;

    __asm volatile (
        "msr msp, %0      \n"
        "bx  %1           \n"
        :
        : "r" (app_sp), "r" (app_reset)
        : "memory"
    );

    while (1) { }
}

typedef struct
{
    volatile uint32_t ACR;
    volatile uint32_t KEYR;
    volatile uint32_t OPTKEYR;
    volatile uint32_t SR;
    volatile uint32_t CR;
    volatile uint32_t AR;
    volatile uint32_t RESERVED;
    volatile uint32_t OBR;
    volatile uint32_t WRPR;
} FLASH_TypeDef;

#ifndef FLASH_REG_BASE
#define FLASH_REG_BASE             0x40022000UL
#endif

#define FLASH_REG                  ((FLASH_TypeDef *)FLASH_REG_BASE)
#define FLASH_KEY1                 0x45670123UL
#define FLASH_KEY2                 0xCDEF89ABUL
#define FLASH_SR_BSY               (1UL << 0)
#define FLASH_SR_PGERR             (1UL << 2)
#define FLASH_SR_WRPRTERR          (1UL << 4)
#define FLASH_CR_PG                (1UL << 0)
#define FLASH_CR_PER               (1UL << 1)
#define FLASH_CR_MER               (1UL << 2)
#define FLASH_CR_STRT              (1UL << 6)
#define FLASH_CR_LOCK              (1UL << 7)

#ifndef FLASH_PAGE_SIZE
#define FLASH_PAGE_SIZE            1024UL
#endif

static void flash_wait_ready(void)
{
    while (FLASH_REG->SR & FLASH_SR_BSY) { }
}

static void flash_clear_errors(void)
{
    FLASH_REG->SR = FLASH_SR_PGERR | FLASH_SR_WRPRTERR;
}

static void flash_unlock(void)
{
    if (FLASH_REG->CR & FLASH_CR_LOCK)
    {
        FLASH_REG->KEYR = FLASH_KEY1;
        FLASH_REG->KEYR = FLASH_KEY2;
    }
}

static void flash_lock(void)
{
    FLASH_REG->CR |= FLASH_CR_LOCK;
}

static int flash_erase_page(uint32_t address)
{
    flash_wait_ready();
    flash_clear_errors();
    FLASH_REG->CR |= FLASH_CR_PER;
    FLASH_REG->AR = address;
    FLASH_REG->CR |= FLASH_CR_STRT;
    flash_wait_ready();
    FLASH_REG->CR &= ~FLASH_CR_PER;
    if (FLASH_REG->SR & (FLASH_SR_PGERR | FLASH_SR_WRPRTERR))
        return -1;
    return 0;
}

static int flash_program_halfword(uint32_t address, uint16_t data)
{
    flash_wait_ready();
    flash_clear_errors();
    FLASH_REG->CR |= FLASH_CR_PG;
    *(volatile uint16_t *)address = data;
    flash_wait_ready();
    FLASH_REG->CR &= ~FLASH_CR_PG;
    if (FLASH_REG->SR & (FLASH_SR_PGERR | FLASH_SR_WRPRTERR))
        return -1;
    if (*(volatile uint16_t *)address != data)
        return -1;
    return 0;
}

static int flash_program_buffer(uint32_t address, const uint8_t *data, uint32_t len)
{
    uint32_t i = 0;
    while (i < len)
    {
        uint16_t hw = data[i];
        if ((i + 1U) < len)
            hw |= ((uint16_t)data[i + 1U] << 8);
        else
            hw |= 0xFF00U;
        if (flash_program_halfword(address + i, hw) != 0)
            return -1;
        i += 2U;
    }
    return 0;
}

static int flash_erase_app_region(uint32_t size)
{
    uint32_t start = APP_BASE;
    uint32_t end = APP_BASE + size;
    if (end > FLASH_END)
        return -1;
    flash_unlock();
    for (uint32_t addr = start; addr < end; addr += FLASH_PAGE_SIZE)
    {
        if (flash_erase_page(addr) != 0)
        {
            flash_lock();
            return -1;
        }
    }
    flash_lock();
    return 0;
}

static int flash_write_app(uint32_t offset, const uint8_t *data, uint32_t len)
{
    if ((APP_BASE + offset + len) > FLASH_END)
        return -1;
    flash_unlock();
    int rc = flash_program_buffer(APP_BASE + offset, data, len);
    flash_lock();
    return rc;
}

static void boot_flag_set(void)
{
    flash_unlock();
    flash_erase_page(BL_FLAG_ADDR & ~(FLASH_PAGE_SIZE - 1UL));
    flash_program_halfword(BL_FLAG_ADDR + 0, (uint16_t)(BL_FLAG_VALUE & 0xFFFFU));
    flash_program_halfword(BL_FLAG_ADDR + 2, (uint16_t)((BL_FLAG_VALUE >> 16) & 0xFFFFU));
    flash_lock();
}

static void boot_flag_clear(void)
{
    flash_unlock();
    flash_erase_page(BL_FLAG_ADDR & ~(FLASH_PAGE_SIZE - 1UL));
    flash_lock();
}

static int boot_flag_active(void)
{
    return (*(volatile const uint32_t *)BL_FLAG_ADDR) == BL_FLAG_VALUE;
}

typedef struct
{
    int (*gpio_boot_request)(void);
    void (*uart_init)(uint32_t baudrate);
    int (*uart_read)(uint8_t *buf, uint32_t len, uint32_t timeout_ms);
    int (*uart_write)(const uint8_t *buf, uint32_t len);
    int (*sd_init)(void);
    int (*sd_open)(const char *name);
    int (*sd_read)(uint8_t *buf, uint32_t len);
    int (*sd_close)(void);
} boot_hw_t;

static int weak_gpio_boot_request(void) { return 0; }
static void weak_uart_init(uint32_t baudrate) { (void)baudrate; }
static int weak_uart_read(uint8_t *buf, uint32_t len, uint32_t timeout_ms) { (void)buf; (void)len; (void)timeout_ms; return -1; }
static int weak_uart_write(const uint8_t *buf, uint32_t len) { (void)buf; return (int)len; }
static int weak_sd_init(void) { return -1; }
static int weak_sd_open(const char *name) { (void)name; return -1; }
static int weak_sd_read(uint8_t *buf, uint32_t len) { (void)buf; (void)len; return -1; }
static int weak_sd_close(void) { return 0; }

__attribute__((weak)) int board_gpio_boot_request(void) { return weak_gpio_boot_request(); }
__attribute__((weak)) void board_uart_init(uint32_t baudrate) { weak_uart_init(baudrate); }
__attribute__((weak)) int board_uart_read(uint8_t *buf, uint32_t len, uint32_t timeout_ms) { return weak_uart_read(buf, len, timeout_ms); }
__attribute__((weak)) int board_uart_write(const uint8_t *buf, uint32_t len) { return weak_uart_write(buf, len); }
__attribute__((weak)) int board_sd_init(void) { return weak_sd_init(); }
__attribute__((weak)) int board_sd_open(const char *name) { return weak_sd_open(name); }
__attribute__((weak)) int board_sd_read(uint8_t *buf, uint32_t len) { return weak_sd_read(buf, len); }
__attribute__((weak)) int board_sd_close(void) { return weak_sd_close(); }

static boot_hw_t hw = {
    .gpio_boot_request = board_gpio_boot_request,
    .uart_init = board_uart_init,
    .uart_read = board_uart_read,
    .uart_write = board_uart_write,
    .sd_init = board_sd_init,
    .sd_open = board_sd_open,
    .sd_read = board_sd_read,
    .sd_close = board_sd_close
};

static int firmware_stream_program(int (*read_fn)(uint8_t *buf, uint32_t len), fw_header_t *hdr_out)
{
    fw_header_t hdr;
    uint8_t buf[FW_CHUNK_SIZE];
    uint32_t remaining;
    uint32_t offset = 0;
    uint32_t crc = 0;

    if (read_fn((uint8_t *)&hdr, sizeof(hdr)) != (int)sizeof(hdr))
        return -1;

    if (hdr.magic != FW_MAGIC || hdr.size == 0 || hdr.size > FW_MAX_SIZE)
        return -1;

    if (flash_erase_app_region(hdr.size) != 0)
        return -1;

    remaining = hdr.size;
    while (remaining)
    {
        uint32_t chunk = remaining > sizeof(buf) ? sizeof(buf) : remaining;
        if (read_fn(buf, chunk) != (int)chunk)
            return -1;
        crc = crc32_update(crc, buf, chunk);
        if (flash_write_app(offset, buf, chunk) != 0)
            return -1;
        offset += chunk;
        remaining -= chunk;
    }

    if (crc != hdr.crc32)
        return -1;

    if (!app_is_valid())
        return -1;

    if (hdr_out)
        *hdr_out = hdr;
    return 0;
}

static int sd_reader(uint8_t *buf, uint32_t len)
{
    return hw.sd_read(buf, len);
}

static int uart_reader_stateful(uint8_t *buf, uint32_t len)
{
    return hw.uart_read(buf, len, UART_BYTE_TIMEOUT_MS);
}

static int try_update_from_sd(void)
{
    if (hw.sd_init() != 0)
        return -1;
    if (hw.sd_open(UPDATE_FILENAME) != 0)
        return -1;

    fw_header_t hdr;
    int rc = firmware_stream_program(sd_reader, &hdr);
    hw.sd_close();
    return rc;
}

static int uart_expect_magic(void)
{
    uint8_t sync[4];
    if (hw.uart_read(sync, sizeof(sync), UART_RX_TIMEOUT_MS) != 4)
        return -1;
    if (sync[0] != 'U' || sync[1] != 'P' || sync[2] != 'D' || sync[3] != 'T')
        return -1;
    return 0;
}

static int try_update_from_uart(void)
{
    static const uint8_t ready[] = "BOOTLOADER_READY\n";
    static const uint8_t ok[] = "UPDATE_OK\n";
    static const uint8_t err[] = "UPDATE_ERR\n";

    hw.uart_init(115200);
    hw.uart_write(ready, sizeof(ready) - 1U);

    if (uart_expect_magic() != 0)
        return -1;

    fw_header_t hdr;
    int rc = firmware_stream_program(uart_reader_stateful, &hdr);
    if (rc == 0)
        hw.uart_write(ok, sizeof(ok) - 1U);
    else
        hw.uart_write(err, sizeof(err) - 1U);
    return rc;
}

static int bootloader_requested(void)
{
    if (hw.gpio_boot_request && hw.gpio_boot_request())
        return 1;
    if (boot_flag_active())
        return 1;
    return 0;
}

static void bootloader_main(void)
{
    if (try_update_from_sd() == 0)
    {
        boot_flag_clear();
        system_reset();
    }

    if (try_update_from_uart() == 0)
    {
        boot_flag_clear();
        system_reset();
    }

    if (app_is_valid())
    {
        boot_flag_clear();
        jump_to_app();
    }

    while (1)
    {
        try_update_from_uart();
        if (app_is_valid())
        {
            boot_flag_clear();
            system_reset();
        }
    }
}

void bootloader_enter_recovery(void)
{
    boot_flag_set();
    system_reset();
}

int main(void)
{
    systick_init();

    if (!bootloader_requested() && app_is_valid())
        jump_to_app();

    bootloader_main();
    while (1) { }
}