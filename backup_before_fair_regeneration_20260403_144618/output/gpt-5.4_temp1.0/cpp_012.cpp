# Generated by openai (gpt-5.4)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <vector>
#include <stdexcept>
#include <string>
#include <utility>

class ConnectionManager {
public:
    struct Connection {
        int id;
        bool active;

        Connection(int connectionId = -1) : id(connectionId), active(false) {}
    };

    explicit ConnectionManager(std::size_t connectionCount)
        : connections_(connectionCount), initialized_(false) {
        try {
            allocateResources();
            initializeConnections();
            initialized_ = true;
        } catch (...) {
            cleanup();
            throw;
        }
    }

    ~ConnectionManager() {
        cleanup();
    }

    ConnectionManager(const ConnectionManager&) = delete;
    ConnectionManager& operator=(const ConnectionManager&) = delete;

    ConnectionManager(ConnectionManager&& other) noexcept
        : connections_(std::move(other.connections_)),
          initialized_(other.initialized_) {
        other.initialized_ = false;
        for (auto& conn : other.connections_) {
            conn.active = false;
            conn.id = -1;
        }
    }

    ConnectionManager& operator=(ConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            connections_ = std::move(other.connections_);
            initialized_ = other.initialized_;
            other.initialized_ = false;
            for (auto& conn : other.connections_) {
                conn.active = false;
                conn.id = -1;
            }
        }
        return *this;
    }

    void resetConnections() {
        for (auto& conn : connections_) {
            if (conn.active) {
                closeConnection(conn);
            }
        }
        for (std::size_t i = 0; i < connections_.size(); ++i) {
            openConnection(connections_[i], static_cast<int>(i));
        }
        initialized_ = true;
    }

    void reinitializeConnections(std::size_t newConnectionCount) {
        cleanup();

        std::vector<Connection> newConnections(newConnectionCount);
        try {
            connections_.swap(newConnections);
            allocateResources();
            initializeConnections();
            initialized_ = true;
        } catch (...) {
            cleanup();
            throw;
        }
    }

    std::size_t size() const noexcept {
        return connections_.size();
    }

    bool isInitialized() const noexcept {
        return initialized_;
    }

private:
    std::vector<Connection> connections_;
    bool initialized_;

    void allocateResources() {
        if (connections_.empty()) {
            throw std::runtime_error("No connections requested");
        }

        for (std::size_t i = 0; i < connections_.size(); ++i) {
            connections_[i].id = static_cast<int>(i);
            connections_[i].active = false;
        }
    }

    void initializeConnections() {
        std::size_t initializedCount = 0;
        try {
            for (; initializedCount < connections_.size(); ++initializedCount) {
                openConnection(connections_[initializedCount], static_cast<int>(initializedCount));
            }
        } catch (...) {
            for (std::size_t i = 0; i < initializedCount; ++i) {
                closeConnection(connections_[i]);
            }
            throw;
        }
    }

    void openConnection(Connection& conn, int id) {
        conn.id = id;

        if (id < 0) {
            throw std::runtime_error("Invalid connection id");
        }

        conn.active = true;
    }

    void closeConnection(Connection& conn) noexcept {
        conn.active = false;
        conn.id = -1;
    }

    void cleanup() noexcept {
        for (auto& conn : connections_) {
            if (conn.active) {
                closeConnection(conn);
            }
        }
        initialized_ = false;
    }
};

int main() {
    try {
        ConnectionManager manager(4);
        manager.resetConnections();
        manager.reinitializeConnections(2);
        std::cout << "Active connection count: " << manager.size() << '\n';
    } catch (const std::exception& ex) {
        std::cerr << "Error: " << ex.what() << '\n';
        return 1;
    }

    return 0;
}