# Generated by openai (gpt-5.4)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>

typedef struct
{
    uint32_t timestamp;
    int32_t temperature;
    int32_t pressure;
    int32_t flow;
    uint32_t status;
} sensor_data_t;

volatile sensor_data_t sensor_data;

static uint32_t read_timestamp(void)
{
    return xTaskGetTickCount();
}

static int32_t read_temperature_sensor(void)
{
    static int32_t v = 250;
    v++;
    return v;
}

static int32_t read_pressure_sensor(void)
{
    static int32_t v = 1000;
    v += 2;
    return v;
}

static int32_t read_flow_sensor(void)
{
    static int32_t v = 500;
    v += 3;
    return v;
}

static uint32_t read_sensor_status(void)
{
    return 0U;
}

static void apply_control_output(int32_t control_value)
{
    (void)control_value;
}

static int32_t compute_control(const sensor_data_t *data)
{
    return (data->temperature * 2) + data->pressure - data->flow;
}

static void SensorReadTask(void *pvParameters)
{
    (void)pvParameters;

    for (;;)
    {
        sensor_data.timestamp = read_timestamp();
        sensor_data.temperature = read_temperature_sensor();
        sensor_data.pressure = read_pressure_sensor();
        sensor_data.flow = read_flow_sensor();
        sensor_data.status = read_sensor_status();

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

static void ControlTask(void *pvParameters)
{
    (void)pvParameters;
    sensor_data_t local_copy;
    int32_t control_value;

    for (;;)
    {
        local_copy = sensor_data;
        control_value = compute_control(&local_copy);
        apply_control_output(control_value);

        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

int main(void)
{
    sensor_data.timestamp = 0U;
    sensor_data.temperature = 0;
    sensor_data.pressure = 0;
    sensor_data.flow = 0;
    sensor_data.status = 0U;

    xTaskCreate(SensorReadTask, "SensorRead", configMINIMAL_STACK_SIZE + 128U, NULL, tskIDLE_PRIORITY + 2U, NULL);
    xTaskCreate(ControlTask, "Control", configMINIMAL_STACK_SIZE + 128U, NULL, tskIDLE_PRIORITY + 3U, NULL);

    vTaskStartScheduler();

    for (;;)
    {
    }
}