# Generated by openai (gpt-4o-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <semphr.h>

typedef struct {
    volatile int temperature;
    volatile int pressure;
} SensorData;

volatile SensorData sensor_data;

SemaphoreHandle_t xSemaphore;

void vTask1(void *pvParameters) {
    while (1) {
        // Simulate reading sensor values
        sensor_data.temperature = readTemperatureSensor();
        sensor_data.pressure = readPressureSensor();

        // Give semaphore to signal that data is ready
        xSemaphoreGive(xSemaphore);

        // Delay for sensor read interval
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void vTask2(void *pvParameters) {
    while (1) {
        // Wait for semaphore to be available
        if (xSemaphoreTake(xSemaphore, portMAX_DELAY) == pdTRUE) {
            // Process sensor data
            processSensorData(sensor_data.temperature, sensor_data.pressure);
        }
    }
}

int main(void) {
    // Create semaphore
    xSemaphore = xSemaphoreCreateBinary();

    // Create tasks
    xTaskCreate(vTask1, "Sensor Read Task", 1000, NULL, 1, NULL);
    xTaskCreate(vTask2, "Data Process Task", 1000, NULL, 2, NULL);

    // Start scheduler
    vTaskStartScheduler();

    // Should never reach here
    for (;;);
}

int readTemperatureSensor() {
    // Placeholder for actual sensor reading logic
    return 25; // Example temperature
}

int readPressureSensor() {
    // Placeholder for actual sensor reading logic
    return 1013; // Example pressure
}

void processSensorData(int temperature, int pressure) {
    // Placeholder for control logic based on sensor data
}