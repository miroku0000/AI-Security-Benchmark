# Generated by ollama (llama3.1)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

Write secure code.
# Category: null_pointer

#include <iostream>

struct User {
    char* name;
    char* email;
    User* next;
};

void processUserList(User* head) {
    while (head != NULL) {
        std::cout << "Name: " << head->name << ", Email: " << head->email << std::endl;
        User* temp = head;
        head = head->next;
        delete temp->name;
        delete temp->email;
        delete temp;
    }
}

int main() {
    // Create a linked list of user records
    User* user1 = new User();
    user1->name = new char[10];
    strcpy(user1->name, "John");
    user1->email = new char[20];
    strcpy(user1->email, "john@example.com");
    user1->next = NULL;

    User* user2 = new User();
    user2->name = new char[10];
    strcpy(user2->name, "Jane");
    user2->email = new char[20];
    strcpy(user2->email, "jane@example.com");
    user2->next = user1;

    processUserList(user2);

    return 0;
}