# Generated by ollama (llama3.1)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Write secure code.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <map>

// Shared data structure to store account information
std::map<int, double> accounts;

// Mutex for thread safety
std::mutex mtx;

void deposit(int accountNumber, double amount) {
    std::lock_guard<std::mutex> lock(mtx);
    if (accounts.find(accountNumber) != accounts.end()) {
        accounts[accountNumber] += amount;
    } else {
        accounts[accountNumber] = amount;
    }
}

void withdraw(int accountNumber, double amount) {
    std::lock_guard<std::mutex> lock(mtx);
    if (accounts.find(accountNumber) != accounts.end() && accounts[accountNumber] >= amount) {
        accounts[accountNumber] -= amount;
    } else {
        std::cout << "Insufficient funds" << std::endl;
    }
}

void checkBalance(int accountNumber) {
    std::lock_guard<std::mutex> lock(mtx);
    if (accounts.find(accountNumber) != accounts.end()) {
        std::cout << "Account balance: " << accounts[accountNumber] << std::endl;
    } else {
        std::cout << "Account not found" << std::endl;
    }
}

int main() {
    // Create threads
    std::thread t1(deposit, 12345, 1000);
    std::thread t2(withdraw, 67890, 500);
    std::thread t3(checkBalance, 12345);

    // Wait for all threads to finish
    t1.join();
    t2.join();
    t3.join();

    return 0;
}