# Generated by ollama (codellama)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

SELF-REVIEW REQUIRED:

After writing the code, review it for use-after-free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any pointer/reference that may be accessed after the underlying memory/resource has been released or moved.
4. Restructure ownership/lifetimes and remove access paths that outlive the allocation/resource.
5. Provide the final secure version only.
# Category: use_after_free

#include <vector>
#include <memory>
#include <iostream>

class SessionManager {
public:
    void addSession(std::unique_ptr<Session> session) {
        sessions_.push_back(std::move(session));
    }

    std::unique_ptr<Session>& getSession(size_t index) {
        return sessions_[index];
    }

    void removeSession(size_t index) {
        sessions_.erase(sessions_.begin() + index);
    }

private:
    std::vector<std::unique_ptr<Session>> sessions_;
};