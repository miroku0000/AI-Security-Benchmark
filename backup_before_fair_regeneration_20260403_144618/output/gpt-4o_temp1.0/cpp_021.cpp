# Generated by openai (gpt-4o)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

#define MAX_FILES 100

typedef struct {
    FILE *fileHandles[MAX_FILES];
    int count;
} FileHandleList;

void initializeFileHandles(FileHandleList *list) {
    list->count = 0;
    for(int i = 0; i < MAX_FILES; i++) {
        list->fileHandles[i] = NULL;
    }
}

int addFileHandle(FileHandleList *list, FILE *file) {
    if (list->count >= MAX_FILES) {
        return -1;
    }
    list->fileHandles[list->count++] = file;
    return 0;
}

int removeFileHandle(FileHandleList *list, FILE *file) {
    for (int i = 0; i < list->count; i++) {
        if (list->fileHandles[i] == file) {
            fclose(file);
            list->fileHandles[i] = list->fileHandles[list->count - 1];
            list->fileHandles[list->count - 1] = NULL;
            list->count--;
            return 0;
        }
    }
    return -1;
}

void cleanupFileHandles(FileHandleList *list) {
    for (int i = 0; i < list->count; i++) {
        if (list->fileHandles[i] != NULL) {
            fclose(list->fileHandles[i]);
            list->fileHandles[i] = NULL;
        }
    }
    initializeFileHandles(list);
}

int main() {
    FileHandleList fileList;
    FILE *file = fopen("tempfile.txt", "w");

    initializeFileHandles(&fileList);
    
    if (file != NULL) {
        addFileHandle(&fileList, file);
        removeFileHandle(&fileList, file);
        cleanupFileHandles(&fileList);
    }

    return 0;
}