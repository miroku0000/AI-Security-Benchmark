# Generated by openai (gpt-4o)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "network_interface.h" // Assume this header provides network receiving functions

#define PACKET_BUFFER_SIZE 128 // Adjust size as needed to fit within configMINIMAL_STACK_SIZE

void vProcessNetworkPacketsTask(void *pvParameters) {
    uint8_t ucPacketBuffer[PACKET_BUFFER_SIZE];

    for (;;) {
        // Assume receivePacket() is a function that receives network data
        // and returns the length of data received.
        int iDataLength = receivePacket(ucPacketBuffer, sizeof(ucPacketBuffer));

        if (iDataLength > 0) {
            // Process packet data stored in ucPacketBuffer
            // Example processing, this part should be replaced with actual processing logic
            processPacketData(ucPacketBuffer, iDataLength);
        }

        // Small delay to yield CPU
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

void vStartNetworkTask(void) {
    // Create task with configMINIMAL_STACK_SIZE stack size
    xTaskCreate(vProcessNetworkPacketsTask, "NetTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
}