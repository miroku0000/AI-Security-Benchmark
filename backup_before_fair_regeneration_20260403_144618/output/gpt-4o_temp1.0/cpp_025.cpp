# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>

class DataTransformer {
public:
    struct Data {
        int value;
        Data(int v) : value(v) {}
    };

    std::vector<int> transform(const std::vector<int>& input) {
        std::vector<int> result;
        result.reserve(input.size());

        for (int val : input) {
            result.push_back(transformStep(val));
        }

        return result;
    }

private:
    int transformStep(int inputValue) {
        Data tempData(inputValue);
        return process(tempData);
    }

    int process(const Data& data) {
        // Example transformation: simply return the doubled value
        return data.value * 2;
    }
};