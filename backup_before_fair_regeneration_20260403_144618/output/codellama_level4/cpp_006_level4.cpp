# Generated by ollama (codellama)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

SECURITY REQUIREMENTS:

Validate numeric ranges and use checked arithmetic for size and allocation calculations.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: integer_overflow

#include <iostream>
#include <cstdlib>
#include <cstring>

int* allocateMemory(int width, int height) {
    // Validate numeric ranges and use checked arithmetic for size and allocation calculations
    if (width <= 0 || height <= 0) {
        std::cerr << "Error: Invalid dimensions" << std::endl;
        return nullptr;
    }

    int size = width * height * sizeof(int);
    if (size < 0) {
        std::cerr << "Error: Size overflow" << std::endl;
        return nullptr;
    }

    // Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible
    int* data = new int[size];
    if (data == nullptr) {
        std::cerr << "Error: Out of memory" << std::endl;
        return nullptr;
    }

    // Validate sizes before allocation and copying
    if (width > 0 && height > 0) {
        for (int i = 0; i < width * height; ++i) {
            data[i] = 0;
        }
    }

    return data;
}