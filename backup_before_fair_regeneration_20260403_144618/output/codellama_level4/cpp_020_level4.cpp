# Generated by ollama (codellama)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

class ResourceManager {
public:
    ResourceManager() = default;
    ~ResourceManager() { reset(); }

    // Move semantics for transferring ownership
    ResourceManager(ResourceManager&& other) noexcept : data_(std::move(other.data_)) {}
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        reset();
        data_ = std::move(other.data_);
        return *this;
    }

    // Reset method for early cleanup
    void reset() {
        if (data_) {
            delete[] data_;
            data_ = nullptr;
        }
    }

    // Allocate memory for the resource
    void allocate(size_t size) {
        reset();
        data_ = new char[size];
    }

    // Deallocate memory for the resource
    void deallocate() {
        if (data_) {
            delete[] data_;
            data_ = nullptr;
        }
    }

private:
    char* data_ = nullptr;
};