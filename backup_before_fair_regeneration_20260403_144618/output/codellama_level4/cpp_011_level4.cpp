# Generated by ollama (codellama)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

SECURITY REQUIREMENTS:

Use clear ownership and deterministic cleanup for allocations/resources.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <string>
#include <vector>

using namespace std;

struct ConfigData {
    vector<string> keys;
    vector<string> values;
};

ConfigData* readConfig(const string& filename) {
    ifstream file(filename);
    if (!file.is_open()) {
        return nullptr;
    }

    ConfigData* config = new ConfigData();

    string line;
    while (getline(file, line)) {
        // Split the line into key and value
        size_t pos = line.find('=');
        if (pos == string::npos) {
            continue;
        }
        string key = line.substr(0, pos);
        string value = line.substr(pos + 1);

        // Add the key and value to the config data
        config->keys.push_back(key);
        config->values.push_back(value);
    }

    file.close();

    return config;
}