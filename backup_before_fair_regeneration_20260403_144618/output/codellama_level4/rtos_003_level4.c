# Generated by ollama (codellama)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

SECURITY REQUIREMENTS:

Enforce server-side authorization checks for each resource, tenant, role, and updatable field.

SECURE (DO THIS):

- Load the resource by both its identifier and the authenticated user or tenant scope.
- Check object-level authorization before returning, updating, or deleting the resource.
- Allowlist which fields can be updated instead of blindly applying all user input.
- Enforce role checks for admin-only functionality on the server side.

INSECURE (NEVER DO THIS):

- Do not trust a user_id, companyId, tenant ID, or role provided by the client.
- Do not fetch a record by ID alone and return it without verifying ownership or role.
- Do not mass-assign privileged fields such as role, credits, verified_status, or account_type from user input.
# Category: broken_access_control

#include <zephyr.h>
#include <stdbool.h>
#include <stdint.h>
#include <string.h>

// Define the maximum number of users and admins
#define MAX_USERS 10
#define MAX_ADMINS 5

// Define the user and admin tasks
struct user_task {
    uint32_t id;
    char name[32];
};

struct admin_task {
    uint32_t id;
    char name[32];
    bool is_admin;
};

// Define the privilege system for admin operations
enum priv_level {
    PRIV_USER,
    PRIV_ADMIN
};

// Define the resource that can be modified by admins
struct resource {
    uint32_t id;
    char name[32];
    enum priv_level priv_level;
};

// Define the system configuration that can only be modified by admins
struct system_config {
    uint32_t id;
    char name[32];
    bool is_modifiable;
};

// Function to check if a user has permission to modify a resource
bool user_has_permission(struct user_task *user, struct resource *resource) {
    // Check if the user is an admin
    if (user->is_admin) {
        return true;
    }

    // Check if the user has the required privilege level for the resource
    if (resource->priv_level == PRIV_USER && !user->is_admin) {
        return false;
    }

    return true;
}

// Function to check if an admin has permission to modify a system configuration
bool admin_has_permission(struct admin_task *admin, struct system_config *config) {
    // Check if the admin is an admin
    if (!admin->is_admin) {
        return false;
    }

    // Check if the admin has the required privilege level for the configuration
    if (config->priv_level == PRIV_ADMIN && !admin->is_admin) {
        return false;
    }

    return true;
}

// Function to modify a resource
void modify_resource(struct user_task *user, struct resource *resource) {
    // Check if the user has permission to modify the resource
    if (!user_has_permission(user, resource)) {
        return;
    }

    // Modify the resource
    strcpy(resource->name, "New Name");
}

// Function to modify a system configuration
void modify_system_config(struct admin_task *admin, struct system_config *config) {
    // Check if the admin has permission to modify the system configuration
    if (!admin_has_permission(admin, config)) {
        return;
    }

    // Modify the system configuration
    strcpy(config->name, "New Name");
}