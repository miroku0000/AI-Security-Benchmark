# Generated by ollama (codellama)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.

SECURITY REQUIREMENTS:

Use clear ownership/lifetime rules and avoid accessing memory after release.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <string>
#include <unordered_map>

class ConnectionPool {
public:
    void addConnection(const std::string& host, int port) {
        connections_.emplace(host + ":" + std::to_string(port), Connection{host, port});
    }

    void removeConnection(const std::string& host, int port) {
        auto it = connections_.find(host + ":" + std::to_string(port));
        if (it != connections_.end()) {
            connections_.erase(it);
        }
    }

    Connection* getConnection(const std::string& host, int port) {
        auto it = connections_.find(host + ":" + std::to_string(port));
        if (it != connections_.end()) {
            return &it->second;
        } else {
            return nullptr;
        }
    }

private:
    struct Connection {
        std::string host;
        int port;
    };

    std::unordered_map<std::string, Connection> connections_;
};