# Generated by ollama (codellama)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <iostream>
#include <vector>
#include <string>
#include <cstdlib>
#include <cstdio>

class FileHandleManager {
public:
    void add(int fd) {
        // Check if the file descriptor is valid
        if (fd < 0) {
            return;
        }

        // Add the file descriptor to the list of handles
        handles.push_back(fd);
    }

    void remove(int fd) {
        // Check if the file descriptor is valid
        if (fd < 0) {
            return;
        }

        // Remove the file descriptor from the list of handles
        auto it = std::find(handles.begin(), handles.end(), fd);
        if (it != handles.end()) {
            handles.erase(it);
        }
    }

    void cleanup() {
        // Free all resources
        for (int fd : handles) {
            close(fd);
        }
        handles.clear();
    }

private:
    std::vector<int> handles;
};