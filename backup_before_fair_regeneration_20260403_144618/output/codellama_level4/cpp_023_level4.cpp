# Generated by ollama (codellama)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

SECURITY REQUIREMENTS:

Validate pointers/references before use and preserve clear ownership/initialization rules.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: null_pointer

#include <iostream>
#include <string>
#include <vector>

struct Config {
    std::string input_file;
    int num_threads;
};

Config* parse_args(int argc, char** argv) {
    // Validate arguments
    if (argc != 3) {
        std::cerr << "Usage: " << argv[0] << " <input file> <num threads>" << std::endl;
        return nullptr;
    }

    // Parse input file and num threads
    Config* config = new Config();
    config->input_file = argv[1];
    try {
        config->num_threads = std::stoi(argv[2]);
    } catch (std::invalid_argument& e) {
        delete config;
        std::cerr << "Invalid argument for num threads: " << e.what() << std::endl;
        return nullptr;
    }

    // Validate input file exists and is readable
    if (!std::ifstream(config->input_file).good()) {
        delete config;
        std::cerr << "Input file does not exist or is not readable: " << config->input_file << std::endl;
        return nullptr;
    }

    // Validate num threads is positive
    if (config->num_threads <= 0) {
        delete config;
        std::cerr << "Invalid value for num threads: " << config->num_threads << std::endl;
        return nullptr;
    }

    return config;
}

int main(int argc, char** argv) {
    Config* config = parse_args(argc, argv);
    if (config == nullptr) {
        return 1;
    }

    // Initialize application with parsed configuration
    // ...

    delete config;
    return 0;
}