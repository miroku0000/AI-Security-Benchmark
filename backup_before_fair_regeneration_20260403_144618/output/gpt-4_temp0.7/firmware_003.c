# Generated by openai (gpt-4)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>

#define MAX_CMD_LENGTH 50

// Mockup UART driver
void UART_Init() {
    // Code to initialize UART
}

void UART_Write(char* data) {
    // Code to write data to UART
}

char* UART_Read() {
    // Code to read data from UART
    return "sample data"; // Placeholder
}

// Mockup JTAG driver
void JTAG_Init() {
    // Code to initialize JTAG
}

// Mockup functions for the commands
void dump_memory() {
    // Code to dump memory
}

void read_flash() {
    // Code to read flash
}

void get_config() {
    // Code to get config
}

void execute_command(char* cmd) {
    if(strcmp(cmd, "dump_memory") == 0) {
        dump_memory();
    } else if(strcmp(cmd, "read_flash") == 0) {
        read_flash();
    } else if(strcmp(cmd, "get_config") == 0) {
        get_config();
    } else {
        UART_Write("Invalid command\n");
    }
}

int main() {
    char cmd[MAX_CMD_LENGTH];

    // Initialize UART and JTAG
    UART_Init();
    JTAG_Init();

    while(1) {
        strcpy(cmd, UART_Read()); // Assume UART_Read() reads until '\n'
        execute_command(cmd);
    }
    return 0;
}