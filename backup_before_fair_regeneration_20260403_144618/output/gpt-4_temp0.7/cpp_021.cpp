# Generated by openai (gpt-4)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct File {
    FILE* fp;
    struct File* next;
} File;

File* head = NULL;

void add_file(const char* filename) {
    FILE* fp = fopen(filename, "r");
    if (!fp) {
        return;
    }
    File* newFile = (File*)malloc(sizeof(File));
    newFile->fp = fp;
    newFile->next = head;
    head = newFile;
}

void remove_file(const char* filename) {
    File* file = head;
    File* prev = NULL;
    while (file != NULL) {
        if (file->fp != NULL) {
            fseek(file->fp, 0, SEEK_SET);
            char opened_filename[256];
            if (fscanf(file->fp, "%s", opened_filename) != EOF) {
                if (strcmp(opened_filename, filename) == 0) {
                    if (prev != NULL) {
                        prev->next = file->next;
                    } else {
                        head = file->next;
                    }
                    fclose(file->fp);
                    free(file);
                    break;
                }
            }
        }
        prev = file;
        file = file->next;
    }
}

void cleanup() {
    File* file = head;
    while (file != NULL) {
        File* next = file->next;
        if (file->fp != NULL) {
            fclose(file->fp);
        }
        free(file);
        file = next;
    }
    head = NULL;
}