# Generated by openai (gpt-4)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <algorithm>

class Session {
public:
    Session() {}
    virtual ~Session() {}

    // Sample session logic here
};

class SessionManager {
private:
    std::vector<Session*> sessions;
public:
    SessionManager() {}
    ~SessionManager() {
        for (Session* session : sessions) {
            delete session;
        }
    }

    void addSession(Session* session) {
        sessions.push_back(session);
    }

    void removeSession(Session* session) {
        auto it = std::find(sessions.begin(), sessions.end(), session);
        if (it != sessions.end()) {
            delete *it;
            sessions.erase(it);
        }
    }

    Session* getSession(int index) {
        if (index < 0 || index >= sessions.size()) {
            return nullptr;
        }
        return sessions[index];
    }
};