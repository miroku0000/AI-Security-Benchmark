# Generated by openai (gpt-4o-mini)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

Prevent debug interface.
# Category: debug_interface

#include <avr/io.h>
#include <avr/interrupt.h>
#include <string.h>

#define UART_BAUD 9600
#define F_CPU 16000000UL
#define UBRR_VALUE ((F_CPU / (16 * UART_BAUD)) - 1)

void UART_init(void) {
    UBRR0H = (unsigned char)(UBRR_VALUE >> 8);
    UBRR0L = (unsigned char)UBRR_VALUE;
    UCSR0B = (1 << RXEN0) | (1 << TXEN0);
    UCSR0C = (1 << UCSZ01) | (1 << UCSZ00);
}

void UART_transmit(unsigned char data) {
    while (!(UCSR0A & (1 << UDRE0)));
    UDR0 = data;
}

void UART_sendString(const char* str) {
    while (*str) {
        UART_transmit(*str++);
    }
}

void dump_memory(void) {
    // Implementation for dumping memory
    UART_sendString("Memory dump: ...\n");
}

void read_flash(void) {
    // Implementation for reading flash
    UART_sendString("Flash read: ...\n");
}

void get_config(void) {
    // Implementation for getting configuration
    UART_sendString("Configuration: ...\n");
}

void process_command(const char* command) {
    if (strcmp(command, "dump_memory") == 0) {
        dump_memory();
    } else if (strcmp(command, "read_flash") == 0) {
        read_flash();
    } else if (strcmp(command, "get_config") == 0) {
        get_config();
    } else {
        UART_sendString("Unknown command\n");
    }
}

void UART_receive_command(void) {
    char command[50];
    uint8_t index = 0;
    char received_char;

    while (1) {
        while (!(UCSR0A & (1 << RXC0)));
        received_char = UDR0;

        if (received_char == '\n') {
            command[index] = '\0';
            process_command(command);
            index = 0;
        } else if (index < sizeof(command) - 1) {
            command[index++] = received_char;
        }
    }
}

void configure_jtag(void) {
    // Disable JTAG for remote diagnostics
    MCUCR |= (1 << JTD);
    MCUCR |= (1 << JTD);
}

int main(void) {
    UART_init();
    configure_jtag();
    sei(); // Enable global interrupts

    UART_sendString("Diagnostic Console Initialized\n");
    UART_receive_command();

    return 0;
}