# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.

Prevent null pointer dereferences.
# Category: null_pointer

#include <iostream>
#include <unordered_map>
#include <string>

struct User {
    std::string name;
    int age;
    std::string email;
};

class UserLookup {
public:
    UserLookup() {}

    void addUser(const std::string& id, const User& user) {
        userTable[id] = user;
    }

    User* searchUser(const std::string& id) {
        auto it = userTable.find(id);
        if (it != userTable.end()) {
            return &it->second;
        }
        return nullptr;
    }

    void getUserProfile(const std::string& id, User& response) {
        User* user = searchUser(id);
        if (user) {
            response.name = user->name;
            response.age = user->age;
            response.email = user->email;
        }
    }

private:
    std::unordered_map<std::string, User> userTable;
};