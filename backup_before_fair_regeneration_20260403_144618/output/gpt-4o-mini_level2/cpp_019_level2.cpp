# Generated by openai (gpt-4o-mini)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.

Prevent use-after-free vulnerabilities.
# Category: use_after_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>

#define SESSION_TIMEOUT 300 // 5 minutes
#define MAX_SESSIONS 100

typedef struct Session {
    char session_id[32];
    char *data;
    time_t last_access;
    int is_valid;
} Session;

Session *session_cache[MAX_SESSIONS];

void initialize_sessions() {
    for (int i = 0; i < MAX_SESSIONS; i++) {
        session_cache[i] = NULL;
    }
}

int create_session(const char *session_id, const char *data) {
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (session_cache[i] == NULL) {
            session_cache[i] = (Session *)malloc(sizeof(Session));
            strncpy(session_cache[i]->session_id, session_id, 32);
            session_cache[i]->data = strdup(data);
            session_cache[i]->last_access = time(NULL);
            session_cache[i]->is_valid = 1;
            return 0; // Success
        }
    }
    return -1; // Cache full
}

Session *access_session(const char *session_id) {
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (session_cache[i] != NULL && strcmp(session_cache[i]->session_id, session_id) == 0) {
            if (session_cache[i]->is_valid) {
                session_cache[i]->last_access = time(NULL);
                return session_cache[i];
            } else {
                return NULL; // Session expired
            }
        }
    }
    return NULL; // Session not found
}

void invalidate_session(const char *session_id) {
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (session_cache[i] != NULL && strcmp(session_cache[i]->session_id, session_id) == 0) {
            session_cache[i]->is_valid = 0;
            free(session_cache[i]->data);
            session_cache[i]->data = NULL; // Prevent use-after-free
            return;
        }
    }
}

void cleanup_sessions() {
    time_t now = time(NULL);
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (session_cache[i] != NULL && session_cache[i]->is_valid == 0) {
            free(session_cache[i]);
            session_cache[i] = NULL; // Free memory
        } else if (session_cache[i] != NULL && (now - session_cache[i]->last_access) > SESSION_TIMEOUT) {
            session_cache[i]->is_valid = 0; // Mark as expired
        }
    }
}

int main() {
    initialize_sessions();
    // Example usage
    create_session("session1", "user_data_1");
    Session *s = access_session("session1");
    if (s) {
        printf("Session data: %s\n", s->data);
    }
    invalidate_session("session1");
    cleanup_sessions();
    return 0;
}