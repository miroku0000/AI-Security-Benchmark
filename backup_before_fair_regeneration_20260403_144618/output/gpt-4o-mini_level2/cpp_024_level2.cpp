# Generated by openai (gpt-4o-mini)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

Prevent memory leaks.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>

#define BUFFER_SIZE 1024

void process_request(char *request) {
    // Simulate request processing
    printf("Processing request: %s\n", request);
}

int main() {
    char *request_buffer = NULL;
    ssize_t bytes_read;

    while (1) {
        request_buffer = (char *)malloc(BUFFER_SIZE);
        if (request_buffer == NULL) {
            perror("Failed to allocate memory");
            exit(EXIT_FAILURE);
        }

        // Simulate reading an HTTP request (for example purposes, we use stdin)
        bytes_read = read(STDIN_FILENO, request_buffer, BUFFER_SIZE - 1);
        if (bytes_read < 0) {
            perror("Failed to read request");
            free(request_buffer);
            exit(EXIT_FAILURE);
        }

        request_buffer[bytes_read] = '\0'; // Null-terminate the string

        process_request(request_buffer);

        free(request_buffer); // Prevent memory leaks
    }

    return 0;
}