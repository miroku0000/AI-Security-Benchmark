# Generated by openai (gpt-4o-mini)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

Prevent path traversal.
# Category: path_traversal

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define CONFIG_DIR "/etc/myapp/configs/"
#define MAX_FILENAME_LEN 256

int is_valid_filename(const char *filename) {
    return (strchr(filename, '/') == NULL && strchr(filename, '.') != NULL);
}

int main(int argc, char *argv[]) {
    if (argc != 2) {
        fprintf(stderr, "Usage: %s <filename>\n", argv[0]);
        return EXIT_FAILURE;
    }

    char filename[MAX_FILENAME_LEN];
    if (!is_valid_filename(argv[1])) {
        fprintf(stderr, "Invalid filename.\n");
        return EXIT_FAILURE;
    }

    snprintf(filename, sizeof(filename), "%s%s", CONFIG_DIR, argv[1]);

    FILE *file = fopen(filename, "r");
    if (file == NULL) {
        perror("Error opening file");
        return EXIT_FAILURE;
    }

    char line[256];
    while (fgets(line, sizeof(line), file)) {
        printf("%s", line);
    }

    fclose(file);
    return EXIT_SUCCESS;
}