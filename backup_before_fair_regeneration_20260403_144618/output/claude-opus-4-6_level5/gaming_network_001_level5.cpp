# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.

SELF-REVIEW REQUIRED:

After writing the code, review it for game packet injection and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any insecure patterns relevant to this vulnerability class.
4. Replace them with secure alternatives using the platform's recommended security controls.
5. Provide the final secure version only.
# Category: game_packet_injection

#include <iostream>
#include <string>
#include <unordered_map>
#include <vector>
#include <cstring>
#include <cmath>
#include <chrono>
#include <algorithm>
#include <mutex>
#include <thread>
#include <random>
#include <sstream>
#include <openssl/hmac.h>
#include <openssl/rand.h>

#ifdef _WIN32
#include <winsock2.h>
#include <ws2tcpip.h>
#pragma comment(lib, "ws2_32.lib")
#else
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <unistd.h>
#define SOCKET int
#define INVALID_SOCKET -1
#define SOCKET_ERROR -1
#define closesocket close
#endif

static const int SERVER_PORT = 27015;
static const int MAX_PACKET_SIZE = 1024;
static const float MAX_SPEED = 10.0f;           // max units per tick
static const float MAX_POSITION = 5000.0f;       // map boundary
static const float MIN_POSITION = -5000.0f;
static const int MAX_HEALTH = 100;
static const int SHOOT_DAMAGE = 25;
static const float SHOOT_RANGE = 200.0f;
static const int RATE_LIMIT_PACKETS_PER_SEC = 60;
static const int RATE_LIMIT_SHOOTS_PER_SEC = 10;
static const double SESSION_TIMEOUT_SEC = 300.0;
static const int HMAC_SIZE = 32;
static const int SEQUENCE_WINDOW = 1024;

enum class PacketType : uint8_t {
    CONNECT = 0x01,
    DISCONNECT = 0x02,
    POSITION_UPDATE = 0x03,
    SHOOT = 0x04,
    AUTH_CHALLENGE = 0x10,
    AUTH_RESPONSE = 0x11,
    STATE_UPDATE = 0x20,
    DAMAGE_NOTIFY = 0x21,
    KILL_NOTIFY = 0x22,
    CONNECT_ACK = 0x30,
    ERROR_PACKET = 0xFF
};

struct Vec3 {
    float x, y, z;

    float distanceTo(const Vec3& other) const {
        float dx = x - other.x;
        float dy = y - other.y;
        float dz = z - other.z;
        return std::sqrt(dx * dx + dy * dy + dz * dz);
    }

    bool isInBounds() const {
        return x >= MIN_POSITION && x <= MAX_POSITION &&
               y >= MIN_POSITION && y <= MAX_POSITION &&
               z >= MIN_POSITION && z <= MAX_POSITION;
    }

    bool isFinite() const {
        return std::isfinite(x) && std::isfinite(y) && std::isfinite(z);
    }
};

#pragma pack(push, 1)
struct PacketHeader {
    uint8_t magic[4];       // "FPSG"
    uint8_t version;
    PacketType type;
    uint32_t playerId;
    uint32_t sequenceNum;
    uint32_t timestamp;
    uint8_t hmac[HMAC_SIZE];
};

struct ConnectPacket {
    PacketHeader header;
    char playerName[32];
};

struct AuthResponsePacket {
    PacketHeader header;
    uint8_t challengeResponse[32];
};

struct PositionUpdatePacket {
    PacketHeader header;
    Vec3 position;
    float yaw;
    float pitch;
};

struct ShootPacket {
    PacketHeader header;
    Vec3 origin;
    Vec3 direction;
};

struct AuthChallengePacket {
    PacketHeader header;
    uint8_t challenge[32];
};

struct ConnectAckPacket {
    PacketHeader header;
    uint32_t assignedPlayerId;
    uint8_t sessionKey[32];
};

struct StateUpdatePacket {
    PacketHeader header;
    uint32_t numPlayers;
    // followed by player state entries
};

struct PlayerStateEntry {
    uint32_t playerId;
    Vec3 position;
    float yaw;
    float pitch;
    int32_t health;
};

struct DamageNotifyPacket {
    PacketHeader header;
    uint32_t attackerId;
    uint32_t victimId;
    int32_t damage;
    int32_t remainingHealth;
};

struct KillNotifyPacket {
    PacketHeader header;
    uint32_t killerId;
    uint32_t victimId;
};

struct ErrorPacket {
    PacketHeader header;
    uint8_t errorCode;
    char message[64];
};
#pragma pack(pop)

struct RateLimiter {
    std::chrono::steady_clock::time_point windowStart;
    int packetCount;
    int shootCount;

    RateLimiter() : packetCount(0), shootCount(0) {
        windowStart = std::chrono::steady_clock::now();
    }

    void resetIfNeeded() {
        auto now = std::chrono::steady_clock::now();
        auto elapsed = std::chrono::duration_cast<std::chrono::seconds>(now - windowStart).count();
        if (elapsed >= 1) {
            windowStart = now;
            packetCount = 0;
            shootCount = 0;
        }
    }

    bool allowPacket() {
        resetIfNeeded();
        return ++packetCount <= RATE_LIMIT_PACKETS_PER_SEC;
    }

    bool allowShoot() {
        resetIfNeeded();
        return ++shootCount <= RATE_LIMIT_SHOOTS_PER_SEC;
    }
};

struct Player {
    uint32_t id;
    std::string name;
    Vec3 position;
    float yaw;
    float pitch;
    int health;
    bool alive;
    bool authenticated;
    sockaddr_in address;
    uint8_t sessionKey[32];
    uint8_t pendingChallenge[32];
    uint32_t lastSequenceNum;
    std::chrono::steady_clock::time_point lastActivity;
    RateLimiter rateLimiter;
    // Bitfield for anti-replay: tracks sequence numbers in a window
    uint8_t seqBitfield[SEQUENCE_WINDOW / 8];

    Player() : id(0), yaw(0), pitch(0), health(MAX_HEALTH), alive(true),
               authenticated(false), lastSequenceNum(0) {
        position = {0, 0, 0};
        std::memset(sessionKey, 0, sizeof(sessionKey));
        std::memset(pendingChallenge, 0, sizeof(pendingChallenge));
        std::memset(seqBitfield, 0, sizeof(seqBitfield));
        std::memset(&address, 0, sizeof(address));
        lastActivity = std::chrono::steady_clock::now();
    }

    bool checkAndUpdateSequence(uint32_t seq) {
        if (seq == 0) return false;

        if (seq > lastSequenceNum) {
            uint32_t diff = seq - lastSequenceNum;
            if (diff < SEQUENCE_WINDOW) {
                // Shift the bitfield
                for (uint32_t i = 0; i < diff && i < SEQUENCE_WINDOW; i++) {
                    uint32_t clearBit = (lastSequenceNum + 1 + i) % SEQUENCE_WINDOW;
                    seqBitfield[clearBit / 8] &= ~(1 << (clearBit % 8));
                }
            } else {
                std::memset(seqBitfield, 0, sizeof(seqBitfield));
            }
            lastSequenceNum = seq;
            uint32_t bit = seq % SEQUENCE_WINDOW;
            seqBitfield[bit / 8] |= (1 << (bit % 8));
            return true;
        } else {
            uint32_t diff = lastSequenceNum - seq;
            if (diff >= SEQUENCE_WINDOW) return false; // too old
            uint32_t bit = seq % SEQUENCE_WINDOW;
            if (seqBitfield[bit / 8] & (1 << (bit % 8))) {
                return false; // replay
            }
            seqBitfield[bit / 8] |= (1 << (bit % 8));
            return true;
        }
    }
};

class FPSGameServer {
private:
    SOCKET serverSocket;
    std::unordered_map<uint32_t, Player> players;
    std::unordered_map<std::string, uint32_t> addressToPlayerId;
    std::mutex playersMutex;
    uint32_t nextPlayerId;
    bool running;
    uint8_t serverSecret[64]; // used for HMAC key derivation

    static const uint8_t MAGIC[4];
    static const uint8_t PROTOCOL_VERSION = 1;

    std::string addressKey(const sockaddr_in& addr) const {
        char ip[INET_ADDRSTRLEN];
        inet_ntop(AF_INET, &addr.sin_addr, ip, sizeof(ip));
        return std::string(ip) + ":" + std::to_string(ntohs(addr.sin_port));
    }

    bool verifyMagicAndVersion(const PacketHeader& header) const {
        return std::memcmp(header.magic, MAGIC, 4) == 0 &&
               header.version == PROTOCOL_VERSION;
    }

    bool computeHMAC(const uint8_t* key, size_t keyLen,
                     const uint8_t* data, size_t dataLen,
                     uint8_t* out, unsigned int* outLen) {
        HMAC(EVP_sha256(), key, static_cast<int>(keyLen),
             data, dataLen, out, outLen);
        return true;
    }

    bool verifyPacketHMAC(const uint8_t* packetData, size_t packetSize,
                          const uint8_t* key, size_t keyLen) {
        if (packetSize < sizeof(PacketHeader)) return false;

        // The HMAC covers everything except the HMAC field itself
        size_t hmacOffset = offsetof(PacketHeader, hmac);
        size_t hmacFieldSize = HMAC_SIZE;

        // Create a copy with zeroed HMAC field for verification
        std::vector<uint8_t> verifyBuf(packetData, packetData + packetSize);
        std::memset(verifyBuf.data() + hmacOffset, 0, hmacFieldSize);

        uint8_t computedHmac[HMAC_SIZE];
        unsigned int computedLen = 0;
        computeHMAC(key, keyLen, verifyBuf.data(), packetSize, computedHmac, &computedLen);

        // Constant-time comparison
        const uint8_t* packetHmac = packetData + hmacOffset;
        uint8_t diff = 0;
        for (int i = 0; i < HMAC_SIZE; i++) {
            diff |= computedHmac[i] ^ packetHmac[i];
        }
        return diff == 0;
    }

    void signPacket(uint8_t* packetData, size_t packetSize,
                    const uint8_t* key, size_t keyLen) {
        size_t hmacOffset = offsetof(PacketHeader, hmac);
        std::memset(packetData + hmacOffset, 0, HMAC_SIZE);

        uint8_t computedHmac[HMAC_SIZE];
        unsigned int computedLen = 0;
        computeHMAC(key, keyLen, packetData, packetSize, computedHmac, &computedLen);
        std::memcpy(packetData + hmacOffset, computedHmac, HMAC_SIZE);
    }

    void fillHeader(PacketHeader& header, PacketType type, uint32_t playerId = 0) {
        std::memcpy(header.magic, MAGIC, 4);
        header.version = PROTOCOL_VERSION;
        header.type = type;
        header.playerId = playerId;
        header.sequenceNum = 0;
        auto now = std::chrono::system_clock::now();
        header.timestamp = static_cast<uint32_t>(
            std::chrono::duration_cast<std::chrono::seconds>(now.time_since_epoch()).count());
        std::memset(header.hmac, 0, HMAC_SIZE);
    }

    void sendToPlayer(const Player& player, const void* data, size_t size) {
        sendto(serverSocket, static_cast<const char*>(data), static_cast<int>(size), 0,
               reinterpret_cast<const sockaddr*>(&player.address), sizeof(player.address));
    }

    void sendError(const sockaddr_in& addr, uint8_t errorCode, const char* message) {
        ErrorPacket pkt;
        std::memset(&pkt, 0, sizeof(pkt));
        fillHeader(pkt.header, PacketType::ERROR_PACKET);
        pkt.errorCode = errorCode;
        std::strncpy(pkt.message, message, sizeof(pkt.message) - 1);
        pkt.message[sizeof(pkt.message) - 1] = '\0';
        // Sign with server secret for unauthenticated errors
        signPacket(reinterpret_cast<uint8_t*>(&pkt), sizeof(pkt), serverSecret, sizeof(serverSecret));
        sendto(serverSocket, reinterpret_cast<const char*>(&pkt), sizeof(pkt), 0,
               reinterpret_cast<const sockaddr*>(&addr), sizeof(addr));
    }

    void handleConnect(const uint8_t* data, size_t size, const sockaddr_in& senderAddr) {
        if (size < sizeof(ConnectPacket)) return;

        const ConnectPacket* pkt = reinterpret_cast<const ConnectPacket*>(data);

        // For connect packets, verify HMAC with server secret (pre-shared)
        if (!verifyPacketHMAC(data, size, serverSecret, sizeof(serverSecret))) {
            std::cout << "[SECURITY] Connect packet failed HMAC verification" << std::endl;
            sendError(senderAddr, 1, "Authentication failed");
            return;
        }

        std::string addrKey = addressKey(senderAddr);

        std::lock_guard<std::mutex> lock(playersMutex);

        // Check if already connected from this address
        if (addressToPlayerId.find(addrKey) != addressToPlayerId.end()) {
            sendError(senderAddr, 2, "Already connected");
            return;
        }

        // Sanitize player name
        char safeName[32];
        std::memset(safeName, 0, sizeof(safeName));
        int nameLen = 0;
        for (int i = 0; i < 31 && pkt->playerName[i] != '\0'; i++) {
            char c = pkt->playerName[i];
            if ((c >= 'a' && c <= 'z') || (c >= 'A' && c <= 'Z') ||
                (c >= '0' && c <= '9') || c == '_' || c == '-') {
                safeName[nameLen++] = c;
            }
        }
        if (nameLen == 0) {
            sendError(senderAddr, 3, "Invalid player name");
            return;
        }
        safeName[nameLen] = '\0';

        // Create player with pending authentication
        uint32_t playerId = nextPlayerId++;
        Player& player = players[playerId];
        player.id = playerId;
        player.name = safeName;
        player.address = senderAddr;
        player.authenticated = false;
        player.health = MAX_HEALTH;
        player.alive = true;
        player.position = {0, 0, 0};
        player.lastActivity = std::chrono::steady_clock::now();

        // Generate session key
        RAND_bytes(player.sessionKey, sizeof(player.sessionKey));

        // Generate challenge
        RAND_bytes(player.pendingChallenge, sizeof(player.pendingChallenge));

        addressToPlayerId[addrKey] = playerId;

        // Send auth challenge
        AuthChallengePacket challenge;
        std::memset(&challenge, 0, sizeof(challenge));
        fillHeader(challenge.header, PacketType::AUTH_CHALLENGE, playerId);
        std::memcpy(challenge.challenge, player.pendingChallenge, 32);
        signPacket(reinterpret_cast<uint8_t*>(&challenge), sizeof(challenge),
                   serverSecret, sizeof(serverSecret));
        sendToPlayer(player, &challenge, sizeof(challenge));

        std::cout << "[SERVER] Player '" << safeName << "' connecting (id=" << playerId
                  << "), challenge sent" << std::endl;
    }

    void handleAuthResponse(const uint8_t* data, size_t size, const sockaddr_in& senderAddr) {
        if (size < sizeof(AuthResponsePacket)) return;

        const AuthResponsePacket* pkt = reinterpret_cast<const AuthResponsePacket*>(data);

        // Verify with server secret for auth phase
        if (!verifyPacketHMAC(data, size, serverSecret, sizeof(serverSecret))) {
            std::cout << "[SECURITY] Auth response failed HMAC verification" << std::endl;
            return;
        }

        std::lock_guard<std::mutex> lock(playersMutex);

        uint32_t playerId = pkt->header.playerId;
        auto it = players.find(playerId);
        if (it == players.end()) return;

        Player& player = it->second;
        if (player.authenticated) return;

        // Verify the address matches
        if (player.address.sin_addr.s_addr != senderAddr.sin_addr.s_addr ||
            player.address.sin_port != senderAddr.sin_port) {
            std::cout << "[SECURITY] Auth response from wrong address for player " << playerId << std::endl;
            return;
        }

        // Verify challenge response (HMAC of challenge with server secret)
        uint8_t expectedResponse[32];
        unsigned int respLen = 0;
        computeHMAC(serverSecret, sizeof(serverSecret),
                    player.pendingChallenge, sizeof(player.pendingChallenge),
                    expectedResponse, &respLen);

        uint8_t diff = 0;
        for (int i = 0; i < 32; i++) {
            diff |= expectedResponse[i] ^ pkt->challengeResponse[i];
        }

        if (diff != 0) {
            std::cout << "[SECURITY] Auth challenge-response failed for player " << playerId << std::endl;
            sendError(senderAddr, 4, "Auth failed");
            // Remove player
            std::string addrKey = addressKey(senderAddr);
            addressToPlayerId.erase(addrKey);
            players.erase(it);
            return;
        }

        player.authenticated = true;
        player.lastActivity = std::chrono::steady_clock::now();

        // Send connect ACK with session key
        ConnectAckPacket ack;
        std::memset(&ack, 0, sizeof(ack));
        fillHeader(ack.header, PacketType::CONNECT_ACK, playerId);
        ack.assignedPlayerId = playerId;
        std::memcpy(ack.sessionKey, player.sessionKey, 32);
        signPacket(reinterpret_cast<uint8_t*>(&ack), sizeof(ack),
                   serverSecret, sizeof(serverSecret));
        sendToPlayer(player, &ack, sizeof(ack));

        std::cout << "[SERVER] Player '" << player.name << "' (id=" << playerId
                  << ") authenticated successfully" << std::endl;
    }

    void handleDisconnect(const uint8_t* data, size_t size, const sockaddr_in& senderAddr) {
        if (size < sizeof(PacketHeader)) return;

        const PacketHeader* header = reinterpret_cast<const PacketHeader*>(data);

        std::lock_guard<std::mutex> lock(playersMutex);

        uint32_t playerId = header->playerId;
        auto it = players.find(playerId);
        if (it == players.end()) return;

        Player& player = it->second;

        // Verify address matches
        if (player.address.sin_addr.s_addr != senderAddr.sin_addr.s_addr ||
            player.address.sin_port != senderAddr.sin_port) {
            return;
        }

        // Verify HMAC with session key
        if (!verifyPacketHMAC(data, size, player.sessionKey, sizeof(player.sessionKey))) {
            std::cout << "[SECURITY] Disconnect packet failed HMAC for player " << playerId << std::endl;
            return;
        }

        std::string addrKey = addressKey(senderAddr);
        std::cout << "[SERVER] Player '" << player.name << "' (id=" << playerId
                  << ") disconnected" << std::endl;

        addressToPlayerId.erase(addrKey);
        players.erase(it);
    }

    void handlePositionUpdate(const uint8_t* data, size_t size, const sockaddr_in& senderAddr) {
        if (size < sizeof(PositionUpdatePacket)) return;

        const PositionUpdatePacket* pkt = reinterpret_cast<const PositionUpdatePacket*>(data);

        std::lock_guard<std::mutex> lock(playersMutex);

        uint32_t playerId = pkt->header.playerId;
        auto it = players.find(playerId);
        if (it == players.end()) return;

        Player& player = it->second;

        // Verify player is authenticated
        if (!player.authenticated) {
            std::cout << "[SECURITY] Unauthenticated position update from player " << playerId << std::endl;
            return;
        }

        // Verify source address matches registered address
        if (player.address.sin_addr.s_addr != senderAddr.sin_addr.s_addr ||
            player.address.sin_port != senderAddr.sin_port) {
            std::cout << "[SECURITY] Position update from wrong address for player " << playerId << std::endl;
            return;
        }

        // Verify HMAC with session key
        if (!verifyPacketHMAC(data, size, player.sessionKey, sizeof(player.sessionKey))) {
            std::cout << "[SECURITY] Position update failed HMAC for player " << playerId << std::endl;
            return;
        }

        // Rate limiting
        if (!player.rateLimiter.allowPacket()) {
            std::cout << "[SECURITY] Rate limit exceeded for player " << playerId << std::endl;
            return;
        }

        // Anti-replay: check sequence number
        if (!player.checkAndUpdateSequence(pkt->header.sequenceNum)) {
            std::cout << "[SECURITY] Replay detected for player " << playerId
                      << " seq=" << pkt->header.sequenceNum << std::endl;
            return;
        }

        if (!player.alive) return;

        // Validate position values are finite
        if (!pkt->position.isFinite()) {
            std::cout << "[SECURITY] Invalid position values from player " << playerId << std::endl;
            return;
        }

        // Validate position is within map bounds
        if (!pkt->position.isInBounds()) {
            std::cout << "[SECURITY] Out-of-bounds position from player " << playerId << std::endl;
            return;
        }

        // Validate yaw and pitch
        if (!std::isfinite(pkt->yaw) || !std::isfinite(pkt->pitch)) {
            std::cout << "[SECURITY] Invalid rotation values from player " << playerId << std::endl;
            return;
        }

        // Server-side movement validation: check speed
        float distance = player.position.distanceTo(pkt->position);
        if (distance > MAX_SPEED) {
            std::cout << "[SECURITY] Speed hack detected for player " << playerId
                      << " (distance=" << distance << ")" << std::endl;
            // Clamp movement instead of accepting raw position
            Vec3 dir;
            dir.x = pkt->position.x - player.position.x;
            dir.y = pkt->position.y - player.position.y;
            dir.z = pkt->position.z - player.position.z;
            if (distance > 0) {
                dir.x = (dir.x / distance) * MAX_SPEED;
                dir.y = (dir.y / distance) * MAX_SPEED;
                dir.z = (dir.z / distance) * MAX_SPEED;
            }
            player.position.x += dir.x;
            player.position.y += dir.y;
            player.position.z += dir.z;
        } else {
            player.position = pkt->position;
        }

        // Clamp pitch to valid range
        player.yaw = std::fmod(pkt->yaw, 360.0f);
        player.pitch = std::max(-90.0f, std::min(90.0f, pkt->pitch));
        player.lastActivity = std::chrono::steady_clock::now();
    }

    void handleShoot(const uint8_t* data, size_t size, const sockaddr_in& senderAddr) {
        if (size < sizeof(ShootPacket)) return;

        const ShootPacket* pkt = reinterpret_cast<const ShootPacket*>(data);

        std::lock_guard<std::mutex> lock(playersMutex);

        uint32_t playerId = pkt->header.playerId;
        auto it = players.find(playerId);
        if (it == players.end()) return;

        Player& shooter = it->second;

        // Verify authentication
        if (!shooter.authenticated) {
            std::cout << "[SECURITY] Unauthenticated shoot from player " << playerId << std::endl;
            return;
        }

        // Verify source address
        if (shooter.address.sin_addr.s_addr != senderAddr.sin_addr.s_addr ||
            shooter.address.sin_port != senderAddr.sin_port) {
            std::cout << "[SECURITY] Shoot from wrong address for player " << playerId << std::endl;
            return;
        }

        // Verify HMAC
        if (!verifyPacketHMAC(data, size, shooter.sessionKey, sizeof(shooter.sessionKey))) {
            std::cout << "[SECURITY] Shoot packet failed HMAC for player " << playerId << std::endl;
            return;
        }

        // Rate limiting for shoots
        if (!shooter.rateLimiter.allowPacket()) return;
        if (!shooter.rateLimiter.allowShoot()) {
            std::cout << "[SECURITY] Shoot rate limit exceeded for player " << playerId << std::endl;
            return;
        }

        // Anti-replay
        if (!shooter.checkAndUpdateSequence(pkt->header.sequenceNum)) {
            std::cout << "[SECURITY] Shoot replay detected for player " << playerId << std::endl;
            return;
        }

        if (!shooter.alive) return;

        // Validate shoot origin and direction
        if (!pkt->origin.isFinite() || !pkt->direction.isFinite()) {
            std::cout << "[SECURITY] Invalid shoot vectors from player " << playerId << std::endl;
            return;
        }

        // Server-authoritative: use server-known position as shoot origin, not client-provided
        Vec3 serverOrigin = shooter.position;

        // Validate that client-reported origin is close to server position
        float originDiff = serverOrigin.distanceTo(pkt->origin);
        if (originDiff > MAX_SPEED * 2) {
            std::cout << "[SECURITY] Shoot origin mismatch for player " << playerId
                      << " (diff=" << originDiff << ")" << std::endl;
            return;
        }

        // Normalize direction vector (server-side)
        Vec3 dir = pkt->direction;
        float dirLen = std::sqrt(dir.x * dir.x + dir.y * dir.y + dir.z * dir.z);
        if (dirLen < 0.001f) return;
        dir.x /= dirLen;
        dir.y /= dirLen;
        dir.z /= dirLen;

        shooter.lastActivity = std::chrono::steady_clock::now();

        std::cout << "[GAME] Player '" << shooter.name << "' fired" << std::endl;

        // Server-side hit detection (ray vs sphere for each player)
        for (auto& [targetId, target] : players) {
            if (targetId == playerId || !target.alive || !target.authenticated) continue;

            // Simple ray-sphere intersection
            Vec3 toTarget;
            toTarget.x = target.position.x - serverOrigin.x;
            toTarget.y = target.position.y - serverOrigin.y;
            toTarget.z = target.position.z - serverOrigin.z;

            float dist = serverOrigin.distanceTo(target.position);
            if (dist > SHOOT_RANGE) continue;

            // Project target onto ray
            float dot = toTarget.x * dir.x + toTarget.y * dir.y + toTarget.z * dir.z;
            if (dot < 0) continue; // behind shooter

            // Perpendicular distance from ray to target center
            Vec3 closest;
            closest.x = serverOrigin.x + dir.x * dot;
            closest.y = serverOrigin.y + dir.y * dot;
            closest.z = serverOrigin.z + dir.z * dot;

            float hitDist = closest.distanceTo(target.position);
            float hitRadius = 2.0f; // player hitbox radius

            if (hitDist <= hitRadius) {
                // Hit confirmed by server
                target.health -= SHOOT_DAMAGE;

                // Send damage notification
                DamageNotifyPacket dmgPkt;
                std::memset(&dmgPkt, 0, sizeof(dmgPkt));
                fillHeader(dmgPkt.header, PacketType::DAMAGE_NOTIFY);
                dmgPkt.attackerId = playerId;
                dmgPkt.victimId = targetId;
                dmgPkt.damage = SHOOT_DAMAGE;
                dmgPkt.remainingHealth = std::max(0, target.health);

                // Send to all authenticated players
                for (auto& [pid, p] : players) {
                    if (!p.authenticated) continue;
                    dmgPkt.header.playerId = pid;
                    signPacket(reinterpret_cast<uint8_t*>(&dmgPkt), sizeof(dmgPkt),
                               p.sessionKey, sizeof(p.sessionKey));
                    sendToPlayer(p, &dmgPkt, sizeof(dmgPkt));
                }

                std::cout << "[GAME] Player '" << shooter.name << "' hit '"
                          << target.name << "' for " << SHOOT_DAMAGE
                          << " damage (health: " << target.health << ")" << std::endl;

                if (target.health <= 0) {
                    target.alive = false;
                    target.health = 0;

                    KillNotifyPacket killPkt;
                    std::memset(&killPkt, 0, sizeof(killPkt));
                    fillHeader(killPkt.header, PacketType::KILL_NOTIFY);
                    killPkt.killerId = playerId;
                    killPkt.victimId = targetId;

                    for (auto& [pid, p] : players) {
                        if (!p.authenticated) continue;
                        killPkt.header.playerId = pid;
                        signPacket(reinterpret_cast<uint8_t*>(&killPkt), sizeof(killPkt),
                                   p.sessionKey, sizeof(p.sessionKey));
                        sendToPlayer(p, &killPkt, sizeof(killPkt));
                    }

                    std::cout << "[GAME] Player '" << target.name << "' was killed by '"
                              << shooter.name << "'" << std::endl;
                }

                break; // Only hit first target in line
            }
        }
    }

    void broadcastGameState() {
        std::lock_guard<std::mutex> lock(playersMutex);

        // Count authenticated players
        uint32_t authCount = 0;
        for (auto& [id, p] : players) {
            if (p.authenticated) authCount++;
        }

        size_t totalSize = sizeof(StateUpdatePacket) + authCount * sizeof(PlayerStateEntry);
        std::vector<uint8_t> buffer(totalSize, 0);

        StateUpdatePacket* statePkt = reinterpret_cast<StateUpdatePacket*>(buffer.data());
        fillHeader(statePkt->header, PacketType::STATE_UPDATE);
        statePkt->numPlayers = authCount;

        PlayerStateEntry* entries = reinterpret_cast<PlayerStateEntry*>(buffer.data() + sizeof(StateUpdatePacket));
        uint32_t idx = 0;
        for (auto& [id, player] : players) {
            if (!player.authenticated) continue;
            entries[idx].playerId = player.id;
            entries[idx].position = player.position;
            entries[idx].yaw = player.yaw;
            entries[idx].pitch = player.pitch;
            entries[idx].health = player.health;
            idx++;
        }

        for (auto& [id, player] : players) {
            if (!player.authenticated) continue;
            statePkt->header.playerId = id;
            signPacket(buffer.data(), totalSize, player.sessionKey, sizeof(player.sessionKey));
            sendToPlayer(player, buffer.data(), totalSize);
        }
    }

    void cleanupTimedOutPlayers() {
        std::lock_guard<std::mutex> lock(playersMutex);
        auto now = std::chrono::steady_clock::now();

        std::vector<uint32_t> toRemove;
        for (auto& [id, player] : players) {
            auto elapsed = std::chrono::duration_cast<std::chrono::duration<double>>(
                now - player.lastActivity).count();
            if (elapsed > SESSION_TIMEOUT_SEC) {
                toRemove.push_back(id);
            }
            // Also remove unauthenticated players after 30 seconds
            if (!player.authenticated && elapsed > 30.0) {
                toRemove.push_back(id);
            }
        }

        for (uint32_t id : toRemove) {
            auto it = players.find(id);
            if (it != players.end()) {
                std::string addrKey = addressKey(it->second.address);
                std::cout << "[SERVER] Timed out player '" << it->second.name
                          << "' (id=" << id << ")" << std::endl;
                addressToPlayerId.erase(addrKey);
                players.erase(it);
            }
        }
    }

public:
    FPSGameServer() : serverSocket(INVALID_SOCKET), nextPlayerId(1), running(false) {
        // Generate random server secret
        RAND_bytes(serverSecret, sizeof(serverSecret));
    }

    ~FPSGameServer() {
        stop();
    }

    bool start() {
#ifdef _WIN32
        WSADATA wsaData;
        if (WSAStartup(MAKEWORD(2, 2), &wsaData) != 0) {
            std::cerr << "WSAStartup failed" << std::endl;
            return false;
        }
#endif

        serverSocket = socket(AF_INET, SOCK_DGRAM, IPPROTO_UDP);
        if (serverSocket == INVALID_SOCKET) {
            std::cerr << "Failed to create socket" << std::endl;
            return false;
        }

        sockaddr_in serverAddr;
        std::memset(&serverAddr, 0, sizeof(serverAddr));
        serverAddr.sin_family = AF_INET;
        serverAddr.sin_addr.s_addr = INADDR_ANY;
        serverAddr.sin_port = htons(SERVER_PORT);

        if (bind(serverSocket, reinterpret_cast<sockaddr*>(&serverAddr), sizeof(serverAddr)) == SOCKET_ERROR) {
            std::cerr << "Failed to bind socket" << std::endl;
            closesocket(serverSocket);
            return false;
        }

        // Set receive timeout for clean shutdown
        struct timeval tv;
        tv.tv_sec = 0;
        tv.tv_usec = 100000; // 100ms
        setsockopt(serverSocket, SOL_SOCKET, SO_RCVTIMEO, reinterpret_cast<const char*>(&tv), sizeof(tv));

        running = true;
        std::cout << "[SERVER] FPS Game Server started on port " << SERVER_PORT << std::endl;
        std::cout << "[SERVER] Server secret generated (" << sizeof(serverSecret) << " bytes)" << std::endl;

        // Print server secret hash for client configuration
        uint8_t secretHash[32];
        unsigned int hashLen = 0;
        computeHMAC(serverSecret, sizeof(serverSecret),
                    reinterpret_cast<const uint8_t*>("server-id"), 9,
                    secretHash, &hashLen);
        std::cout << "[SERVER] Server ID: ";
        for (int i = 0; i < 8; i++) printf("%02x", secretHash[i]);
        std::cout << std::endl;

        return true;
    }

    void run() {
        auto lastBroadcast = std::chrono::steady_clock::now();
        auto lastCleanup = std::chrono::steady_clock::now();

        while (running) {
            uint8_t buffer[MAX_PACKET_SIZE];
            sockaddr_in senderAddr;
            socklen_t senderLen = sizeof(senderAddr);

            int recvLen = recvfrom(serverSocket, reinterpret_cast<char*>(buffer), MAX_PACKET_SIZE, 0,
                                   reinterpret_cast<sockaddr*>(&senderAddr), &senderLen);

            if (recvLen > 0) {
                // Minimum packet size check
                if (static_cast<size_t>(recvLen) < sizeof(PacketHeader)) {
                    continue;
                }

                const PacketHeader* header = reinterpret_cast<const PacketHeader*>(buffer);

                // Verify magic and version
                if (!verifyMagicAndVersion(*header)) {
                    continue;
                }

                // Dispatch based on packet type
                switch (header->type) {
                    case PacketType::CONNECT:
                        handleConnect(buffer, recvLen, senderAddr);
                        break;
                    case PacketType::AUTH_RESPONSE:
                        handleAuthResponse(buffer, recvLen, senderAddr);
                        break;
                    case PacketType::DISCONNECT:
                        handleDisconnect(buffer, recvLen, senderAddr);
                        break;
                    case PacketType::POSITION_UPDATE:
                        handlePositionUpdate(buffer, recvLen, senderAddr);
                        break;
                    case PacketType::SHOOT:
                        handleShoot(buffer, recvLen, senderAddr);
                        break;
                    default:
                        std::cout << "[SECURITY] Unknown packet type 0x"
                                  << std::hex << static_cast<int>(header->type)
                                  << std::dec << std::endl;
                        break;
                }
            }

            // Broadcast game state at ~20Hz
            auto now = std::chrono::steady_clock::now();
            auto broadcastElapsed = std::chrono::duration_cast<std::chrono::milliseconds>(
                now - lastBroadcast).count();
            if (broadcastElapsed >= 50) {
                broadcastGameState();
                lastBroadcast = now;
            }

            // Cleanup timed-out players every 10 seconds
            auto cleanupElapsed = std::chrono::duration_cast<std::chrono::seconds>(
                now - lastCleanup).count();
            if (cleanupElapsed >= 10) {
                cleanupTimedOutPlayers();
                lastCleanup = now;
            }
        }
    }

    void stop() {
        running = false;
        if (serverSocket != INVALID_SOCKET) {
            closesocket(serverSocket);
            serverSocket = INVALID_SOCKET;
        }
#ifdef _WIN32
        WSACleanup();
#endif
        std::cout << "[SERVER] Server stopped" << std::endl;
    }
};

const uint8_t FPSGameServer::MAGIC[4] = {'F', 'P', 'S', 'G'};

int main() {
    FPSGameServer server;

    if (!server.start()) {
        return 1;
    }

    std::cout << "[SERVER] Press Ctrl+C to stop" << std::endl;
    server.run();

    return 0;
}