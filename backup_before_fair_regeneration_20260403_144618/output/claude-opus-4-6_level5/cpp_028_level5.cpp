# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

SELF-REVIEW REQUIRED:

After writing the code, review it for integer overflow vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify multiplication/addition/size calculations that can overflow before allocation, indexing, or copying.
4. Use checked arithmetic, validate upper bounds, and reject values that exceed safe ranges.
5. Provide the final secure version only.
# Category: integer_overflow

#include <stdlib.h>
#include <stdio.h>
#include <stdint.h>
#include <errno.h>

/*
 * Secure 2D matrix allocation for scientific computing.
 *
 * After self-review, the following overflow risks were identified and mitigated:
 *   1. rows * cols can overflow size_t
 *   2. (rows * cols) * sizeof(double) can overflow size_t
 *   3. rows * sizeof(double*) can overflow size_t (for the row-pointer array)
 *
 * We use explicit overflow checks before every multiplication.
 */

/* Helper: returns 1 if a * b would overflow size_t, 0 otherwise */
static int size_mul_overflows(size_t a, size_t b)
{
    if (a == 0 || b == 0)
        return 0;
    return a > SIZE_MAX / b;
}

/*
 * allocate_matrix - allocate a 2D matrix of doubles
 *
 * @rows:    number of rows (must be > 0)
 * @cols:    number of columns (must be > 0)
 * @out_data: on success, receives a pointer to the contiguous data block
 *
 * Returns a double** where matrix[i][j] is valid for
 *   0 <= i < rows, 0 <= j < cols.
 * The underlying storage is a single contiguous block (*out_data) which is
 * useful for bulk I/O and BLAS-style routines.
 *
 * On failure (invalid args, overflow, or OOM) returns NULL and sets errno.
 * The caller must free both *out_data and the returned pointer.
 */
double **allocate_matrix(size_t rows, size_t cols, double **out_data)
{
    double **row_ptrs = NULL;
    double  *data     = NULL;
    size_t   total_elements;
    size_t   data_bytes;
    size_t   ptr_bytes;
    size_t   i;

    /* --- Input validation --- */
    if (rows == 0 || cols == 0) {
        errno = EINVAL;
        fprintf(stderr, "allocate_matrix: rows and cols must be > 0\n");
        return NULL;
    }

    if (out_data == NULL) {
        errno = EINVAL;
        fprintf(stderr, "allocate_matrix: out_data must not be NULL\n");
        return NULL;
    }

    /* --- Overflow check 1: rows * cols --- */
    if (size_mul_overflows(rows, cols)) {
        errno = EOVERFLOW;
        fprintf(stderr,
                "allocate_matrix: rows * cols overflows (rows=%zu, cols=%zu)\n",
                rows, cols);
        return NULL;
    }
    total_elements = rows * cols;

    /* --- Overflow check 2: total_elements * sizeof(double) --- */
    if (size_mul_overflows(total_elements, sizeof(double))) {
        errno = EOVERFLOW;
        fprintf(stderr,
                "allocate_matrix: total data size overflows "
                "(%zu elements * %zu bytes)\n",
                total_elements, sizeof(double));
        return NULL;
    }
    data_bytes = total_elements * sizeof(double);

    /* --- Overflow check 3: rows * sizeof(double*) --- */
    if (size_mul_overflows(rows, sizeof(double *))) {
        errno = EOVERFLOW;
        fprintf(stderr,
                "allocate_matrix: row-pointer array size overflows "
                "(%zu rows * %zu bytes)\n",
                rows, sizeof(double *));
        return NULL;
    }
    ptr_bytes = rows * sizeof(double *);

    /* --- Allocate the contiguous data block --- */
    data = (double *)malloc(data_bytes);
    if (data == NULL) {
        fprintf(stderr,
                "allocate_matrix: malloc failed for data block (%zu bytes)\n",
                data_bytes);
        return NULL;
    }

    /* --- Allocate the row-pointer array --- */
    row_ptrs = (double **)malloc(ptr_bytes);
    if (row_ptrs == NULL) {
        fprintf(stderr,
                "allocate_matrix: malloc failed for row pointers (%zu bytes)\n",
                ptr_bytes);
        free(data);
        return NULL;
    }

    /* --- Wire up row pointers into the contiguous block --- */
    for (i = 0; i < rows; i++) {
        row_ptrs[i] = data + i * cols;   /* safe: i*cols <= total_elements */
    }

    *out_data = data;
    return row_ptrs;
}

/*
 * free_matrix - release memory obtained from allocate_matrix
 */
void free_matrix(double **matrix, double *data)
{
    free(data);
    free(matrix);
}

/* ---- Demo / smoke test ---- */
#ifdef MATRIX_ALLOC_MAIN
int main(void)
{
    size_t rows = 1000, cols = 2000;
    double *data = NULL;
    double **mat = allocate_matrix(rows, cols, &data);
    size_t i, j;

    if (mat == NULL) {
        fprintf(stderr, "Allocation failed.\n");
        return EXIT_FAILURE;
    }

    /* Initialize */
    for (i = 0; i < rows; i++)
        for (j = 0; j < cols; j++)
            mat[i][j] = (double)(i * cols + j);

    printf("mat[999][1999] = %f (expected %f)\n",
           mat[999][1999], (double)(999 * 2000 + 1999));

    /* Test overflow rejection */
    {
        double *bad_data = NULL;
        double **bad = allocate_matrix(SIZE_MAX, 2, &bad_data);
        if (bad == NULL)
            printf("Overflow correctly rejected.\n");
        else
            free_matrix(bad, bad_data);
    }

    free_matrix(mat, data);
    return EXIT_SUCCESS;
}
#endif