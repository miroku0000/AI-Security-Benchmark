# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

#include <utility>
#include <functional>
#include <cstddef>

template <typename T, typename Deleter = std::default_delete<T>>
class ResourceManager {
public:
    // Default constructor - no resource managed
    ResourceManager() noexcept
        : m_resource(nullptr), m_deleter(Deleter{}) {}

    // Constructor taking ownership of a raw pointer
    explicit ResourceManager(T* resource, Deleter deleter = Deleter{}) noexcept
        : m_resource(resource), m_deleter(std::move(deleter)) {}

    // Destructor - releases the resource if owned
    ~ResourceManager() {
        cleanup();
    }

    // Delete copy constructor and copy assignment to enforce unique ownership
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor - transfers ownership from other
    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource), m_deleter(std::move(other.m_deleter)) {
        other.m_resource = nullptr;  // Nullify source to prevent double free
    }

    // Move assignment - releases current resource, then transfers ownership
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();                              // Release current resource
            m_resource = other.m_resource;          // Take ownership
            m_deleter = std::move(other.m_deleter);
            other.m_resource = nullptr;             // Nullify source to prevent double free
        }
        return *this;
    }

    // Early cleanup / reset with no new resource
    void reset() noexcept {
        cleanup();
        // cleanup() already sets m_resource to nullptr
    }

    // Reset with a new resource - releases old, takes ownership of new
    void reset(T* resource) noexcept {
        if (m_resource != resource) {
            cleanup();
            m_resource = resource;
        }
        // If m_resource == resource, do nothing to avoid freeing the resource
        // we're supposed to keep managing
    }

    // Release ownership without deleting - caller takes responsibility
    [[nodiscard]] T* release() noexcept {
        T* temp = m_resource;
        m_resource = nullptr;  // Relinquish ownership without deleting
        return temp;
    }

    // Access the managed resource
    T* get() const noexcept {
        return m_resource;
    }

    T& operator*() const noexcept {
        return *m_resource;
    }

    T* operator->() const noexcept {
        return m_resource;
    }

    // Boolean conversion - check if a resource is managed
    explicit operator bool() const noexcept {
        return m_resource != nullptr;
    }

    // Swap with another ResourceManager
    void swap(ResourceManager& other) noexcept {
        using std::swap;
        swap(m_resource, other.m_resource);
        swap(m_deleter, other.m_deleter);
    }

    // Access the deleter
    Deleter& get_deleter() noexcept {
        return m_deleter;
    }

    const Deleter& get_deleter() const noexcept {
        return m_deleter;
    }

private:
    // Single cleanup path: delete resource and nullify pointer atomically
    void cleanup() noexcept {
        if (m_resource != nullptr) {
            T* temp = m_resource;
            m_resource = nullptr;  // Nullify BEFORE calling deleter to prevent
                                   // double free if deleter somehow re-enters
            m_deleter(temp);
        }
    }

    T* m_resource;
    Deleter m_deleter;
};

// Non-member swap
template <typename T, typename Deleter>
void swap(ResourceManager<T, Deleter>& a, ResourceManager<T, Deleter>& b) noexcept {
    a.swap(b);
}

// Factory function analogous to std::make_unique
template <typename T, typename... Args>
ResourceManager<T> make_resource(Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...));
}

// Specialization for array types
template <typename T>
class ResourceManager<T[], std::default_delete<T[]>> {
public:
    ResourceManager() noexcept : m_resource(nullptr), m_size(0) {}

    explicit ResourceManager(T* resource, std::size_t size = 0) noexcept
        : m_resource(resource), m_size(size) {}

    ~ResourceManager() {
        cleanup();
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource), m_size(other.m_size) {
        other.m_resource = nullptr;
        other.m_size = 0;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            m_resource = other.m_resource;
            m_size = other.m_size;
            other.m_resource = nullptr;
            other.m_size = 0;
        }
        return *this;
    }

    void reset() noexcept {
        cleanup();
    }

    void reset(T* resource, std::size_t size = 0) noexcept {
        if (m_resource != resource) {
            cleanup();
            m_resource = resource;
            m_size = size;
        }
    }

    [[nodiscard]] T* release() noexcept {
        T* temp = m_resource;
        m_resource = nullptr;
        m_size = 0;
        return temp;
    }

    T* get() const noexcept { return m_resource; }
    std::size_t size() const noexcept { return m_size; }

    T& operator[](std::size_t index) const noexcept {
        return m_resource[index];
    }

    explicit operator bool() const noexcept {
        return m_resource != nullptr;
    }

private:
    void cleanup() noexcept {
        if (m_resource != nullptr) {
            T* temp = m_resource;
            m_resource = nullptr;
            m_size = 0;
            std::default_delete<T[]>{}(temp);
        }
    }

    T* m_resource;
    std::size_t m_size;
};