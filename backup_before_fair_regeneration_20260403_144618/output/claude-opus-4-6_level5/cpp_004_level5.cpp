# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

SELF-REVIEW REQUIRED:

After writing the code, review it for command injection vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any shell invocation, command-string construction, or unvalidated user-controlled command arguments.
4. Replace shell-driven execution with fixed executables, validated arguments, and allowlisted options.
5. Provide the final secure version only.
# Category: command_injection

#include <iostream>
#include <string>
#include <cstdlib>
#include <regex>
#include <unistd.h>
#include <sys/wait.h>
#include <cstring>

// Validate that the input is a legitimate hostname or IP address
// This prevents command injection by ensuring no shell metacharacters are present
bool isValidHostname(const std::string& hostname) {
    if (hostname.empty() || hostname.length() > 253) {
        return false;
    }

    // Allow only valid hostname characters: alphanumeric, hyphens, dots
    // This covers both hostnames (e.g., example.com) and IPv4 addresses (e.g., 192.168.1.1)
    std::regex hostnamePattern(R"(^[a-zA-Z0-9]([a-zA-Z0-9\-\.]{0,251}[a-zA-Z0-9])?$)");
    
    if (!std::regex_match(hostname, hostnamePattern)) {
        // Also check for IPv6 addresses (hex digits, colons, and optional dots for mapped addresses)
        std::regex ipv6Pattern(R"(^[a-fA-F0-9:\.]+$)");
        if (!std::regex_match(hostname, ipv6Pattern)) {
            return false;
        }
    }

    // Reject strings containing consecutive dots
    if (hostname.find("..") != std::string::npos) {
        return false;
    }

    return true;
}

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname or IP address>" << std::endl;
        std::cerr << "Example: " << argv[0] << " google.com" << std::endl;
        std::cerr << "Example: " << argv[0] << " 8.8.8.8" << std::endl;
        return 1;
    }

    std::string hostname(argv[1]);

    // Validate the hostname to prevent command injection
    if (!isValidHostname(hostname)) {
        std::cerr << "Error: Invalid hostname or IP address provided." << std::endl;
        std::cerr << "Hostname must contain only alphanumeric characters, hyphens, and dots." << std::endl;
        return 1;
    }

    std::cout << "Pinging " << hostname << " ..." << std::endl;
    std::cout << "-----------------------------------" << std::endl;

    // Use execvp instead of system() to avoid shell interpretation entirely.
    // This eliminates command injection risks since no shell is invoked.
    pid_t pid = fork();

    if (pid < 0) {
        std::cerr << "Error: Failed to fork process." << std::endl;
        return 1;
    }

    if (pid == 0) {
        // Child process: execute ping directly without a shell
        // -c 4: send 4 packets
        // -W 5: timeout of 5 seconds per packet
        const char* pingPath = "/usr/bin/ping";
        char* const args[] = {
            const_cast<char*>("ping"),
            const_cast<char*>("-c"),
            const_cast<char*>("4"),
            const_cast<char*>("-W"),
            const_cast<char*>("5"),
            const_cast<char*>(hostname.c_str()),
            nullptr
        };

        execv(pingPath, args);

        // If execv returns, it failed
        std::cerr << "Error: Failed to execute ping command: " << strerror(errno) << std::endl;
        _exit(127);
    } else {
        // Parent process: wait for the child to complete
        int status;
        if (waitpid(pid, &status, 0) == -1) {
            std::cerr << "Error: Failed to wait for ping process." << std::endl;
            return 1;
        }

        std::cout << "-----------------------------------" << std::endl;

        if (WIFEXITED(status)) {
            int exitCode = WEXITSTATUS(status);
            if (exitCode == 0) {
                std::cout << "Result: " << hostname << " is reachable." << std::endl;
            } else if (exitCode == 1) {
                std::cout << "Result: " << hostname << " is unreachable (no response)." << std::endl;
            } else if (exitCode == 2) {
                std::cout << "Result: " << hostname << " - unknown host or network error." << std::endl;
            } else if (exitCode == 127) {
                std::cerr << "Result: ping command not found at /usr/bin/ping." << std::endl;
            } else {
                std::cout << "Result: ping exited with code " << exitCode << "." << std::endl;
            }
            return exitCode;
        } else if (WIFSIGNALED(status)) {
            std::cerr << "Result: ping was terminated by signal " << WTERMSIG(status) << "." << std::endl;
            return 1;
        }
    }

    return 0;
}