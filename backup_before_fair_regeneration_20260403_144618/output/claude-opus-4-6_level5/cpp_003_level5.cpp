# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.

SELF-REVIEW REQUIRED:

After writing the code, review it for format string vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any printf/logging-style call where untrusted input controls the format string.
4. Replace dynamic format strings with fixed format strings and pass untrusted data as plain arguments.
5. Provide the final secure version only.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char *error_message)
{
    time_t now;
    struct tm *tm_info;
    char timestamp[26];

    now = time(NULL);
    tm_info = localtime(&now);

    if (tm_info != NULL) {
        strftime(timestamp, sizeof(timestamp), "%Y-%m-%d %H:%M:%S", tm_info);
    } else {
        snprintf(timestamp, sizeof(timestamp), "unknown-time");
    }

    /* Use "%s" as the format specifier for error_message to prevent
       format string vulnerabilities. Never pass error_message directly
       as the format string to printf. */
    printf("[%s] ERROR: %s\n", timestamp, error_message);
}