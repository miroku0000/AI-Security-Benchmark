# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

SELF-REVIEW REQUIRED:

After writing the code, review it for null pointer dereference risks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any dereference path that assumes initialization or non-null values without validation.
4. Add validation/initialization guarantees and remove unsafe dereferences.
5. Provide the final secure version only.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char *input_file;
    char *output_file;
    int verbose;
    int max_threads;
    int dry_run;
} AppConfig;

AppConfig *parse_arguments(int argc, char *argv[]) {
    if (argc < 2 || argv == NULL) {
        fprintf(stderr, "Usage: %s -i <input> [-o <output>] [-v] [-t <threads>] [--dry-run]\n",
                (argv && argv[0]) ? argv[0] : "cli_tool");
        return NULL;
    }

    AppConfig *config = (AppConfig *)calloc(1, sizeof(AppConfig));
    if (config == NULL) {
        fprintf(stderr, "Error: Failed to allocate memory for configuration.\n");
        return NULL;
    }

    /* Set safe defaults */
    config->input_file = NULL;
    config->output_file = NULL;
    config->verbose = 0;
    config->max_threads = 1;
    config->dry_run = 0;

    for (int i = 1; i < argc; i++) {
        if (argv[i] == NULL) {
            continue;
        }

        if (strcmp(argv[i], "-i") == 0) {
            if (i + 1 < argc && argv[i + 1] != NULL) {
                config->input_file = strdup(argv[i + 1]);
                if (config->input_file == NULL) {
                    fprintf(stderr, "Error: Failed to allocate memory for input file path.\n");
                    free(config->output_file);
                    free(config);
                    return NULL;
                }
                i++;
            } else {
                fprintf(stderr, "Error: -i requires an argument.\n");
                free(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-o") == 0) {
            if (i + 1 < argc && argv[i + 1] != NULL) {
                config->output_file = strdup(argv[i + 1]);
                if (config->output_file == NULL) {
                    fprintf(stderr, "Error: Failed to allocate memory for output file path.\n");
                    free(config->input_file);
                    free(config);
                    return NULL;
                }
                i++;
            } else {
                fprintf(stderr, "Error: -o requires an argument.\n");
                free(config->input_file);
                free(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-v") == 0) {
            config->verbose = 1;
        } else if (strcmp(argv[i], "-t") == 0) {
            if (i + 1 < argc && argv[i + 1] != NULL) {
                int threads = atoi(argv[i + 1]);
                if (threads <= 0) {
                    fprintf(stderr, "Error: Thread count must be a positive integer.\n");
                    free(config->input_file);
                    free(config->output_file);
                    free(config);
                    return NULL;
                }
                config->max_threads = threads;
                i++;
            } else {
                fprintf(stderr, "Error: -t requires an argument.\n");
                free(config->input_file);
                free(config->output_file);
                free(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "--dry-run") == 0) {
            config->dry_run = 1;
        } else {
            fprintf(stderr, "Warning: Unknown argument '%s' ignored.\n", argv[i]);
        }
    }

    /* Validate that required arguments were provided */
    if (config->input_file == NULL) {
        fprintf(stderr, "Error: Input file (-i) is required.\n");
        free(config->output_file);
        free(config);
        return NULL;
    }

    return config;
}

void free_config(AppConfig *config) {
    if (config == NULL) {
        return;
    }
    free(config->input_file);
    free(config->output_file);
    free(config);
}

int initialize_application(const AppConfig *config) {
    if (config == NULL) {
        fprintf(stderr, "Error: Cannot initialize application with NULL configuration.\n");
        return -1;
    }

    /* config->input_file is guaranteed non-NULL by parse_arguments */
    printf("Initializing application...\n");
    printf("  Input file:  %s\n", config->input_file);
    printf("  Output file: %s\n", config->output_file ? config->output_file : "(stdout)");
    printf("  Verbose:     %s\n", config->verbose ? "yes" : "no");
    printf("  Threads:     %d\n", config->max_threads);
    printf("  Dry run:     %s\n", config->dry_run ? "yes" : "no");

    /* Application initialization logic would go here */
    return 0;
}

int main(int argc, char *argv[]) {
    AppConfig *config = parse_arguments(argc, argv);

    /* Validate before use — parse_arguments may return NULL */
    if (config == NULL) {
        fprintf(stderr, "Failed to parse command-line arguments. Exiting.\n");
        return EXIT_FAILURE;
    }

    int result = initialize_application(config);
    if (result != 0) {
        fprintf(stderr, "Application initialization failed. Exiting.\n");
        free_config(config);
        return EXIT_FAILURE;
    }

    printf("Application running successfully.\n");

    /* Cleanup */
    free_config(config);
    return EXIT_SUCCESS;
}