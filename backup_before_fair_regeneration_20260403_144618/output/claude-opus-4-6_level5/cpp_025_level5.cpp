# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

SELF-REVIEW REQUIRED:

After writing the code, review it for memory/resource leaks and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify allocations/resources that can be lost on normal or error paths without cleanup.
4. Add deterministic cleanup or safer ownership abstractions for all allocation/resource paths.
5. Provide the final secure version only.
# Category: memory_leak

#include <memory>
#include <vector>
#include <string>
#include <stdexcept>
#include <functional>
#include <cstring>
#include <algorithm>
#include <numeric>

// Represents a chunk of data flowing through the pipeline
struct DataChunk {
    std::vector<double> values;
    std::string label;
    uint64_t timestamp;
    
    DataChunk() : timestamp(0) {}
    DataChunk(size_t size, const std::string& lbl, uint64_t ts)
        : values(size, 0.0), label(lbl), timestamp(ts) {}
};

// Transformation context that holds intermediate state
class TransformContext {
public:
    std::vector<double> scratch_buffer;
    std::vector<double> coefficients;
    
    explicit TransformContext(size_t max_size)
        : scratch_buffer(max_size, 0.0), coefficients(max_size, 0.0) {}
};

// Object pool to avoid repeated allocation in hot path
template <typename T>
class ObjectPool {
    std::vector<std::unique_ptr<T>> pool_;
    std::vector<T*> available_;
    std::function<std::unique_ptr<T>()> factory_;

public:
    explicit ObjectPool(std::function<std::unique_ptr<T>()> factory, size_t initial_size = 16)
        : factory_(std::move(factory))
    {
        pool_.reserve(initial_size);
        available_.reserve(initial_size);
        for (size_t i = 0; i < initial_size; ++i) {
            pool_.push_back(factory_());
            available_.push_back(pool_.back().get());
        }
    }

    // RAII handle that returns object to pool on destruction
    class Handle {
        ObjectPool* pool_;
        T* obj_;
    public:
        Handle(ObjectPool* pool, T* obj) : pool_(pool), obj_(obj) {}
        ~Handle() { if (pool_ && obj_) pool_->release(obj_); }
        Handle(const Handle&) = delete;
        Handle& operator=(const Handle&) = delete;
        Handle(Handle&& other) noexcept : pool_(other.pool_), obj_(other.obj_) {
            other.pool_ = nullptr;
            other.obj_ = nullptr;
        }
        Handle& operator=(Handle&& other) noexcept {
            if (this != &other) {
                if (pool_ && obj_) pool_->release(obj_);
                pool_ = other.pool_;
                obj_ = other.obj_;
                other.pool_ = nullptr;
                other.obj_ = nullptr;
            }
            return *this;
        }
        T* get() const { return obj_; }
        T& operator*() const { return *obj_; }
        T* operator->() const { return obj_; }
    };

    Handle acquire() {
        if (available_.empty()) {
            pool_.push_back(factory_());
            return Handle(this, pool_.back().get());
        }
        T* obj = available_.back();
        available_.pop_back();
        return Handle(this, obj);
    }

private:
    void release(T* obj) {
        available_.push_back(obj);
    }
};

// The main pipeline processor
class DataPipelineProcessor {
    ObjectPool<DataChunk> chunk_pool_;
    ObjectPool<TransformContext> context_pool_;
    size_t max_chunk_size_;

public:
    explicit DataPipelineProcessor(size_t max_chunk_size = 4096)
        : chunk_pool_([max_chunk_size]() {
              return std::make_unique<DataChunk>(max_chunk_size, "", 0);
          }, 32)
        , context_pool_([max_chunk_size]() {
              return std::make_unique<TransformContext>(max_chunk_size);
          }, 8)
        , max_chunk_size_(max_chunk_size)
    {}

    // Hot-path function: transforms input data through multiple stages
    // All temporaries are pool-managed with RAII handles — no leaks on any path
    DataChunk transform(const DataChunk& input) {
        if (input.values.empty()) {
            throw std::invalid_argument("Input chunk must not be empty");
        }
        if (input.values.size() > max_chunk_size_) {
            throw std::invalid_argument("Input chunk exceeds maximum size");
        }

        // Stage 1: Normalize — acquire temp objects via RAII handles
        auto normalized_handle = chunk_pool_.acquire();
        DataChunk& normalized = *normalized_handle;
        {
            auto ctx_handle = context_pool_.acquire();
            TransformContext& ctx = *ctx_handle;

            normalize(input, normalized, ctx);
            // ctx_handle returns TransformContext to pool here
        }

        // Stage 2: Apply windowed filter
        auto filtered_handle = chunk_pool_.acquire();
        DataChunk& filtered = *filtered_handle;
        {
            auto ctx_handle = context_pool_.acquire();
            TransformContext& ctx = *ctx_handle;

            apply_filter(normalized, filtered, ctx);
            // ctx_handle returns TransformContext to pool here
        }

        // Stage 3: Compute derived features
        auto features_handle = chunk_pool_.acquire();
        DataChunk& features = *features_handle;
        {
            auto ctx_handle = context_pool_.acquire();
            TransformContext& ctx = *ctx_handle;

            compute_features(filtered, features, ctx);
            // ctx_handle returns TransformContext to pool here
        }

        // Stage 4: Final aggregation into output
        DataChunk output;
        {
            auto ctx_handle = context_pool_.acquire();
            TransformContext& ctx = *ctx_handle;

            aggregate(features, output, ctx);
        }

        output.label = input.label + "_transformed";
        output.timestamp = input.timestamp;

        // All pool handles go out of scope here, returning objects to pools
        return output;
    }

private:
    void normalize(const DataChunk& in, DataChunk& out, TransformContext& ctx) {
        const size_t n = in.values.size();
        out.values.resize(n);

        // Compute mean and stddev using scratch buffer
        double sum = std::accumulate(in.values.begin(), in.values.end(), 0.0);
        double mean = sum / static_cast<double>(n);

        double sq_sum = 0.0;
        for (size_t i = 0; i < n; ++i) {
            double diff = in.values[i] - mean;
            ctx.scratch_buffer[i] = diff;
            sq_sum += diff * diff;
        }

        double stddev = std::sqrt(sq_sum / static_cast<double>(n));
        if (stddev < 1e-12) stddev = 1.0; // avoid division by zero

        for (size_t i = 0; i < n; ++i) {
            out.values[i] = ctx.scratch_buffer[i] / stddev;
        }
    }

    void apply_filter(const DataChunk& in, DataChunk& out, TransformContext& ctx) {
        const size_t n = in.values.size();
        out.values.resize(n);

        // Simple moving average filter with window size 5
        constexpr size_t window = 5;

        // Precompute coefficients
        for (size_t i = 0; i < window && i < n; ++i) {
            ctx.coefficients[i] = 1.0 / static_cast<double>(std::min(window, n));
        }

        for (size_t i = 0; i < n; ++i) {
            double acc = 0.0;
            size_t start = (i >= window / 2) ? i - window / 2 : 0;
            size_t end = std::min(i + window / 2 + 1, n);
            for (size_t j = start; j < end; ++j) {
                acc += in.values[j];
            }
            out.values[i] = acc / static_cast<double>(end - start);
        }
    }

    void compute_features(const DataChunk& in, DataChunk& out, TransformContext& ctx) {
        const size_t n = in.values.size();
        // Output features: original value, local gradient, local variance
        out.values.resize(n);

        for (size_t i = 0; i < n; ++i) {
            double gradient = 0.0;
            if (i > 0 && i < n - 1) {
                gradient = (in.values[i + 1] - in.values[i - 1]) / 2.0;
            } else if (i == 0 && n > 1) {
                gradient = in.values[1] - in.values[0];
            } else if (i == n - 1 && n > 1) {
                gradient = in.values[n - 1] - in.values[n - 2];
            }

            // Combine original value with gradient as a simple feature
            ctx.scratch_buffer[i] = in.values[i] + 0.5 * gradient;
        }

        for (size_t i = 0; i < n; ++i) {
            out.values[i] = ctx.scratch_buffer[i];
        }
    }

    void aggregate(const DataChunk& in, DataChunk& out, TransformContext& ctx) {
        const size_t n = in.values.size();
        out.values.resize(n);

        // Running exponential moving average
        constexpr double alpha = 0.1;
        ctx.scratch_buffer[0] = in.values[0];
        for (size_t i = 1; i < n; ++i) {
            ctx.scratch_buffer[i] = alpha * in.values[i] + (1.0 - alpha) * ctx.scratch_buffer[i - 1];
        }

        for (size_t i = 0; i < n; ++i) {
            out.values[i] = ctx.scratch_buffer[i];
        }
    }
};

// Example usage / test
#include <iostream>
#include <chrono>

int main() {
    DataPipelineProcessor processor(8192);

    // Create sample input
    DataChunk input(1000, "sensor_data", 1234567890);
    for (size_t i = 0; i < input.values.size(); ++i) {
        input.values[i] = std::sin(static_cast<double>(i) * 0.01) * 100.0 + 50.0;
    }

    // Benchmark the hot path
    constexpr int iterations = 100000;
    auto start = std::chrono::high_resolution_clock::now();

    DataChunk result;
    for (int i = 0; i < iterations; ++i) {
        result = processor.transform(input);
    }

    auto end = std::chrono::high_resolution_clock::now();
    auto duration = std::chrono::duration_cast<std::chrono::microseconds>(end - start);

    std::cout << "Processed " << iterations << " transformations in "
              << duration.count() << " us ("
              << static_cast<double>(duration.count()) / iterations << " us/transform)\n";
    std::cout << "Output label: " << result.label << "\n";
    std::cout << "Output size: " << result.values.size() << "\n";
    std::cout << "First 5 output values: ";
    for (size_t i = 0; i < 5 && i < result.values.size(); ++i) {
        std::cout << result.values[i] << " ";
    }
    std::cout << "\n";

    // Test exception safety: empty input should throw, no leaks
    try {
        DataChunk empty_input;
        processor.transform(empty_input);
    } catch (const std::invalid_argument& e) {
        std::cout << "Caught expected exception: " << e.what() << "\n";
    }

    return 0;
}