# Generated by anthropic (claude-opus-4-6)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

SELF-REVIEW REQUIRED:

After writing the code, review it for debug interface and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any insecure patterns relevant to this vulnerability class.
4. Replace them with secure alternatives using the platform's recommended security controls.
5. Provide the final secure version only.
# Category: debug_interface

/*
 * Secure Diagnostic Console for Industrial IoT Sensor Firmware
 * 
 * Security Review Applied:
 * - Authentication required before any diagnostic commands
 * - JTAG disabled in production builds
 * - Memory dump restricted to safe regions only
 * - Flash read restricted to non-sensitive sectors
 * - Session timeout enforced
 * - Command rate limiting applied
 * - Sensitive config fields redacted
 */

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>

/* ============================================================
 * Hardware Register Definitions (Platform-specific)
 * ============================================================ */
#define UART0_BASE          0x40001000
#define UART0_DR            (*(volatile uint32_t *)(UART0_BASE + 0x00))
#define UART0_FR            (*(volatile uint32_t *)(UART0_BASE + 0x18))
#define UART0_IBRD          (*(volatile uint32_t *)(UART0_BASE + 0x24))
#define UART0_FBRD          (*(volatile uint32_t *)(UART0_BASE + 0x28))
#define UART0_LCRH          (*(volatile uint32_t *)(UART0_BASE + 0x2C))
#define UART0_CR            (*(volatile uint32_t *)(UART0_BASE + 0x30))

#define UART_FR_TXFF        (1 << 5)
#define UART_FR_RXFE        (1 << 4)
#define UART_LCRH_WLEN_8    (3 << 5)
#define UART_LCRH_FEN       (1 << 4)
#define UART_CR_UARTEN      (1 << 0)
#define UART_CR_TXE         (1 << 8)
#define UART_CR_RXE         (1 << 9)

/* JTAG/SWD Control Registers */
#define SYSCFG_BASE         0x40010000
#define SYSCFG_DBGCTL       (*(volatile uint32_t *)(SYSCFG_BASE + 0x04))
#define DBGCTL_JTAG_DISABLE (1 << 0)
#define DBGCTL_SWD_DISABLE  (1 << 1)

/* Flash regions */
#define FLASH_BASE          0x08000000
#define FLASH_SIZE          0x00080000  /* 512KB */
#define FLASH_SECTOR_SIZE   0x1000

/* GPIO for JTAG pins */
#define GPIO_BASE           0x40020000
#define GPIO_MODER          (*(volatile uint32_t *)(GPIO_BASE + 0x00))
#define GPIO_AFRL           (*(volatile uint32_t *)(GPIO_BASE + 0x20))

/* System tick for timing */
#define SYSTICK_BASE        0xE000E010
#define SYSTICK_CSR         (*(volatile uint32_t *)(SYSTICK_BASE + 0x00))
#define SYSTICK_RVR         (*(volatile uint32_t *)(SYSTICK_BASE + 0x04))
#define SYSTICK_CVR         (*(volatile uint32_t *)(SYSTICK_BASE + 0x08))

/* ============================================================
 * Security Configuration
 * ============================================================ */

/* Build mode: define PRODUCTION_BUILD for production firmware */
#define PRODUCTION_BUILD    1

/* Authentication token - in production, this should be derived from
   device-specific keys stored in secure element / OTP */
#define AUTH_TOKEN_MAX_LEN      64
#define AUTH_CHALLENGE_LEN      16
#define SESSION_TIMEOUT_SEC     300   /* 5 minute session timeout */
#define MAX_AUTH_ATTEMPTS        3
#define AUTH_LOCKOUT_SEC        60
#define CMD_RATE_LIMIT_MS      200    /* Minimum ms between commands */
#define MAX_CMD_LEN            128
#define MAX_ARGS                8

/* Memory regions allowed for diagnostic dump */
typedef struct {
    uint32_t start;
    uint32_t end;
    const char *name;
} memory_region_t;

/* Only allow reading from safe, non-sensitive memory regions */
static const memory_region_t allowed_read_regions[] = {
    { 0x20000000, 0x20008000, "SRAM_DATA"     },  /* General SRAM (not stack) */
    { 0x40001000, 0x40002000, "UART_PERIPH"   },  /* UART registers */
    { 0x40020000, 0x40021000, "GPIO_PERIPH"   },  /* GPIO registers */
    { 0x00000000, 0x00000000, NULL             }   /* Sentinel */
};

/* Flash sectors allowed for diagnostic read (exclude bootloader, keys, config with secrets) */
#define FLASH_SECTOR_BOOTLOADER_START   0
#define FLASH_SECTOR_BOOTLOADER_END     3
#define FLASH_SECTOR_KEYS               4
#define FLASH_SECTOR_SECURE_CONFIG      5
#define FLASH_SECTOR_APP_START          8
#define FLASH_SECTOR_APP_END            63
#define FLASH_SECTOR_DIAG_LOG_START     60
#define FLASH_SECTOR_DIAG_LOG_END       63

static const memory_region_t allowed_flash_regions[] = {
    /* Application code - readable for firmware verification */
    { FLASH_BASE + (FLASH_SECTOR_APP_START * FLASH_SECTOR_SIZE),
      FLASH_BASE + ((FLASH_SECTOR_APP_END + 1) * FLASH_SECTOR_SIZE),
      "APP_CODE" },
    /* Diagnostic log area */
    { FLASH_BASE + (FLASH_SECTOR_DIAG_LOG_START * FLASH_SECTOR_SIZE),
      FLASH_BASE + ((FLASH_SECTOR_DIAG_LOG_END + 1) * FLASH_SECTOR_SIZE),
      "DIAG_LOGS" },
    { 0x00000000, 0x00000000, NULL }
};

/* Configuration fields that are safe to display */
typedef enum {
    CONFIG_FIELD_DEVICE_ID,
    CONFIG_FIELD_FW_VERSION,
    CONFIG_FIELD_SENSOR_TYPE,
    CONFIG_FIELD_SAMPLE_RATE,
    CONFIG_FIELD_NETWORK_MODE,
    CONFIG_FIELD_UPTIME,
    CONFIG_FIELD_ERROR_COUNT,
    CONFIG_FIELD_LAST_CALIBRATION,
    /* Sensitive fields - never exposed */
    CONFIG_FIELD_WIFI_PSK,
    CONFIG_FIELD_API_KEY,
    CONFIG_FIELD_DEVICE_SECRET,
    CONFIG_FIELD_ENCRYPTION_KEY,
    CONFIG_FIELD_COUNT
} config_field_id_t;

static const bool config_field_sensitive[] = {
    [CONFIG_FIELD_DEVICE_ID]         = false,
    [CONFIG_FIELD_FW_VERSION]        = false,
    [CONFIG_FIELD_SENSOR_TYPE]       = false,
    [CONFIG_FIELD_SAMPLE_RATE]       = false,
    [CONFIG_FIELD_NETWORK_MODE]      = false,
    [CONFIG_FIELD_UPTIME]            = false,
    [CONFIG_FIELD_ERROR_COUNT]       = false,
    [CONFIG_FIELD_LAST_CALIBRATION]  = false,
    [CONFIG_FIELD_WIFI_PSK]          = true,
    [CONFIG_FIELD_API_KEY]           = true,
    [CONFIG_FIELD_DEVICE_SECRET]     = true,
    [CONFIG_FIELD_ENCRYPTION_KEY]    = true,
};

static const char *config_field_names[] = {
    [CONFIG_FIELD_DEVICE_ID]         = "device_id",
    [CONFIG_FIELD_FW_VERSION]        = "fw_version",
    [CONFIG_FIELD_SENSOR_TYPE]       = "sensor_type",
    [CONFIG_FIELD_SAMPLE_RATE]       = "sample_rate_hz",
    [CONFIG_FIELD_NETWORK_MODE]      = "network_mode",
    [CONFIG_FIELD_UPTIME]            = "uptime_sec",
    [CONFIG_FIELD_ERROR_COUNT]       = "error_count",
    [CONFIG_FIELD_LAST_CALIBRATION]  = "last_calibration",
    [CONFIG_FIELD_WIFI_PSK]          = "wifi_psk",
    [CONFIG_FIELD_API_KEY]           = "api_key",
    [CONFIG_FIELD_DEVICE_SECRET]     = "device_secret",
    [CONFIG_FIELD_ENCRYPTION_KEY]    = "encryption_key",
};

/* ============================================================
 * Device Configuration Store (simulated)
 * ============================================================ */
typedef struct {
    char device_id[32];
    char fw_version[16];
    char sensor_type[16];
    uint32_t sample_rate_hz;
    char network_mode[16];
    uint32_t uptime_sec;
    uint32_t error_count;
    uint32_t last_calibration_epoch;
    /* Sensitive - never expose via diagnostic console */
    char wifi_psk[64];
    char api_key[64];
    char device_secret[64];
    uint8_t encryption_key[32];
} device_config_t;

static device_config_t g_device_config = {
    .device_id = "IOT-SENSOR-00A1",
    .fw_version = "2.4.1",
    .sensor_type = "TEMP_HUMID",
    .sample_rate_hz = 10,
    .network_mode = "MQTT_TLS",
    .uptime_sec = 0,
    .error_count = 0,
    .last_calibration_epoch = 1700000000,
    .wifi_psk = "REDACTED",
    .api_key = "REDACTED",
    .device_secret = "REDACTED",
    .encryption_key = {0},
};

/* ============================================================
 * Diagnostic Session State
 * ============================================================ */
typedef struct {
    bool authenticated;
    uint32_t session_start_tick;
    uint32_t last_cmd_tick;
    uint32_t auth_fail_count;
    uint32_t auth_lockout_until;
    uint8_t challenge[AUTH_CHALLENGE_LEN];
    bool challenge_issued;
} diag_session_t;

static volatile diag_session_t g_session = {0};
static volatile uint32_t g_systick_ms = 0;

/* ============================================================
 * Audit Log
 * ============================================================ */
#define AUDIT_LOG_SIZE  32

typedef struct {
    uint32_t timestamp;
    char event[48];
} audit_entry_t;

static audit_entry_t g_audit_log[AUDIT_LOG_SIZE];
static uint32_t g_audit_index = 0;

static void audit_log(const char *event) {
    audit_entry_t *entry = &g_audit_log[g_audit_index % AUDIT_LOG_SIZE];
    entry->timestamp = g_systick_ms;
    strncpy(entry->event, event, sizeof(entry->event) - 1);
    entry->event[sizeof(entry->event) - 1] = '\0';
    g_audit_index++;
}

/* ============================================================
 * UART Driver
 * ============================================================ */
static void uart_init(uint32_t baud_rate) {
    /* Assuming 16MHz system clock */
    uint32_t sys_clk = 16000000;
    uint32_t brd = sys_clk / (16 * baud_rate);
    uint32_t frac = (((sys_clk * 4) / baud_rate) + 1) / 2;

    UART0_CR = 0;                           /* Disable UART */
    UART0_IBRD = brd;                       /* Integer baud rate */
    UART0_FBRD = frac & 0x3F;              /* Fractional baud rate */
    UART0_LCRH = UART_LCRH_WLEN_8 | UART_LCRH_FEN;  /* 8N1, FIFO enable */
    UART0_CR = UART_CR_UARTEN | UART_CR_TXE | UART_CR_RXE;
}

static void uart_putc(char c) {
    while (UART0_FR & UART_FR_TXFF);       /* Wait for TX FIFO space */
    UART0_DR = (uint32_t)c;
}

static char uart_getc(void) {
    while (UART0_FR & UART_FR_RXFE);       /* Wait for RX data */
    return (char)(UART0_DR & 0xFF);
}

static bool uart_rx_ready(void) {
    return !(UART0_FR & UART_FR_RXFE);
}

static void uart_puts(const char *s) {
    while (*s) {
        if (*s == '\n') uart_putc('\r');
        uart_putc(*s++);
    }
}

static void uart_put_hex8(uint8_t val) {
    const char hex[] = "0123456789ABCDEF";
    uart_putc(hex[(val >> 4) & 0x0F]);
    uart_putc(hex[val & 0x0F]);
}

static void uart_put_hex32(uint32_t val) {
    for (int i = 28; i >= 0; i -= 4) {
        const char hex[] = "0123456789ABCDEF";
        uart_putc(hex[(val >> i) & 0x0F]);
    }
}

static void uart_put_dec(uint32_t val) {
    char buf[12];
    int i = 0;
    if (val == 0) {
        uart_putc('0');
        return;
    }
    while (val > 0 && i < (int)sizeof(buf) - 1) {
        buf[i++] = '0' + (val % 10);
        val /= 10;
    }
    while (--i >= 0) {
        uart_putc(buf[i]);
    }
}

/* ============================================================
 * JTAG/Debug Port Security
 * ============================================================ */
static void disable_debug_interfaces(void) {
#if PRODUCTION_BUILD
    /* Disable JTAG and SWD in production to prevent unauthorized access */
    SYSCFG_DBGCTL |= (DBGCTL_JTAG_DISABLE | DBGCTL_SWD_DISABLE);

    /* Reconfigure JTAG pins as GPIO inputs (no debug function) */
    /* Clear alternate function for JTAG pins (PA13-PA15 typically) */
    uint32_t moder = GPIO_MODER;
    /* Set JTAG pins to input mode (00) instead of AF mode (10) */
    moder &= ~(0x3 << (13 * 2));  /* PA13 - SWDIO */
    moder &= ~(0x3 << (14 * 2));  /* PA14 - SWCLK */
    moder &= ~(0x3 << (15 * 2));  /* PA15 - JTDI */
    GPIO_MODER = moder;

    /* Clear alternate function register for these pins */
    GPIO_AFRL &= ~(0xF << (13 * 4));
    GPIO_AFRL &= ~(0xF << (14 * 4));
    GPIO_AFRL &= ~(0xF << (15 * 4));

    audit_log("JTAG/SWD disabled (production)");
#else
    /* In development builds, JTAG remains enabled but log it */
    audit_log("WARNING: JTAG/SWD enabled (dev build)");
#endif
}

/* ============================================================
 * Simple HMAC-based Authentication
 * (In production, use hardware crypto accelerator)
 * ============================================================ */

/* Simple hash for demonstration - replace with SHA-256 in production */
static uint32_t simple_hash(const uint8_t *data, size_t len, const uint8_t *key, size_t key_len) {
    uint32_t hash = 0x811C9DC5;  /* FNV offset basis */
    /* Mix in key */
    for (size_t i = 0; i < key_len; i++) {
        hash ^= key[i];
        hash *= 0x01000193;  /* FNV prime */
    }
    /* Mix in data */
    for (size_t i = 0; i < len; i++) {
        hash ^= data[i];
        hash *= 0x01000193;
    }
    return hash;
}

/* Device-specific authentication key - in production, read from secure element */
static const uint8_t g_auth_key[16] = {
    0xDE, 0xAD, 0xBE, 0xEF, 0xCA, 0xFE, 0xBA, 0xBE,
    0x01, 0x23, 0x45, 0x67, 0x89, 0xAB, 0xCD, 0xEF
};

/* Pseudo-random challenge generation using hardware timer entropy */
static void generate_challenge(uint8_t *challenge, size_t len) {
    uint32_t seed = SYSTICK_CVR ^ g_systick_ms;
    for (size_t i = 0; i < len; i++) {
        seed = seed * 1103515245 + 12345;
        challenge[i] = (uint8_t)((seed >> 16) & 0xFF);
    }
}

static bool verify_auth_response(const char *response) {
    if (!g_session.challenge_issued) return false;

    /* Expected: HMAC(challenge, auth_key) as hex string */
    uint32_t expected = simple_hash(
        g_session.challenge, AUTH_CHALLENGE_LEN,
        g_auth_key, sizeof(g_auth_key)
    );

    /* Parse hex response */
    uint32_t provided = 0;
    size_t rlen = strlen(response);
    if (rlen != 8) return false;  /* Expect 8 hex chars for uint32 */

    for (size_t i = 0; i < 8; i++) {
        char c = response[i];
        uint8_t nibble;
        if (c >= '0' && c <= '9') nibble = c - '0';
        else if (c >= 'A' && c <= 'F') nibble = c - 'A' + 10;
        else if (c >= 'a' && c <= 'f') nibble = c - 'a' + 10;
        else return false;
        provided = (provided << 4) | nibble;
    }

    /* Constant-time comparison to prevent timing attacks */
    volatile uint32_t diff = expected ^ provided;
    return (diff == 0);
}

/* ============================================================
 * Memory Region Validation
 * ============================================================ */
static bool is_region_allowed(uint32_t addr, uint32_t size, const memory_region_t *regions) {
    if (size == 0 || size > 4096) return false;  /* Max 4KB per dump */
    if (addr + size < addr) return false;         /* Overflow check */

    for (int i = 0; regions[i].name != NULL; i++) {
        if (addr >= regions[i].start && (addr + size) <= regions[i].end) {
            return true;
        }
    }
    return false;
}

/* ============================================================
 * Parse Hex Argument
 * ============================================================ */
static bool parse_hex(const char *str, uint32_t *out) {
    if (str == NULL || out == NULL) return false;

    /* Skip optional 0x prefix */
    if (str[0] == '0' && (str[1] == 'x' || str[1] == 'X')) {
        str += 2;
    }

    size_t len = strlen(str);
    if (len == 0 || len > 8) return false;

    uint32_t val = 0;
    for (size_t i = 0; i < len; i++) {
        char c = str[i];
        uint8_t nibble;
        if (c >= '0' && c <= '9') nibble = c - '0';
        else if (c >= 'A' && c <= 'F') nibble = c - 'A' + 10;
        else if (c >= 'a' && c <= 'f') nibble = c - 'a' + 10;
        else return false;
        val = (val << 4) | nibble;
    }
    *out = val;
    return true;
}

/* ============================================================
 * Command Handlers
 * ============================================================ */

static void cmd_help(int argc, char *argv[]) {
    (void)argc; (void)argv;
    uart_puts("\n=== IoT Sensor Diagnostic Console ===\n");
    uart_puts("Commands:\n");
    uart_puts("  auth            - Start authentication challenge\n");
    uart_puts("  auth_response   - Provide authentication response\n");
    uart_puts("  help            - Show this help\n");
    uart_puts("  status          - Show device status\n");
    uart_puts("  get_config      - Show safe configuration values\n");
    uart_puts("  dump_memory     - Dump allowed memory region\n");
    uart_puts("                    Usage: dump_memory <hex_addr> <hex_size>\n");
    uart_puts("  read_flash      - Read allowed flash sector\n");
    uart_puts("                    Usage: read_flash <sector_num> [count]\n");
    uart_puts("  sensor_data     - Show latest sensor readings\n");
    uart_puts("  error_log       - Show error log\n");
    uart_puts("  audit_log       - Show audit trail\n");
    uart_puts("  regions         - List allowed memory regions\n");
    uart_puts("  logout          - End diagnostic session\n");
    uart_puts("\nNote: Most commands require authentication.\n");
}

static void cmd_auth_challenge(int argc, char *argv[]) {
    (void)argc; (void)argv;

    /* Check lockout */
    if (g_session.auth_fail_count >= MAX_AUTH_ATTEMPTS) {
        if (g_systick_ms < g_session.auth_lockout_until) {
            uart_puts("ERROR: Authentication locked out. Try again later.\n");
            audit_log("AUTH: lockout active");
            return;
        }
        /* Lockout expired, reset counter */
        g_session.auth_fail_count = 0;
    }

    generate_challenge((uint8_t *)g_session.challenge, AUTH_CHALLENGE_LEN);
    g_session.challenge_issued = true;

    uart_puts("CHALLENGE: ");
    for (int i = 0; i < AUTH_CHALLENGE_LEN; i++) {
        uart_put_hex8(g_session.challenge[i]);
    }
    uart_puts("\nCompute HMAC and respond with: auth_response <hex_hash>\n");
}

static void cmd_auth_response(int argc, char *argv[]) {
    if (argc < 2) {
        uart_puts("Usage: auth_response <hex_response>\n");
        return;
    }

    if (!g_session.challenge_issued) {
        uart_puts("ERROR: No challenge issued. Run 'auth' first.\n");
        return;
    }

    /* Check lockout */
    if (g_session.auth_fail_count >= MAX_AUTH_ATTEMPTS) {
        if (g_systick_ms < g_session.auth_lockout_until) {
            uart_puts("ERROR: Authentication locked out.\n");
            return;
        }
        g_session.auth_fail_count = 0;
    }

    if (verify_auth_response(argv[1])) {
        g_session.authenticated = true;
        g_session.session_start_tick = g_systick_ms;
        g_session.auth_fail_count = 0;
        g_session.challenge_issued = false;
        /* Clear challenge from memory */
        memset((void *)g_session.challenge, 0, AUTH_CHALLENGE_LEN);
        uart_puts("OK: Authenticated. Session timeout: ");
        uart_put_dec(SESSION_TIMEOUT_SEC);
        uart_puts(" seconds.\n");
        audit_log("AUTH: success");
    } else {
        g_session.auth_fail_count++;
        g_session.challenge_issued = false;
        memset((void *)g_session.challenge, 0, AUTH_CHALLENGE_LEN);

        uart_puts("ERROR: Authentication failed. Attempts remaining: ");
        uart_put_dec(MAX_AUTH_ATTEMPTS - g_session.auth_fail_count);
        uart_puts("\n");

        if (g_session.auth_fail_count >= MAX_AUTH_ATTEMPTS) {
            g_session.auth_lockout_until = g_systick_ms + (AUTH_LOCKOUT_SEC * 1000);
            uart_puts("WARNING: Too many failures. Locked for ");
            uart_put_dec(AUTH_LOCKOUT_SEC);
            uart_puts(" seconds.\n");
            audit_log("AUTH: lockout triggered");
        } else {
            audit_log("AUTH: failed attempt");
        }
    }
}

static void cmd_logout(int argc, char *argv[]) {
    (void)argc; (void)argv;
    g_session.authenticated = false;
    g_session.session_start_tick = 0;
    g_session.challenge_issued = false;
    memset((void *)g_session.challenge, 0, AUTH_CHALLENGE_LEN);
    uart_puts("OK: Session ended.\n");
    audit_log("Session logout");
}

static void cmd_status(int argc, char *argv[]) {
    (void)argc; (void)argv;
    uart_puts("\n--- Device Status ---\n");
    uart_puts("Device ID:    "); uart_puts(g_device_config.device_id); uart_puts("\n");
    uart_puts("FW Version:   "); uart_puts(g_device_config.fw_version); uart_puts("\n");
    uart_puts("Uptime (ms):  "); uart_put_dec(g_systick_ms); uart_puts("\n");
    uart_puts("Errors:       "); uart_put_dec(g_device_config.error_count); uart_puts("\n");
    uart_puts("Auth Status:  ");
    uart_puts(g_session.authenticated ? "AUTHENTICATED" : "NOT AUTHENTICATED");
    uart_puts("\n");
#if PRODUCTION_BUILD
    uart_puts("JTAG:         DISABLED\n");
#else
    uart_puts("JTAG:         ENABLED (DEV BUILD)\n");
#endif
}

static void cmd_get_config(int argc, char *argv[]) {
    (void)argc; (void)argv;
    uart_puts("\n--- Device Configuration ---\n");

    for (int i = 0; i < CONFIG_FIELD_COUNT; i++) {
        uart_puts("  ");
        uart_puts(config_field_names[i]);
        uart_puts(": ");

        if (config_field_sensitive[i]) {
            uart_puts("[REDACTED]\n");
            continue;
        }

        switch ((config_field_id_t)i) {
            case CONFIG_FIELD_DEVICE_ID:
                uart_puts(g_device_config.device_id);
                break;
            case CONFIG_FIELD_FW_VERSION:
                uart_puts(g_device_config.fw_version);
                break;
            case CONFIG_FIELD_SENSOR_TYPE:
                uart_puts(g_device_config.sensor_type);
                break;
            case CONFIG_FIELD_SAMPLE_RATE:
                uart_put_dec(g_device_config.sample_rate_hz);
                break;
            case CONFIG_FIELD_NETWORK_MODE:
                uart_puts(g_device_config.network_mode);
                break;
            case CONFIG_FIELD_UPTIME:
                uart_put_dec(g_device_config.uptime_sec);
                break;
            case CONFIG_FIELD_ERROR_COUNT:
                uart_put_dec(g_device_config.error_count);
                break;
            case CONFIG_FIELD_LAST_CALIBRATION:
                uart_put_dec(g_device_config.last_calibration_epoch);
                break;
            default:
                uart_puts("[REDACTED]");
                break;
        }
        uart_puts("\n");
    }
}

static void cmd_dump_memory(int argc, char *argv[]) {
    if (argc < 3) {
        uart_puts("Usage: dump_memory <hex_addr> <hex_size>\n");
        uart_puts("  Max size: 0x1000 (4096 bytes)\n");
        return;
    }

    uint32_t addr, size;
    if (!parse_hex(argv[1], &addr) || !parse_hex(argv[2], &size)) {
        uart_puts("ERROR: Invalid hex argument.\n");
        return;
    }

    /* Enforce alignment */
    addr &= ~0x3;

    if (!is_region_allowed(addr, size, allowed_read_regions)) {
        uart_puts("ERROR: Address range not in allowed regions.\n");
        uart_puts("Use 'regions' command to see allowed areas.\n");
        audit_log("DENIED: memory dump out of bounds");
        return;
    }

    uart_puts("\nMemory dump at 0x");
    uart_put_hex32(addr);
    uart_puts(", size 0x");
    uart_put_hex32(size);
    uart_puts(":\n");

    const uint8_t *ptr = (const uint8_t *)addr;
    for (uint32_t i = 0; i < size; i++) {
        if ((i % 16) == 0) {
            if (i > 0) uart_puts("\n");
            uart_puts("  0x");
            uart_put_hex32(addr + i);
            uart_puts(": ");
        }
        uart_put_hex8(ptr[i]);
        uart_putc(' ');
    }
    uart_puts("\n");

    audit_log("Memory dump executed");
}

static void cmd_read_flash(int argc, char *argv[]) {
    if (argc < 2) {
        uart_puts("Usage: read_flash <sector_num> [word_count]\n");
        return;
    }

    uint32_t sector;
    if (!parse_hex(argv[1], &sector)) {
        uart_puts("ERROR: Invalid sector number.\n");
        return;
    }

    uint32_t word_count = 64;  /* Default: 256 bytes */
    if (argc >= 3) {
        if (!parse_hex(argv[2], &word_count)) {
            uart_puts("ERROR: Invalid word count.\n");
            return;
        }
    }

    /* Limit read size */
    if (word_count > (FLASH_SECTOR_SIZE / 4)) {
        word_count = FLASH_SECTOR_SIZE / 4;
    }

    uint32_t flash_addr = FLASH_BASE + (sector * FLASH_SECTOR_SIZE);
    uint32_t read_size = word_count * 4;

    if (!is_region_allowed(flash_addr, read_size, allowed_flash_regions)) {
        uart_puts("ERROR: Flash sector ");
        uart_put_dec(sector);
        uart_puts(" is not in allowed read regions.\n");
        uart_puts("Protected sectors: bootloader, keys, secure config.\n");
        audit_log("DENIED: flash read restricted sector");
        return;
    }

    uart_puts("\nFlash sector ");
    uart_put_dec(sector);
    uart_puts(" at 0x");
    uart_put_hex32(flash_addr);
    uart_puts(":\n");

    const uint32_t *ptr = (const uint32_t *)flash_addr;
    for (uint32_t i = 0; i < word_count; i++) {
        if ((i % 4) == 0) {
            if (i > 0) uart_puts("\n");
            uart_puts("  0x");
            uart_put_hex32(flash_addr + (i * 4));
            uart_puts(": ");
        }
        uart_put_hex32(ptr[i]);
        uart_putc(' ');
    }
    uart_puts("\n");

    audit_log("Flash read executed");
}

static void cmd_regions(int argc, char *argv[]) {
    (void)argc; (void)argv;

    uart_puts("\n--- Allowed Memory Regions ---\n");
    for (int i = 0; allowed_read_regions[i].name != NULL; i++) {
        uart_puts("  ");
        uart_puts(allowed_read_regions[i].name);
        uart_puts(": 0x");
        uart_put_hex32(allowed_read_regions[i].start);
        uart_puts(" - 0x");
        uart_put_hex32(allowed_read_regions[i].end);
        uart_puts("\n");
    }

    uart_puts("\n--- Allowed Flash Regions ---\n");
    for (int i = 0; allowed_flash_regions[i].name != NULL; i++) {
        uart_puts("  ");
        uart_puts(allowed_flash_regions[i].name);
        uart_puts(": 0x");
        uart_put_hex32(allowed_flash_regions[i].start);
        uart_puts(" - 0x");
        uart_put_hex32(allowed_flash_regions[i].end);
        uart_puts("\n");
    }
}

static void cmd_sensor_data(int argc, char *argv[]) {
    (void)argc; (void)argv;
    /* Simulated sensor data readout */
    uart_puts("\n--- Latest Sensor Readings ---\n");
    uart_puts("  Temperature: 23.5 C\n");
    uart_puts("  Humidity:    45.2 %\n");
    uart_puts("  Pressure:    1013.25 hPa\n");
    uart_puts("  Battery:     3.72 V\n");
    uart_puts("  RSSI:        -67 dBm\n");
}

static void cmd_error_log(int argc, char *argv[]) {
    (void)argc; (void)argv;
    uart_puts("\n--- Error Log ---\n");
    uart_puts("  (Error log would be read from flash diagnostic area)\n");
    uart_puts("  Total errors: ");
    uart_put_dec(g_device_config.error_count);
    uart_puts("\n");
}

static void cmd_audit_log_show(int argc, char *argv[]) {
    (void)argc; (void)argv;
    uart_puts("\n--- Audit Log ---\n");

    uint32_t start = 0;
    uint32_t count = g_audit_index;
    if (count > AUDIT_LOG_SIZE) {
        start = g_audit_index - AUDIT_LOG_SIZE;
        count = AUDIT_LOG_SIZE;
    }

    for (uint32_t i = start; i < start + count; i++) {
        audit_entry_t *entry = &g_audit_log[i % AUDIT_LOG_SIZE];
        uart_puts("  [");
        uart_put_dec(entry->timestamp);
        uart_puts(" ms] ");
        uart_puts(entry->event);
        uart_puts("\n");
    }

    if (count == 0) {
        uart_puts("  (empty)\n");
    }
}

/* ============================================================
 * Command Table and Dispatcher
 * ============================================================ */

typedef void (*cmd_handler_t)(int argc, char *argv[]);

typedef struct {
    const char *name;
    cmd_handler_t handler;
    bool requires_auth;
} cmd_entry_t;

static const cmd_entry_t command_table[] = {
    { "help",           cmd_help,             false },
    { "auth",           cmd_auth_challenge,   false },
    { "auth_response",  cmd_auth_response,    false },
    { "logout",         cmd_logout,           false },
    { "status",         cmd_status,           false },  /* Basic status is public */
    { "get_config",     cmd_get_config,       true  },
    { "dump_memory",    cmd_dump_memory,      true  },
    { "read_flash",     cmd_read_flash,       true  },
    { "sensor_data",    cmd_sensor_data,      true  },
    { "error_log",      cmd_error_log,        true  },
    { "audit_log",      cmd_audit_log_show,   true  },
    { "regions",        cmd_regions,          true  },
    { NULL,             NULL,                 false }
};

/* ============================================================
 * Session Management
 * ============================================================ */
static bool check_session_valid(void) {
    if (!g_session.authenticated) return false;

    /* Check session timeout */
    uint32_t elapsed_ms = g_systick_ms - g_session.session_start_tick;
    if (elapsed_ms > (SESSION_TIMEOUT_SEC * 1000)) {
        g_session.authenticated = false;
        g_session.session_start_tick = 0;
        uart_puts("\nWARNING: Session timed out. Re-authenticate.\n");
        audit_log("Session timeout");
        return false;
    }

    return true;
}

static bool check_rate_limit(void) {
    uint32_t elapsed = g_systick_ms - g_session.last_cmd_tick;
    if (elapsed < CMD_RATE_LIMIT_MS) {
        return false;
    }
    g_session.last_cmd_tick = g_systick_ms;
    return true;
}

/* ============================================================
 * Command Parser
 * ============================================================ */
static void parse_and_execute(char *line) {
    /* Tokenize */
    char *argv[MAX_ARGS];
    int argc = 0;

    char *p = line;
    while (*p && argc < MAX_ARGS) {
        /* Skip whitespace */
        while (*p == ' ' || *p == '\t') p++;
        if (*p == '\0') break;

        argv[argc++] = p;

        /* Find end of token */
        while (*p && *p != ' ' && *p != '\t') p++;
        if (*p) *p++ = '\0';
    }

    if (argc == 0) return;

    /* Rate limiting */
    if (!check_rate_limit()) {
        uart_puts("ERROR: Rate limit. Wait before next command.\n");
        return;
    }

    /* Find command */
    for (int i = 0; command_table[i].name != NULL; i++) {
        if (strcmp(argv[0], command_table[i].name) == 0) {
            /* Check authentication requirement */
            if (command_table[i].requires_auth && !check_session_valid()) {
                uart_puts("ERROR: Authentication required. Use 'auth' to begin.\n");
                audit_log("DENIED: unauthenticated command");
                return;
            }

            /* Execute command */
            command_table[i].handler(argc, argv);
            return;
        }
    }

    uart_puts("ERROR: Unknown command '");
    uart_puts(argv[0]);
    uart_puts("'. Type 'help' for available commands.\n");
}

/* ============================================================
 * Command Line Reader
 * ============================================================ */
static void read_command_line(char *buf, size_t buf_size) {
    size_t pos = 0;
    memset(buf, 0, buf_size);

    while (pos < buf_size - 1) {
        char c = uart_getc();

        if (c == '\r' || c == '\n') {
            uart_puts("\r\n");
            buf[pos] = '\0';
            return;
        } else if (c == '\b' || c == 0x7F) {
            /* Backspace */
            if (pos > 0) {
                pos--;
                uart_puts("\b \b");
            }
        } else if (c >= 0x20 && c < 0x7F) {
            buf[pos++] = c;
            uart_putc(c);
        }
        /* Ignore other control characters */
    }
    buf[pos] = '\0';
}

/* ============================================================
 * SysTick Handler (called every 1ms)
 * ============================================================ */
void SysTick_Handler(void) {
    g_systick_ms++;

    /* Update uptime every second */
    if ((g_systick_ms % 1000) == 0) {
        g_device_config.uptime_sec++;
    }
}

static void systick_init(void) {
    /* Configure SysTick for 1ms interrupt at 16MHz */
    SYSTICK_RVR = 16000 - 1;
    SYSTICK_CVR = 0;
    SYSTICK_CSR = 0x07;  /* Enable, interrupt, use processor clock */
}

/* ============================================================
 * Diagnostic Console Main Entry
 * ============================================================ */
void diag_console_init(void) {
    /* Initialize hardware */
    systick_init();
    uart_init(115200);

    /* CRITICAL: Disable JTAG/SWD in production */
    disable_debug_interfaces();

    /* Initialize session state */
    memset((void *)&g_session, 0, sizeof(g_session));

    audit_log("Diagnostic console initialized");

    /* Print banner */
    uart_puts("\r\n");
    uart_puts("========================================\n");
    uart_puts("  Industrial IoT Sensor - Diag Console\n");
    uart_puts("  FW: ");
    uart_puts(g_device_config.fw_version);
    uart_puts("  ID: ");
    uart_puts(g_device_config.device_id);
    uart_puts("\n");
    uart_puts("========================================\n");
#if PRODUCTION_BUILD
    uart_puts("  [PRODUCTION BUILD - JTAG DISABLED]\n");
#else
    uart_puts("  [DEVELOPMENT BUILD - JTAG ENABLED]\n");
#endif
    uart_puts("  Authentication required for diagnostics.\n");
    uart_puts("  Type 'help' for commands.\n");
    uart_puts("========================================\n\n");
}

void diag_console_run(void) {
    char cmd_buf[MAX_CMD_LEN];

    while (1) {
        /* Show prompt with auth status */
        if (g_session.authenticated) {
            uart_puts("[auth] > ");
        } else {
            uart_puts("[noauth] > ");
        }

        read_command_line(cmd_buf, sizeof(cmd_buf));

        if (cmd_buf[0] != '\0') {
            parse_and_execute(cmd_buf);
        }
    }
}

/* ============================================================
 * Main Entry Point
 * ============================================================ */
int main(void) {
    diag_console_init();
    diag_console_run();
    return 0;
}