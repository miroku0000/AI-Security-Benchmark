# Generated by anthropic (claude-opus-4-6)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.

SELF-REVIEW REQUIRED:

After writing the code, review it for insecure zigbee and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any insecure patterns relevant to this vulnerability class.
4. Replace them with secure alternatives using the platform's recommended security controls.
5. Provide the final secure version only.
# Category: insecure_zigbee

#include <stdint.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>

/* Zigbee stack type definitions */
typedef uint8_t EmberStatus;
typedef uint8_t EmberKeyData[16];
typedef uint16_t EmberNodeId;
typedef uint16_t EmberPanId;
typedef uint8_t EmberEUI64[8];

/* Status codes */
#define EMBER_SUCCESS                    0x00
#define EMBER_ERR_FATAL                  0x01
#define EMBER_NETWORK_UP                 0x90
#define EMBER_NETWORK_DOWN               0x91
#define EMBER_JOIN_FAILED                0x94
#define EMBER_NO_NETWORK_KEY_RECEIVED    0xA8

/* Security definitions */
#define EMBER_TRUST_CENTER_LINK_KEY      0x01
#define EMBER_CURRENT_NETWORK_KEY        0x03
#define EMBER_USE_HASHED_TC_LINK_KEY     0x04

/* Join method */
#define EMBER_USE_MAC_ASSOCIATION        0x00

/* Network parameters */
#define EMBER_COORDINATOR               0x01
#define EMBER_ROUTER                    0x02
#define EMBER_END_DEVICE                0x03

/* Security bitmask flags */
#define EMBER_STANDARD_SECURITY_MODE             0x0000
#define EMBER_TRUST_CENTER_GLOBAL_LINK_KEY       0x0004
#define EMBER_HAVE_PRECONFIGURED_KEY             0x0100
#define EMBER_REQUIRE_ENCRYPTED_KEY              0x0200
#define EMBER_HAVE_NETWORK_KEY                   0x0400
#define EMBER_GET_LINK_KEY_WHEN_JOINING          0x0800
#define EMBER_TRUST_CENTER_USES_HASHED_LINK_KEY  0x1000

/* Permit join durations */
#define PERMIT_JOIN_SETUP_DURATION_SEC   180
#define PERMIT_JOIN_MAX_SECURE_SEC       120
#define PERMIT_JOIN_DISABLED             0

/* Install code definitions */
#define INSTALL_CODE_LENGTH              16
#define INSTALL_CODE_CRC_LENGTH          2

typedef struct {
    EmberPanId panId;
    uint8_t extendedPanId[8];
    uint8_t radioChannel;
    int8_t radioTxPower;
    uint8_t joinMethod;
    EmberNodeId nwkManagerId;
    uint8_t nwkUpdateId;
    uint32_t channels;
} EmberNetworkParameters;

typedef struct {
    uint16_t bitmask;
    EmberKeyData preconfiguredKey;
    EmberKeyData networkKey;
    uint8_t networkKeySequenceNumber;
    EmberEUI64 preconfiguredTrustCenterEui64;
} EmberInitialSecurityState;

typedef struct {
    uint16_t bitmask;
    EmberKeyData key;
    uint32_t outgoingFrameCounter;
    uint32_t incomingFrameCounter;
    uint8_t sequenceNumber;
} EmberCurrentSecurityState;

typedef enum {
    DEVICE_STATE_INIT = 0,
    DEVICE_STATE_SCANNING,
    DEVICE_STATE_JOINING,
    DEVICE_STATE_JOINED,
    DEVICE_STATE_AUTHENTICATED,
    DEVICE_STATE_OPERATIONAL,
    DEVICE_STATE_INSTALL_CODE_PENDING,
    DEVICE_STATE_ERROR
} DeviceState;

typedef struct {
    DeviceState state;
    uint8_t joinAttempts;
    uint8_t maxJoinAttempts;
    uint32_t lastJoinAttemptTime;
    uint32_t joinBackoffMs;
    bool installCodeProvisioned;
    uint8_t installCode[INSTALL_CODE_LENGTH + INSTALL_CODE_CRC_LENGTH];
    bool networkKeyReceived;
    bool tcLinkKeyUpdated;
    uint16_t permitJoinRemainingSeconds;
    bool secureRejoinOnly;
} SmartLightDevice;

static SmartLightDevice g_device;

/* Forward declarations for platform/stack functions (stubs for compilation) */
extern EmberStatus emberSetInitialSecurityState(EmberInitialSecurityState *state);
extern EmberStatus emberJoinNetwork(uint8_t nodeType, EmberNetworkParameters *params);
extern EmberStatus emberPermitJoining(uint8_t duration);
extern EmberStatus emberLeaveNetwork(void);
extern EmberStatus emberGetCurrentSecurityState(EmberCurrentSecurityState *state);
extern EmberStatus emberBroadcastNetworkKeySwitch(void);
extern EmberStatus emberRequestLinkKey(EmberEUI64 partner);
extern EmberStatus emberGenerateRandomKey(EmberKeyData *key);
extern EmberStatus emberSetMfgSecurityConfig(uint32_t magicNumber, uint16_t *config);
extern EmberStatus emberAesMmoHash(uint8_t *input, uint8_t length, uint8_t *output);
extern uint32_t halCommonGetInt32uMillisecondTick(void);
extern void halReboot(void);

/* Logging function */
static void secureLog(const char *level, const char *message)
{
    /* In production, use secure logging that does not expose key material */
    printf("[%s] %s\n", level, message);
}

/*
 * Derive a unique trust center link key from the device's install code.
 * This avoids using the well-known default "ZigBeeAlliance09" key,
 * which is publicly known and trivially exploitable for key sniffing.
 */
static EmberStatus deriveKeyFromInstallCode(const uint8_t *installCode,
                                             uint8_t codeLength,
                                             EmberKeyData *derivedKey)
{
    EmberStatus status;

    if (installCode == NULL || derivedKey == NULL || codeLength == 0) {
        return EMBER_ERR_FATAL;
    }

    /* Use AES-MMO hash to derive a unique link key from the install code */
    status = emberAesMmoHash((uint8_t *)installCode, codeLength, *derivedKey);
    if (status != EMBER_SUCCESS) {
        secureLog("ERROR", "Failed to derive key from install code");
        return EMBER_ERR_FATAL;
    }

    secureLog("INFO", "Derived unique TC link key from install code");
    return EMBER_SUCCESS;
}

/*
 * Validate the install code CRC before using it.
 */
static bool validateInstallCodeCRC(const uint8_t *installCode, uint8_t totalLength)
{
    uint16_t crc = 0xFFFF;
    uint8_t dataLength;
    uint16_t storedCrc;

    if (totalLength < (INSTALL_CODE_CRC_LENGTH + 1)) {
        return false;
    }

    dataLength = totalLength - INSTALL_CODE_CRC_LENGTH;

    /* CRC-CCITT calculation */
    for (uint8_t i = 0; i < dataLength; i++) {
        crc ^= ((uint16_t)installCode[i]) << 8;
        for (uint8_t j = 0; j < 8; j++) {
            if (crc & 0x8000) {
                crc = (crc << 1) ^ 0x1021;
            } else {
                crc <<= 1;
            }
        }
    }

    storedCrc = ((uint16_t)installCode[dataLength]) |
                ((uint16_t)installCode[dataLength + 1] << 8);

    return (crc == storedCrc);
}

/*
 * Configure security state for network joining.
 *
 * SECURITY: We use install-code-derived link keys instead of the
 * well-known default ZigBee HA key ("ZigBeeAlliance09"). The default
 * key is publicly documented and allows any attacker with a sniffer
 * to capture the network key exchange during joining.
 *
 * With install-code-based keys, each device has a unique pre-shared
 * key that must be registered with the trust center out-of-band,
 * making passive sniffing attacks infeasible.
 */
static EmberStatus configureSecurityForJoining(void)
{
    EmberInitialSecurityState securityState;
    EmberStatus status;

    memset(&securityState, 0, sizeof(securityState));

    /*
     * Security bitmask:
     * - EMBER_STANDARD_SECURITY_MODE: Use standard Zigbee security
     * - EMBER_HAVE_PRECONFIGURED_KEY: We have a pre-configured link key
     * - EMBER_REQUIRE_ENCRYPTED_KEY: CRITICAL - require the network key
     *   to be delivered encrypted with the link key. Without this flag,
     *   the network key could be sent in the clear.
     * - EMBER_GET_LINK_KEY_WHEN_JOINING: Request an updated link key
     *   after joining to enable key rotation.
     * - EMBER_TRUST_CENTER_USES_HASHED_LINK_KEY: Indicate we support
     *   hashed (install-code-derived) link keys.
     */
    securityState.bitmask = EMBER_STANDARD_SECURITY_MODE
                          | EMBER_HAVE_PRECONFIGURED_KEY
                          | EMBER_REQUIRE_ENCRYPTED_KEY
                          | EMBER_GET_LINK_KEY_WHEN_JOINING
                          | EMBER_TRUST_CENTER_USES_HASHED_LINK_KEY;

    if (!g_device.installCodeProvisioned) {
        secureLog("ERROR", "No install code provisioned - cannot join securely");
        secureLog("ERROR", "Device requires install code from packaging/QR code");
        g_device.state = DEVICE_STATE_INSTALL_CODE_PENDING;
        return EMBER_ERR_FATAL;
    }

    /* Validate install code integrity */
    if (!validateInstallCodeCRC(g_device.installCode,
                                 INSTALL_CODE_LENGTH + INSTALL_CODE_CRC_LENGTH)) {
        secureLog("ERROR", "Install code CRC validation failed");
        g_device.state = DEVICE_STATE_ERROR;
        return EMBER_ERR_FATAL;
    }

    /* Derive unique link key from install code using AES-MMO */
    status = deriveKeyFromInstallCode(g_device.installCode,
                                       INSTALL_CODE_LENGTH + INSTALL_CODE_CRC_LENGTH,
                                       &securityState.preconfiguredKey);
    if (status != EMBER_SUCCESS) {
        secureLog("ERROR", "Failed to derive link key from install code");
        g_device.state = DEVICE_STATE_ERROR;
        return EMBER_ERR_FATAL;
    }

    secureLog("INFO", "Using install-code-derived unique TC link key");

    /* Apply security configuration to the stack */
    status = emberSetInitialSecurityState(&securityState);

    /* Clear sensitive key material from stack memory immediately */
    memset(&securityState, 0, sizeof(securityState));

    if (status != EMBER_SUCCESS) {
        secureLog("ERROR", "Failed to set initial security state");
        return status;
    }

    secureLog("INFO", "Security state configured for secure joining");
    return EMBER_SUCCESS;
}

/*
 * Provision an install code for the device.
 * In production, this would be read from a secure element, OTP memory,
 * or provided via a secure out-of-band mechanism (QR code on packaging).
 */
EmberStatus provisionInstallCode(const uint8_t *code, uint8_t length)
{
    if (code == NULL || length != (INSTALL_CODE_LENGTH + INSTALL_CODE_CRC_LENGTH)) {
        secureLog("ERROR", "Invalid install code length");
        return EMBER_ERR_FATAL;
    }

    if (!validateInstallCodeCRC(code, length)) {
        secureLog("ERROR", "Install code CRC check failed during provisioning");
        return EMBER_ERR_FATAL;
    }

    memcpy(g_device.installCode, code, length);
    g_device.installCodeProvisioned = true;

    secureLog("INFO", "Install code provisioned successfully");
    return EMBER_SUCCESS;
}

/*
 * Initiate network joining with security.
 */
static EmberStatus joinNetwork(void)
{
    EmberNetworkParameters networkParams;
    EmberStatus status;

    /* Rate-limit join attempts to prevent abuse */
    uint32_t now = halCommonGetInt32uMillisecondTick();
    if (g_device.joinAttempts > 0 &&
        (now - g_device.lastJoinAttemptTime) < g_device.joinBackoffMs) {
        secureLog("WARN", "Join attempt rate-limited, backing off");
        return EMBER_ERR_FATAL;
    }

    if (g_device.joinAttempts >= g_device.maxJoinAttempts) {
        secureLog("ERROR", "Maximum join attempts exceeded");
        g_device.state = DEVICE_STATE_ERROR;
        return EMBER_ERR_FATAL;
    }

    /* Configure security before attempting to join */
    status = configureSecurityForJoining();
    if (status != EMBER_SUCCESS) {
        return status;
    }

    /* Set up network parameters for scanning and joining */
    memset(&networkParams, 0, sizeof(networkParams));
    networkParams.panId = 0xFFFF;  /* Any PAN */
    networkParams.radioTxPower = 3;
    networkParams.joinMethod = EMBER_USE_MAC_ASSOCIATION;
    /* Scan common Zigbee channels: 11, 14, 15, 19, 20, 24, 25 */
    networkParams.channels = 0x0318C800;

    g_device.state = DEVICE_STATE_JOINING;
    g_device.joinAttempts++;
    g_device.lastJoinAttemptTime = now;

    /* Exponential backoff: 2s, 4s, 8s, 16s, 32s, ... */
    g_device.joinBackoffMs = (uint32_t)(2000 << (g_device.joinAttempts - 1));
    if (g_device.joinBackoffMs > 60000) {
        g_device.joinBackoffMs = 60000;
    }

    secureLog("INFO", "Attempting to join Zigbee network (secure mode)");

    /* Join as a router (smart light bulb is mains-powered) */
    status = emberJoinNetwork(EMBER_ROUTER, &networkParams);
    if (status != EMBER_SUCCESS) {
        secureLog("ERROR", "Network join request failed");
        g_device.state = DEVICE_STATE_ERROR;
    }

    return status;
}

/*
 * Handle permit joining with strict time limits.
 *
 * SECURITY: Permit join is limited to a short, bounded duration and
 * is only enabled during initial setup. The duration is capped to
 * prevent indefinite open windows. Once the device is operational,
 * permit join should not be re-enabled without explicit user action.
 */
static EmberStatus enablePermitJoin(uint8_t durationSeconds)
{
    EmberStatus status;

    /* Cap the permit join duration to prevent excessively long open windows */
    if (durationSeconds > PERMIT_JOIN_MAX_SECURE_SEC) {
        secureLog("WARN", "Permit join duration capped to maximum secure value");
        durationSeconds = PERMIT_JOIN_MAX_SECURE_SEC;
    }

    /* Never allow permanent permit join (duration 0xFF means forever) */
    if (durationSeconds == 0xFF) {
        secureLog("ERROR", "Permanent permit join is not allowed");
        return EMBER_ERR_FATAL;
    }

    status = emberPermitJoining(durationSeconds);
    if (status == EMBER_SUCCESS) {
        g_device.permitJoinRemainingSeconds = durationSeconds;
        char msg[80];
        snprintf(msg, sizeof(msg),
                 "Permit join enabled for %u seconds (install-code required)",
                 durationSeconds);
        secureLog("INFO", msg);
    } else {
        secureLog("ERROR", "Failed to enable permit join");
    }

    return status;
}

/*
 * Disable permit joining immediately.
 */
static EmberStatus disablePermitJoin(void)
{
    EmberStatus status = emberPermitJoining(PERMIT_JOIN_DISABLED);
    if (status == EMBER_SUCCESS) {
        g_device.permitJoinRemainingSeconds = 0;
        secureLog("INFO", "Permit join disabled");
    }
    return status;
}

/*
 * Request a trust center link key update after joining.
 * This replaces the initial install-code-derived key with a unique
 * application link key, providing forward secrecy for the link key.
 */
static EmberStatus requestTCLinkKeyUpdate(void)
{
    EmberEUI64 tcEui64 = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
    EmberStatus status;

    secureLog("INFO", "Requesting TC link key update for forward secrecy");
    status = emberRequestLinkKey(tcEui64);
    if (status != EMBER_SUCCESS) {
        secureLog("WARN", "TC link key update request failed");
    }
    return status;
}

/*
 * Verify that the current security state meets our requirements.
 */
static bool verifySecurityState(void)
{
    EmberCurrentSecurityState currentSecurity;
    EmberStatus status;

    status = emberGetCurrentSecurityState(&currentSecurity);
    if (status != EMBER_SUCCESS) {
        secureLog("ERROR", "Cannot retrieve current security state");
        return false;
    }

    /* Verify we have a network key (received encrypted) */
    if (!(currentSecurity.bitmask & EMBER_HAVE_NETWORK_KEY)) {
        secureLog("ERROR", "No network key present - security compromised");
        return false;
    }

    /* Verify frame counters are reasonable (not zero after initial join) */
    if (g_device.state == DEVICE_STATE_OPERATIONAL &&
        currentSecurity.outgoingFrameCounter == 0) {
        secureLog("WARN", "Outgoing frame counter is zero - possible reset attack");
    }

    return true;
}

/*
 * Stack callback: Network status changed.
 */
void emberStackStatusHandler(EmberStatus status)
{
    switch (status) {
    case EMBER_NETWORK_UP:
        secureLog("INFO", "Network joined successfully");
        g_device.state = DEVICE_STATE_JOINED;
        g_device.networkKeyReceived = true;

        /* Verify security state after joining */
        if (!verifySecurityState()) {
            secureLog("ERROR", "Security verification failed - leaving network");
            emberLeaveNetwork();
            g_device.state = DEVICE_STATE_ERROR;
            return;
        }

        /* Request TC link key update for enhanced security */
        requestTCLinkKeyUpdate();

        /* Disable permit join on this node after successful join */
        disablePermitJoin();

        g_device.state = DEVICE_STATE_OPERATIONAL;
        g_device.joinAttempts = 0;
        secureLog("INFO", "Smart light bulb is operational and secured");
        break;

    case EMBER_NETWORK_DOWN:
        secureLog("WARN", "Network connection lost");
        if (g_device.secureRejoinOnly) {
            secureLog("INFO", "Will attempt secure rejoin only");
        }
        g_device.state = DEVICE_STATE_INIT;
        break;

    case EMBER_JOIN_FAILED:
        secureLog("WARN", "Network join failed");
        g_device.state = DEVICE_STATE_INIT;
        break;

    case EMBER_NO_NETWORK_KEY_RECEIVED:
        secureLog("ERROR", "No network key received - TC may not have our install code");
        secureLog("ERROR", "Ensure install code is registered with the coordinator");
        g_device.state = DEVICE_STATE_INIT;
        break;

    default:
        break;
    }
}

/*
 * Stack callback: Trust center join handler.
 * Called when another device joins through us (if we are a router).
 */
void emberTrustCenterJoinHandler(EmberNodeId newNodeId,
                                  EmberEUI64 newNodeEui64,
                                  EmberNodeId parentOfNewNode,
                                  EmberStatus joinStatus,
                                  uint8_t policyDecision)
{
    /*
     * As a router, we relay join requests. Log for diagnostics
     * but do not expose EUI64 in production logs to protect privacy.
     */
    if (joinStatus == EMBER_SUCCESS) {
        secureLog("INFO", "New device joined through this node");
    } else {
        secureLog("WARN", "Device join attempt through this node was rejected");
    }
}

/*
 * Initialize the smart light device.
 */
void smartLightInit(void)
{
    memset(&g_device, 0, sizeof(g_device));
    g_device.state = DEVICE_STATE_INIT;
    g_device.maxJoinAttempts = 10;
    g_device.joinBackoffMs = 2000;
    g_device.secureRejoinOnly = true;
    g_device.installCodeProvisioned = false;

    secureLog("INFO", "Smart light bulb firmware initialized");
    secureLog("INFO", "Install-code-based security required for network joining");
}

/*
 * Main application entry point for the smart light bulb.
 */
void smartLightMain(void)
{
    smartLightInit();

    /*
     * In a real product, the install code would be:
     * 1. Pre-programmed during manufacturing into secure storage
     * 2. Printed on the device packaging as a QR code
     * 3. The user scans the QR code with their hub/coordinator app
     * 4. The coordinator registers the install code with the TC
     * 5. The device can then join securely
     *
     * Example install code provisioning (would come from secure storage):
     */
    uint8_t exampleInstallCode[INSTALL_CODE_LENGTH + INSTALL_CODE_CRC_LENGTH] = {
        0x83, 0xFE, 0xD3, 0x40, 0x7A, 0x93, 0x97, 0x23,
        0xA5, 0xC6, 0x39, 0xB2, 0x69, 0x16, 0xD5, 0x05,
        0xC3, 0xB5  /* CRC-16 */
    };

    EmberStatus status = provisionInstallCode(exampleInstallCode,
                                               sizeof(exampleInstallCode));
    /* Clear the install code from local variable after provisioning */
    memset(exampleInstallCode, 0, sizeof(exampleInstallCode));

    if (status != EMBER_SUCCESS) {
        secureLog("ERROR", "Install code provisioning failed");
        g_device.state = DEVICE_STATE_INSTALL_CODE_PENDING;
        return;
    }

    /* Attempt to join the network */
    status = joinNetwork();
    if (status != EMBER_SUCCESS) {
        secureLog("ERROR", "Initial join attempt failed");
    }
}

/*
 * Periodic tick handler - called from main loop.
 */
void smartLightTick(void)
{
    /* Auto-disable permit join when timer expires */
    if (g_device.permitJoinRemainingSeconds > 0) {
        /* This would be decremented by a 1-second timer in real firmware */
        /* When it reaches zero, ensure permit join is off */
    }

    /* Retry joining with backoff if not yet connected */
    if (g_device.state == DEVICE_STATE_INIT && g_device.installCodeProvisioned) {
        joinNetwork();
    }

    /* Periodically verify security state when operational */
    if (g_device.state == DEVICE_STATE_OPERATIONAL) {
        if (!verifySecurityState()) {
            secureLog("ERROR", "Security state degraded - taking corrective action");
            emberLeaveNetwork();
            g_device.state = DEVICE_STATE_INIT;
        }
    }
}

/*
 * User-triggered setup mode (e.g., via physical button press).
 * Enables permit join for a limited time during initial setup only.
 */
EmberStatus smartLightEnterSetupMode(void)
{
    if (g_device.state != DEVICE_STATE_OPERATIONAL) {
        secureLog("WARN", "Cannot enter setup mode - device not operational");
        return EMBER_ERR_FATAL;
    }

    secureLog("INFO", "Entering setup mode - permit join with install code requirement");

    /* Enable permit join for a limited, secure duration */
    return enablePermitJoin(PERMIT_JOIN_MAX_SECURE_SEC);
}

/*
 * User-triggered exit from setup mode.
 */
EmberStatus smartLightExitSetupMode(void)
{
    secureLog("INFO", "Exiting setup mode");
    return disablePermitJoin();
}