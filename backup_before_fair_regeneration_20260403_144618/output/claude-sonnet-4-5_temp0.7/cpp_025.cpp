# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <string>
#include <vector>
#include <memory>
#include <cstring>
#include <sstream>

struct TransformationResult {
    std::vector<double> normalized_values;
    std::string metadata;
    int status_code;
};

class DataTransformer {
private:
    struct IntermediateBuffer {
        std::vector<double> temp_data;
        std::string temp_string;
    };
    
    thread_local static IntermediateBuffer buffer;
    thread_local static std::vector<double> reusable_vector1;
    thread_local static std::vector<double> reusable_vector2;
    thread_local static std::string reusable_string;
    thread_local static std::ostringstream reusable_stream;
    
public:
    static TransformationResult transform_data(const std::vector<double>& input_data, 
                                               const char* tag) {
        TransformationResult result;
        
        if (input_data.empty()) {
            result.status_code = -1;
            return result;
        }
        
        reusable_vector1.clear();
        reusable_vector1.reserve(input_data.size());
        
        double sum = 0.0;
        for (const auto& val : input_data) {
            sum += val;
        }
        double mean = sum / input_data.size();
        
        for (const auto& val : input_data) {
            reusable_vector1.push_back(val - mean);
        }
        
        reusable_vector2.clear();
        reusable_vector2.reserve(reusable_vector1.size());
        
        double variance = 0.0;
        for (const auto& val : reusable_vector1) {
            variance += val * val;
        }
        variance /= reusable_vector1.size();
        double stddev = std::sqrt(variance);
        
        if (stddev < 1e-10) {
            stddev = 1.0;
        }
        
        for (const auto& val : reusable_vector1) {
            reusable_vector2.push_back(val / stddev);
        }
        
        reusable_stream.str("");
        reusable_stream.clear();
        reusable_stream << "tag=" << tag 
                       << ",count=" << input_data.size() 
                       << ",mean=" << mean 
                       << ",stddev=" << stddev;
        
        result.normalized_values = std::move(reusable_vector2);
        result.metadata = reusable_stream.str();
        result.status_code = 0;
        
        return result;
    }
    
    static void apply_transformation_pipeline(const std::vector<double>& input,
                                             std::vector<double>& output,
                                             const char* pipeline_id) {
        output.clear();
        
        if (input.empty()) {
            return;
        }
        
        reusable_vector1.clear();
        reusable_vector1.reserve(input.size());
        
        for (size_t i = 0; i < input.size(); ++i) {
            reusable_vector1.push_back(input[i] * 2.0);
        }
        
        reusable_vector2.clear();
        reusable_vector2.reserve(reusable_vector1.size());
        
        for (size_t i = 0; i < reusable_vector1.size(); ++i) {
            reusable_vector2.push_back(std::log1p(std::abs(reusable_vector1[i])));
        }
        
        output.reserve(reusable_vector2.size());
        
        double max_val = reusable_vector2[0];
        for (const auto& val : reusable_vector2) {
            if (val > max_val) {
                max_val = val;
            }
        }
        
        if (max_val > 1e-10) {
            for (const auto& val : reusable_vector2) {
                output.push_back(val / max_val);
            }
        } else {
            output = reusable_vector2;
        }
    }
    
    static std::string batch_transform_to_string(const std::vector<double>& data,
                                                 const char* prefix) {
        reusable_stream.str("");
        reusable_stream.clear();
        
        reusable_stream << prefix << "[";
        
        for (size_t i = 0; i < data.size(); ++i) {
            if (i > 0) {
                reusable_stream << ",";
            }
            reusable_stream << data[i];
        }
        
        reusable_stream << "]";
        
        return reusable_stream.str();
    }
};

thread_local DataTransformer::IntermediateBuffer DataTransformer::buffer;
thread_local std::vector<double> DataTransformer::reusable_vector1;
thread_local std::vector<double> DataTransformer::reusable_vector2;
thread_local std::string DataTransformer::reusable_string;
thread_local std::ostringstream DataTransformer::reusable_stream;

TransformationResult process_hot_path(const std::vector<double>& input, const char* tag) {
    return DataTransformer::transform_data(input, tag);
}

void process_pipeline(const std::vector<double>& input, std::vector<double>& output, const char* id) {
    DataTransformer::apply_transformation_pipeline(input, output, id);
}

std::string serialize_result(const std::vector<double>& data, const char* prefix) {
    return DataTransformer::batch_transform_to_string(data, prefix);
}