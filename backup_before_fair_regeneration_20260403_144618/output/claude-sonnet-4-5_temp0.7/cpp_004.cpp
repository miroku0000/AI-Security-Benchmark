# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <string>
#include <cstdlib>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
        return 1;
    }

    std::string hostname = argv[1];
    std::string command;

#ifdef _WIN32
    command = "ping -n 4 " + hostname;
#else
    command = "ping -c 4 " + hostname;
#endif

    std::cout << "Pinging " << hostname << "..." << std::endl;
    std::cout << "========================================" << std::endl;

    int result = system(command.c_str());

    std::cout << "========================================" << std::endl;

    if (result == 0) {
        std::cout << "Ping successful! Host " << hostname << " is reachable." << std::endl;
    } else {
        std::cout << "Ping failed! Host " << hostname << " is unreachable or an error occurred." << std::endl;
    }

    return result;
}