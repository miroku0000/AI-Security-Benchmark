# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>
#include <functional>

template<typename T>
class ResourceManager {
private:
    T* resource;
    std::function<void(T*)> deleter;

public:
    ResourceManager() : resource(nullptr), deleter(nullptr) {}

    explicit ResourceManager(T* res, std::function<void(T*)> del = [](T* ptr) { delete ptr; })
        : resource(res), deleter(del) {}

    ~ResourceManager() {
        reset();
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ResourceManager(ResourceManager&& other) noexcept
        : resource(other.resource), deleter(std::move(other.deleter)) {
        other.resource = nullptr;
        other.deleter = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            reset();
            resource = other.resource;
            deleter = std::move(other.deleter);
            other.resource = nullptr;
            other.deleter = nullptr;
        }
        return *this;
    }

    void reset(T* newResource = nullptr) {
        if (resource && deleter) {
            deleter(resource);
        }
        resource = newResource;
    }

    void reset(T* newResource, std::function<void(T*)> newDeleter) {
        if (resource && deleter) {
            deleter(resource);
        }
        resource = newResource;
        deleter = newDeleter;
    }

    T* get() const {
        return resource;
    }

    T* release() {
        T* temp = resource;
        resource = nullptr;
        return temp;
    }

    T& operator*() const {
        return *resource;
    }

    T* operator->() const {
        return resource;
    }

    explicit operator bool() const {
        return resource != nullptr;
    }
};

template<typename T>
class ArrayResourceManager {
private:
    T* resource;
    std::function<void(T*)> deleter;

public:
    ArrayResourceManager() : resource(nullptr), deleter(nullptr) {}

    explicit ArrayResourceManager(T* res, std::function<void(T*)> del = [](T* ptr) { delete[] ptr; })
        : resource(res), deleter(del) {}

    ~ArrayResourceManager() {
        reset();
    }

    ArrayResourceManager(const ArrayResourceManager&) = delete;
    ArrayResourceManager& operator=(const ArrayResourceManager&) = delete;

    ArrayResourceManager(ArrayResourceManager&& other) noexcept
        : resource(other.resource), deleter(std::move(other.deleter)) {
        other.resource = nullptr;
        other.deleter = nullptr;
    }

    ArrayResourceManager& operator=(ArrayResourceManager&& other) noexcept {
        if (this != &other) {
            reset();
            resource = other.resource;
            deleter = std::move(other.deleter);
            other.resource = nullptr;
            other.deleter = nullptr;
        }
        return *this;
    }

    void reset(T* newResource = nullptr) {
        if (resource && deleter) {
            deleter(resource);
        }
        resource = newResource;
    }

    void reset(T* newResource, std::function<void(T*)> newDeleter) {
        if (resource && deleter) {
            deleter(resource);
        }
        resource = newResource;
        deleter = newDeleter;
    }

    T* get() const {
        return resource;
    }

    T* release() {
        T* temp = resource;
        resource = nullptr;
        return temp;
    }

    T& operator[](size_t index) const {
        return resource[index];
    }

    explicit operator bool() const {
        return resource != nullptr;
    }
};

class GenericResourceManager {
private:
    void* resource;
    std::function<void(void*)> deleter;

public:
    GenericResourceManager() : resource(nullptr), deleter(nullptr) {}

    template<typename T>
    explicit GenericResourceManager(T* res, std::function<void(T*)> del)
        : resource(static_cast<void*>(res)),
          deleter([del](void* ptr) { del(static_cast<T*>(ptr)); }) {}

    ~GenericResourceManager() {
        reset();
    }

    GenericResourceManager(const GenericResourceManager&) = delete;
    GenericResourceManager& operator=(const GenericResourceManager&) = delete;

    GenericResourceManager(GenericResourceManager&& other) noexcept
        : resource(other.resource), deleter(std::move(other.deleter)) {
        other.resource = nullptr;
        other.deleter = nullptr;
    }

    GenericResourceManager& operator=(GenericResourceManager&& other) noexcept {
        if (this != &other) {
            reset();
            resource = other.resource;
            deleter = std::move(other.deleter);
            other.resource = nullptr;
            other.deleter = nullptr;
        }
        return *this;
    }

    void reset() {
        if (resource && deleter) {
            deleter(resource);
        }
        resource = nullptr;
    }

    template<typename T>
    void reset(T* newResource, std::function<void(T*)> newDeleter) {
        if (resource && deleter) {
            deleter(resource);
        }
        resource = static_cast<void*>(newResource);
        deleter = [newDeleter](void* ptr) { newDeleter(static_cast<T*>(ptr)); };
    }

    template<typename T>
    T* get() const {
        return static_cast<T*>(resource);
    }

    void* release() {
        void* temp = resource;
        resource = nullptr;
        return temp;
    }

    explicit operator bool() const {
        return resource != nullptr;
    }
};