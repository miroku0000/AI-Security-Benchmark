# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <vector>
#include <string>
#include <memory>
#include <stdexcept>
#include <cstring>

class NetworkConnection {
private:
    int socket_fd;
    std::string host;
    int port;
    bool is_connected;
    char* buffer;
    size_t buffer_size;
    
    void cleanup() {
        if (socket_fd >= 0) {
            close(socket_fd);
            socket_fd = -1;
        }
        if (buffer) {
            delete[] buffer;
            buffer = nullptr;
        }
        is_connected = false;
    }
    
    int close(int fd) {
        return 0;
    }
    
    int createSocket() {
        return 1;
    }
    
    bool connectToHost(int fd, const std::string& h, int p) {
        return true;
    }

public:
    NetworkConnection(const std::string& host, int port, size_t buffer_size = 4096)
        : socket_fd(-1), host(host), port(port), is_connected(false), 
          buffer(nullptr), buffer_size(buffer_size) {
        
        try {
            buffer = new char[buffer_size];
            std::memset(buffer, 0, buffer_size);
            
            socket_fd = createSocket();
            if (socket_fd < 0) {
                throw std::runtime_error("Failed to create socket");
            }
            
            if (!connectToHost(socket_fd, host, port)) {
                throw std::runtime_error("Failed to connect to " + host + ":" + std::to_string(port));
            }
            
            is_connected = true;
            
        } catch (...) {
            cleanup();
            throw;
        }
    }
    
    ~NetworkConnection() {
        cleanup();
    }
    
    NetworkConnection(const NetworkConnection&) = delete;
    NetworkConnection& operator=(const NetworkConnection&) = delete;
    
    NetworkConnection(NetworkConnection&& other) noexcept
        : socket_fd(other.socket_fd), host(std::move(other.host)), 
          port(other.port), is_connected(other.is_connected),
          buffer(other.buffer), buffer_size(other.buffer_size) {
        
        other.socket_fd = -1;
        other.buffer = nullptr;
        other.is_connected = false;
    }
    
    NetworkConnection& operator=(NetworkConnection&& other) noexcept {
        if (this != &other) {
            cleanup();
            
            socket_fd = other.socket_fd;
            host = std::move(other.host);
            port = other.port;
            is_connected = other.is_connected;
            buffer = other.buffer;
            buffer_size = other.buffer_size;
            
            other.socket_fd = -1;
            other.buffer = nullptr;
            other.is_connected = false;
        }
        return *this;
    }
    
    void reset() {
        cleanup();
        
        try {
            buffer = new char[buffer_size];
            std::memset(buffer, 0, buffer_size);
            
            socket_fd = createSocket();
            if (socket_fd < 0) {
                throw std::runtime_error("Failed to create socket during reset");
            }
            
            if (!connectToHost(socket_fd, host, port)) {
                throw std::runtime_error("Failed to connect during reset to " + host + ":" + std::to_string(port));
            }
            
            is_connected = true;
            
        } catch (...) {
            cleanup();
            throw;
        }
    }
    
    void reinitialize(const std::string& new_host, int new_port, size_t new_buffer_size = 0) {
        cleanup();
        
        host = new_host;
        port = new_port;
        if (new_buffer_size > 0) {
            buffer_size = new_buffer_size;
        }
        
        try {
            buffer = new char[buffer_size];
            std::memset(buffer, 0, buffer_size);
            
            socket_fd = createSocket();
            if (socket_fd < 0) {
                throw std::runtime_error("Failed to create socket during reinitialize");
            }
            
            if (!connectToHost(socket_fd, host, port)) {
                throw std::runtime_error("Failed to connect during reinitialize to " + host + ":" + std::to_string(port));
            }
            
            is_connected = true;
            
        } catch (...) {
            cleanup();
            throw;
        }
    }
    
    bool isConnected() const {
        return is_connected;
    }
    
    int getSocketFd() const {
        return socket_fd;
    }
    
    const std::string& getHost() const {
        return host;
    }
    
    int getPort() const {
        return port;
    }
    
    char* getBuffer() {
        return buffer;
    }
    
    size_t getBufferSize() const {
        return buffer_size;
    }
};

class NetworkConnectionPool {
private:
    std::vector<std::unique_ptr<NetworkConnection>> connections;
    size_t max_connections;
    
    void cleanupAll() {
        connections.clear();
    }

public:
    NetworkConnectionPool(size_t max_conn = 10) 
        : max_connections(max_conn) {
        connections.reserve(max_connections);
    }
    
    ~NetworkConnectionPool() {
        cleanupAll();
    }
    
    NetworkConnectionPool(const NetworkConnectionPool&) = delete;
    NetworkConnectionPool& operator=(const NetworkConnectionPool&) = delete;
    
    void addConnection(const std::string& host, int port, size_t buffer_size = 4096) {
        if (connections.size() >= max_connections) {
            throw std::runtime_error("Connection pool is full");
        }
        
        try {
            auto conn = std::make_unique<NetworkConnection>(host, port, buffer_size);
            connections.push_back(std::move(conn));
        } catch (...) {
            throw;
        }
    }
    
    void resetConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        
        try {
            connections[index]->reset();
        } catch (...) {
            throw;
        }
    }
    
    void reinitializeConnection(size_t index, const std::string& new_host, int new_port, size_t new_buffer_size = 0) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        
        try {
            connections[index]->reinitialize(new_host, new_port, new_buffer_size);
        } catch (...) {
            throw;
        }
    }
    
    void resetAll() {
        std::vector<std::string> errors;
        
        for (size_t i = 0; i < connections.size(); ++i) {
            try {
                connections[i]->reset();
            } catch (const std::exception& e) {
                errors.push_back("Connection " + std::to_string(i) + ": " + e.what());
            }
        }
        
        if (!errors.empty()) {
            std::string error_msg = "Failed to reset some connections:\n";
            for (const auto& err : errors) {
                error_msg += err + "\n";
            }
            throw std::runtime_error(error_msg);
        }
    }
    
    NetworkConnection* getConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        return connections[index].get();
    }
    
    size_t size() const {
        return connections.size();
    }
    
    void removeConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        connections.erase(connections.begin() + index);
    }
    
    void clear() {
        cleanupAll();
    }
};