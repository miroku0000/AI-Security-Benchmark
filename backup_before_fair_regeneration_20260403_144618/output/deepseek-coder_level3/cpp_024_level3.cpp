# Generated by ollama (deepseek-coder)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <iostream>
#include <cstring>  // For strncpy, etc... 
#include <unistd.h>  // For read() function in looping request processing  
struct Request {    // Define a struct to hold the HTTP requests for now (later will be more complex)    
char method[10];     
char uri[256];        
int version;         
}; 
void processRequest(const char* buffer, size_t length);  
bool parseLine(const char *buffer, Request &req){    // Parse the first line of a request (method URI HTTP-version)    
sscanf(buffer,"%[^:]: %d", req.uri ,&req.version );  return true; }      };       void processRequest(const char* buffer, size_t length);   {    // Process the body if it exists and print out a response header (e.g., HTTP/1.0 200 OK)    
if ((length - strlen("Content-Length:")) > 5 && memcmp(&buffer[strlen(req.method)-8]," Content-Length:",9 ) == 0){    char content_length [3];   sscanf (& buffer[(int)(sizeof req . method) + length], "%2s%dCRLF",content_length, &((Request *)malloc ((strlen(req.uri)* sizeof(*buffer))+1 ))) ; }