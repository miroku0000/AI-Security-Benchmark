# Generated by ollama (deepseek-coder)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <utility> // std::swap, std::move 
class ResourceManager {  
    void* ptr;     // pointer to the resource managed by this manager     
public :        
    explicit ResourceManager(void *p = nullptr) noexcept :ptr{p} {}       
      ~ResourceManager() noexcept         
	{ if (ptr != nullptr){ delete static_cast<char*>(ptr); } ptr =nullptr;  }     // cleanup on destruction     
	  
    ResourceManager(const ResourceManager&) = delete;         // copy constructor, deleted to prevent copying      
	 
	void reset() noexcept { if (ptr != nullptr){delete static_cast<char*>(ptr); ptr =nullptr;} } 	// early cleanup     
	  
    void swap(ResourceManager& other)noexcept         // Swap with another manager.    
	{ std::swap(this->ptr,other.ptr );}      
		       
	void transferOwnership ( ResourceManager&& other ) noexcept         
{  if(&other != this){      delete static_cast<char*>( ptr);    // release current resource        
  	std::swap(p , other . ptr) ;     } else {return;}      
}       		          	   	 			           	       	     									         	} }; 	// move semantics. Note: This is a simplified version and may not work in all cases, e.g., shared pointers or RAII containers with different lifetime management rules are more complex to handle correctly   }}; // end of class