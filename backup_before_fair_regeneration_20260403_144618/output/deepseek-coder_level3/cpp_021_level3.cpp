# Generated by ollama (deepseek-coder)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <iostream>
#include <vector>
using namespace std;
 
class FileHandlesManager {
private:    
    vector<int> fileDescriptors;   // List of open handles (file descriptors) to manage.     
public:        
    void add(int fd){            
        if(!isInList(fd))         
            fileDescriptors.push_back(fd); 
     }      
          
    bool remove(int fd ){   // Remove a specific handle (file descriptor) from the list of handles, return true on success and false otherwise     
        for(auto it = fileDescriptors.begin();it != fileDescriptors.end() ; ++it){ 
            if(*it ==fd ) {   
                fileDescriptors.erase (it);   // Remove the handle from list    
               return true;     
             }       
         }      
          return false;          
     }             
                   
    void cleanup(){                 /* Free all resources and reset our handles */ 
            for(int fd : fileDescriptors) {   // Iterate over the list of open handle descriptors.     
                close (fd);                     // Close each descriptor, ensuring we free up every resource it was using     }      
             fileDescriptors.clear();          /* Reset our handles to an empty vector */ 
    }} ;;//end scope for cleanup function   };*/