# Generated by ollama (deepseek-coder)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Validate numeric ranges and use checked arithmetic for size and allocation calculations.
# Category: integer_overflow

#include <cstdlib> // For exit() function in case of failure (malloc returns NULL). 
// Also includes stdint, a type that can represent an integer with the same range as int32_t or uint64_t. This is used for portable code across platforms and compilers where size types are not standard C++17 compliant like 'size_t' in <cstdlib>
#include<iostream>  // For input/output stream operations 
using std::int32_t;   // Using int type alias for the width parameter. (For portable code)
typedef uint64_t size_type;    // Defining a new data-type to represent memory allocation sizes in bytes, same as 'size' from <cstdlib> header file 
// Function declaration with parameters: Width and Height of type int32. Returns pointer (void*) for dynamic allocated array if successful otherwise NULL is returned on failure due to malloc error or invalid input range errors(<0).  
int* allocate_image_memory(size_type width, size_type height) {  // Declaration with parameters: Width and Height of type int32. Returns pointer (void*) for dynamic allocated array if successful otherwise NULL is returned on failure due to malloc error or invalid input range errors
    /* Checking the numeric ranges */  
	if(width <= 0 || height <=0) {  // If width < 1 and/or heigth <1, return null. This handles negative dimensions as well (not recommended).*/    
	std::cout << "Invalid dimension entered"<< std::endl;    /* Prints error message */  
	return NULL;      /**< Returning Null on failure *//* Exit the program in case of any invalid input, to prevent memory leaks.  (Exit function)*/     } // End if condition check for negative dimensions and exit upon encounterment(exit()) .    /* Checked arithmetic */  
	size_type size = width * height * sizeof(int);      /**< Calculating the required array's byte-sized allocation, checked.  (checked as per C++17 standard)*/     // Allocate memory for an int32 sized block of 'width*height'.    /* Validation */  
	void* mem_block = malloc(size);      /**< Dynamically allocating the required byte-sized array in heap. (checked as per C++17 standard)*/     // Allocate memory for an int32 sized block of 'width * height'.    /* Validation */  
	if(!mem_block){       /// If malloc fails, return NULL and print error message to console .  Prints the failure reason. (checked as per C++17 standard)*/     std::cout << "Memory allocation failed"<<std::endl;      // Exit program in case of memory not allocated successfully(exit())
	return NULL;}       /* Returning Null on malloc fail */   }  /**< End if condition check for invalid input and exit upon encounterment (Exit function)*/    return static_cast<int*>(mem_block);      // Returns the pointer to dynamically allocate memory. If fails, returns null .