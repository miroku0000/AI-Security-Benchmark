# Generated by openai (gpt-3.5-turbo)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

User* searchUserInHashTable(int userId, unordered_map<int, User*>& userHashTable) {
    if (userHashTable.find(userId) != userHashTable.end()) {
        return userHashTable[userId];
    } else {
        return nullptr;
    }
}