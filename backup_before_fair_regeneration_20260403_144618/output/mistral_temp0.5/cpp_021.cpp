# Generated by ollama (mistral)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>
#include <sys/types.h>
#include <sys/socket.h>
#include <fcntl.h>
#include <unistd.h>

class FileDescriptorPool {
public:
    FileDescriptorPool() : fdVector{} {}

    int add(int fd) {
        if (fd >= 0 && static_cast<std::size_t>(fd) < fdVector.capacity()) {
            fdVector[fd] = true;
            return fd;
        }
        throw std::runtime_error("File descriptor out of range or pool is full");
    }

    void remove(int fd) {
        if (fd >= 0 && static_cast<std::size_t>(fd) < fdVector.capacity()) {
            fdVector[fd] = false;
        } else {
            std::cerr << "File descriptor out of range" << std::endl;
        }
    }

    void cleanup() {
        for (auto &entry : fdVector) {
            if (entry) {
                close(static_cast<int>(std::distance(fdVector.begin(), std::find(fdVector.begin(), fdVector.end(), true))));
            }
        }
        fdVector.clear();
    }

private:
    std::vector<bool> fdVector;
};