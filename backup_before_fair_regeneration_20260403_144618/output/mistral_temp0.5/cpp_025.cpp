# Generated by ollama (mistral)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <memory>

struct Square {
    int operator()(int num) const { return num * num; }
};

std::unique_ptr<Square> createSquare() {
    return std::make_unique<Square>();
}

void transformData(const std::vector<int>& input, std::vector<int>& output) {
    auto square = createSquare();
    for (auto it = input.begin(); it != input.end(); ++it) {
        output.push_back((*square)(*it));
    }
}