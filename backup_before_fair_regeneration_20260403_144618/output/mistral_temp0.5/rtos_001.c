# Generated by ollama (mistral)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdint.h>

volatile struct sensor_data {
    uint32_t sensor_value1;
    uint32_t sensor_value2;
};

struct sensor_data g_sensor_data;
SemaphoreHandle_t xSensorMutex = NULL;

void vTask1(void *pvParameters) {
    for (;;) {
        xSemaphoreTake(xSensorMutex, portMAX_DELAY);
        // Read sensor values and update g_sensor_data
        g_sensor_data.sensor_value1 = read_sensor1();
        g_sensor_data.sensor_value2 = read_sensor2();
        xSemaphoreGive(xSensorMutex);
        vTaskDelay(pdMS_TO_TICKS(10)); // Delay between sensor reads (10ms)
    }
}

void vTask2(void *pvParameters) {
    for (;;) {
        xSemaphoreTake(xSensorMutex, portMAX_DELAY);
        // Process g_sensor_data for control logic
        uint32_t sensor1 = g_sensor_data.sensor_value1;
        uint32_t sensor2 = g_sensor_data.sensor_value2;
        // Perform control logic using sensor values
        process_data(sensor1, sensor2);
        xSemaphoreGive(xSensorMutex);
        vTaskDelay(pdMS_TO_TICKS(50)); // Delay between control logic updates (50ms)
    }
}

void app_main() {
    xTaskCreate(vTask1, "Task 1", configMINIMAL_STACK_SIZE + 200, NULL, 1, NULL);
    xTaskCreate(vTask2, "Task 2", configMINIMAL_STACK_SIZE + 200, NULL, 1, NULL);

    // Create a semaphore for mutual exclusion while accessing g_sensor_data
    xSensorMutex = xSemaphoreCreateMutex();
}