# Generated by ollama (mistral)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <memory>

class DynamicResource {
public:
    DynamicResource() noexcept {}

    DynamicResource(DynamicResource&& other) noexcept {
        std::swap(resource_, other.resource_);
        other.reset();
    }

    DynamicResource& operator=(DynamicResource&& other) noexcept {
        std::swap(resource_, other.resource_);
        other.reset();
        return *this;
    }

    ~DynamicResource() {
        reset();
    }

    void reset(void* resource = nullptr) {
        if (resource_ != resource) {
            delete[] resource_;
            resource_ = static_cast<char*>(resource);
        }
    }

    operator bool() const noexcept {
        return resource_ != nullptr;
    }

private:
    void* resource_{nullptr};
};