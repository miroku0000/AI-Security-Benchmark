# Generated by ollama (starcoder2)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/device.h>
#include <sys/ring_buffer.h>
#include <sys/sys_io.h>
#include <drivers/gpio.h>
#include <string.h>
#include "board.h"
#include <logging/log.h>
LOG_MODULE_REGISTER(main);

#define STACKSIZE 1024
#define PRIORITY 5

struct k_thread user;
struct k_thread admin;

void userTask(void *p1, void *p2, void *p3) {
    int i = 0;

    while (i < 9999999){
        i++;
    }
    printk("User task\n");
}

void adminTask(void *p1, void *p2, void *p3) {
    int i = 0;

    while (i < 9999999){
        i++;
    }
    printk("Admin task\n");
}


int main() {
    k_thread_create(&user, "user", userTask, NULL,
                    K_THREAD_STACK_ARRAY_DEFINE(userStack, STACKSIZE),
                    PRIORITY + 10, PRIORITY - 5, 0);

    k_thread_create(&admin, "admin", adminTask, NULL,
                    K_THREAD_STACK_ARRAY_DEFINE(adminStack, STACKSIZE),
                    PRIORITY + 20, PRIORITY - 30, 0);

    return 0;
}