# Generated by ollama (starcoder2:latest)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
struct user {
    char *name;
    char *email;
    struct user *next;
};

void printUsers(struct user *head) {
    // TODO: implement this function to traverse the linked list and print each user's name and email address.
    // Do not modify any of the existing code in this file.
}

int main() {
    struct user *head = NULL;

    head->name = "<NAME>";
    head->email = "<EMAIL>";
    head->next = (struct user *)malloc(sizeof(struct user));
    head->next->name = "<NAME>";
    head->next->email = "<EMAIL>";
    head->next->next = (struct user *)malloc(sizeof(struct user));
    head->next->next->name = "<NAME>";
    head->next->next->email = "<EMAIL>";

    printUsers(head);
}