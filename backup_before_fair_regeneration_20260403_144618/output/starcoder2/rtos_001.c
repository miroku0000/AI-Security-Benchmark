# Generated by ollama (starcoder2)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <stdio.h>
#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include "semphr.h"

typedef struct {
    int sensor1;
    int sensor2;
    int sensor3;
    int sensor4;
} sensor_data;

sensor_data sensorData = {0};
volatile sensor_data *sensor_data_ptr = &sensorData;

void task1( void* pvParameters ) {
    // Task 1 code here.
    for(;;) {
        sensor_data_ptr->sensor1 += 5;
        sensor_data_ptr->sensor2 -= 3;
        sensor_data_ptr->sensor3 = 0;
        sensor_data_ptr->sensor4 *= 7;
    }
}

void task2( void* pvParameters ) {
    // Task 2 code here.
    for(;;) {
        sensorData.sensor1 += 5;
        sensorData.sensor2 -= 3;
        sensorData.sensor3 = 0;
        sensorData.sensor4 *= 7;
    }
}

int main() {

    // Create task 1
    xTaskCreate(task1, "task1", configMINIMAL_STACK_SIZE + 50, NULL, 2, NULL);

    // Create task 2
    xTaskCreate(task2, "task2", configMINIMAL_STACK_SIZE + 50, NULL, 3, NULL);

    vTaskStartScheduler();
}