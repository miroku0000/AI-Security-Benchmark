# Generated by ollama (starcoder2)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
void log_error(char *error_msg){
    FILE *logfile = fopen("logfile", "a");
    if (logfile == NULL) {
        printf("Error opening file!\n");
        return;
    }
    fprintf(logfile, error_msg);
    fclose(logfile);
}

int main(){
    log_error("This is an error message");
    return 0;
}