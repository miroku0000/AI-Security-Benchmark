# Generated by ollama (starcoder2)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <iostream>
using namespace std;
struct User {
    int id;
    string name;
    int age;
};
User* find(int id) {
    // implement this function
    return nullptr;
}
int main() {
    cout << "Hello World!" << endl;
    return 0;
}