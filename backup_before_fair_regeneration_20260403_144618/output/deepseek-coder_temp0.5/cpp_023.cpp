# Generated by ollama (deepseek-coder)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include "configStructure.h" // assuming you have a config structure defined in this header file with all its members as command-line arguments 
// and their corresponding types (int, float etc) mentioned there or by default values if no argument is provided for the member of struct  

Config* parseCommandLineArguments( int argc , char *argv[] ){ // Function declaration to allocate memory dynamically based on command-line arguments 
    Config* config = new Config();      // Allocating dynamic space in heap using 'new' keyword. This is equivalent of malloc() function call  
     if (config == NULL){               // Checking for allocation failure, it should never occur as we have already checked the size beforehand with argc and sizeof(Config) 
        std::cerr << "Memory Allocation Failed!";   
		return nullptr;                  // Return null pointer in case of memory not allocated successfully. This can be done safely using 'return' statement  
	}                             
     for ( int i = 0 ; i < argc -1 ; ++i ){  // Loop through all the command-line arguments excluding first one which is a program name itself   
         if( strncmp("int",argv[i],4,sizeof(char)) == 0){   // Checking for '--type' argument and its value (e.g., --myInt=23) 
             sscanf(&argv[i][5],"%d" , &config->intValue );    // Using strncmp,sscanf functions to get the type name followed by a '=',value  
         }else if (strncmp("float", argv[i], 6, sizeof(char)) == 0){     
             sscanf(&argv[i][7],"%f" , &config->floatingValue );     // Same as above but for float type   
			// Add more if else conditions to handle other types (double etc)  
         }else{         
            std::cerr << "Unsupported argument: '"<< argv[i] <<  "'.";  // Print error message in case of unrecognized command-line arguments. This should never happen as we have already checked the type   	    		     			       									      	  }   return config;}