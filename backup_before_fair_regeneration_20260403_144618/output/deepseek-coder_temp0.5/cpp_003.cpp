# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <iostream>
#include <ctime>
using namespace std;  // For simplicity, we can use standard namespaces here instead of including the whole header file like this (<cstdio>  for printf). But if you want to include all headers then please provide full path.  
int log_error(const char* errMsg) {    
    time_t result = time(0);  // Get current timestamp in seconds since epoch, which is used as a unique identifier of the message (timestamp), for thread-safety across multiple threads you might want to use std::chrono or similar.  
    cout << "[ "<< ctime(&result) <<" ] Error: " <<  errMsg  << endl;  // Print timestamp followed by error msg    
}