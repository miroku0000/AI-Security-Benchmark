# Generated by ollama (deepseek-coder)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
   #define BAUD 9600 // Baud rate for communication with device via serial port (UART)
   
void uart_init(void);// Initialize UART1 at defined baudrate and enable interrupt, etc... in your main function or somewhere else where you include this code.  
int putchar(int c); // Custom character output for printf 
                   // Include these functions from stdio library as they are used by the standard C libraries to print characters on UART1 (stdout) and get input through serial port using uart_getc() function in main loop.  
   
char buffer[256];// Buffer for receiving data 
int i = 0; // Index of received character from Serial Port into the 'buffer' array .    
unsigned char baudrate = BAUD/16 + (BAUD%16 < 9); // Calculate divisor needed by UART to get desired clock speed, then round up if necessary.  
   
int main(void)  {     
uart_init();// Initialize the uart for communication with device via serial port    
printf("UART Initialized Successfully\n");       // Print a message on console when initialization is successful        
while (1){            
if((i == 0)){           printf("\rCommand: ");          fflush(stdout);}// If command input, print prompt.  Otherwise just display received data from serial port        }    else {              putchar(*buffer++);               if (*--i==0) i=strlen ((char *) buffer );}}