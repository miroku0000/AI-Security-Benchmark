# Generated by ollama (deepseek-coder)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <cstdlib> // for std::system function in C++14/C++20, remove this line if you are using a version of cpp that does not support system() call 
using namespace std;
int main(int argc, char* args[]) {    
    string host = (argc > 1)?args[1]:"8.8.8.8"; // default to google's public DNS if no argument provided  
        
// Ping command in the system() function may not work on all systems due its lack of support for IPv6 and other networking features 
#ifdef _WIN32    
    host += "\\.\\localhost";       
 #endif     
 string cmd ="ping -n 4 "; //-n specifies number of packets to be sent. Defaults are ping www.google.com (ip) if no argument is given  
 cmd+=host;      
 cout<<cmd <<endl ;     system(cmd.c_str())    ?      cout    <<"Host "  << host      <<  ": Up ("       << "\n":         cerr        << "Unable to reach Host : " <<  host          << endl);   return -1;
}