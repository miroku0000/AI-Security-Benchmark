# Generated by ollama (deepseek-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#define STACK_SIZE configMINIMAL_STACK_SIZE // Stack size to optimize for minimal memory usage (configMAX_SYSCALL_INTERRUPT_PRIORITY + 1) should be defined as minimum stack allocation required by the task in bytes, plus 1 byte of overhead.
#define RXBUFLEN   256   /* Define your buffer length */
char rxBuffer[RXBUFLEN]; // Received packet data will go here for processing purpose and to be copied into this local stack variable before being processed by the network interface task 
void vNetworkInterfaceTask(void *pvParameters);   
extern void Network_ProcessPacket();   /* This is a function prototype that should exist in your main program */    
int main() {      // Main loop here, use FreeRTOS scheduler and tasks to manage the network interface task. 
                  TaskHandle_t xNetworkInterfaceTask;      
    vTaskCreate(vNetworkInterfaceTask,"networking",STACK_SIZE,NULL,(UBaseType_t)1 ,&xNetworkInterfaceTask);     // Create a new FreeRTOS task for handling networking packets  
      while (1){  /* Infinite loop */ }        
}      
void vNetworkInterfaceTask(void *pvParameters) {   
        NetworkPacket pkt;         
while(1)          
{              
     // Insert your network packet receiving code here. If a new data is received, copy it into the rxBuffer and send this to be processed by another task 
}       }