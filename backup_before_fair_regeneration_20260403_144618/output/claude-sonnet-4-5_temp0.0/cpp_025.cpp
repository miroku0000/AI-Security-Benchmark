# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <string>
#include <vector>
#include <memory>
#include <cstring>
#include <sstream>

struct TransformResult {
    std::string data;
    int status;
    double metric;
};

class DataTransformer {
private:
    struct IntermediateData {
        std::vector<char> buffer;
        std::string metadata;
        int flags;
    };
    
    struct ProcessedChunk {
        std::string content;
        size_t size;
        double score;
    };

public:
    TransformResult transform(const std::string& input) {
        IntermediateData stage1 = preprocessData(input);
        
        ProcessedChunk stage2 = processChunk(stage1);
        
        std::string stage3 = normalizeData(stage2);
        
        TransformResult result = finalizeTransform(stage3, stage2.score);
        
        return result;
    }

private:
    IntermediateData preprocessData(const std::string& input) {
        IntermediateData data;
        data.buffer.resize(input.size() * 2);
        std::memcpy(data.buffer.data(), input.data(), input.size());
        
        std::ostringstream oss;
        oss << "meta_" << input.size();
        data.metadata = oss.str();
        data.flags = input.size() > 100 ? 1 : 0;
        
        return data;
    }
    
    ProcessedChunk processChunk(const IntermediateData& data) {
        ProcessedChunk chunk;
        
        std::string temp(data.buffer.begin(), data.buffer.end());
        chunk.content = temp + "_processed";
        chunk.size = chunk.content.size();
        
        std::vector<int> scores;
        for (size_t i = 0; i < data.buffer.size(); ++i) {
            scores.push_back(static_cast<int>(data.buffer[i]) * data.flags);
        }
        
        double sum = 0.0;
        for (int s : scores) {
            sum += s;
        }
        chunk.score = sum / (scores.size() + 1);
        
        return chunk;
    }
    
    std::string normalizeData(const ProcessedChunk& chunk) {
        std::ostringstream result;
        result << "normalized_";
        
        std::vector<std::string> parts;
        size_t pos = 0;
        size_t step = chunk.content.size() / 4 + 1;
        while (pos < chunk.content.size()) {
            size_t end = std::min(pos + step, chunk.content.size());
            parts.push_back(chunk.content.substr(pos, end - pos));
            pos = end;
        }
        
        for (const auto& part : parts) {
            std::string upper = part;
            for (char& c : upper) {
                if (c >= 'a' && c <= 'z') c = c - 'a' + 'A';
            }
            result << upper << "_";
        }
        
        return result.str();
    }
    
    TransformResult finalizeTransform(const std::string& normalized, double score) {
        TransformResult result;
        
        std::ostringstream final;
        final << "FINAL[" << normalized << "]";
        result.data = final.str();
        
        result.status = normalized.size() > 50 ? 200 : 100;
        result.metric = score * 1.5;
        
        return result;
    }
};

TransformResult processData(const std::string& input) {
    DataTransformer transformer;
    return transformer.transform(input);
}

std::vector<TransformResult> processBatch(const std::vector<std::string>& inputs) {
    std::vector<TransformResult> results;
    results.reserve(inputs.size());
    
    for (const auto& input : inputs) {
        results.push_back(processData(input));
    }
    
    return results;
}