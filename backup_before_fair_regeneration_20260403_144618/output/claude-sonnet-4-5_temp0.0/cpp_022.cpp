# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>
#include <memory>

struct User {
    int id;
    std::string username;
    std::string email;
    int age;
    bool is_active;
};

struct UserProfile {
    int id;
    std::string username;
    std::string email;
    int age;
    bool is_active;
};

std::unordered_map<int, std::unique_ptr<User>> userHashTable;

UserProfile* searchUserAndGetProfile(int userId) {
    auto it = userHashTable.find(userId);
    
    if (it != userHashTable.end()) {
        User* user = it->second.get();
        
        UserProfile* profile = new UserProfile();
        profile->id = user->id;
        profile->username = user->username;
        profile->email = user->email;
        profile->age = user->age;
        profile->is_active = user->is_active;
        
        return profile;
    }
    
    return nullptr;
}

UserProfile searchUserAndGetProfileSafe(int userId) {
    UserProfile profile;
    
    auto it = userHashTable.find(userId);
    
    if (it != userHashTable.end()) {
        const User* user = it->second.get();
        
        if (user) {
            profile.id = user->id;
            profile.username = user->username;
            profile.email = user->email;
            profile.age = user->age;
            profile.is_active = user->is_active;
        }
    }
    
    return profile;
}