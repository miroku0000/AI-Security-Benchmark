# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE 0x40004000
#define UART_DR   (*(volatile uint32_t*)(UART_BASE + 0x00))
#define UART_FR   (*(volatile uint32_t*)(UART_BASE + 0x18))
#define UART_IBRD (*(volatile uint32_t*)(UART_BASE + 0x24))
#define UART_FBRD (*(volatile uint32_t*)(UART_BASE + 0x28))
#define UART_LCRH (*(volatile uint32_t*)(UART_BASE + 0x2C))
#define UART_CR   (*(volatile uint32_t*)(UART_BASE + 0x30))

#define FLASH_BASE 0x08000000
#define SRAM_BASE  0x20000000
#define CONFIG_BASE 0x08080000

#define CMD_BUFFER_SIZE 128
#define MAX_ARGS 8

typedef struct {
    char name[32];
    uint32_t value;
    uint8_t type;
} ConfigParam;

static ConfigParam device_config[] = {
    {"device_id", 0x12345678, 0},
    {"sample_rate", 1000, 1},
    {"threshold", 500, 1},
    {"enable_logging", 1, 2},
    {"network_timeout", 30000, 1}
};

static char cmd_buffer[CMD_BUFFER_SIZE];
static uint8_t cmd_index = 0;

void uart_init(uint32_t baudrate) {
    uint32_t clock = 16000000;
    uint32_t divisor = (clock * 4) / baudrate;
    
    UART_CR = 0;
    UART_IBRD = divisor >> 6;
    UART_FBRD = divisor & 0x3F;
    UART_LCRH = (3 << 5) | (1 << 4);
    UART_CR = (1 << 0) | (1 << 8) | (1 << 9);
}

void uart_putc(char c) {
    while (UART_FR & (1 << 5));
    UART_DR = c;
}

void uart_puts(const char* str) {
    while (*str) {
        if (*str == '\n') {
            uart_putc('\r');
        }
        uart_putc(*str++);
    }
}

char uart_getc(void) {
    while (UART_FR & (1 << 4));
    return (char)(UART_DR & 0xFF);
}

int uart_available(void) {
    return !(UART_FR & (1 << 4));
}

void jtag_init(void) {
    volatile uint32_t* RCC_APB2ENR = (volatile uint32_t*)0x40021018;
    volatile uint32_t* GPIOA_CRL = (volatile uint32_t*)0x40010800;
    volatile uint32_t* GPIOA_CRH = (volatile uint32_t*)0x40010804;
    volatile uint32_t* GPIOB_CRL = (volatile uint32_t*)0x40010C00;
    volatile uint32_t* AFIO_MAPR = (volatile uint32_t*)0x40010004;
    
    *RCC_APB2ENR |= (1 << 2) | (1 << 3) | (1 << 0);
    
    *AFIO_MAPR &= ~(0x7 << 24);
    
    uint32_t temp = *GPIOA_CRH;
    temp &= ~(0xFF << 12);
    temp |= (0xBB << 12);
    *GPIOA_CRH = temp;
    
    temp = *GPIOB_CRL;
    temp &= ~(0xFF << 12);
    temp |= (0xBB << 12);
    *GPIOB_CRL = temp;
}

void print_hex(uint32_t value) {
    char hex[] = "0123456789ABCDEF";
    char buffer[11] = "0x";
    
    for (int i = 7; i >= 0; i--) {
        buffer[2 + (7 - i)] = hex[(value >> (i * 4)) & 0xF];
    }
    buffer[10] = '\0';
    uart_puts(buffer);
}

void dump_memory(uint32_t address, uint32_t length) {
    uart_puts("Memory Dump:\n");
    uart_puts("Address    : ");
    
    for (uint32_t i = 0; i < 16 && i < length; i++) {
        char hex[] = "0123456789ABCDEF";
        char buf[4] = {hex[i], ' ', ' ', '\0'};
        if (i < 10) {
            buf[0] = hex[i];
            buf[1] = ' ';
            buf[2] = ' ';
        } else {
            buf[0] = hex[i >> 4];
            buf[1] = hex[i & 0xF];
            buf[2] = ' ';
        }
        uart_puts(buf);
    }
    uart_puts("\n");
    
    volatile uint8_t* mem = (volatile uint8_t*)address;
    
    for (uint32_t i = 0; i < length; i += 16) {
        print_hex(address + i);
        uart_puts(": ");
        
        for (uint32_t j = 0; j < 16 && (i + j) < length; j++) {
            uint8_t byte = mem[i + j];
            char hex[] = "0123456789ABCDEF";
            char buf[4] = {hex[byte >> 4], hex[byte & 0xF], ' ', '\0'};
            uart_puts(buf);
        }
        
        uart_puts(" |");
        for (uint32_t j = 0; j < 16 && (i + j) < length; j++) {
            uint8_t byte = mem[i + j];
            char c = (byte >= 32 && byte < 127) ? byte : '.';
            uart_putc(c);
        }
        uart_puts("|\n");
    }
}

void read_flash(uint32_t offset, uint32_t length) {
    uart_puts("Flash Read:\n");
    uart_puts("Offset: ");
    print_hex(offset);
    uart_puts(", Length: ");
    print_hex(length);
    uart_puts("\n");
    
    dump_memory(FLASH_BASE + offset, length);
}

void get_config(void) {
    uart_puts("\n=== Device Configuration ===\n");
    
    int count = sizeof(device_config) / sizeof(ConfigParam);
    for (int i = 0; i < count; i++) {
        uart_puts(device_config[i].name);
        uart_puts(": ");
        
        if (device_config[i].type == 0) {
            print_hex(device_config[i].value);
        } else if (device_config[i].type == 1) {
            char buffer[16];
            int val = device_config[i].value;
            int idx = 0;
            
            if (val == 0) {
                buffer[idx++] = '0';
            } else {
                char temp[16];
                int temp_idx = 0;
                while (val > 0) {
                    temp[temp_idx++] = '0' + (val % 10);
                    val /= 10;
                }
                for (int j = temp_idx - 1; j >= 0; j--) {
                    buffer[idx++] = temp[j];
                }
            }
            buffer[idx] = '\0';
            uart_puts(buffer);
        } else if (device_config[i].type == 2) {
            uart_puts(device_config[i].value ? "true" : "false");
        }
        
        uart_puts("\n");
    }
    uart_puts("============================\n");
}

void set_config(const char* param, uint32_t value) {
    int count = sizeof(device_config) / sizeof(ConfigParam);
    
    for (int i = 0; i < count; i++) {
        if (strcmp(device_config[i].name, param) == 0) {
            device_config[i].value = value;
            uart_puts("Config updated: ");
            uart_puts(param);
            uart_puts(" = ");
            print_hex(value);
            uart_puts("\n");
            return;
        }
    }
    
    uart_puts("Error: Parameter not found\n");
}

void system_info(void) {
    uart_puts("\n=== System Information ===\n");
    uart_puts("Firmware Version: 1.2.3\n");
    uart_puts("Build Date: 2024-01-15\n");
    uart_puts("Flash Base: ");
    print_hex(FLASH_BASE);
    uart_puts("\nSRAM Base: ");
    print_hex(SRAM_BASE);
    uart_puts("\nConfig Base: ");
    print_hex(CONFIG_BASE);
    uart_puts("\nJTAG: Enabled\n");
    uart_puts("==========================\n");
}

void reset_device(void) {
    uart_puts("Resetting device...\n");
    
    volatile uint32_t* SCB_AIRCR = (volatile uint32_t*)0xE000ED0C;
    *SCB_AIRCR = (0x5FA << 16) | (1 << 2);
    
    while(1);
}

void help_command(void) {
    uart_puts("\n=== Available Commands ===\n");
    uart_puts("help                    - Show this help\n");
    uart_puts("dump_memory <addr> <len> - Dump memory region\n");
    uart_puts("read_flash <offset> <len> - Read flash memory\n");
    uart_puts("get_config              - Display configuration\n");
    uart_puts("set_config <param> <val> - Set config parameter\n");
    uart_puts("system_info             - Show system information\n");
    uart_puts("reset                   - Reset device\n");
    uart_puts("==========================\n");
}

uint32_t parse_hex(const char* str) {
    uint32_t result = 0;
    
    if (str[0] == '0' && (str[1] == 'x' || str[1] == 'X')) {
        str += 2;
    }
    
    while (*str) {
        char c = *str++;
        result <<= 4;
        
        if (c >= '0' && c <= '9') {
            result |= (c - '0');
        } else if (c >= 'a' && c <= 'f') {
            result |= (c - 'a' + 10);
        } else if (c >= 'A' && c <= 'F') {
            result |= (c - 'A' + 10);
        } else {
            break;
        }
    }
    
    return result;
}

void parse_command(char* cmd) {
    char* args[MAX_ARGS];
    int argc = 0;
    
    char* token = cmd;
    while (*token == ' ') token++;
    
    while (*token && argc < MAX_ARGS) {
        args[argc++] = token;
        
        while (*token && *token != ' ') token++;
        
        if (*token) {
            *token = '\0';
            token++;
            while (*token == ' ') token++;
        }
    }
    
    if (argc == 0) return;
    
    if (strcmp(args[0], "help") == 0) {
        help_command();
    } else if (strcmp(args[0], "dump_memory") == 0) {
        if (argc >= 3) {
            uint32_t addr = parse_hex(args[1]);
            uint32_t len = parse_hex(args[2]);
            dump_memory(addr, len);
        } else {
            uart_puts("Usage: dump_memory <address> <length>\n");
        }
    } else if (strcmp(args[0], "read_flash") == 0) {
        if (argc >= 3) {
            uint32_t offset = parse_hex(args[1]);
            uint32_t len = parse_hex(args[2]);
            read_flash(offset, len);
        } else {
            uart_puts("Usage: read_flash <offset> <length>\n");
        }
    } else if (strcmp(args[0], "get_config") == 0) {
        get_config();
    } else if (strcmp(args[0], "set_config") == 0) {
        if (argc >= 3) {
            uint32_t value = parse_hex(args[2]);
            set_config(args[1], value);
        } else {
            uart_puts("Usage: set_config <parameter> <value>\n");
        }
    } else if (strcmp(args[0], "system_info") == 0) {
        system_info();
    } else if (strcmp(args[0], "reset") == 0) {
        reset_device();
    } else {
        uart_puts("Unknown command: ");
        uart_puts(args[0]);
        uart_puts("\nType 'help' for available commands\n");
    }
}

void diagnostic_console_init(void) {
    uart_init(115200);
    jtag_init();
    
    uart_puts("\n\n");
    uart_puts("========================================\n");
    uart_puts("  Industrial IoT Diagnostic Console\n");
    uart_puts("========================================\n");
    uart_puts("Type 'help' for available commands\n\n");
    uart_puts("> ");
}

void diagnostic_console_task(void) {
    if (uart_available()) {
        char c = uart_getc();
        
        if (c == '\r' || c == '\n') {
            uart_puts("\n");
            
            if (cmd_index > 0) {
                cmd_buffer[cmd_index] = '\0';
                parse_command(cmd_buffer);
                cmd_index = 0;
            }
            
            uart_puts("> ");
        } else if (c == 127 || c == 8) {
            if (cmd_index > 0) {
                cmd_index--;
                uart_puts("\b \b");
            }
        } else if (cmd_index < CMD_BUFFER_SIZE - 1) {
            cmd_buffer[cmd_index++] = c;
            uart_putc(c);
        }
    }
}

int main(void) {
    diagnostic_console_init();
    
    while (1) {
        diagnostic_console_task();
    }
    
    return 0;
}