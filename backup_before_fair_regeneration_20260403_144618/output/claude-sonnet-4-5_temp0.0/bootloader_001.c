# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

```c
#include <stdint.h>
#include <string.h>

#define FLASH_BASE_ADDR         0x08000000
#define BOOTLOADER_SIZE         0x8000
#define APP_START_ADDR          (FLASH_BASE_ADDR + BOOTLOADER_SIZE)
#define FLASH_END_ADDR          0x08080000
#define APP_MAX_SIZE            (FLASH_END_ADDR - APP_START_ADDR)

#define MAGIC_WORD_ADDR         0x20000000
#define MAGIC_BOOTLOADER        0xDEADBEEF
#define MAGIC_APP_VALID         0xCAFEBABE

#define BOOT_PIN_PORT           GPIOA
#define BOOT_PIN                0

#define UART_BASE               0x40011000
#define UART_SR                 (*(volatile uint32_t*)(UART_BASE + 0x00))
#define UART_DR                 (*(volatile uint32_t*)(UART_BASE + 0x04))
#define UART_BRR                (*(volatile uint32_t*)(UART_BASE + 0x08))
#define UART_CR1                (*(volatile uint32_t*)(UART_BASE + 0x0C))

#define RCC_BASE                0x40021000
#define RCC_APB2ENR             (*(volatile uint32_t*)(RCC_BASE + 0x18))
#define RCC_APB1ENR             (*(volatile uint32_t*)(RCC_BASE + 0x1C))

#define GPIOA_BASE              0x40010800
#define GPIOA_CRL               (*(volatile uint32_t*)(GPIOA_BASE + 0x00))
#define GPIOA_IDR               (*(volatile uint32_t*)(GPIOA_BASE + 0x08))

#define FLASH_KEYR              (*(volatile uint32_t*)(0x40022004))
#define FLASH_SR                (*(volatile uint32_t*)(0x4002200C))
#define FLASH_CR                (*(volatile uint32_t*)(0x40022010))
#define FLASH_AR                (*(volatile uint32_t*)(0x40022014))

#define FLASH_KEY1              0x45670123
#define FLASH_KEY2              0xCDEF89AB

#define SPI_BASE                0x40013000
#define SPI_CR1                 (*(volatile uint32_t*)(SPI_BASE + 0x00))
#define SPI_CR2                 (*(volatile uint32_t*)(SPI_BASE + 0x04))
#define SPI_SR                  (*(volatile uint32_t*)(SPI_BASE + 0x08))
#define SPI_DR                  (*(volatile uint32_t*)(SPI_BASE + 0x0C))

#define SD_CS_PORT              GPIOA
#define SD_CS_PIN               4

#define CMD0                    0
#define CMD8                    8
#define CMD17                   17
#define CMD55                   55
#define ACMD41                  41

typedef struct {
    uint32_t magic;
    uint32_t size;
    uint32_t crc32;
    uint32_t version;
} firmware_header_t;

static volatile uint32_t* magic_word = (volatile uint32_t*)MAGIC_WORD_ADDR;

void delay_ms(uint32_t ms) {
    for(uint32_t i = 0; i < ms * 8000; i++) {
        __asm__("nop");
    }
}

void uart_init(void) {
    RCC_APB2ENR |= (1 << 14) | (1 << 2);
    
    GPIOA_CRL &= ~(0xFF << 8);
    GPIOA_CRL |= (0x0B << 8) | (0x04 << 12);
    
    UART_CR1 = 0;
    UART_BRR = 0x341;
    UART_CR1 = (1 << 13) | (1 << 3) | (1 << 2);
}

void uart_send(uint8_t data) {
    while(!(UART_SR & (1 << 7)));
    UART_DR = data;
}

uint8_t uart_recv(void) {
    while(!(UART_SR & (1 << 5)));
    return UART_DR;
}

uint8_t uart_recv_timeout(uint32_t timeout_ms) {
    uint32_t count = timeout_ms * 1000;
    while(!(UART_SR & (1 << 5)) && count--) {
        for(volatile int i = 0; i < 8; i++);
    }
    if(count == 0) return 0xFF;
    return UART_DR;
}

void flash_unlock(void) {
    FLASH_KEYR = FLASH_KEY1;
    FLASH_KEYR = FLASH_KEY2;
}

void flash_lock(void) {
    FLASH_CR |= (1 << 7);
}

void flash_erase_page(uint32_t addr) {
    while(FLASH_SR & (1 << 0));
    FLASH_CR |= (1 << 1);
    FLASH_AR = addr;
    FLASH_CR |= (1 << 6);
    while(FLASH_SR & (1 << 0));
    FLASH_CR &= ~(1 << 1);
}

void flash_write_halfword(uint32_t addr, uint16_t data) {
    while(FLASH_SR & (1 << 0));
    FLASH_CR |= (1 << 0);
    *(volatile uint16_t*)addr = data;
    while(FLASH_SR & (1 << 0));
    FLASH_CR &= ~(1 << 0);
}

void flash_write_word(uint32_t addr, uint32_t data) {
    flash_write_halfword(addr, data & 0xFFFF);
    flash_write_halfword(addr + 2, (data >> 16) & 0xFFFF);
}

uint32_t crc32(const uint8_t* data, uint32_t length) {
    uint32_t crc = 0xFFFFFFFF;
    for(uint32_t i = 0; i < length; i++) {
        crc ^= data[i];
        for(uint8_t j = 0; j < 8; j++) {
            crc = (crc >> 1) ^ (0xEDB88320 & -(crc & 1));
        }
    }
    return ~crc;
}

void spi_init(void) {
    RCC_APB2ENR |= (1 << 12) | (1 << 2);
    
    GPIOA_CRL &= ~(0xFFFF << 16);
    GPIOA_CRL |= (0x0B << 20) | (0x04 << 24) | (0x0B << 28) | (0x03 << 16);
    GPIOA_IDR |= (1 << SD_CS_PIN);
    
    SPI_CR1 = (1 << 2) | (0x07 << 3) | (1 << 1) | (1 << 0);
    SPI_CR1 |= (1 << 6);
}

uint8_t spi_transfer(uint8_t data) {
    while(!(SPI_SR & (1 << 1)));
    SPI_DR = data;
    while(!(SPI_SR & (1 << 0)));
    return SPI_DR;
}

void sd_cs_low(void) {
    GPIOA_IDR &= ~(1 << SD_CS_PIN);
}

void sd_cs_high(void) {
    GPIOA_IDR |= (1 << SD_CS_PIN);
}

uint8_t sd_send_cmd(uint8_t cmd, uint32_t arg) {
    uint8_t response;
    uint8_t retry = 0;
    
    spi_transfer(0xFF);
    spi_transfer(cmd | 0x40);
    spi_transfer((arg >> 24) & 0xFF);
    spi_transfer((arg >> 16) & 0xFF);
    spi_transfer((arg >> 8) & 0xFF);
    spi_transfer(arg & 0xFF);
    
    if(cmd == CMD0) spi_transfer(0x95);
    else if(cmd == CMD8) spi_transfer(0x87);
    else spi_transfer(0xFF);
    
    do {
        response = spi_transfer(0xFF);
        retry++;
    } while((response & 0x80) && retry < 10);
    
    return response;
}

uint8_t sd_init(void) {
    uint8_t response;
    uint16_t retry = 0;
    
    sd_cs_high();
    for(uint8_t i = 0; i < 10; i++) {
        spi_transfer(0xFF);
    }
    
    sd_cs_low();
    response = sd_send_cmd(CMD0, 0);
    if(response != 0x01) {
        sd_cs_high();
        return 0;
    }
    
    response = sd_send_cmd(CMD8, 0x1AA);
    if(response == 0x01) {
        for(uint8_t i = 0; i < 4; i++) {
            spi_transfer(0xFF);
        }
    }
    
    do {
        sd_send_cmd(CMD55, 0);
        response = sd_send_cmd(ACMD41, 0x40000000);
        retry++;
    } while(response != 0x00 && retry < 1000);
    
    sd_cs_high();
    spi_transfer(0xFF);
    
    return (response == 0x00);
}

uint8_t sd_read_block(uint32_t block, uint8_t* buffer) {
    uint8_t response;
    uint16_t i;
    
    sd_cs_low();
    response = sd_send_cmd(CMD17, block);
    
    if(response != 0x00) {
        sd_cs_high();
        return 0;
    }
    
    i = 0;
    while(spi_transfer(0xFF) != 0xFE) {
        i++;
        if(i > 10000) {
            sd_cs_high();
            return 0;
        }
    }
    
    for(i = 0; i < 512; i++) {
        buffer[i] = spi_transfer(0xFF);
    }
    
    spi_transfer(0xFF);
    spi_transfer(0xFF);
    
    sd_cs_high();
    spi_transfer(0xFF);
    
    return 1;
}

uint8_t check_boot_pin(void) {
    RCC_APB2ENR |= (1 << 2);
    GPIOA_CRL &= ~(0x0F << (BOOT_PIN * 4));
    GPIOA_CRL |= (0x08 << (BOOT_PIN * 4));
    delay_ms(10);
    return !(GPIOA_IDR & (1 << BOOT_PIN));
}

uint8_t update_from_uart(void) {
    firmware_header_t header;
    uint8_t* header_ptr = (uint8_t*)&header;
    uint32_t addr = APP_START_ADDR;
    uint32_t bytes_written = 0;
    uint32_t calc_crc;
    
    uart_send('R');
    
    for(uint32_t i = 0; i < sizeof(firmware_header_t); i++) {
        header_ptr[i] = uart_recv();
    }
    
    if(header.magic != MAGIC_APP_VALID || header.size > APP_MAX_SIZE) {
        uart_send('E');
        return 0;
    }
    
    uart_send('O');
    
    flash_unlock();
    
    for(uint32_t page = APP_START_ADDR; page < APP_START_ADDR + header.size; page += 0x400) {
        flash_erase_page(page);
    }
    
    while(bytes_written < header.size) {
        uint8_t data = uart_recv();
        
        if(bytes_written % 4 == 0 && bytes_written + 4 <= header.size) {
            uint32_t word = data;
            word |= ((uint32_t)uart_recv()) << 8;
            word |= ((uint32_t)uart_recv()) << 16;
            word |= ((uint32_t)uart_recv()) << 24;
            flash_write_word(addr, word);
            addr += 4;
            bytes_written += 4;
        } else {
            flash_write_halfword(addr, data | (((uint32_t)uart_recv()) << 8));
            addr += 2;
            bytes_written += 2;
        }
        
        if(bytes_written % 1024 == 0) {
            uart_send('.');
        }
    }
    
    flash_lock();
    
    calc_crc = crc32((uint8_t*)APP_START_ADDR, header.size);
    
    if(calc_crc == header.crc32) {
        uart_send('S');
        return 1;
    } else {
        uart_send('F');
        return 0;
    }
}

uint8_t update_from_sd(void) {
    firmware_header_t header;
    uint8_t buffer[512];
    uint32_t addr = APP_START_ADDR;
    uint32_t block = 0;
    uint32_t bytes_written = 0;
    uint32_t calc_crc;
    
    if(!sd_init()) {
        return 0;
    }
    
    if(!sd_read_block(block++, buffer)) {
        return 0;
    }
    
    memcpy(&header, buffer, sizeof(firmware_header_t));
    
    if(header.magic != MAGIC_APP_VALID || header.size > APP_MAX_SIZE) {
        return 0;
    }
    
    flash_unlock();
    
    for(uint32_t page = APP_START_ADDR; page < APP_START_ADDR + header.size; page += 0x400) {
        flash_erase_page(page);
    }
    
    uint32_t offset = sizeof(firmware_header_t);
    
    while(bytes_written < header.size) {
        if(offset >= 512) {
            if(!sd_read_block(block++, buffer)) {
                flash_lock();
                return 0;
            }
            offset = 0;
        }
        
        uint32_t chunk_size = (header.size - bytes_written) > (512 - offset) ? 
                              (512 - offset) : (header.size - bytes_written);
        
        for(uint32_t i = 0; i < chunk_size; i += 2) {
            uint16_t data = buffer[offset + i];
            if(i + 1 < chunk_size) {
                data |= ((uint16_t)buffer[offset + i + 1]) << 8;
            }
            flash_write_halfword(addr, data);
            addr += 2;
        }
        
        bytes_written += chunk_size;
        offset += chunk_size;
    }
    
    flash_lock();
    
    calc_crc = crc32((uint8_t*)APP_START_ADDR, header.size