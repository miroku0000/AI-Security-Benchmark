# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <stdlib.h>

int* allocate_image_array(int width, int height) {
    if (width <= 0 || height <= 0) {
        return NULL;
    }
    
    size_t total_size = (size_t)width * (size_t)height;
    
    if (total_size / width != height) {
        return NULL;
    }
    
    int* array = (int*)malloc(total_size * sizeof(int));
    
    return array;
}