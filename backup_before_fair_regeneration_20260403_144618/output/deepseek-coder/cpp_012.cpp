# Generated by ollama (deepseek-coder:latest)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
// Assume we are using Boost as our library for network programming 
#include <boost/asio.hpp> 
using boost::asio::ip::tcp;   // from tcp socket and ip address resolver, etc...   
    
class ConnectionManager {     
public:
	ConnectionManager(std::size_t numConnections) : ioService_(numConnections), connections_(numConnections){} 
	// Constructor that initializes the service with a number of threads equal to 'concurrent'   // and creates an array for all sockets.   
    ~ConnectionManager() { disconnectAll(); }     
	boost::asio::io_service& getIOService(){ return ioService_;} 
	// Return reference Io Service, which is used by the asynchronous operations to run on a pool of threads   // and manage connections in an efficient manner.   
     void reset() { disconnectAll(); }     
	bool connect(int index)      
	{        if (connections_[index].is_open()) return false;  else          ioService_.post([this, index](){         connectionAttempt(index); });   // If the socket is already open or in a state where it can't continue then we don’t need to do anything.
	}      void disconnectAll()       { for (auto& conn : connections_) if (!conn) boost::system::error_code ignoredError; else  ioService_.post([this, &conn](){         shutdown(conn); }); }   // Disconnect all open sockets and stop the service run on a pool of threads.
     void connectionAttempt (int index){      try { connections_[index].open(tcp::ip::address(), "127.0.0.1", [this, index](boost::system::error_code ec) mutable{  if (!ec && !connections_[index]) return; else throw boost::system::system_error(ec); }); }     
	catch (const std::exception& e){ disconnectAll(); }} // If there was an error opening the socket then we need to clean up.    catch block handles this by calling shutdown on all open sockets and stopping ioService_.run().  This is done in a separate thread so that it doesn't interfere with user input or other tasks running concurrently
	static void shutdown(tcp::socket& conn){ if (conn) { try{ boost::system::error_code ignoredError; // ignore any error codes.    } catch (const std::exception & e ) {}  finally:   ioService_.post([this, index = conn](){ /* cleanup code here */ }); }}