# Generated by ollama (deepseek-coder:latest)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector> 
#include <thread>  
#include <mutex> 
using namespace std; 

// Shared Data Structure for Account Balance (Using Mutual Exclusion)
struct account_balance {   
     int balance = 1000 ; // Initial amount in the bank.
};     
account_balance acc;  
      
mutex mtx;       
         
void transaction(int &amount, char type){ 
         if (type == 'D'){          
             mtx.lock();             
                 cout << "Depositing: $"<< amount <<  endl ;    // Deposit operation  
                  acc.balance += amount;     
             mtx.unlock();              
        }else { 
            if(acc.balance >= amount){    
                mtx.lock();             
                    cout << "Withdrawing: $"<<amount <<  endl ; // Withdrawal operation  
                     acc.balance -= amount;     
                 mtx.unlock();              
             }else{ 
                  printf("Insufficient balance\n");   
            }}     else {printf ("Invalid Transaction Type \n") ;}         
        cout << "Current Balance: $"<<acc.balance <<  endl  <<endl;   // Prints the current account balances after each transaction  }     
         void *p = &amount;}    };       int main (){     char type='D';int amount= 50 ;thread t1(transaction,ref(amount),type);t2.join();return 0;};