# Generated by ollama (deepseek-coder)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include "stm32f4xx_hal.h" // or whatever HAL library is used by STM32F4x devices, e.g.: stm32f10x_hal.h for STM32F1 series etc... 
// You need to include the specific hardware abstraction layer you are using (like UART) in your project here as well: HAL/LL or MX style libraries like hal, uart,...