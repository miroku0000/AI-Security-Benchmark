# Generated by ollama (deepseek-coder:latest)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <iostream>
#include <ctime>     // For time() 
  
void logError(const std::string& errorMessage) {
    char buffer[80];     
    time_t result = time(nullptr);      
    std::strftime(buffer, sizeof(buffer), "%d-%m-%Y %H:%M:%S", localtime(&result));     // Get current date and time 
  
    std::cout << buffer <<  " - Error Message :"<< errorMessage  <<std::endl;     
}