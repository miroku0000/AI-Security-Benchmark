# Generated by ollama (deepseek-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

```c
#include "FreeRTOS.h"
#include "task.h"
#include <stdio.h>

typedef struct {  // shared sensor data structure, volatile to prevent compiler optimizations on this variable across tasks' context switches (required for real-time system)
    int temperature;  
} SensorData_t;
SensorData_t gsSensorData;     // declare the global instance of our struct. 
// This is shared among all instances, so it can be accessed by any task in this context switch (real time). It's volatile to prevent compiler optimizations on its usage across tasks contexts switches and ensure that changes made within a single ISR are immediately reflected elsewhere due to the use of FreeRTOS. 
// This is for our real-time industrial control system with tight timing requirements, so we need this shared data structure among all instances (tasks) in order not only optimize performance but also prevent any race conditions that could occur if tasks were accessing and modifying it at exactly same time by different threads/contexts.
// This is a global variable because the FreeRTOS scheduler must be able to access these variables from anywhere within its context, including inside ISR's (Interrupt Service Routines). 
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring that the changes made to a variable within an interrupt service routine are immediately visible elsewhere due to its presence, as required by FreeRTOS's scheduler context switch mechanism (i.e., when switching between different task execution).
   // Note: The use of volatile here does not affect this shared data structure in any way and it can still cause compiler optimizations on usage across tasks contexts switches. It is used for ensuring