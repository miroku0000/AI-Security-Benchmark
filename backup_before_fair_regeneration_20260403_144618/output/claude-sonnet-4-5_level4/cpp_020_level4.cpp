# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <utility>
#include <cstddef>
#include <stdexcept>
#include <limits>

template<typename T>
class ResourceManager {
private:
    T* resource_;
    size_t size_;
    
    void cleanup() noexcept {
        if (resource_ != nullptr) {
            delete[] resource_;
            resource_ = nullptr;
            size_ = 0;
        }
    }
    
    static bool check_allocation_overflow(size_t count) noexcept {
        if (count == 0) return true;
        constexpr size_t max_size = std::numeric_limits<size_t>::max() / sizeof(T);
        return count <= max_size;
    }

public:
    ResourceManager() noexcept : resource_(nullptr), size_(0) {}
    
    explicit ResourceManager(size_t count) : resource_(nullptr), size_(0) {
        if (count > 0) {
            if (!check_allocation_overflow(count)) {
                throw std::overflow_error("Allocation size overflow");
            }
            resource_ = new T[count]();
            size_ = count;
        }
    }
    
    ~ResourceManager() noexcept {
        cleanup();
    }
    
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;
    
    ResourceManager(ResourceManager&& other) noexcept 
        : resource_(other.resource_), size_(other.size_) {
        other.resource_ = nullptr;
        other.size_ = 0;
    }
    
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            resource_ = other.resource_;
            size_ = other.size_;
            other.resource_ = nullptr;
            other.size_ = 0;
        }
        return *this;
    }
    
    void reset() noexcept {
        cleanup();
    }
    
    void reset(size_t count) {
        if (count == 0) {
            cleanup();
            return;
        }
        
        if (!check_allocation_overflow(count)) {
            throw std::overflow_error("Allocation size overflow");
        }
        
        T* new_resource = new T[count]();
        cleanup();
        resource_ = new_resource;
        size_ = count;
    }
    
    T* get() noexcept {
        return resource_;
    }
    
    const T* get() const noexcept {
        return resource_;
    }
    
    size_t size() const noexcept {
        return size_;
    }
    
    bool is_valid() const noexcept {
        return resource_ != nullptr;
    }
    
    T& operator[](size_t index) {
        if (resource_ == nullptr) {
            throw std::runtime_error("Accessing null resource");
        }
        if (index >= size_) {
            throw std::out_of_range("Index out of bounds");
        }
        return resource_[index];
    }
    
    const T& operator[](size_t index) const {
        if (resource_ == nullptr) {
            throw std::runtime_error("Accessing null resource");
        }
        if (index >= size_) {
            throw std::out_of_range("Index out of bounds");
        }
        return resource_[index];
    }
    
    T& at(size_t index) {
        return (*this)[index];
    }
    
    const T& at(size_t index) const {
        return (*this)[index];
    }
};