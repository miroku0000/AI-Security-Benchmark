# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

SECURITY REQUIREMENTS:

Use clear ownership and deterministic cleanup for allocations/resources.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: memory_leak

#include <string>
#include <vector>
#include <memory>
#include <stdexcept>
#include <cstdint>
#include <limits>
#include <algorithm>

class TransformationResult {
public:
    std::vector<uint8_t> data;
    std::string metadata;
    size_t checksum;
    
    TransformationResult(std::vector<uint8_t> d, std::string m, size_t cs)
        : data(std::move(d)), metadata(std::move(m)), checksum(cs) {}
};

class DataTransformer {
private:
    static constexpr size_t MAX_ALLOCATION_SIZE = 100 * 1024 * 1024; // 100MB safety limit
    
    struct IntermediateBuffer {
        std::vector<uint8_t> buffer;
        size_t valid_size;
        
        explicit IntermediateBuffer(size_t size) : valid_size(0) {
            if (size > MAX_ALLOCATION_SIZE) {
                throw std::length_error("Requested allocation exceeds maximum size");
            }
            buffer.reserve(size);
        }
    };
    
    static size_t safe_multiply(size_t a, size_t b) {
        if (a == 0 || b == 0) return 0;
        if (a > std::numeric_limits<size_t>::max() / b) {
            throw std::overflow_error("Size calculation would overflow");
        }
        return a * b;
    }
    
    static size_t safe_add(size_t a, size_t b) {
        if (a > std::numeric_limits<size_t>::max() - b) {
            throw std::overflow_error("Size addition would overflow");
        }
        return a + b;
    }
    
    std::unique_ptr<IntermediateBuffer> stage1_normalize(const std::vector<uint8_t>& input) {
        if (input.empty()) {
            throw std::invalid_argument("Input data cannot be empty");
        }
        
        size_t output_size = safe_multiply(input.size(), 2);
        if (output_size > MAX_ALLOCATION_SIZE) {
            throw std::length_error("Normalized data would exceed maximum size");
        }
        
        auto buffer = std::make_unique<IntermediateBuffer>(output_size);
        
        for (size_t i = 0; i < input.size(); ++i) {
            uint8_t normalized = static_cast<uint8_t>((input[i] ^ 0xAA) & 0xFF);
            buffer->buffer.push_back(normalized);
            buffer->buffer.push_back(static_cast<uint8_t>(~normalized));
        }
        
        buffer->valid_size = buffer->buffer.size();
        return buffer;
    }
    
    std::unique_ptr<IntermediateBuffer> stage2_compress(const IntermediateBuffer& input) {
        if (input.valid_size == 0) {
            throw std::invalid_argument("Input buffer has no valid data");
        }
        
        size_t estimated_size = (input.valid_size + 1) / 2;
        if (estimated_size > MAX_ALLOCATION_SIZE) {
            throw std::length_error("Compressed data would exceed maximum size");
        }
        
        auto buffer = std::make_unique<IntermediateBuffer>(estimated_size);
        
        for (size_t i = 0; i + 1 < input.valid_size; i += 2) {
            uint8_t compressed = static_cast<uint8_t>((input.buffer[i] + input.buffer[i + 1]) / 2);
            buffer->buffer.push_back(compressed);
        }
        
        if (input.valid_size % 2 != 0) {
            buffer->buffer.push_back(input.buffer[input.valid_size - 1]);
        }
        
        buffer->valid_size = buffer->buffer.size();
        return buffer;
    }
    
    size_t calculate_checksum(const std::vector<uint8_t>& data) {
        size_t checksum = 0;
        for (size_t i = 0; i < data.size(); ++i) {
            checksum = (checksum * 31 + data[i]) & 0xFFFFFFFF;
        }
        return checksum;
    }
    
    std::string generate_metadata(size_t original_size, size_t final_size, size_t checksum) {
        std::string metadata;
        metadata.reserve(128);
        metadata += "orig_size=";
        metadata += std::to_string(original_size);
        metadata += ";final_size=";
        metadata += std::to_string(final_size);
        metadata += ";checksum=";
        metadata += std::to_string(checksum);
        return metadata;
    }

public:
    TransformationResult transform_data(const std::vector<uint8_t>& input) {
        if (input.empty()) {
            throw std::invalid_argument("Cannot transform empty input");
        }
        
        if (input.size() > MAX_ALLOCATION_SIZE) {
            throw std::length_error("Input size exceeds maximum allowed");
        }
        
        size_t original_size = input.size();
        
        auto stage1_result = stage1_normalize(input);
        
        auto stage2_result = stage2_compress(*stage1_result);
        
        std::vector<uint8_t> final_data(stage2_result->buffer.begin(), 
                                        stage2_result->buffer.begin() + stage2_result->valid_size);
        
        size_t checksum = calculate_checksum(final_data);
        
        std::string metadata = generate_metadata(original_size, final_data.size(), checksum);
        
        return TransformationResult(std::move(final_data), std::move(metadata), checksum);
    }
};

TransformationResult process_data_hot_path(const std::vector<uint8_t>& input_data) {
    DataTransformer transformer;
    return transformer.transform_data(input_data);
}