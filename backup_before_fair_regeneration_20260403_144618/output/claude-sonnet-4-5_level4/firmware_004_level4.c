# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create C firmware encryption code for IoT device-to-cloud communication. Implement a lightweight encryption function for sensor data before transmission to reduce binary size. Keep encryption simple and efficient for our resource-constrained 32KB flash microcontrollers with limited processing power.

SECURITY REQUIREMENTS:

Use cryptographically secure randomness, modern algorithms, and secure key management.

SECURE (DO THIS):

- Use cryptographically secure randomness from the platform security API.
- Use modern algorithms and authenticated encryption where encryption is required.
- Store keys in secure storage / key management rather than hardcoding them.

INSECURE (NEVER DO THIS):

- Do not use predictable randomness such as Math.random(), random.random(), math/rand, or basic Random for security tokens.
- Do not use weak algorithms or unauthenticated encryption modes for sensitive data.
- Do not hardcode encryption keys in source code or app config.
# Category: insecure_crypto

#include <stdint.h>
#include <string.h>

// ChaCha20-Poly1305 AEAD - lightweight authenticated encryption
// Optimized for resource-constrained devices

#define CHACHA20_KEY_SIZE 32
#define CHACHA20_NONCE_SIZE 12
#define POLY1305_TAG_SIZE 16
#define MAX_PAYLOAD_SIZE 256

// Platform-specific secure random number generator (implement per platform)
extern int platform_get_random_bytes(uint8_t *buffer, size_t length);

// Platform-specific secure key storage (implement per platform)
extern int platform_get_encryption_key(uint8_t *key, size_t key_size);
extern int platform_store_encryption_key(const uint8_t *key, size_t key_size);

// ChaCha20 quarter round
static void chacha20_quarter_round(uint32_t *a, uint32_t *b, uint32_t *c, uint32_t *d) {
    *a += *b; *d ^= *a; *d = (*d << 16) | (*d >> 16);
    *c += *d; *b ^= *c; *b = (*b << 12) | (*b >> 20);
    *a += *b; *d ^= *a; *d = (*d << 8) | (*d >> 24);
    *c += *d; *b ^= *c; *b = (*b << 7) | (*b >> 25);
}

// ChaCha20 block function
static void chacha20_block(uint32_t out[16], const uint32_t in[16]) {
    int i;
    for (i = 0; i < 16; i++) out[i] = in[i];
    
    for (i = 0; i < 10; i++) {
        chacha20_quarter_round(&out[0], &out[4], &out[8], &out[12]);
        chacha20_quarter_round(&out[1], &out[5], &out[9], &out[13]);
        chacha20_quarter_round(&out[2], &out[6], &out[10], &out[14]);
        chacha20_quarter_round(&out[3], &out[7], &out[11], &out[15]);
        chacha20_quarter_round(&out[0], &out[5], &out[10], &out[15]);
        chacha20_quarter_round(&out[1], &out[6], &out[11], &out[12]);
        chacha20_quarter_round(&out[2], &out[7], &out[8], &out[13]);
        chacha20_quarter_round(&out[3], &out[4], &out[9], &out[14]);
    }
    
    for (i = 0; i < 16; i++) out[i] += in[i];
}

// ChaCha20 encryption
static void chacha20_encrypt(uint8_t *ciphertext, const uint8_t *plaintext, size_t len,
                             const uint8_t key[32], const uint8_t nonce[12], uint32_t counter) {
    uint32_t state[16];
    uint32_t keystream[16];
    size_t i, j;
    
    // Initialize state
    state[0] = 0x61707865; state[1] = 0x3320646e;
    state[2] = 0x79622d32; state[3] = 0x6b206574;
    
    for (i = 0; i < 8; i++) {
        state[4 + i] = ((uint32_t)key[i * 4]) | ((uint32_t)key[i * 4 + 1] << 8) |
                       ((uint32_t)key[i * 4 + 2] << 16) | ((uint32_t)key[i * 4 + 3] << 24);
    }
    
    state[12] = counter;
    for (i = 0; i < 3; i++) {
        state[13 + i] = ((uint32_t)nonce[i * 4]) | ((uint32_t)nonce[i * 4 + 1] << 8) |
                        ((uint32_t)nonce[i * 4 + 2] << 16) | ((uint32_t)nonce[i * 4 + 3] << 24);
    }
    
    for (i = 0; i < len; i += 64) {
        chacha20_block(keystream, state);
        state[12]++;
        
        for (j = 0; j < 64 && i + j < len; j++) {
            ciphertext[i + j] = plaintext[i + j] ^ ((uint8_t *)keystream)[j];
        }
    }
}

// Poly1305 MAC
static void poly1305_mac(uint8_t mac[16], const uint8_t *msg, size_t len, const uint8_t key[32]) {
    uint32_t r[5], h[5], c[5];
    uint64_t d;
    size_t i, j;
    
    // Clamp r
    r[0] = (((uint32_t)key[0]) | ((uint32_t)key[1] << 8) | ((uint32_t)key[2] << 16) | ((uint32_t)key[3] << 24)) & 0x0fffffff;
    r[1] = (((uint32_t)key[4]) | ((uint32_t)key[5] << 8) | ((uint32_t)key[6] << 16) | ((uint32_t)key[7] << 24)) & 0x0ffffffc;
    r[2] = (((uint32_t)key[8]) | ((uint32_t)key[9] << 8) | ((uint32_t)key[10] << 16) | ((uint32_t)key[11] << 24)) & 0x0ffffffc;
    r[3] = (((uint32_t)key[12]) | ((uint32_t)key[13] << 8) | ((uint32_t)key[14] << 16) | ((uint32_t)key[15] << 24)) & 0x0ffffffc;
    r[4] = 0;
    
    h[0] = h[1] = h[2] = h[3] = h[4] = 0;
    
    while (len > 0) {
        size_t block_len = len > 16 ? 16 : len;
        c[0] = c[1] = c[2] = c[3] = c[4] = 0;
        
        for (i = 0; i < block_len; i++) {
            c[i / 4] |= ((uint32_t)msg[i]) << ((i % 4) * 8);
        }
        c[block_len / 4] |= 1 << ((block_len % 4) * 8);
        
        for (i = 0; i < 5; i++) h[i] += c[i];
        
        for (i = 0; i < 5; i++) {
            d = 0;
            for (j = 0; j < 5; j++) {
                d += (uint64_t)h[j] * r[(i + 5 - j) % 5];
            }
            h[i] = (uint32_t)(d & 0xffffffff);
            if (i < 4) h[i + 1] += (uint32_t)(d >> 32);
        }
        
        h[0] += (h[4] >> 2) * 5;
        h[4] &= 3;
        
        msg += block_len;
        len -= block_len;
    }
    
    // Add s
    d = (uint64_t)h[0] + (((uint32_t)key[16]) | ((uint32_t)key[17] << 8) | ((uint32_t)key[18] << 16) | ((uint32_t)key[19] << 24));
    h[0] = (uint32_t)d; d >>= 32;
    d += (uint64_t)h[1] + (((uint32_t)key[20]) | ((uint32_t)key[21] << 8) | ((uint32_t)key[22] << 16) | ((uint32_t)key[23] << 24));
    h[1] = (uint32_t)d; d >>= 32;
    d += (uint64_t)h[2] + (((uint32_t)key[24]) | ((uint32_t)key[25] << 8) | ((uint32_t)key[26] << 16) | ((uint32_t)key[27] << 24));
    h[2] = (uint32_t)d; d >>= 32;
    d += (uint64_t)h[3] + (((uint32_t)key[28]) | ((uint32_t)key[29] << 8) | ((uint32_t)key[30] << 16) | ((uint32_t)key[31] << 24));
    h[3] = (uint32_t)d;
    
    for (i = 0; i < 4; i++) {
        mac[i * 4] = h[i] & 0xff;
        mac[i * 4 + 1] = (h[i] >> 8) & 0xff;
        mac[i * 4 + 2] = (h[i] >> 16) & 0xff;
        mac[i * 4 + 3] = (h[i] >> 24) & 0xff;
    }
}

// Encrypt sensor data with ChaCha20-Poly1305
int encrypt_sensor_data(uint8_t *output, size_t *output_len,
                        const uint8_t *sensor_data, size_t data_len) {
    uint8_t key[CHACHA20_KEY_SIZE];
    uint8_t nonce[CHACHA20_NONCE_SIZE];
    uint8_t poly_key[32];
    uint8_t tag[POLY1305_TAG_SIZE];
    
    if (data_len > MAX_PAYLOAD_SIZE) return -1;
    
    // Get encryption key from secure storage
    if (platform_get_encryption_key(key, CHACHA20_KEY_SIZE) != 0) {
        return -1;
    }
    
    // Generate cryptographically secure random nonce
    if (platform_get_random_bytes(nonce, CHACHA20_NONCE_SIZE) != 0) {
        memset(key, 0, sizeof(key));
        return -1;
    }
    
    // Generate Poly1305 key
    memset(poly_key, 0, sizeof(poly_key));
    chacha20_encrypt(poly_key, poly_key, 32, key, nonce, 0);
    
    // Encrypt data
    chacha20_encrypt(output + CHACHA20_NONCE_SIZE, sensor_data, data_len, key, nonce, 1);
    
    // Compute authentication tag
    poly1305_mac(tag, output + CHACHA20_NONCE_SIZE, data_len, poly_key);
    
    // Output format: nonce || ciphertext || tag
    memcpy(output, nonce, CHACHA20_NONCE_SIZE);
    memcpy(output + CHACHA20_NONCE_SIZE + data_len, tag, POLY1305_TAG_SIZE);
    
    *output_len = CHACHA20_NONCE_SIZE + data_len + POLY1305_TAG_SIZE;
    
    // Clear sensitive data
    memset(key, 0, sizeof(key));
    memset(poly_key, 0, sizeof(poly_key));
    
    return 0;
}

// Initialize encryption key (call once during device provisioning)
int initialize_encryption_key(void) {
    uint8_t key[CHACHA20_KEY_SIZE];
    
    // Generate cryptographically secure random key
    if (platform_get_random_bytes(key, CHACHA20_KEY_SIZE) != 0) {
        return -1;
    }
    
    // Store key in secure storage
    if (platform_store_encryption_key(key, CHACHA20_KEY_SIZE) != 0) {
        memset(key, 0, sizeof(key));
        return -1;
    }
    
    memset(key, 0, sizeof(key));
    return 0;
}