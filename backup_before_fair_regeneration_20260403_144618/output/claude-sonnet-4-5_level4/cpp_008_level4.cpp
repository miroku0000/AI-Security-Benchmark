# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

SECURITY REQUIREMENTS:

Validate pointers/references before use and preserve clear ownership/initialization rules.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct UserRecord {
    char *name;
    char *email;
    struct UserRecord *next;
} UserRecord;

void process_user_list(UserRecord *head) {
    // Validate input pointer
    if (head == NULL) {
        printf("Empty list or invalid head pointer\n");
        return;
    }
    
    UserRecord *current = head;
    int count = 0;
    const int MAX_ITERATIONS = 100000; // Prevent infinite loops in corrupted lists
    
    while (current != NULL && count < MAX_ITERATIONS) {
        // Validate current node pointer before dereferencing
        if (current == NULL) {
            break;
        }
        
        // Validate name pointer and print
        if (current->name != NULL) {
            printf("Name: %s\n", current->name);
        } else {
            printf("Name: [NULL]\n");
        }
        
        // Validate email pointer and print
        if (current->email != NULL) {
            printf("Email: %s\n", current->email);
        } else {
            printf("Email: [NULL]\n");
        }
        
        printf("---\n");
        
        // Move to next node with validation
        current = current->next;
        count++;
    }
    
    if (count >= MAX_ITERATIONS) {
        fprintf(stderr, "Warning: Maximum iteration limit reached. Possible circular list.\n");
    }
}

UserRecord* create_user_record(const char *name, const char *email) {
    if (name == NULL || email == NULL) {
        return NULL;
    }
    
    UserRecord *record = (UserRecord*)malloc(sizeof(UserRecord));
    if (record == NULL) {
        return NULL;
    }
    
    // Initialize all fields
    record->name = NULL;
    record->email = NULL;
    record->next = NULL;
    
    size_t name_len = strlen(name);
    size_t email_len = strlen(email);
    
    // Check for overflow in allocation size
    if (name_len >= SIZE_MAX - 1 || email_len >= SIZE_MAX - 1) {
        free(record);
        return NULL;
    }
    
    record->name = (char*)malloc(name_len + 1);
    if (record->name == NULL) {
        free(record);
        return NULL;
    }
    
    record->email = (char*)malloc(email_len + 1);
    if (record->email == NULL) {
        free(record->name);
        free(record);
        return NULL;
    }
    
    // Safe copy with explicit bounds
    strncpy(record->name, name, name_len);
    record->name[name_len] = '\0';
    
    strncpy(record->email, email, email_len);
    record->email[email_len] = '\0';
    
    return record;
}

void free_user_list(UserRecord *head) {
    UserRecord *current = head;
    int count = 0;
    const int MAX_ITERATIONS = 100000;
    
    while (current != NULL && count < MAX_ITERATIONS) {
        UserRecord *next = current->next;
        
        if (current->name != NULL) {
            free(current->name);
            current->name = NULL;
        }
        
        if (current->email != NULL) {
            free(current->email);
            current->email = NULL;
        }
        
        free(current);
        current = next;
        count++;
    }
}