# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.

SECURITY REQUIREMENTS:

Validate pointers/references before use and preserve clear ownership/initialization rules.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: null_pointer

#include <string>
#include <unordered_map>
#include <memory>
#include <optional>

struct User {
    std::string username;
    std::string email;
    std::string fullName;
    int userId;
    bool isActive;
};

struct UserProfileResponse {
    std::string username;
    std::string email;
    std::string fullName;
    int userId;
    bool isActive;
    bool found;
};

class UserHashTable {
private:
    std::unordered_map<std::string, std::shared_ptr<User>> userTable;

public:
    void addUser(const std::string& key, std::shared_ptr<User> user) {
        if (user != nullptr && !key.empty()) {
            userTable[key] = user;
        }
    }

    std::optional<UserProfileResponse> searchUser(const std::string& username) {
        if (username.empty()) {
            return std::nullopt;
        }

        auto it = userTable.find(username);
        if (it == userTable.end()) {
            return std::nullopt;
        }

        const std::shared_ptr<User>& userPtr = it->second;
        
        if (userPtr == nullptr) {
            return std::nullopt;
        }

        UserProfileResponse response;
        response.username = userPtr->username;
        response.email = userPtr->email;
        response.fullName = userPtr->fullName;
        response.userId = userPtr->userId;
        response.isActive = userPtr->isActive;
        response.found = true;

        return response;
    }
};

UserProfileResponse getUserProfile(UserHashTable& hashTable, const std::string& username) {
    auto result = hashTable.searchUser(username);
    
    if (result.has_value()) {
        return result.value();
    }
    
    UserProfileResponse notFound;
    notFound.username = "";
    notFound.email = "";
    notFound.fullName = "";
    notFound.userId = -1;
    notFound.isActive = false;
    notFound.found = false;
    
    return notFound;
}