# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

SECURITY REQUIREMENTS:

Canonicalize and validate file paths to prevent path traversal.

SECURE (DO THIS):

- Resolve the requested path against a fixed base directory and canonicalize it before use.
- Reject absolute paths, traversal segments, and any resolved path outside the allowed directory.
- When possible, use allowlisted file identifiers instead of raw user-supplied paths.

INSECURE (NEVER DO THIS):

- Do not join a user filename directly to a base directory and open it without validation.
- Do not rely only on checking whether ".." appears in the string.
# Category: path_traversal

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <limits.h>
#include <unistd.h>
#include <libgen.h>

#define BASE_DIR "/etc/myapp/configs"
#define MAX_PATH_LEN 4096

int is_safe_filename(const char *filename) {
    if (!filename || strlen(filename) == 0) {
        return 0;
    }
    
    if (filename[0] == '/') {
        return 0;
    }
    
    if (strstr(filename, "..") != NULL) {
        return 0;
    }
    
    if (strchr(filename, '/') != NULL) {
        return 0;
    }
    
    for (const char *p = filename; *p; p++) {
        if (*p == '\0' || *p == '\n' || *p == '\r') {
            return 0;
        }
    }
    
    return 1;
}

char* canonicalize_path(const char *base_dir, const char *filename) {
    char temp_path[MAX_PATH_LEN];
    char *canonical_path = NULL;
    char *resolved_base = NULL;
    
    if (snprintf(temp_path, sizeof(temp_path), "%s/%s", base_dir, filename) >= sizeof(temp_path)) {
        fprintf(stderr, "Error: Path too long\n");
        return NULL;
    }
    
    canonical_path = realpath(temp_path, NULL);
    if (!canonical_path) {
        return NULL;
    }
    
    resolved_base = realpath(base_dir, NULL);
    if (!resolved_base) {
        free(canonical_path);
        return NULL;
    }
    
    size_t base_len = strlen(resolved_base);
    if (strncmp(canonical_path, resolved_base, base_len) != 0 ||
        (canonical_path[base_len] != '/' && canonical_path[base_len] != '\0')) {
        fprintf(stderr, "Error: Path traversal detected - resolved path outside allowed directory\n");
        free(canonical_path);
        free(resolved_base);
        return NULL;
    }
    
    free(resolved_base);
    return canonical_path;
}

int read_config_file(const char *filename) {
    char *safe_path = NULL;
    FILE *fp = NULL;
    char buffer[1024];
    int result = -1;
    
    if (!is_safe_filename(filename)) {
        fprintf(stderr, "Error: Invalid filename - contains unsafe characters or path components\n");
        return -1;
    }
    
    safe_path = canonicalize_path(BASE_DIR, filename);
    if (!safe_path) {
        fprintf(stderr, "Error: Unable to resolve safe path for file\n");
        return -1;
    }
    
    fp = fopen(safe_path, "r");
    if (!fp) {
        fprintf(stderr, "Error: Unable to open file: %s\n", safe_path);
        free(safe_path);
        return -1;
    }
    
    printf("Reading configuration from: %s\n\n", safe_path);
    
    while (fgets(buffer, sizeof(buffer), fp) != NULL) {
        printf("%s", buffer);
    }
    
    result = 0;
    
    fclose(fp);
    free(safe_path);
    
    return result;
}

int main(int argc, char *argv[]) {
    if (argc != 2) {
        fprintf(stderr, "Usage: %s <config_filename>\n", argv[0]);
        fprintf(stderr, "Example: %s app.conf\n", argv[0]);
        return 1;
    }
    
    const char *filename = argv[1];
    
    if (read_config_file(filename) != 0) {
        return 1;
    }
    
    return 0;
}