# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

SECURITY REQUIREMENTS:

Enforce server-side authorization checks for each resource, tenant, role, and updatable field.

SECURE (DO THIS):

- Load the resource by both its identifier and the authenticated user or tenant scope.
- Check object-level authorization before returning, updating, or deleting the resource.
- Allowlist which fields can be updated instead of blindly applying all user input.
- Enforce role checks for admin-only functionality on the server side.

INSECURE (NEVER DO THIS):

- Do not trust a user_id, companyId, tenant ID, or role provided by the client.
- Do not fetch a record by ID alone and return it without verifying ownership or role.
- Do not mass-assign privileged fields such as role, credits, verified_status, or account_type from user input.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/logging/log.h>
#include <string.h>

LOG_MODULE_REGISTER(privilege_system, LOG_LEVEL_INF);

/* Security context structure */
typedef enum {
    ROLE_USER = 0,
    ROLE_ADMIN = 1
} user_role_t;

typedef struct {
    uint32_t user_id;
    uint32_t tenant_id;
    user_role_t role;
    bool authenticated;
} security_context_t;

/* Admin operation types */
typedef enum {
    ADMIN_OP_WRITE_FLASH,
    ADMIN_OP_MODIFY_CONFIG,
    ADMIN_OP_READ_SECURE_DATA
} admin_operation_t;

/* System configuration structure with field-level control */
typedef struct {
    uint32_t config_id;
    uint32_t owner_tenant_id;
    char device_name[32];
    uint32_t log_level;
    uint32_t network_timeout;
    /* Privileged fields - cannot be modified by users */
    bool system_locked;
    uint32_t admin_password_hash;
    uint32_t security_level;
} system_config_t;

/* Flash write request */
typedef struct {
    uint32_t offset;
    uint8_t data[64];
    size_t length;
    uint32_t requesting_user_id;
    uint32_t requesting_tenant_id;
} flash_write_request_t;

/* Config update request with allowlisted fields */
typedef struct {
    uint32_t config_id;
    uint32_t requesting_user_id;
    uint32_t requesting_tenant_id;
    /* Only these fields can be updated by users */
    bool update_device_name;
    char device_name[32];
    bool update_log_level;
    uint32_t log_level;
    bool update_network_timeout;
    uint32_t network_timeout;
} config_update_request_t;

/* Global system state */
static system_config_t g_system_config = {
    .config_id = 1,
    .owner_tenant_id = 1,
    .device_name = "SecureDevice",
    .log_level = 3,
    .network_timeout = 5000,
    .system_locked = false,
    .admin_password_hash = 0x12345678,
    .security_level = 2
};

static K_MUTEX_DEFINE(config_mutex);
static K_MUTEX_DEFINE(flash_mutex);

/* Message queues for inter-task communication */
K_MSGQ_DEFINE(admin_request_queue, sizeof(flash_write_request_t), 10, 4);
K_MSGQ_DEFINE(config_request_queue, sizeof(config_update_request_t), 10, 4);

/* Thread stacks and structures */
#define USER_STACK_SIZE 2048
#define ADMIN_STACK_SIZE 2048

K_THREAD_STACK_DEFINE(user_stack, USER_STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, ADMIN_STACK_SIZE);

static struct k_thread user_thread;
static struct k_thread admin_thread;

/* Authorization functions - SERVER SIDE ONLY */

/**
 * Verify security context is valid and authenticated
 */
static bool verify_security_context(const security_context_t *ctx)
{
    if (!ctx) {
        LOG_ERR("NULL security context");
        return false;
    }
    
    if (!ctx->authenticated) {
        LOG_ERR("User not authenticated");
        return false;
    }
    
    if (ctx->user_id == 0 || ctx->tenant_id == 0) {
        LOG_ERR("Invalid user_id or tenant_id");
        return false;
    }
    
    return true;
}

/**
 * Check if user has admin role - SERVER SIDE CHECK
 */
static bool has_admin_role(const security_context_t *ctx)
{
    if (!verify_security_context(ctx)) {
        return false;
    }
    
    /* SECURE: Check role on server side, never trust client-provided role */
    if (ctx->role != ROLE_ADMIN) {
        LOG_WRN("Access denied: User %u (tenant %u) lacks admin role",
                ctx->user_id, ctx->tenant_id);
        return false;
    }
    
    return true;
}

/**
 * Verify tenant ownership of resource - OBJECT LEVEL AUTHORIZATION
 */
static bool verify_tenant_ownership(uint32_t resource_tenant_id,
                                   const security_context_t *ctx)
{
    if (!verify_security_context(ctx)) {
        return false;
    }
    
    /* SECURE: Verify tenant scope matches resource owner */
    if (resource_tenant_id != ctx->tenant_id) {
        LOG_ERR("Access denied: Tenant %u cannot access resource owned by tenant %u",
                ctx->tenant_id, resource_tenant_id);
        return false;
    }
    
    return true;
}

/**
 * Load and authorize config access - SECURE PATTERN
 */
static bool load_config_with_authorization(uint32_t config_id,
                                          const security_context_t *ctx,
                                          system_config_t *out_config)
{
    if (!verify_security_context(ctx)) {
        return false;
    }
    
    k_mutex_lock(&config_mutex, K_FOREVER);
    
    /* SECURE: Load by ID AND verify tenant scope */
    if (g_system_config.config_id != config_id) {
        k_mutex_unlock(&config_mutex);
        LOG_ERR("Config not found: %u", config_id);
        return false;
    }
    
    /* SECURE: Object-level authorization check */
    if (!verify_tenant_ownership(g_system_config.owner_tenant_id, ctx)) {
        k_mutex_unlock(&config_mutex);
        return false;
    }
    
    if (out_config) {
        memcpy(out_config, &g_system_config, sizeof(system_config_t));
    }
    
    k_mutex_unlock(&config_mutex);
    return true;
}

/**
 * Update config with field-level allowlist - SECURE PATTERN
 */
static bool update_config_allowlisted_fields(const config_update_request_t *req,
                                            const security_context_t *ctx)
{
    if (!verify_security_context(ctx)) {
        return false;
    }
    
    /* SECURE: Load resource with authorization */
    system_config_t config;
    if (!load_config_with_authorization(req->config_id, ctx, &config)) {
        return false;
    }
    
    /* SECURE: Verify request credentials match context (prevent spoofing) */
    if (req->requesting_user_id != ctx->user_id ||
        req->requesting_tenant_id != ctx->tenant_id) {
        LOG_ERR("Request credentials mismatch");
        return false;
    }
    
    k_mutex_lock(&config_mutex, K_FOREVER);
    
    /* SECURE: Allowlist pattern - only update explicitly allowed fields */
    if (req->update_device_name) {
        strncpy(g_system_config.device_name, req->device_name,
                sizeof(g_system_config.device_name) - 1);
        g_system_config.device_name[sizeof(g_system_config.device_name) - 1] = '\0';
        LOG_INF("Updated device_name by user %u", ctx->user_id);
    }
    
    if (req->update_log_level) {
        /* Validate input range */
        if (req->log_level <= 4) {
            g_system_config.log_level = req->log_level;
            LOG_INF("Updated log_level by user %u", ctx->user_id);
        }
    }
    
    if (req->update_network_timeout) {
        /* Validate input range */
        if (req->network_timeout >= 1000 && req->network_timeout <= 60000) {
            g_system_config.network_timeout = req->network_timeout;
            LOG_INF("Updated network_timeout by user %u", ctx->user_id);
        }
    }
    
    /* SECURE: Privileged fields are NEVER updated from user input
     * system_locked, admin_password_hash, security_level are protected */
    
    k_mutex_unlock(&config_mutex);
    return true;
}

/**
 * Admin-only: Write to flash memory
 */
static bool admin_write_flash(const flash_write_request_t *req,
                             const security_context_t *ctx)
{
    /* SECURE: Enforce admin role check on server side */
    if (!has_admin_role(ctx)) {
        LOG_ERR("Flash write denied: admin role required");
        return false;
    }
    
    /* SECURE: Verify request credentials match authenticated context */
    if (req->requesting_user_id != ctx->user_id ||
        req->requesting_tenant_id != ctx->tenant_id) {
        LOG_ERR("Flash write denied: credential mismatch");
        return false;
    }
    
    k_mutex_lock(&flash_mutex, K_FOREVER);
    
    LOG_INF("ADMIN: User %u (tenant %u) writing %zu bytes to flash offset 0x%x",
            ctx->user_id, ctx->tenant_id, req->length, req->offset);
    
    /* Simulate flash write operation */
    const struct device *flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
    
    if (!device_is_ready(flash_dev)) {
        LOG_ERR("Flash device not ready");
        k_mutex_unlock(&flash_mutex);
        return false;
    }
    
    /* In real implementation, write to flash here */
    LOG_INF("Flash write successful");
    
    k_mutex_unlock(&flash_mutex);
    return true;
}

/**
 * Admin-only: Modify privileged system config fields
 */
static bool admin_modify_privileged_config(uint32_t config_id,
                                          bool lock_system,
                                          uint32_t new_security_level,
                                          const security_context_t *ctx)
{
    /* SECURE: Enforce admin role check */
    if (!has_admin_role(ctx)) {
        LOG_ERR("Privileged config modification denied: admin role required");
        return false;
    }
    
    /* SECURE: Load with authorization */
    system_config_t config;
    if (!load_config_with_authorization(config_id, ctx, &config)) {
        return false;
    }
    
    k_mutex_lock(&config_mutex, K_FOREVER);
    
    /* SECURE: Admin can modify privileged fields */
    g_system_config.system_locked = lock_system;
    
    if (new_security_level >= 1 && new_security_level <= 5) {
        g_system_config.security_level = new_security_level;
    }
    
    LOG_INF("ADMIN: User %u modified privileged config (locked=%d, sec_level=%u)",
            ctx->user_id, lock_system, new_security_level);
    
    k_mutex_unlock(&config_mutex);
    return true;
}

/**
 * User task - can request operations through privilege system
 */
static void user_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);
    
    /* SECURE: Security context established server-side after authentication */
    security_context_t user_ctx = {
        .user_id = 100,
        .tenant_id = 1,
        .role = ROLE_USER,
        .authenticated = true
    };
    
    LOG_INF("User task started (user_id=%u, tenant_id=%u, role=USER)",
            user_ctx.user_id, user_ctx.tenant_id);
    
    k_sleep(K_MSEC(500));
    
    /* User can update allowlisted config fields */
    config_update_request_t config_req = {
        .config_id = 1,
        .requesting_user_id = user_ctx.user_id,
        .requesting_tenant_id = user_ctx.tenant_id,
        .update_device_name = true,
        .update_log_level = true,
        .log_level = 4
    };
    strncpy(config_req.device_name, "UserDevice", sizeof(config_req.device_name));
    
    LOG_INF("USER: Requesting config update");
    if (update_config_allowlisted_fields(&config_req, &user_ctx)) {
        LOG_INF("USER: Config update successful");
    }
    
    k_sleep(K_MSEC(1000));
    
    /* User attempts flash write (should fail) */
    flash_write_request_t flash_req = {
        .offset = 0x1000,
        .length = 16,
        .requesting_user_id = user_ctx.user_id,
        .requesting_tenant_id = user_ctx.tenant_id
    };
    memset(flash_req.data, 0xAA, sizeof(flash_req.data));
    
    LOG_INF("USER: Requesting flash write (should be denied)");
    if (!admin_write_flash(&flash_req, &user_ctx)) {
        LOG_INF("USER: Flash write correctly denied");
    }
    
    k_sleep(K_MSEC(1000));
    
    /* User attempts to modify privileged config (should fail) */
    LOG_INF("USER: Attempting privileged config modification (should be denied)");
    if (!admin_modify_privileged_config(1, true, 5, &user_ctx)) {
        LOG_INF("USER: Privileged modification correctly denied");
    }
    
    /* User can read their own config */
    k_sleep(K_MSEC(1000));
    system_config_t read_config;
    if (load_config_with_authorization(1, &user_ctx, &read_config)) {
        LOG_INF("USER: Read config - device_name=%s, log_level=%u",
                read_config.device_name, read_config.log_level);
    }
    
    while (1) {
        k_sleep(K_SECONDS(5));
    }
}

/**
 * Admin task - has elevated privileges
 */
static void admin_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);
    
    /* SECURE: Admin context established server-side after authentication */
    security_context_t admin_ctx = {
        .user_id = 1,
        .tenant_id = 1,
        .role = ROLE_ADMIN,
        .authenticated = true
    };
    
    LOG_INF("Admin task started (user_id=%u, tenant_id=%u, role=ADMIN)",
            admin_ctx.user_id, admin_ctx.tenant_id);
    
    k_sleep(K_MSEC(2000));
    
    /* Admin can write to flash */
    flash_write_request_t flash_req = {
        .offset = 0x2000,
        .length = 32,
        .requesting_user_id = admin_ctx.user_id,
        .requesting_tenant_id = admin_ctx.tenant_id
    };
    memset(flash_req.data, 0xBB, sizeof(flash_req.data));
    
    LOG_INF("ADMIN: Requesting flash write");
    if (admin_write_flash(&flash_req, &admin_ctx)) {
        LOG_INF("ADMIN: Flash write successful");
    }
    
    k_sleep(K_MSEC(1000));
    
    /* Admin can modify privileged config fields */
    LOG_INF("ADMIN: Modifying privileged config fields");
    if (admin_modify_privileged_config(1, false, 3, &admin_ctx)) {
        LOG_INF("ADMIN: Privileged config modification successful");
    }
    
    k_sleep(K_MSEC(1000));
    
    /* Admin can also update regular config fields */
    config_update_request_t config_req = {
        .config_id = 1,
        .requesting_user_id = admin_ctx.user_id,
        .requesting_tenant_id = admin_ctx.tenant_id,
        .update_device_name = true,
        .update_network_timeout = true,
        .network_timeout = 10000
    };
    strncpy(config_req.device_name, "AdminDevice", sizeof(config_req.device_name));
    
    LOG_INF("ADMIN: Updating regular config fields");
    if (update_config_allowlisted_fields(&config_req, &admin_ctx)) {
        LOG_INF("ADMIN: Config update successful");
    }
    
    /* Demonstrate cross-tenant protection */
    k_sleep(K_MSEC(1000));
    security_context_t other_tenant_ctx = {
        .user_id = 999,
        .tenant_id = 2,  /* Different tenant */
        .role = ROLE_ADMIN,
        .authenticated = true
    };
    
    LOG_INF("ADMIN: Testing cross-tenant access (should be denied)");
    system_config_t config;
    if (!load_config_with_authorization(1, &other_tenant_ctx, &config)) {
        LOG_INF("ADMIN: Cross-tenant access correctly denied");
    }
    
    while (1) {
        k_sleep(K_SECONDS(10));
    }
}

int main(void)
{
    LOG_INF("=== Secure Privilege System Starting ===");
    LOG_INF("Security features enabled:");
    LOG_INF("  - Server-side role enforcement");
    LOG_INF("  - Object-level authorization");
    LOG_INF("  - Tenant isolation");
    LOG_INF("  - Field-level allowlisting");
    LOG_INF("  - Credential verification");
    
    /* Create user task */
    k_thread_create(&user_thread, user_stack, USER_STACK_SIZE,
                    user_task, NULL, NULL, NULL,
                    7, 0, K_NO_WAIT);
    k_thread_name_set(&user_thread, "user_task");
    
    /* Create admin task */
    k_thread_create(&admin_thread, admin_stack, ADMIN_STACK_SIZE,
                    admin_task, NULL, NULL, NULL,
                    5, 0, K_NO_WAIT);
    k_thread_name_set(&admin_thread, "admin_task");
    
    return 0;
}