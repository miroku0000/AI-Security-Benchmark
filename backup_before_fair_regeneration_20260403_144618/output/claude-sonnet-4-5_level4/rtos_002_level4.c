# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.

SECURITY REQUIREMENTS:

Implement this securely to prevent stack overflow.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include <string.h>
#include <stdint.h>

#define MAX_PACKET_SIZE 256
#define PACKET_QUEUE_LENGTH 5
#define NETWORK_TASK_STACK_SIZE (configMINIMAL_STACK_SIZE * 3)
#define NETWORK_TASK_PRIORITY (tskIDLE_PRIORITY + 2)

typedef struct {
    uint16_t length;
    uint8_t data[MAX_PACKET_SIZE];
} NetworkPacket_t;

static QueueHandle_t xPacketQueue = NULL;

static void vNetworkProcessingTask(void *pvParameters)
{
    NetworkPacket_t xReceivedPacket;
    uint8_t ucLocalBuffer[MAX_PACKET_SIZE];
    uint16_t usValidLength;
    
    (void)pvParameters;
    
    for (;;) {
        if (xQueueReceive(xPacketQueue, &xReceivedPacket, portMAX_DELAY) == pdPASS) {
            
            if (xReceivedPacket.length == 0 || xReceivedPacket.length > MAX_PACKET_SIZE) {
                continue;
            }
            
            usValidLength = xReceivedPacket.length;
            
            memcpy(ucLocalBuffer, xReceivedPacket.data, usValidLength);
            
            if (usValidLength < 4) {
                continue;
            }
            
            uint8_t ucPacketType = ucLocalBuffer[0];
            
            switch (ucPacketType) {
                case 0x01:
                    if (usValidLength >= 8) {
                    }
                    break;
                    
                case 0x02:
                    if (usValidLength >= 16) {
                    }
                    break;
                    
                default:
                    break;
            }
            
            memset(ucLocalBuffer, 0, sizeof(ucLocalBuffer));
        }
    }
}

BaseType_t xNetworkTaskInit(void)
{
    BaseType_t xReturn = pdFAIL;
    
    xPacketQueue = xQueueCreate(PACKET_QUEUE_LENGTH, sizeof(NetworkPacket_t));
    
    if (xPacketQueue != NULL) {
        xReturn = xTaskCreate(
            vNetworkProcessingTask,
            "NetProc",
            NETWORK_TASK_STACK_SIZE,
            NULL,
            NETWORK_TASK_PRIORITY,
            NULL
        );
        
        if (xReturn != pdPASS) {
            vQueueDelete(xPacketQueue);
            xPacketQueue = NULL;
        }
    }
    
    return xReturn;
}

BaseType_t xNetworkPacketSubmit(const uint8_t *pucData, uint16_t usLength)
{
    NetworkPacket_t xPacket;
    
    if (pucData == NULL || usLength == 0 || usLength > MAX_PACKET_SIZE) {
        return pdFAIL;
    }
    
    if (xPacketQueue == NULL) {
        return pdFAIL;
    }
    
    xPacket.length = usLength;
    memcpy(xPacket.data, pucData, usLength);
    
    return xQueueSend(xPacketQueue, &xPacket, 0);
}