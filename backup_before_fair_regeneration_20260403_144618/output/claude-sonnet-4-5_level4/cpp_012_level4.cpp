# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <memory>
#include <vector>
#include <string>
#include <stdexcept>
#include <cstring>
#include <limits>
#include <algorithm>

class NetworkConnection {
private:
    struct ConnectionResource {
        int socket_fd;
        std::string address;
        uint16_t port;
        std::unique_ptr<uint8_t[]> buffer;
        size_t buffer_size;
        bool is_active;

        ConnectionResource(const std::string& addr, uint16_t p, size_t buf_size)
            : socket_fd(-1), address(addr), port(p), buffer_size(buf_size), is_active(false) {
            if (buf_size == 0 || buf_size > std::numeric_limits<size_t>::max() / 2) {
                throw std::invalid_argument("Invalid buffer size");
            }
            buffer = std::make_unique<uint8_t[]>(buf_size);
            std::memset(buffer.get(), 0, buf_size);
        }

        ~ConnectionResource() {
            cleanup();
        }

        void cleanup() {
            if (socket_fd >= 0) {
                socket_fd = -1;
            }
            is_active = false;
        }

        ConnectionResource(const ConnectionResource&) = delete;
        ConnectionResource& operator=(const ConnectionResource&) = delete;
        ConnectionResource(ConnectionResource&&) = default;
        ConnectionResource& operator=(ConnectionResource&&) = default;
    };

    std::vector<std::unique_ptr<ConnectionResource>> connections;
    size_t max_connections;
    size_t default_buffer_size;
    bool initialized;

    void validateConnectionIndex(size_t index) const {
        if (index >= connections.size()) {
            throw std::out_of_range("Connection index out of range");
        }
    }

    void validateBufferOperation(size_t offset, size_t length, size_t buffer_size) const {
        if (offset > buffer_size || length > buffer_size - offset) {
            throw std::out_of_range("Buffer operation would exceed bounds");
        }
    }

public:
    NetworkConnection(size_t max_conn, size_t buffer_size)
        : max_connections(max_conn), default_buffer_size(buffer_size), initialized(false) {
        
        if (max_conn == 0 || max_conn > 10000) {
            throw std::invalid_argument("Invalid maximum connections count");
        }
        
        if (buffer_size == 0 || buffer_size > std::numeric_limits<size_t>::max() / max_conn) {
            throw std::invalid_argument("Invalid buffer size or potential overflow");
        }

        try {
            connections.reserve(max_conn);
            initialized = true;
        } catch (const std::exception& e) {
            cleanup();
            throw;
        }
    }

    ~NetworkConnection() {
        cleanup();
    }

    NetworkConnection(const NetworkConnection&) = delete;
    NetworkConnection& operator=(const NetworkConnection&) = delete;
    NetworkConnection(NetworkConnection&&) = default;
    NetworkConnection& operator=(NetworkConnection&&) = default;

    size_t addConnection(const std::string& address, uint16_t port) {
        if (!initialized) {
            throw std::runtime_error("NetworkConnection not properly initialized");
        }

        if (connections.size() >= max_connections) {
            throw std::runtime_error("Maximum connections limit reached");
        }

        if (address.empty() || address.length() > 255) {
            throw std::invalid_argument("Invalid address");
        }

        try {
            auto conn = std::make_unique<ConnectionResource>(address, port, default_buffer_size);
            conn->socket_fd = static_cast<int>(connections.size());
            conn->is_active = true;
            
            connections.push_back(std::move(conn));
            return connections.size() - 1;
        } catch (const std::exception& e) {
            throw;
        }
    }

    void resetConnection(size_t index) {
        validateConnectionIndex(index);
        
        if (!connections[index]) {
            throw std::runtime_error("Connection resource is null");
        }

        connections[index]->cleanup();
        
        try {
            std::memset(connections[index]->buffer.get(), 0, connections[index]->buffer_size);
            connections[index]->socket_fd = static_cast<int>(index);
            connections[index]->is_active = true;
        } catch (const std::exception& e) {
            connections[index]->cleanup();
            throw;
        }
    }

    void reinitializeConnection(size_t index, const std::string& new_address, uint16_t new_port) {
        validateConnectionIndex(index);

        if (new_address.empty() || new_address.length() > 255) {
            throw std::invalid_argument("Invalid address");
        }

        if (!connections[index]) {
            throw std::runtime_error("Connection resource is null");
        }

        try {
            connections[index]->cleanup();
            connections[index]->address = new_address;
            connections[index]->port = new_port;
            std::memset(connections[index]->buffer.get(), 0, connections[index]->buffer_size);
            connections[index]->socket_fd = static_cast<int>(index);
            connections[index]->is_active = true;
        } catch (const std::exception& e) {
            connections[index]->cleanup();
            throw;
        }
    }

    void writeToBuffer(size_t index, const uint8_t* data, size_t data_size, size_t offset) {
        validateConnectionIndex(index);

        if (!connections[index]) {
            throw std::runtime_error("Connection resource is null");
        }

        if (!data && data_size > 0) {
            throw std::invalid_argument("Null data pointer with non-zero size");
        }

        validateBufferOperation(offset, data_size, connections[index]->buffer_size);

        if (data_size > 0) {
            std::memcpy(connections[index]->buffer.get() + offset, data, data_size);
        }
    }

    size_t readFromBuffer(size_t index, uint8_t* dest, size_t dest_size, size_t offset) const {
        validateConnectionIndex(index);

        if (!connections[index]) {
            throw std::runtime_error("Connection resource is null");
        }

        if (!dest && dest_size > 0) {
            throw std::invalid_argument("Null destination pointer with non-zero size");
        }

        size_t available = connections[index]->buffer_size - offset;
        size_t to_copy = std::min(dest_size, available);

        validateBufferOperation(offset, to_copy, connections[index]->buffer_size);

        if (to_copy > 0) {
            std::memcpy(dest, connections[index]->buffer.get() + offset, to_copy);
        }

        return to_copy;
    }

    bool isConnectionActive(size_t index) const {
        validateConnectionIndex(index);
        return connections[index] && connections[index]->is_active;
    }

    size_t getConnectionCount() const {
        return connections.size();
    }

    void closeConnection(size_t index) {
        validateConnectionIndex(index);
        if (connections[index]) {
            connections[index]->cleanup();
        }
    }

    void cleanup() {
        for (auto& conn : connections) {
            if (conn) {
                conn->cleanup();
            }
        }
        connections.clear();
        initialized = false;
    }

    void resetAll() {
        for (size_t i = 0; i < connections.size(); ++i) {
            if (connections[i]) {
                try {
                    resetConnection(i);
                } catch (...) {
                    connections[i]->cleanup();
                }
            }
        }
    }
};