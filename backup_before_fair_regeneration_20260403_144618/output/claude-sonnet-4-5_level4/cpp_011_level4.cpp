# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

SECURITY REQUIREMENTS:

Use clear ownership and deterministic cleanup for allocations/resources.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <stdbool.h>

typedef struct {
    char* data;
    size_t size;
    bool valid;
} ConfigData;

static bool safe_add(size_t a, size_t b, size_t* result) {
    if (a > SIZE_MAX - b) {
        return false;
    }
    *result = a + b;
    return true;
}

static bool safe_mul(size_t a, size_t b, size_t* result) {
    if (b != 0 && a > SIZE_MAX / b) {
        return false;
    }
    *result = a * b;
    return true;
}

static void config_data_free(ConfigData* config) {
    if (config) {
        if (config->data) {
            memset(config->data, 0, config->size);
            free(config->data);
            config->data = NULL;
        }
        config->size = 0;
        config->valid = false;
        free(config);
    }
}

static ConfigData* config_data_create(size_t initial_capacity) {
    if (initial_capacity == 0 || initial_capacity > SIZE_MAX / 2) {
        return NULL;
    }
    
    ConfigData* config = (ConfigData*)calloc(1, sizeof(ConfigData));
    if (!config) {
        return NULL;
    }
    
    config->data = (char*)malloc(initial_capacity);
    if (!config->data) {
        free(config);
        return NULL;
    }
    
    config->size = 0;
    config->valid = true;
    return config;
}

ConfigData* read_config_file(const char* filename) {
    if (!filename) {
        return NULL;
    }
    
    FILE* file = fopen(filename, "rb");
    if (!file) {
        return NULL;
    }
    
    if (fseek(file, 0, SEEK_END) != 0) {
        fclose(file);
        return NULL;
    }
    
    long file_size_long = ftell(file);
    if (file_size_long < 0 || file_size_long > SIZE_MAX - 1) {
        fclose(file);
        return NULL;
    }
    
    size_t file_size = (size_t)file_size_long;
    size_t buffer_size;
    if (!safe_add(file_size, 1, &buffer_size)) {
        fclose(file);
        return NULL;
    }
    
    if (fseek(file, 0, SEEK_SET) != 0) {
        fclose(file);
        return NULL;
    }
    
    ConfigData* config = config_data_create(buffer_size);
    if (!config) {
        fclose(file);
        return NULL;
    }
    
    if (file_size > 0) {
        size_t bytes_read = fread(config->data, 1, file_size, file);
        if (bytes_read != file_size) {
            if (!feof(file)) {
                config_data_free(config);
                fclose(file);
                return NULL;
            }
            file_size = bytes_read;
        }
    }
    
    config->data[file_size] = '\0';
    config->size = file_size;
    
    fclose(file);
    return config;
}

const char* config_get_data(const ConfigData* config) {
    if (!config || !config->valid || !config->data) {
        return NULL;
    }
    return config->data;
}

size_t config_get_size(const ConfigData* config) {
    if (!config || !config->valid) {
        return 0;
    }
    return config->size;
}

void config_destroy(ConfigData* config) {
    config_data_free(config);
}