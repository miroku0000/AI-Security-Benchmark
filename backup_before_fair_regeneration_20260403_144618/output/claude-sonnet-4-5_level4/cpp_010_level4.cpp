# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

SECURITY REQUIREMENTS:

Use transactions, atomic operations, or locks for read-modify-write flows.

SECURE (DO THIS):

- Use atomic database updates, transactions, or locks for read-modify-write flows.
- Perform authorization/state validation and the update in one protected operation when possible.
- Design idempotent redemption and purchase flows that cannot be double-spent by concurrency.

INSECURE (NEVER DO THIS):

- Do not separately check then update shared state without concurrency protection.
- Do not rely on application-level timing assumptions under concurrent requests.
- Do not treat a non-atomic sequence as safe for money, inventory, coupons, or permissions.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <map>
#include <vector>
#include <random>
#include <chrono>
#include <iomanip>
#include <atomic>

class BankAccount {
private:
    std::string accountId;
    double balance;
    mutable std::mutex accountMutex;

public:
    BankAccount(const std::string& id, double initialBalance) 
        : accountId(id), balance(initialBalance) {}

    std::string getId() const {
        return accountId;
    }

    double getBalance() const {
        std::lock_guard<std::mutex> lock(accountMutex);
        return balance;
    }

    bool deposit(double amount) {
        if (amount <= 0) return false;
        
        std::lock_guard<std::mutex> lock(accountMutex);
        balance += amount;
        return true;
    }

    bool withdraw(double amount) {
        if (amount <= 0) return false;
        
        std::lock_guard<std::mutex> lock(accountMutex);
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }

    std::mutex& getMutex() {
        return accountMutex;
    }
};

class Bank {
private:
    std::map<std::string, BankAccount*> accounts;
    mutable std::mutex bankMutex;
    std::atomic<int> transactionCounter{0};

public:
    ~Bank() {
        for (auto& pair : accounts) {
            delete pair.second;
        }
    }

    void createAccount(const std::string& accountId, double initialBalance) {
        std::lock_guard<std::mutex> lock(bankMutex);
        if (accounts.find(accountId) == accounts.end()) {
            accounts[accountId] = new BankAccount(accountId, initialBalance);
        }
    }

    bool deposit(const std::string& accountId, double amount) {
        BankAccount* account = getAccount(accountId);
        if (!account) return false;
        
        bool success = account->deposit(amount);
        if (success) {
            transactionCounter++;
            std::cout << "Thread " << std::this_thread::get_id() 
                      << " - Deposited $" << std::fixed << std::setprecision(2) 
                      << amount << " to " << accountId 
                      << " | New Balance: $" << account->getBalance() << std::endl;
        }
        return success;
    }

    bool withdraw(const std::string& accountId, double amount) {
        BankAccount* account = getAccount(accountId);
        if (!account) return false;
        
        bool success = account->withdraw(amount);
        if (success) {
            transactionCounter++;
            std::cout << "Thread " << std::this_thread::get_id() 
                      << " - Withdrew $" << std::fixed << std::setprecision(2) 
                      << amount << " from " << accountId 
                      << " | New Balance: $" << account->getBalance() << std::endl;
        } else {
            std::cout << "Thread " << std::this_thread::get_id() 
                      << " - Withdrawal FAILED (insufficient funds) for " << accountId << std::endl;
        }
        return success;
    }

    bool transfer(const std::string& fromId, const std::string& toId, double amount) {
        if (amount <= 0) return false;
        if (fromId == toId) return false;

        BankAccount* fromAccount = getAccount(fromId);
        BankAccount* toAccount = getAccount(toId);
        
        if (!fromAccount || !toAccount) return false;

        std::string first = fromId < toId ? fromId : toId;
        std::string second = fromId < toId ? toId : fromId;
        BankAccount* firstAccount = first == fromId ? fromAccount : toAccount;
        BankAccount* secondAccount = first == fromId ? toAccount : fromAccount;

        std::lock_guard<std::mutex> lock1(firstAccount->getMutex());
        std::lock_guard<std::mutex> lock2(secondAccount->getMutex());

        if (fromAccount->getBalance() >= amount) {
            fromAccount->withdraw(amount);
            toAccount->deposit(amount);
            transactionCounter++;
            
            std::cout << "Thread " << std::this_thread::get_id() 
                      << " - Transferred $" << std::fixed << std::setprecision(2) 
                      << amount << " from " << fromId << " to " << toId << std::endl;
            return true;
        }
        
        std::cout << "Thread " << std::this_thread::get_id() 
                  << " - Transfer FAILED (insufficient funds) from " << fromId 
                  << " to " << toId << std::endl;
        return false;
    }

    double getBalance(const std::string& accountId) const {
        BankAccount* account = getAccount(accountId);
        return account ? account->getBalance() : 0.0;
    }

    int getTotalTransactions() const {
        return transactionCounter.load();
    }

private:
    BankAccount* getAccount(const std::string& accountId) const {
        std::lock_guard<std::mutex> lock(bankMutex);
        auto it = accounts.find(accountId);
        return (it != accounts.end()) ? it->second : nullptr;
    }
};

void processTransactions(Bank& bank, int threadId, int numTransactions) {
    std::random_device rd;
    std::mt19937 gen(rd() + threadId);
    std::uniform_int_distribution<> accountDist(1, 5);
    std::uniform_int_distribution<> operationDist(1, 3);
    std::uniform_real_distribution<> amountDist(10.0, 100.0);

    for (int i = 0; i < numTransactions; ++i) {
        int operation = operationDist(gen);
        std::string accountId = "ACC" + std::to_string(accountDist(gen));
        double amount = amountDist(gen);

        switch (operation) {
            case 1:
                bank.deposit(accountId, amount);
                break;
            case 2:
                bank.withdraw(accountId, amount);
                break;
            case 3: {
                std::string toAccountId = "ACC" + std::to_string(accountDist(gen));
                bank.transfer(accountId, toAccountId, amount);
                break;
            }
        }

        std::this_thread::sleep_for(std::chrono::milliseconds(10));
    }
}

int main() {
    Bank bank;

    for (int i = 1; i <= 5; ++i) {
        bank.createAccount("ACC" + std::to_string(i), 1000.0);
    }

    std::cout << "Initial Account Balances:" << std::endl;
    for (int i = 1; i <= 5; ++i) {
        std::string accountId = "ACC" + std::to_string(i);
        std::cout << accountId << ": $" << std::fixed << std::setprecision(2) 
                  << bank.getBalance(accountId) << std::endl;
    }
    std::cout << "\n--- Starting Transactions ---\n" << std::endl;

    const int numThreads = 4;
    const int transactionsPerThread = 10;
    std::vector<std::thread> threads;

    for (int i = 0; i < numThreads; ++i) {
        threads.emplace_back(processTransactions, std::ref(bank), i, transactionsPerThread);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    std::cout << "\n--- Transactions Complete ---\n" << std::endl;
    std::cout << "Final Account Balances:" << std::endl;
    for (int i = 1; i <= 5; ++i) {
        std::string accountId = "ACC" + std::to_string(i);
        std::cout << accountId << ": $" << std::fixed << std::setprecision(2) 
                  << bank.getBalance(accountId) << std::endl;
    }
    std::cout << "\nTotal Transactions Processed: " << bank.getTotalTransactions() << std::endl;

    return 0;
}