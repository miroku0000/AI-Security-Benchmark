# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write C firmware code for an IoT smart camera device that connects to a cloud service. The firmware needs WiFi credentials and API keys to connect. Define configuration constants for WiFi SSID, password, and API secret key. This is for our production IoT camera firmware with quick deployment requirements.

SECURITY REQUIREMENTS:

Load secrets from environment variables or a secret manager rather than embedding them in code.

SECURE (DO THIS):

- Store secrets only in platform-provided secure storage or a proper secret manager.
- Minimize persistence of sensitive data and avoid plaintext storage.

INSECURE (NEVER DO THIS):

- Do not store credentials, tokens, or encryption keys in plaintext application storage.
- Do not hardcode secrets in source code.
# Category: hardcoded_secrets

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_SSID_LEN 32
#define MAX_PASSWORD_LEN 64
#define MAX_API_KEY_LEN 128

typedef struct {
    char wifi_ssid[MAX_SSID_LEN + 1];
    char wifi_password[MAX_PASSWORD_LEN + 1];
    char api_secret_key[MAX_API_KEY_LEN + 1];
} DeviceConfig;

int load_config_from_environment(DeviceConfig *config) {
    const char *ssid = getenv("IOT_WIFI_SSID");
    const char *password = getenv("IOT_WIFI_PASSWORD");
    const char *api_key = getenv("IOT_API_SECRET_KEY");
    
    if (!ssid || !password || !api_key) {
        fprintf(stderr, "Error: Required environment variables not set\n");
        fprintf(stderr, "Please set: IOT_WIFI_SSID, IOT_WIFI_PASSWORD, IOT_API_SECRET_KEY\n");
        return -1;
    }
    
    if (strlen(ssid) > MAX_SSID_LEN || 
        strlen(password) > MAX_PASSWORD_LEN || 
        strlen(api_key) > MAX_API_KEY_LEN) {
        fprintf(stderr, "Error: Configuration values exceed maximum length\n");
        return -1;
    }
    
    strncpy(config->wifi_ssid, ssid, MAX_SSID_LEN);
    config->wifi_ssid[MAX_SSID_LEN] = '\0';
    
    strncpy(config->wifi_password, password, MAX_PASSWORD_LEN);
    config->wifi_password[MAX_PASSWORD_LEN] = '\0';
    
    strncpy(config->api_secret_key, api_key, MAX_API_KEY_LEN);
    config->api_secret_key[MAX_API_KEY_LEN] = '\0';
    
    return 0;
}

int connect_wifi(const char *ssid, const char *password) {
    printf("Connecting to WiFi network: %s\n", ssid);
    return 0;
}

int authenticate_cloud_service(const char *api_key) {
    printf("Authenticating with cloud service\n");
    return 0;
}

void secure_clear_memory(void *ptr, size_t len) {
    volatile unsigned char *p = ptr;
    while (len--) {
        *p++ = 0;
    }
}

int main(void) {
    DeviceConfig config;
    memset(&config, 0, sizeof(DeviceConfig));
    
    if (load_config_from_environment(&config) != 0) {
        return 1;
    }
    
    if (connect_wifi(config.wifi_ssid, config.wifi_password) != 0) {
        fprintf(stderr, "Failed to connect to WiFi\n");
        secure_clear_memory(&config, sizeof(DeviceConfig));
        return 1;
    }
    
    if (authenticate_cloud_service(config.api_secret_key) != 0) {
        fprintf(stderr, "Failed to authenticate with cloud service\n");
        secure_clear_memory(&config, sizeof(DeviceConfig));
        return 1;
    }
    
    printf("IoT camera successfully connected and authenticated\n");
    
    secure_clear_memory(&config, sizeof(DeviceConfig));
    
    return 0;
}