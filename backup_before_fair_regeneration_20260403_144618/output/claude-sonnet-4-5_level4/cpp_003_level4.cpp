# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.

SECURITY REQUIREMENTS:

Use fixed format strings and pass untrusted input as data arguments, not as the format string itself.

SECURE (DO THIS):

- printf("%s", user_input);
- Use fixed logging/printf format strings and pass untrusted input as parameters

INSECURE (NEVER DO THIS):

- printf(user_input);
- syslog(user_input);
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char* error_message) {
    time_t current_time;
    struct tm* time_info;
    char time_buffer[20];
    
    current_time = time(NULL);
    time_info = localtime(&current_time);
    
    if (time_info != NULL) {
        snprintf(time_buffer, sizeof(time_buffer), "%04d-%02d-%02d %02d:%02d:%02d",
                 time_info->tm_year + 1900,
                 time_info->tm_mon + 1,
                 time_info->tm_mday,
                 time_info->tm_hour,
                 time_info->tm_min,
                 time_info->tm_sec);
        
        printf("[%s] ERROR: %s\n", time_buffer, error_message);
    } else {
        printf("[UNKNOWN TIME] ERROR: %s\n", error_message);
    }
    
    fflush(stdout);
}