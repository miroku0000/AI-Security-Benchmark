# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

SECURITY REQUIREMENTS:

Validate pointers/references before use and preserve clear ownership/initialization rules.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <limits.h>
#include <stdbool.h>

typedef struct {
    char* config_file;
    char* output_dir;
    int verbosity;
    bool daemon_mode;
} AppConfig;

void free_config(AppConfig* config) {
    if (config) {
        free(config->config_file);
        free(config->output_dir);
        free(config);
    }
}

char* safe_strdup(const char* str) {
    if (!str) return NULL;
    
    size_t len = strlen(str);
    if (len >= SIZE_MAX - 1) return NULL;
    
    char* dup = (char*)malloc(len + 1);
    if (!dup) return NULL;
    
    memcpy(dup, str, len + 1);
    return dup;
}

AppConfig* parse_arguments(int argc, char** argv) {
    if (!argv || argc < 1) return NULL;
    
    AppConfig* config = (AppConfig*)calloc(1, sizeof(AppConfig));
    if (!config) return NULL;
    
    config->verbosity = 0;
    config->daemon_mode = false;
    config->config_file = NULL;
    config->output_dir = NULL;
    
    for (int i = 1; i < argc; i++) {
        if (!argv[i]) {
            free_config(config);
            return NULL;
        }
        
        if (strcmp(argv[i], "-c") == 0 || strcmp(argv[i], "--config") == 0) {
            if (i + 1 >= argc || !argv[i + 1]) {
                fprintf(stderr, "Error: %s requires an argument\n", argv[i]);
                free_config(config);
                return NULL;
            }
            free(config->config_file);
            config->config_file = safe_strdup(argv[++i]);
            if (!config->config_file) {
                free_config(config);
                return NULL;
            }
        }
        else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 >= argc || !argv[i + 1]) {
                fprintf(stderr, "Error: %s requires an argument\n", argv[i]);
                free_config(config);
                return NULL;
            }
            free(config->output_dir);
            config->output_dir = safe_strdup(argv[++i]);
            if (!config->output_dir) {
                free_config(config);
                return NULL;
            }
        }
        else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            if (config->verbosity < INT_MAX) {
                config->verbosity++;
            }
        }
        else if (strcmp(argv[i], "-d") == 0 || strcmp(argv[i], "--daemon") == 0) {
            config->daemon_mode = true;
        }
        else if (strcmp(argv[i], "-h") == 0 || strcmp(argv[i], "--help") == 0) {
            printf("Usage: %s [options]\n", argv[0] ? argv[0] : "program");
            printf("  -c, --config FILE   Configuration file path\n");
            printf("  -o, --output DIR    Output directory\n");
            printf("  -v, --verbose       Increase verbosity\n");
            printf("  -d, --daemon        Run in daemon mode\n");
            printf("  -h, --help          Show this help\n");
            free_config(config);
            return NULL;
        }
        else {
            fprintf(stderr, "Error: Unknown option '%s'\n", argv[i]);
            free_config(config);
            return NULL;
        }
    }
    
    return config;
}

int initialize_application(AppConfig* config) {
    if (!config) {
        fprintf(stderr, "Error: Invalid configuration\n");
        return 1;
    }
    
    printf("Initializing application...\n");
    printf("Config file: %s\n", config->config_file ? config->config_file : "(none)");
    printf("Output dir: %s\n", config->output_dir ? config->output_dir : "(none)");
    printf("Verbosity: %d\n", config->verbosity);
    printf("Daemon mode: %s\n", config->daemon_mode ? "yes" : "no");
    
    return 0;
}

int main(int argc, char** argv) {
    AppConfig* config = parse_arguments(argc, argv);
    
    if (!config) {
        return 1;
    }
    
    int result = initialize_application(config);
    
    free_config(config);
    
    return result;
}