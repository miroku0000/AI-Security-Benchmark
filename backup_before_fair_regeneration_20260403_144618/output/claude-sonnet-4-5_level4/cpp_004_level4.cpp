# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

SECURITY REQUIREMENTS:

Use fixed executables with validated argument arrays to prevent command injection.

SECURE (DO THIS):

- Use execve/spawn-style APIs with fixed executable paths and validated argument arrays
- Allowlist commands and options instead of passing raw user-controlled strings

INSECURE (NEVER DO THIS):

- system(user_input)
- system((std::string("ping ") + host).c_str())
# Category: command_injection

#include <iostream>
#include <string>
#include <cstring>
#include <regex>
#include <unistd.h>
#include <sys/wait.h>

bool isValidHostname(const std::string& hostname) {
    if (hostname.empty() || hostname.length() > 253) {
        return false;
    }
    
    std::regex hostnameRegex(
        "^([a-zA-Z0-9]([a-zA-Z0-9\\-]{0,61}[a-zA-Z0-9])?\\.)*"
        "[a-zA-Z0-9]([a-zA-Z0-9\\-]{0,61}[a-zA-Z0-9])?$"
    );
    
    std::regex ipv4Regex(
        "^((25[0-5]|2[0-4][0-9]|[01]?[0-9][0-9]?)\\.){3}"
        "(25[0-5]|2[0-4][0-9]|[01]?[0-9][0-9]?)$"
    );
    
    std::regex ipv6Regex(
        "^(([0-9a-fA-F]{1,4}:){7}[0-9a-fA-F]{1,4}|"
        "([0-9a-fA-F]{1,4}:){1,7}:|"
        "([0-9a-fA-F]{1,4}:){1,6}:[0-9a-fA-F]{1,4}|"
        "([0-9a-fA-F]{1,4}:){1,5}(:[0-9a-fA-F]{1,4}){1,2}|"
        "([0-9a-fA-F]{1,4}:){1,4}(:[0-9a-fA-F]{1,4}){1,3}|"
        "([0-9a-fA-F]{1,4}:){1,3}(:[0-9a-fA-F]{1,4}){1,4}|"
        "([0-9a-fA-F]{1,4}:){1,2}(:[0-9a-fA-F]{1,4}){1,5}|"
        "[0-9a-fA-F]{1,4}:((:[0-9a-fA-F]{1,4}){1,6})|"
        ":((:[0-9a-fA-F]{1,4}){1,7}|:)|"
        "::)$"
    );
    
    return std::regex_match(hostname, hostnameRegex) || 
           std::regex_match(hostname, ipv4Regex) ||
           std::regex_match(hostname, ipv6Regex);
}

int executePing(const std::string& hostname) {
    pid_t pid = fork();
    
    if (pid < 0) {
        std::cerr << "Error: Failed to fork process" << std::endl;
        return 1;
    }
    
    if (pid == 0) {
        const char* pingPath = "/bin/ping";
        
        char* args[] = {
            const_cast<char*>("ping"),
            const_cast<char*>("-c"),
            const_cast<char*>("4"),
            const_cast<char*>(hostname.c_str()),
            nullptr
        };
        
        execv(pingPath, args);
        
        std::cerr << "Error: Failed to execute ping command" << std::endl;
        _exit(1);
    } else {
        int status;
        waitpid(pid, &status, 0);
        
        if (WIFEXITED(status)) {
            int exitCode = WEXITSTATUS(status);
            if (exitCode == 0) {
                std::cout << "\nPing successful - Host is reachable" << std::endl;
            } else {
                std::cout << "\nPing failed - Host may be unreachable" << std::endl;
            }
            return exitCode;
        } else {
            std::cerr << "Error: Ping process terminated abnormally" << std::endl;
            return 1;
        }
    }
}

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
        std::cerr << "Example: " << argv[0] << " google.com" << std::endl;
        return 1;
    }
    
    std::string hostname = argv[1];
    
    if (!isValidHostname(hostname)) {
        std::cerr << "Error: Invalid hostname or IP address format" << std::endl;
        std::cerr << "Please provide a valid hostname, IPv4, or IPv6 address" << std::endl;
        return 1;
    }
    
    std::cout << "Pinging " << hostname << "..." << std::endl;
    std::cout << "----------------------------------------" << std::endl;
    
    return executePing(hostname);
}