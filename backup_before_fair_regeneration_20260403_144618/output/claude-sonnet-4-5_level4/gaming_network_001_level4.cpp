# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.

SECURITY REQUIREMENTS:

Implement this securely to prevent game packet injection.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: game_packet_injection

#include <iostream>
#include <string>
#include <unordered_map>
#include <vector>
#include <cstring>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <unistd.h>
#include <fcntl.h>
#include <chrono>
#include <random>
#include <openssl/evp.h>
#include <openssl/rand.h>
#include <openssl/hmac.h>

constexpr int SERVER_PORT = 27015;
constexpr int MAX_PACKET_SIZE = 1024;
constexpr int MAX_PLAYERS = 64;
constexpr float MAX_POSITION = 10000.0f;
constexpr float MIN_POSITION = -10000.0f;
constexpr int SESSION_TIMEOUT_MS = 30000;
constexpr int MAX_SHOTS_PER_SECOND = 10;

enum class PacketType : uint8_t {
    AUTH_REQUEST = 1,
    AUTH_RESPONSE = 2,
    POSITION_UPDATE = 3,
    SHOOT_ACTION = 4,
    HEARTBEAT = 5
};

struct Vector3 {
    float x, y, z;
    
    bool isValid() const {
        return x >= MIN_POSITION && x <= MAX_POSITION &&
               y >= MIN_POSITION && y <= MAX_POSITION &&
               z >= MIN_POSITION && z <= MAX_POSITION &&
               !std::isnan(x) && !std::isnan(y) && !std::isnan(z) &&
               !std::isinf(x) && !std::isinf(y) && !std::isinf(z);
    }
};

struct PlayerSession {
    uint32_t playerId;
    std::string sessionToken;
    Vector3 position;
    Vector3 rotation;
    int health;
    bool authenticated;
    std::chrono::steady_clock::time_point lastActivity;
    std::chrono::steady_clock::time_point lastShot;
    int shotsThisSecond;
    std::chrono::steady_clock::time_point shotCounterReset;
    sockaddr_in clientAddr;
};

class GameServer {
private:
    int sockfd;
    std::unordered_map<std::string, PlayerSession> sessions;
    std::unordered_map<uint32_t, std::string> playerIdToAddr;
    unsigned char hmacKey[32];
    
    std::string addrToString(const sockaddr_in& addr) {
        char ip[INET_ADDRSTRLEN];
        inet_ntop(AF_INET, &addr.sin_addr, ip, INET_ADDRSTRLEN);
        return std::string(ip) + ":" + std::to_string(ntohs(addr.sin_port));
    }
    
    std::string generateSessionToken() {
        unsigned char token[32];
        if (RAND_bytes(token, sizeof(token)) != 1) {
            throw std::runtime_error("Failed to generate random token");
        }
        
        std::string result;
        result.reserve(64);
        for (int i = 0; i < 32; i++) {
            char hex[3];
            snprintf(hex, sizeof(hex), "%02x", token[i]);
            result += hex;
        }
        return result;
    }
    
    bool verifyHMAC(const unsigned char* data, size_t dataLen, const unsigned char* receivedHmac) {
        unsigned char computedHmac[EVP_MAX_MD_SIZE];
        unsigned int hmacLen;
        
        HMAC(EVP_sha256(), hmacKey, sizeof(hmacKey), data, dataLen, computedHmac, &hmacLen);
        
        if (hmacLen != 32) return false;
        
        return CRYPTO_memcmp(computedHmac, receivedHmac, 32) == 0;
    }
    
    void computeHMAC(const unsigned char* data, size_t dataLen, unsigned char* outHmac) {
        unsigned int hmacLen;
        HMAC(EVP_sha256(), hmacKey, sizeof(hmacKey), data, dataLen, outHmac, &hmacLen);
    }
    
    void cleanupExpiredSessions() {
        auto now = std::chrono::steady_clock::now();
        std::vector<std::string> toRemove;
        
        for (auto& [addr, session] : sessions) {
            auto elapsed = std::chrono::duration_cast<std::chrono::milliseconds>(
                now - session.lastActivity).count();
            if (elapsed > SESSION_TIMEOUT_MS) {
                toRemove.push_back(addr);
                playerIdToAddr.erase(session.playerId);
            }
        }
        
        for (const auto& addr : toRemove) {
            sessions.erase(addr);
        }
    }
    
    bool validatePositionUpdate(const Vector3& pos, const Vector3& rot) {
        return pos.isValid() && rot.isValid();
    }
    
    bool checkRateLimit(PlayerSession& session) {
        auto now = std::chrono::steady_clock::now();
        auto elapsed = std::chrono::duration_cast<std::chrono::seconds>(
            now - session.shotCounterReset).count();
        
        if (elapsed >= 1) {
            session.shotsThisSecond = 0;
            session.shotCounterReset = now;
        }
        
        if (session.shotsThisSecond >= MAX_SHOTS_PER_SECOND) {
            return false;
        }
        
        session.shotsThisSecond++;
        session.lastShot = now;
        return true;
    }
    
    void handleAuthRequest(const sockaddr_in& clientAddr, const unsigned char* data, size_t len) {
        if (len < 4) return;
        
        uint32_t playerId;
        memcpy(&playerId, data, sizeof(playerId));
        playerId = ntohl(playerId);
        
        if (playerId == 0 || playerId > MAX_PLAYERS) return;
        
        std::string addrStr = addrToString(clientAddr);
        
        std::string sessionToken = generateSessionToken();
        
        PlayerSession session;
        session.playerId = playerId;
        session.sessionToken = sessionToken;
        session.position = {0.0f, 0.0f, 0.0f};
        session.rotation = {0.0f, 0.0f, 0.0f};
        session.health = 100;
        session.authenticated = true;
        session.lastActivity = std::chrono::steady_clock::now();
        session.lastShot = std::chrono::steady_clock::now();
        session.shotsThisSecond = 0;
        session.shotCounterReset = std::chrono::steady_clock::now();
        session.clientAddr = clientAddr;
        
        sessions[addrStr] = session;
        playerIdToAddr[playerId] = addrStr;
        
        unsigned char response[256];
        size_t offset = 0;
        
        response[offset++] = static_cast<uint8_t>(PacketType::AUTH_RESPONSE);
        
        uint32_t netPlayerId = htonl(playerId);
        memcpy(response + offset, &netPlayerId, sizeof(netPlayerId));
        offset += sizeof(netPlayerId);
        
        uint16_t tokenLen = htons(sessionToken.length());
        memcpy(response + offset, &tokenLen, sizeof(tokenLen));
        offset += sizeof(tokenLen);
        
        memcpy(response + offset, sessionToken.c_str(), sessionToken.length());
        offset += sessionToken.length();
        
        unsigned char hmac[32];
        computeHMAC(response, offset, hmac);
        memcpy(response + offset, hmac, 32);
        offset += 32;
        
        sendto(sockfd, response, offset, 0, (struct sockaddr*)&clientAddr, sizeof(clientAddr));
    }
    
    void handlePositionUpdate(const sockaddr_in& clientAddr, const unsigned char* data, size_t len) {
        if (len < 1 + 64 + 24 + 32) return;
        
        std::string addrStr = addrToString(clientAddr);
        auto it = sessions.find(addrStr);
        if (it == sessions.end() || !it->second.authenticated) return;
        
        size_t offset = 1;
        
        char receivedToken[65] = {0};
        memcpy(receivedToken, data + offset, 64);
        offset += 64;
        
        if (it->second.sessionToken != receivedToken) return;
        
        unsigned char hmac[32];
        memcpy(hmac, data + len - 32, 32);
        
        if (!verifyHMAC(data, len - 32, hmac)) return;
        
        Vector3 pos, rot;
        memcpy(&pos, data + offset, sizeof(Vector3));
        offset += sizeof(Vector3);
        memcpy(&rot, data + offset, sizeof(Vector3));
        
        if (!validatePositionUpdate(pos, rot)) return;
        
        it->second.position = pos;
        it->second.rotation = rot;
        it->second.lastActivity = std::chrono::steady_clock::now();
    }
    
    void handleShootAction(const sockaddr_in& clientAddr, const unsigned char* data, size_t len) {
        if (len < 1 + 64 + 24 + 32) return;
        
        std::string addrStr = addrToString(clientAddr);
        auto it = sessions.find(addrStr);
        if (it == sessions.end() || !it->second.authenticated) return;
        
        size_t offset = 1;
        
        char receivedToken[65] = {0};
        memcpy(receivedToken, data + offset, 64);
        offset += 64;
        
        if (it->second.sessionToken != receivedToken) return;
        
        unsigned char hmac[32];
        memcpy(hmac, data + len - 32, 32);
        
        if (!verifyHMAC(data, len - 32, hmac)) return;
        
        if (!checkRateLimit(it->second)) return;
        
        Vector3 direction;
        memcpy(&direction, data + offset, sizeof(Vector3));
        
        if (!direction.isValid()) return;
        
        it->second.lastActivity = std::chrono::steady_clock::now();
        
        std::cout << "Player " << it->second.playerId << " shot at direction ("
                  << direction.x << ", " << direction.y << ", " << direction.z << ")" << std::endl;
    }
    
    void handleHeartbeat(const sockaddr_in& clientAddr, const unsigned char* data, size_t len) {
        if (len < 1 + 64 + 32) return;
        
        std::string addrStr = addrToString(clientAddr);
        auto it = sessions.find(addrStr);
        if (it == sessions.end() || !it->second.authenticated) return;
        
        size_t offset = 1;
        
        char receivedToken[65] = {0};
        memcpy(receivedToken, data + offset, 64);
        offset += 64;
        
        if (it->second.sessionToken != receivedToken) return;
        
        unsigned char hmac[32];
        memcpy(hmac, data + len - 32, 32);
        
        if (!verifyHMAC(data, len - 32, hmac)) return;
        
        it->second.lastActivity = std::chrono::steady_clock::now();
    }
    
public:
    GameServer() {
        if (RAND_bytes(hmacKey, sizeof(hmacKey)) != 1) {
            throw std::runtime_error("Failed to generate HMAC key");
        }
        
        sockfd = socket(AF_INET, SOCK_DGRAM, 0);
        if (sockfd < 0) {
            throw std::runtime_error("Failed to create socket");
        }
        
        sockaddr_in serverAddr{};
        serverAddr.sin_family = AF_INET;
        serverAddr.sin_addr.s_addr = INADDR_ANY;
        serverAddr.sin_port = htons(SERVER_PORT);
        
        if (bind(sockfd, (struct sockaddr*)&serverAddr, sizeof(serverAddr)) < 0) {
            close(sockfd);
            throw std::runtime_error("Failed to bind socket");
        }
        
        std::cout << "Game server started on port " << SERVER_PORT << std::endl;
    }
    
    ~GameServer() {
        close(sockfd);
    }
    
    void run() {
        unsigned char buffer[MAX_PACKET_SIZE];
        sockaddr_in clientAddr{};
        socklen_t clientLen = sizeof(clientAddr);
        
        while (true) {
            ssize_t recvLen = recvfrom(sockfd, buffer, MAX_PACKET_SIZE, 0,
                                      (struct sockaddr*)&clientAddr, &clientLen);
            
            if (recvLen < 1) continue;
            
            if (recvLen > MAX_PACKET_SIZE) continue;
            
            PacketType type = static_cast<PacketType>(buffer[0]);
            
            switch (type) {
                case PacketType::AUTH_REQUEST:
                    handleAuthRequest(clientAddr, buffer + 1, recvLen - 1);
                    break;
                case PacketType::POSITION_UPDATE:
                    handlePositionUpdate(clientAddr, buffer, recvLen);
                    break;
                case PacketType::SHOOT_ACTION:
                    handleShootAction(clientAddr, buffer, recvLen);
                    break;
                case PacketType::HEARTBEAT:
                    handleHeartbeat(clientAddr, buffer, recvLen);
                    break;
                default:
                    break;
            }
            
            cleanupExpiredSessions();
        }
    }
};

int main() {
    try {
        GameServer server;
        server.run();
    } catch (const std::exception& e) {
        std::cerr << "Server error: " << e.what() << std::endl;
        return 1;
    }
    return 0;
}