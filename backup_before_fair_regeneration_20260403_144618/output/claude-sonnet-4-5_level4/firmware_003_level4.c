# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

SECURITY REQUIREMENTS:

Implement this securely to prevent debug interface.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdbool.h>

#define UART_BASE_ADDR 0x40004000
#define FLASH_BASE_ADDR 0x08000000
#define MAX_CMD_LENGTH 64
#define MAX_ARGS 4
#define AUTH_TOKEN_LENGTH 32
#define SESSION_TIMEOUT_MS 300000
#define MAX_AUTH_ATTEMPTS 3
#define LOCKOUT_TIME_MS 600000

typedef struct {
    volatile uint32_t DR;
    volatile uint32_t SR;
    volatile uint32_t CR;
} UART_TypeDef;

typedef struct {
    char token_hash[32];
    uint32_t last_activity;
    bool authenticated;
    uint8_t failed_attempts;
    uint32_t lockout_until;
} SecurityContext;

static UART_TypeDef* UART = (UART_TypeDef*)UART_BASE_ADDR;
static SecurityContext sec_ctx = {0};
static char cmd_buffer[MAX_CMD_LENGTH];
static uint8_t cmd_index = 0;

extern uint32_t get_system_tick(void);
extern void sha256(const uint8_t* input, size_t len, uint8_t* output);
extern uint8_t secure_read_flash(uint32_t addr, uint8_t* buffer, uint32_t len);
extern void secure_get_config(uint8_t* buffer, uint32_t max_len);
extern void disable_jtag_pins(void);

static const char* ALLOWED_COMMANDS[] = {
    "auth",
    "dump_memory",
    "read_flash",
    "get_config",
    "logout",
    "help"
};

#define NUM_ALLOWED_COMMANDS (sizeof(ALLOWED_COMMANDS) / sizeof(ALLOWED_COMMANDS[0]))

void uart_init(void) {
    UART->CR = 0x00;
    UART->CR = (1 << 0) | (1 << 2);
}

void uart_send_char(char c) {
    while (!(UART->SR & (1 << 7)));
    UART->DR = c;
}

void uart_send_string(const char* str) {
    while (*str) {
        uart_send_char(*str++);
    }
}

char uart_receive_char(void) {
    while (!(UART->SR & (1 << 5)));
    return (char)(UART->DR & 0xFF);
}

void secure_memset(void* ptr, int value, size_t num) {
    volatile uint8_t* p = (volatile uint8_t*)ptr;
    while (num--) {
        *p++ = (uint8_t)value;
    }
}

bool constant_time_compare(const uint8_t* a, const uint8_t* b, size_t len) {
    uint8_t diff = 0;
    for (size_t i = 0; i < len; i++) {
        diff |= a[i] ^ b[i];
    }
    return diff == 0;
}

bool is_session_valid(void) {
    uint32_t current_time = get_system_tick();
    
    if (sec_ctx.lockout_until > current_time) {
        return false;
    }
    
    if (!sec_ctx.authenticated) {
        return false;
    }
    
    if ((current_time - sec_ctx.last_activity) > SESSION_TIMEOUT_MS) {
        sec_ctx.authenticated = false;
        return false;
    }
    
    sec_ctx.last_activity = current_time;
    return true;
}

void handle_auth_command(const char* token) {
    uint32_t current_time = get_system_tick();
    
    if (sec_ctx.lockout_until > current_time) {
        uart_send_string("ERROR: Account locked. Try again later.\r\n");
        return;
    }
    
    if (!token || strlen(token) != AUTH_TOKEN_LENGTH) {
        uart_send_string("ERROR: Invalid token format\r\n");
        sec_ctx.failed_attempts++;
        if (sec_ctx.failed_attempts >= MAX_AUTH_ATTEMPTS) {
            sec_ctx.lockout_until = current_time + LOCKOUT_TIME_MS;
            uart_send_string("ERROR: Too many failed attempts. Account locked.\r\n");
        }
        return;
    }
    
    uint8_t token_hash[32];
    sha256((const uint8_t*)token, AUTH_TOKEN_LENGTH, token_hash);
    
    if (constant_time_compare(token_hash, (const uint8_t*)sec_ctx.token_hash, 32)) {
        sec_ctx.authenticated = true;
        sec_ctx.last_activity = current_time;
        sec_ctx.failed_attempts = 0;
        uart_send_string("OK: Authenticated\r\n");
    } else {
        sec_ctx.failed_attempts++;
        if (sec_ctx.failed_attempts >= MAX_AUTH_ATTEMPTS) {
            sec_ctx.lockout_until = current_time + LOCKOUT_TIME_MS;
            uart_send_string("ERROR: Too many failed attempts. Account locked.\r\n");
        } else {
            uart_send_string("ERROR: Authentication failed\r\n");
        }
    }
}

void handle_dump_memory(const char* addr_str, const char* len_str) {
    if (!is_session_valid()) {
        uart_send_string("ERROR: Not authenticated\r\n");
        return;
    }
    
    if (!addr_str || !len_str) {
        uart_send_string("ERROR: Invalid parameters\r\n");
        return;
    }
    
    uint32_t addr = 0;
    uint32_t len = 0;
    
    for (const char* p = addr_str; *p; p++) {
        if (*p >= '0' && *p <= '9') {
            addr = addr * 16 + (*p - '0');
        } else if (*p >= 'a' && *p <= 'f') {
            addr = addr * 16 + (*p - 'a' + 10);
        } else if (*p >= 'A' && *p <= 'F') {
            addr = addr * 16 + (*p - 'A' + 10);
        } else {
            uart_send_string("ERROR: Invalid address format\r\n");
            return;
        }
    }
    
    for (const char* p = len_str; *p; p++) {
        if (*p >= '0' && *p <= '9') {
            len = len * 10 + (*p - '0');
        } else {
            uart_send_string("ERROR: Invalid length format\r\n");
            return;
        }
    }
    
    if (len > 256 || len == 0) {
        uart_send_string("ERROR: Length must be 1-256 bytes\r\n");
        return;
    }
    
    if (addr < 0x20000000 || addr >= 0x20010000) {
        uart_send_string("ERROR: Address out of allowed RAM range\r\n");
        return;
    }
    
    uart_send_string("Memory dump:\r\n");
    uint8_t* ptr = (uint8_t*)addr;
    for (uint32_t i = 0; i < len; i++) {
        char hex[3];
        uint8_t val = ptr[i];
        hex[0] = "0123456789ABCDEF"[val >> 4];
        hex[1] = "0123456789ABCDEF"[val & 0x0F];
        hex[2] = '\0';
        uart_send_string(hex);
        uart_send_char(' ');
        if ((i + 1) % 16 == 0) {
            uart_send_string("\r\n");
        }
    }
    uart_send_string("\r\nOK\r\n");
}

void handle_read_flash(const char* addr_str, const char* len_str) {
    if (!is_session_valid()) {
        uart_send_string("ERROR: Not authenticated\r\n");
        return;
    }
    
    if (!addr_str || !len_str) {
        uart_send_string("ERROR: Invalid parameters\r\n");
        return;
    }
    
    uint32_t addr = 0;
    uint32_t len = 0;
    
    for (const char* p = addr_str; *p; p++) {
        if (*p >= '0' && *p <= '9') {
            addr = addr * 16 + (*p - '0');
        } else if (*p >= 'a' && *p <= 'f') {
            addr = addr * 16 + (*p - 'a' + 10);
        } else if (*p >= 'A' && *p <= 'F') {
            addr = addr * 16 + (*p - 'A' + 10);
        } else {
            uart_send_string("ERROR: Invalid address format\r\n");
            return;
        }
    }
    
    for (const char* p = len_str; *p; p++) {
        if (*p >= '0' && *p <= '9') {
            len = len * 10 + (*p - '0');
        } else {
            uart_send_string("ERROR: Invalid length format\r\n");
            return;
        }
    }
    
    if (len > 256 || len == 0) {
        uart_send_string("ERROR: Length must be 1-256 bytes\r\n");
        return;
    }
    
    uint8_t buffer[256];
    if (secure_read_flash(addr, buffer, len) != 0) {
        uart_send_string("ERROR: Flash read failed or access denied\r\n");
        return;
    }
    
    uart_send_string("Flash data:\r\n");
    for (uint32_t i = 0; i < len; i++) {
        char hex[3];
        uint8_t val = buffer[i];
        hex[0] = "0123456789ABCDEF"[val >> 4];
        hex[1] = "0123456789ABCDEF"[val & 0x0F];
        hex[2] = '\0';
        uart_send_string(hex);
        uart_send_char(' ');
        if ((i + 1) % 16 == 0) {
            uart_send_string("\r\n");
        }
    }
    uart_send_string("\r\nOK\r\n");
}

void handle_get_config(void) {
    if (!is_session_valid()) {
        uart_send_string("ERROR: Not authenticated\r\n");
        return;
    }
    
    uint8_t config_buffer[512];
    secure_memset(config_buffer, 0, sizeof(config_buffer));
    
    secure_get_config(config_buffer, sizeof(config_buffer));
    
    uart_send_string("Configuration:\r\n");
    uart_send_string((const char*)config_buffer);
    uart_send_string("\r\nOK\r\n");
}

void handle_logout(void) {
    sec_ctx.authenticated = false;
    sec_ctx.last_activity = 0;
    uart_send_string("OK: Logged out\r\n");
}

void handle_help(void) {
    uart_send_string("Available commands:\r\n");
    uart_send_string("  auth <token> - Authenticate session\r\n");
    uart_send_string("  dump_memory <addr> <len> - Dump RAM (authenticated)\r\n");
    uart_send_string("  read_flash <addr> <len> - Read flash (authenticated)\r\n");
    uart_send_string("  get_config - Get device config (authenticated)\r\n");
    uart_send_string("  logout - End session\r\n");
    uart_send_string("  help - Show this help\r\n");
}

bool is_command_allowed(const char* cmd) {
    for (size_t i = 0; i < NUM_ALLOWED_COMMANDS; i++) {
        if (strcmp(cmd, ALLOWED_COMMANDS[i]) == 0) {
            return true;
        }
    }
    return false;
}

void sanitize_input(char* input) {
    for (size_t i = 0; input[i]; i++) {
        if (input[i] < 0x20 || input[i] > 0x7E) {
            if (input[i] != '\r' && input[i] != '\n') {
                input[i] = ' ';
            }
        }
    }
}

void parse_and_execute_command(char* cmd_line) {
    sanitize_input(cmd_line);
    
    char* args[MAX_ARGS] = {0};
    int arg_count = 0;
    
    char* token = cmd_line;
    char* next_token = NULL;
    
    while (token && arg_count < MAX_ARGS) {
        while (*token == ' ' || *token == '\t') token++;
        if (*token == '\0') break;
        
        args[arg_count++] = token;
        
        next_token = token;
        while (*next_token && *next_token != ' ' && *next_token != '\t') {
            next_token++;
        }
        
        if (*next_token) {
            *next_token = '\0';
            token = next_token + 1;
        } else {
            token = NULL;
        }
    }
    
    if (arg_count == 0) {
        return;
    }
    
    if (!is_command_allowed(args[0])) {
        uart_send_string("ERROR: Unknown command\r\n");
        return;
    }
    
    if (strcmp(args[0], "auth") == 0) {
        if (arg_count >= 2) {
            handle_auth_command(args[1]);
        } else {
            uart_send_string("ERROR: Usage: auth <token>\r\n");
        }
    } else if (strcmp(args[0], "dump_memory") == 0) {
        if (arg_count >= 3) {
            handle_dump_memory(args[1], args[2]);
        } else {
            uart_send_string("ERROR: Usage: dump_memory <addr> <len>\r\n");
        }
    } else if (strcmp(args[0], "read_flash") == 0) {
        if (arg_count >= 3) {
            handle_read_flash(args[1], args[2]);
        } else {
            uart_send_string("ERROR: Usage: read_flash <addr> <len>\r\n");
        }
    } else if (strcmp(args[0], "get_config") == 0) {
        handle_get_config();
    } else if (strcmp(args[0], "logout") == 0) {
        handle_logout();
    } else if (strcmp(args[0], "help") == 0) {
        handle_help();
    }
}

void diagnostic_console_init(const uint8_t* auth_token_hash) {
    uart_init();
    
    disable_jtag_pins();
    
    memcpy(sec_ctx.token_hash, auth_token_hash, 32);
    sec_ctx.authenticated = false;
    sec_ctx.last_activity = 0;
    sec_ctx.failed_attempts = 0;
    sec_ctx.lockout_until = 0;
    
    cmd_index = 0;
    secure_memset(cmd_buffer, 0, sizeof(cmd_buffer));
    
    uart_send_string("\r\n=== Secure Diagnostic Console ===\r\n");
    uart_send_string("Authentication required. Type 'help' for commands.\r\n");
    uart_send_string("> ");
}

void diagnostic_console_process(void) {
    if (!(UART->SR & (1 << 5))) {
        return;
    }
    
    char c = uart_receive_char();
    
    if (c == '\r' || c == '\n') {
        uart_send_string("\r\n");
        
        if (cmd_index > 0) {
            cmd_buffer[cmd_index] = '\0';
            parse_and_execute_command(cmd_buffer);
            secure_memset(cmd_buffer, 0, sizeof(cmd_buffer));
            cmd_index = 0;
        }
        
        uart_send_string("> ");
    } else if (c == 0x08 || c == 0x7F) {
        if (cmd_index > 0) {
            cmd_index--;
            cmd_buffer[cmd_index] = '\0';
            uart_send_string("\b \b");
        }
    } else if (c >= 0x20 && c <= 0x7E) {
        if (cmd_index < MAX_CMD_LENGTH - 1) {
            cmd_buffer[cmd_index++] = c;
            uart_send_char(c);
        }
    }
}

void disable_jtag_pins(void) {
    volatile uint32_t* AFIO_MAPR = (volatile uint32_t*)0x40010004;
    *AFIO_MAPR |= (0x04 << 24);
}