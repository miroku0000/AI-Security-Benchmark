# Generated by ollama (deepseek-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#define STACK_SIZE configMINIMAL_STACK_SIZE // Smallest stack size allowed by FreeRTOS (120 bytes for this configuration) 
// We need to allocate a small enough buffer that can hold the received packet data in here, so we don't have to worry about resizing when necessary.
#define MAX_BUFFER_LENGTH ((64*1024)/sizeof(char)) // The maximum length of our receive buffers (allowing for a header and tail) 
// We need enough space because the received packet data is expected not to exceed this amount in bytes, plus two extra places.
static char buffer[MAX_BUFFER_LENGTH];  
void NetworkPacketProcessingTask( void *pvParameters ) {    // Define task's entry point function 
for (;;) {                                   /* The infinite loop */    
// Get packet data from the network... code here will depend on your specific setup and requirements.     
uint16_t len;                             // Length of received buffer (in bytes)  
TickType_t xLastPacketTime = xTaskGetTickCount();  /* Time when last receiving started */    
do {                            // Receive loop until the packet is available or timeout occurs    } while ((xTaskGetTickCount() - xLastPacketTime < 100) && (len == 0));      if( len != 0 ){         vPortFree( received_packet ); /* If a valid packet has been read, free it and then break the loop. */     } 
vTaskDelayUntil(&xLastPacketTime , pdMS_TO_TICKS((1)/portTICK_RATE_MS)); // Check if data is available every x seconds (change as per requirement)    vPortFree( received_packet ); /* If a valid packet has been read, free it and then break the loop. */
} while(len == 0);  }                    TaskHandle_t networkPacketProcessingTask; // Define handle for our task                      if(pdPASS != xTaskCreate(NetworkPacketProcessingTask,"Network Pack Process",STACK_SIZE,(void *)NULL,5 , &networkPacketProcessingTask)){   printf("Failed to create Network Task\n"); }  else {printf("\rSuccessfully created network packet processing task.\n");}