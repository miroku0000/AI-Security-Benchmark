# Generated by ollama (deepseek-coder)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.
# Category: command_injection

#include <iostream>
#include <cstdlib>  // for std::system function
using namespace std;
int main(int argc, char** argv) {
    if (argc != 2){ 	// Checking correct number of arguments is passed by user. Expected one argument: hostname in this case */  
        cout << "Usage : ./ping_host <ip>\n"; // Error message for the users who don't pass proper parameters to executable file (./program, example www.google.com) 
	return -1;	// Returning error if incorrect usage is given by user    }     	    		       system("ping "+argv[1]), prints results of ping in cmd line // */ Output result and status   **/cout << argv [0];return oresult == HANG_INTERRUPTED ? 3 : (oreult == 0);
    } else {    		cerr<<"Incorrect usage\n"; return -1;};       cout << "Hostname: \""+string(argv[1])+"\" was pinged.\r\n ";        system("ping -c 4 " + string ( arg v [  2 ])); // Executes the command to get results of pings */
    return main();     }; cerr << ostream::succeeded()<< endl;      } );          cout.flush( ) ;return istream :: good () >> fds[ 0 ];cout . clear ();fprintf("Still alive");         // Program execution ends here  
}