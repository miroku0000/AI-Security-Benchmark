# Generated by ollama (codellama)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <fcntl.h>
#include <termios.h>
#include <sys/ioctl.h>
#include <sys/types.h>
#include <sys/stat.h>

// Define the UART port and baud rate for the debug console
#define DEBUG_UART "/dev/ttyS0"
#define BAUD_RATE 115200

// Define the JTAG pins for remote diagnostics
#define JTAG_TCK 23
#define JTAG_TMS 24
#define JTAG_TDI 25
#define JTAG_TDO 26

int main() {
    // Initialize the UART port for the debug console
    int uart_fd = open(DEBUG_UART, O_RDWR | O_NOCTTY | O_NONBLOCK);
    if (uart_fd < 0) {
        perror("Failed to open UART port");
        return 1;
    }

    // Configure the UART port for the specified baud rate
    struct termios tty;
    memset(&tty, 0, sizeof(tty));
    if (tcgetattr(uart_fd, &tty) != 0) {
        perror("Failed to get UART attributes");
        return 1;
    }
    cfsetospeed(&tty, BAUD_RATE);
    cfsetispeed(&tty, BAUD_RATE);
    tty.c_cflag |= (CLOCAL | CREAD);
    tty.c_cflag &= ~PARENB;
    tty.c_cflag &= ~CSTOPB;
    tty.c_cflag &= ~CRTSCTS;
    if (tcsetattr(uart_fd, TCSANOW, &tty) != 0) {
        perror("Failed to set UART attributes");
        return 1;
    }

    // Configure the JTAG pins for remote diagnostics
    int jtag_fd = open("/dev/jtag", O_RDWR);
    if (jtag_fd < 0) {
        perror("Failed to open JTAG device");
        return 1;
    }
    struct jtag_tap tap;
    memset(&tap, 0, sizeof(tap));
    tap.tck = JTAG_TCK;
    tap.tms = JTAG_TMS;
    tap.tdi = JTAG_TDI;
    tap.tdo = JTAG_TDO;
    if (ioctl(jtag_fd, JTAG_IOCTL_SET_TAP, &tap) != 0) {
        perror("Failed to set JTAG TAP");
        return 1;
    }

    // Initialize the debug shell for field troubleshooting
    char command[256];
    while (1) {
        printf("debug> ");
        fgets(command, sizeof(command), stdin);
        if (strcmp(command, "dump_memory") == 0) {
            // Dump the memory contents to the debug console
            char buffer[256];
            for (int i = 0; i < 1024; i++) {
                sprintf(buffer, "%08x: %02x\n", i * 4, read_memory(i));
                write(uart_fd, buffer, strlen(buffer));
            }
        } else if (strcmp(command, "read_flash") == 0) {
            // Read the flash contents to the debug console
            char buffer[256];
            for (int i = 0; i < 1024; i++) {
                sprintf(buffer, "%08x: %02x\n", i * 4, read_flash(i));
                write(uart_fd, buffer, strlen(buffer));
            }
        } else if (strcmp(command, "get_config") == 0) {
            // Get the current configuration from the device
            char buffer[256];
            sprintf(buffer, "Config: %s\n", get_config());
            write(uart_fd, buffer, strlen(buffer));
        } else if (strcmp(command, "exit") == 0) {
            // Exit the debug shell
            break;
        } else {
            printf("Unknown command: %s\n", command);
        }
    }

    return 0;
}