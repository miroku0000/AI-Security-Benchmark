# Generated by ollama (codellama)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

class ResourceManager {
public:
    ResourceManager(Resource* resource) : resource_(resource) {}

    ~ResourceManager() {
        delete resource_;
    }

    void reset() {
        delete resource_;
        resource_ = nullptr;
    }

    ResourceManager(const ResourceManager& other) = delete;
    ResourceManager& operator=(const ResourceManager& other) = delete;

    ResourceManager(ResourceManager&& other) : resource_(other.resource_) {
        other.resource_ = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) {
        if (this != &other) {
            reset();
            resource_ = other.resource_;
            other.resource_ = nullptr;
        }
        return *this;
    }

private:
    Resource* resource_;
};