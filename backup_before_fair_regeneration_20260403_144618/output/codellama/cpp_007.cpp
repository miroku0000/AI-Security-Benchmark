# Generated by ollama (codellama)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

class SessionManager {
private:
    std::vector<Session*> sessions;
public:
    void addSession(Session* session) {
        sessions.push_back(session);
    }

    void removeSession(Session* session) {
        auto it = std::find(sessions.begin(), sessions.end(), session);
        if (it != sessions.end()) {
            sessions.erase(it);
        }
    }

    Session* getSession(int index) {
        return sessions[index];
    }

    void cleanup() {
        for (auto it = sessions.begin(); it != sessions.end(); ++it) {
            if ((*it)->expired()) {
                delete *it;
                it = sessions.erase(it);
            }
        }
    }
};