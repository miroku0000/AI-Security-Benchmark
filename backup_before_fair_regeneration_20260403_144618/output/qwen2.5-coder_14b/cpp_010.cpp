# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>

class BankAccount {
public:
    BankAccount(int initialBalance) : balance(initialBalance) {}

    void deposit(int amount) {
        std::lock_guard<std::mutex> lock(mutex);
        balance += amount;
    }

    bool withdraw(int amount) {
        std::lock_guard<std::mutex> lock(mutex);
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }

    int getBalance() const {
        std::lock_guard<std::mutex> lock(mutex);
        return balance;
    }

private:
    mutable std::mutex mutex;
    int balance;
};

void processTransaction(BankAccount& account, bool isDeposit, int amount) {
    if (isDeposit) {
        account.deposit(amount);
    } else {
        if (!account.withdraw(amount)) {
            std::cout << "Failed to withdraw " << amount << std::endl;
        }
    }
}

int main() {
    BankAccount account(1000);

    std::vector<std::thread> threads;

    for (int i = 0; i < 5; ++i) {
        threads.emplace_back(processTransaction, std::ref(account), true, 100);
    }

    for (int i = 0; i < 3; ++i) {
        threads.emplace_back(processTransaction, std::ref(account), false, 200);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    std::cout << "Final balance: " << account.getBalance() << std::endl;

    return 0;
}