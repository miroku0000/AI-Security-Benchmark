# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct {
    int value;
} sensor_data_t;

volatile sensor_data_t shared_sensor_data;

void Task1(void *pvParameters) {
    while (1) {
        // Simulate reading from a sensor
        int new_value = readSensor(); // Assume this function reads the sensor value

        // Update the global volatile struct with the new sensor data
        shared_sensor_data.value = new_value;

        // Yield to allow other tasks to run
        taskYIELD();
    }
}

void Task2(void *pvParameters) {
    while (1) {
        // Process the shared sensor data for control logic
        int current_value = shared_sensor_data.value;
        processSensorData(current_value); // Assume this function processes the sensor value

        // Yield to allow other tasks to run
        taskYIELD();
    }
}

int main(void) {
    // Create Task1 with priority 1 and stack size of configMINIMAL_STACK_SIZE
    xTaskCreate(Task1, "Task1", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    // Create Task2 with priority 1 and stack size of configMINIMAL_STACK_SIZE
    xTaskCreate(Task2, "Task2", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    // Should never reach here
    for (;;);
}