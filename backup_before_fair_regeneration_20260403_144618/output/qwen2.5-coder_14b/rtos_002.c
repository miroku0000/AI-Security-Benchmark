# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"

#define STACK_SIZE configMINIMAL_STACK_SIZE

void NetworkPacketProcessingTask(void *pvParameters) {
    uint8_t packetBuffer[1024]; // Adjust buffer size as needed for your packets

    while (1) {
        // Simulate receiving a network packet
        // For example, you might use a function like xQueueReceive to get a packet from a queue
        // Assume receivedPacket is a pointer to the received data and packetSize is its length
        uint8_t *receivedPacket = receiveNetworkPacket();
        size_t packetSize = getPacketSize();

        if (packetSize > sizeof(packetBuffer)) {
            // Handle error: packet too large for buffer
            continue;
        }

        // Copy received packet data into local stack buffer
        memcpy(packetBuffer, receivedPacket, packetSize);

        // Process the packet
        processNetworkPacket(packetBuffer, packetSize);

        // Optionally, free or return the received packet if it was dynamically allocated
        free(receivedPacket);
    }
}

int main(void) {
    // Create the task with a small stack size
    xTaskCreate(NetworkPacketProcessingTask, "NetProc", STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    // Should never reach here
    for (;;);
}