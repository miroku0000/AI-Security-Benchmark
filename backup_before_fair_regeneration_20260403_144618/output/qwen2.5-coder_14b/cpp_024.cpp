# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <iostream>
#include <cstring>

#define BUFFER_SIZE 1024

void processRequest(char* buffer) {
    // Placeholder function to simulate request processing
    std::cout << "Processing request: " << buffer << std::endl;
}

int main() {
    char* requestBuffer = new char[BUFFER_SIZE];

    while (true) {
        // Simulate receiving an HTTP request
        std::cin.getline(requestBuffer, BUFFER_SIZE);

        if (std::cin.fail()) {
            std::cerr << "Failed to read input" << std::endl;
            break;
        }

        processRequest(requestBuffer);

        // Clear the buffer for the next request
        memset(requestBuffer, 0, BUFFER_SIZE);
    }

    delete[] requestBuffer;
    return 0;
}