# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <shared_mutex>
#include <unordered_map>
#include <vector>
#include <random>
#include <chrono>
#include <iomanip>
#include <sstream>

class Bank {
private:
    std::unordered_map<int, double> accounts;
    mutable std::shared_mutex accounts_mutex;
    std::mutex cout_mutex;

    void log(const std::string& message) {
        std::lock_guard<std::mutex> lock(cout_mutex);
        std::cout << "[Thread " << std::this_thread::get_id() << "] " << message << std::endl;
    }

public:
    void createAccount(int accountId, double initialBalance) {
        std::unique_lock<std::shared_mutex> lock(accounts_mutex);
        accounts[accountId] = initialBalance;
        std::ostringstream oss;
        oss << "Created account " << accountId << " with balance $" << std::fixed << std::setprecision(2) << initialBalance;
        lock.unlock();
        log(oss.str());
    }

    double getBalance(int accountId) const {
        std::shared_lock<std::shared_mutex> lock(accounts_mutex);
        auto it = accounts.find(accountId);
        if (it != accounts.end()) {
            return it->second;
        }
        return -1.0;
    }

    bool deposit(int accountId, double amount) {
        if (amount <= 0) {
            log("Deposit amount must be positive.");
            return false;
        }

        std::unique_lock<std::shared_mutex> lock(accounts_mutex);
        auto it = accounts.find(accountId);
        if (it == accounts.end()) {
            lock.unlock();
            log("Account " + std::to_string(accountId) + " not found for deposit.");
            return false;
        }

        it->second += amount;
        double newBalance = it->second;
        lock.unlock();

        std::ostringstream oss;
        oss << "Deposited $" << std::fixed << std::setprecision(2) << amount
            << " to account " << accountId << ". New balance: $" << newBalance;
        log(oss.str());
        return true;
    }

    bool withdraw(int accountId, double amount) {
        if (amount <= 0) {
            log("Withdrawal amount must be positive.");
            return false;
        }

        std::unique_lock<std::shared_mutex> lock(accounts_mutex);
        auto it = accounts.find(accountId);
        if (it == accounts.end()) {
            lock.unlock();
            log("Account " + std::to_string(accountId) + " not found for withdrawal.");
            return false;
        }

        if (it->second < amount) {
            double currentBalance = it->second;
            lock.unlock();
            std::ostringstream oss;
            oss << "Insufficient funds in account " << accountId
                << ". Balance: $" << std::fixed << std::setprecision(2) << currentBalance
                << ", Requested: $" << amount;
            log(oss.str());
            return false;
        }

        it->second -= amount;
        double newBalance = it->second;
        lock.unlock();

        std::ostringstream oss;
        oss << "Withdrew $" << std::fixed << std::setprecision(2) << amount
            << " from account " << accountId << ". New balance: $" << newBalance;
        log(oss.str());
        return true;
    }

    bool transfer(int fromAccountId, int toAccountId, double amount) {
        if (amount <= 0) {
            log("Transfer amount must be positive.");
            return false;
        }

        if (fromAccountId == toAccountId) {
            log("Cannot transfer to the same account.");
            return false;
        }

        // Lock ordering to prevent deadlocks
        std::unique_lock<std::shared_mutex> lock(accounts_mutex);

        auto fromIt = accounts.find(fromAccountId);
        auto toIt = accounts.find(toAccountId);

        if (fromIt == accounts.end() || toIt == accounts.end()) {
            lock.unlock();
            log("One or both accounts not found for transfer.");
            return false;
        }

        if (fromIt->second < amount) {
            double currentBalance = fromIt->second;
            lock.unlock();
            std::ostringstream oss;
            oss << "Insufficient funds for transfer from account " << fromAccountId
                << ". Balance: $" << std::fixed << std::setprecision(2) << currentBalance
                << ", Requested: $" << amount;
            log(oss.str());
            return false;
        }

        fromIt->second -= amount;
        toIt->second += amount;
        double fromBalance = fromIt->second;
        double toBalance = toIt->second;
        lock.unlock();

        std::ostringstream oss;
        oss << "Transferred $" << std::fixed << std::setprecision(2) << amount
            << " from account " << fromAccountId << " (balance: $" << fromBalance
            << ") to account " << toAccountId << " (balance: $" << toBalance << ")";
        log(oss.str());
        return true;
    }

    void printAllBalances() {
        std::shared_lock<std::shared_mutex> lock(accounts_mutex);
        std::cout << "\n========== Account Balances ==========" << std::endl;
        for (const auto& [id, balance] : accounts) {
            std::cout << "  Account " << id << ": $"
                      << std::fixed << std::setprecision(2) << balance << std::endl;
        }
        std::cout << "======================================\n" << std::endl;
    }
};

void depositorThread(Bank& bank, int accountId, int numTransactions) {
    std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()));
    std::uniform_real_distribution<double> amountDist(10.0, 500.0);

    for (int i = 0; i < numTransactions; ++i) {
        double amount = std::round(amountDist(rng) * 100.0) / 100.0;
        bank.deposit(accountId, amount);
        std::this_thread::sleep_for(std::chrono::milliseconds(50));
    }
}

void withdrawerThread(Bank& bank, int accountId, int numTransactions) {
    std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()) + 42);
    std::uniform_real_distribution<double> amountDist(5.0, 200.0);

    for (int i = 0; i < numTransactions; ++i) {
        double amount = std::round(amountDist(rng) * 100.0) / 100.0;
        bank.withdraw(accountId, amount);
        std::this_thread::sleep_for(std::chrono::milliseconds(70));
    }
}

void transferThread(Bank& bank, int numAccounts, int numTransactions) {
    std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()) + 99);
    std::uniform_int_distribution<int> accountDist(1, numAccounts);
    std::uniform_real_distribution<double> amountDist(10.0, 300.0);

    for (int i = 0; i < numTransactions; ++i) {
        int from = accountDist(rng);
        int to = accountDist(rng);
        while (to == from) {
            to = accountDist(rng);
        }
        double amount = std::round(amountDist(rng) * 100.0) / 100.0;
        bank.transfer(from, to, amount);
        std::this_thread::sleep_for(std::chrono::milliseconds(60));
    }
}

void balanceReaderThread(Bank& bank, int numAccounts, int numReads) {
    std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()) + 200);
    std::uniform_int_distribution<int> accountDist(1, numAccounts);

    for (int i = 0; i < numReads; ++i) {
        int accountId = accountDist(rng);
        double balance = bank.getBalance(accountId);
        std::this_thread::sleep_for(std::chrono::milliseconds(40));
    }
}

int main() {
    Bank bank;

    const int NUM_ACCOUNTS = 5;
    const int INITIAL_BALANCE = 10000;
    const int TRANSACTIONS_PER_THREAD = 5;

    std::cout << "=== Bank Transaction Processing System ===" << std::endl;
    std::cout << "Creating " << NUM_ACCOUNTS << " accounts with $"
              << INITIAL_BALANCE << " each...\n" << std::endl;

    for (int i = 1; i <= NUM_ACCOUNTS; ++i) {
        bank.createAccount(i, INITIAL_BALANCE);
    }

    bank.printAllBalances();

    std::cout << "Starting concurrent transactions...\n" << std::endl;

    std::vector<std::thread> threads;

    // Depositor threads - one per account
    for (int i = 1; i <= NUM_ACCOUNTS; ++i) {
        threads.emplace_back(depositorThread, std::ref(bank), i, TRANSACTIONS_PER_THREAD);
    }

    // Withdrawer threads - one per account
    for (int i = 1; i <= NUM_ACCOUNTS; ++i) {
        threads.emplace_back(withdrawerThread, std::ref(bank), i, TRANSACTIONS_PER_THREAD);
    }

    // Transfer threads
    for (int i = 0; i < 3; ++i) {
        threads.emplace_back(transferThread, std::ref(bank), NUM_ACCOUNTS, TRANSACTIONS_PER_THREAD);
    }

    // Balance reader threads
    for (int i = 0; i < 2; ++i) {
        threads.emplace_back(balanceReaderThread, std::ref(bank), NUM_ACCOUNTS, TRANSACTIONS_PER_THREAD * 2);
    }

    // Wait for all threads to complete
    for (auto& t : threads) {
        t.join();
    }

    std::cout << "\nAll transactions completed." << std::endl;
    bank.printAllBalances();

    // Calculate total money in the system
    double total = 0;
    for (int i = 1; i <= NUM_ACCOUNTS; ++i) {
        total += bank.getBalance(i);
    }

    std::cout << "Total money in system: $" << std::fixed << std::setprecision(2) << total << std::endl;
    std::cout << "Note: Total may differ from initial ($" << NUM_ACCOUNTS * INITIAL_BALANCE
              << ") due to deposits and withdrawals." << std::endl;

    return 0;
}