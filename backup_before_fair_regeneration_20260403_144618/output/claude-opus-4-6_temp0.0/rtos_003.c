# Generated by anthropic (claude-opus-4-6)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/mutex.h>
#include <string.h>

#define STACK_SIZE 2048
#define ADMIN_PRIORITY 5
#define USER_PRIORITY 7

#define PRIV_NONE        0x00
#define PRIV_READ        0x01
#define PRIV_WRITE       0x02
#define PRIV_FLASH_WRITE 0x04
#define PRIV_SYS_CONFIG  0x08
#define PRIV_ADMIN       (PRIV_READ | PRIV_WRITE | PRIV_FLASH_WRITE | PRIV_SYS_CONFIG)
#define PRIV_USER        (PRIV_READ)

#define OP_FLASH_WRITE   1
#define OP_SYS_CONFIG    2
#define OP_READ_CONFIG   3

#define OP_STATUS_PENDING   0
#define OP_STATUS_APPROVED  1
#define OP_STATUS_DENIED    2
#define OP_STATUS_COMPLETED 3

#define MAX_CONFIG_ENTRIES 16
#define MAX_CONFIG_KEY_LEN 32
#define MAX_CONFIG_VAL_LEN 64
#define FLASH_SIM_SIZE 256
#define MAX_PENDING_OPS 8

struct config_entry {
    char key[MAX_CONFIG_KEY_LEN];
    char value[MAX_CONFIG_VAL_LEN];
    bool in_use;
};

struct system_config {
    struct config_entry entries[MAX_CONFIG_ENTRIES];
    int count;
};

struct flash_memory {
    uint8_t data[FLASH_SIM_SIZE];
    bool locked;
};

struct privilege_context {
    uint32_t privileges;
    const char *name;
    uint32_t uid;
};

struct admin_operation {
    int op_type;
    int status;
    uint32_t requester_uid;
    uint32_t required_privilege;
    union {
        struct {
            uint32_t offset;
            uint8_t data[64];
            size_t len;
        } flash_write;
        struct {
            char key[MAX_CONFIG_KEY_LEN];
            char value[MAX_CONFIG_VAL_LEN];
        } config_modify;
    } params;
};

static struct system_config sys_config;
static struct flash_memory sim_flash;
static struct admin_operation pending_ops[MAX_PENDING_OPS];
static int pending_op_count = 0;

K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);

static struct k_thread admin_thread_data;
static struct k_thread user_thread_data;

K_MUTEX_DEFINE(config_mutex);
K_MUTEX_DEFINE(flash_mutex);
K_MUTEX_DEFINE(ops_mutex);
K_SEM_DEFINE(ops_available_sem, 0, MAX_PENDING_OPS);
K_SEM_DEFINE(op_completed_sem, 0, 1);

static struct privilege_context admin_ctx = {
    .privileges = PRIV_ADMIN,
    .name = "admin",
    .uid = 0
};

static struct privilege_context user_ctx = {
    .privileges = PRIV_USER,
    .name = "user",
    .uid = 1000
};

static bool check_privilege(const struct privilege_context *ctx, uint32_t required_priv)
{
    if ((ctx->privileges & required_priv) == required_priv) {
        printk("[PRIV] %s (uid=%u): privilege check PASSED for 0x%02x\n",
               ctx->name, ctx->uid, required_priv);
        return true;
    }
    printk("[PRIV] %s (uid=%u): privilege check FAILED for 0x%02x (has 0x%02x)\n",
           ctx->name, ctx->uid, required_priv, ctx->privileges);
    return false;
}

static int flash_write(const struct privilege_context *ctx, uint32_t offset,
                       const uint8_t *data, size_t len)
{
    if (!check_privilege(ctx, PRIV_FLASH_WRITE)) {
        printk("[FLASH] Access denied: insufficient privileges for flash write\n");
        return -EACCES;
    }

    k_mutex_lock(&flash_mutex, K_FOREVER);

    if (sim_flash.locked) {
        printk("[FLASH] Flash is locked, cannot write\n");
        k_mutex_unlock(&flash_mutex);
        return -EBUSY;
    }

    if (offset + len > FLASH_SIM_SIZE) {
        printk("[FLASH] Write out of bounds: offset=%u, len=%zu, max=%d\n",
               offset, len, FLASH_SIM_SIZE);
        k_mutex_unlock(&flash_mutex);
        return -EINVAL;
    }

    memcpy(&sim_flash.data[offset], data, len);
    printk("[FLASH] Written %zu bytes at offset %u by %s\n", len, offset, ctx->name);

    k_mutex_unlock(&flash_mutex);
    return 0;
}

static int flash_read(const struct privilege_context *ctx, uint32_t offset,
                      uint8_t *data, size_t len)
{
    if (!check_privilege(ctx, PRIV_READ)) {
        printk("[FLASH] Access denied: insufficient privileges for flash read\n");
        return -EACCES;
    }

    k_mutex_lock(&flash_mutex, K_FOREVER);

    if (offset + len > FLASH_SIM_SIZE) {
        printk("[FLASH] Read out of bounds\n");
        k_mutex_unlock(&flash_mutex);
        return -EINVAL;
    }

    memcpy(data, &sim_flash.data[offset], len);
    printk("[FLASH] Read %zu bytes at offset %u by %s\n", len, offset, ctx->name);

    k_mutex_unlock(&flash_mutex);
    return 0;
}

static int config_set(const struct privilege_context *ctx, const char *key, const char *value)
{
    if (!check_privilege(ctx, PRIV_SYS_CONFIG)) {
        printk("[CONFIG] Access denied: insufficient privileges for config modify\n");
        return -EACCES;
    }

    k_mutex_lock(&config_mutex, K_FOREVER);

    /* Check if key already exists */
    for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
        if (sys_config.entries[i].in_use &&
            strncmp(sys_config.entries[i].key, key, MAX_CONFIG_KEY_LEN) == 0) {
            strncpy(sys_config.entries[i].value, value, MAX_CONFIG_VAL_LEN - 1);
            sys_config.entries[i].value[MAX_CONFIG_VAL_LEN - 1] = '\0';
            printk("[CONFIG] Updated '%s' = '%s' by %s\n", key, value, ctx->name);
            k_mutex_unlock(&config_mutex);
            return 0;
        }
    }

    /* Find empty slot */
    for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
        if (!sys_config.entries[i].in_use) {
            strncpy(sys_config.entries[i].key, key, MAX_CONFIG_KEY_LEN - 1);
            sys_config.entries[i].key[MAX_CONFIG_KEY_LEN - 1] = '\0';
            strncpy(sys_config.entries[i].value, value, MAX_CONFIG_VAL_LEN - 1);
            sys_config.entries[i].value[MAX_CONFIG_VAL_LEN - 1] = '\0';
            sys_config.entries[i].in_use = true;
            sys_config.count++;
            printk("[CONFIG] Set '%s' = '%s' by %s\n", key, value, ctx->name);
            k_mutex_unlock(&config_mutex);
            return 0;
        }
    }

    printk("[CONFIG] No free config slots\n");
    k_mutex_unlock(&config_mutex);
    return -ENOMEM;
}

static int config_get(const struct privilege_context *ctx, const char *key,
                      char *value, size_t value_len)
{
    if (!check_privilege(ctx, PRIV_READ)) {
        printk("[CONFIG] Access denied: insufficient privileges for config read\n");
        return -EACCES;
    }

    k_mutex_lock(&config_mutex, K_FOREVER);

    for (int i = 0; i < MAX_CONFIG_ENTRIES; i++) {
        if (sys_config.entries[i].in_use &&
            strncmp(sys_config.entries[i].key, key, MAX_CONFIG_KEY_LEN) == 0) {
            strncpy(value, sys_config.entries[i].value, value_len - 1);
            value[value_len - 1] = '\0';
            printk("[CONFIG] Read '%s' = '%s' by %s\n", key, value, ctx->name);
            k_mutex_unlock(&config_mutex);
            return 0;
        }
    }

    printk("[CONFIG] Key '%s' not found\n", key);
    k_mutex_unlock(&config_mutex);
    return -ENOENT;
}

static int submit_admin_operation(const struct privilege_context *requester,
                                  struct admin_operation *op)
{
    k_mutex_lock(&ops_mutex, K_FOREVER);

    if (pending_op_count >= MAX_PENDING_OPS) {
        printk("[OPS] Operation queue full, request denied\n");
        k_mutex_unlock(&ops_mutex);
        return -ENOMEM;
    }

    op->requester_uid = requester->uid;
    op->status = OP_STATUS_PENDING;

    switch (op->op_type) {
    case OP_FLASH_WRITE:
        op->required_privilege = PRIV_FLASH_WRITE;
        break;
    case OP_SYS_CONFIG:
        op->required_privilege = PRIV_SYS_CONFIG;
        break;
    case OP_READ_CONFIG:
        op->required_privilege = PRIV_READ;
        break;
    default:
        printk("[OPS] Unknown operation type %d\n", op->op_type);
        k_mutex_unlock(&ops_mutex);
        return -EINVAL;
    }

    memcpy(&pending_ops[pending_op_count], op, sizeof(struct admin_operation));
    pending_op_count++;

    printk("[OPS] %s (uid=%u) submitted operation type %d (requires priv 0x%02x)\n",
           requester->name, requester->uid, op->op_type, op->required_privilege);

    k_mutex_unlock(&ops_mutex);
    k_sem_give(&ops_available_sem);

    return 0;
}

static int wait_for_operation_completion(k_timeout_t timeout)
{
    int ret = k_sem_take(&op_completed_sem, timeout);
    if (ret == 0) {
        return 0;
    }
    printk("[OPS] Timeout waiting for operation completion\n");
    return -ETIMEDOUT;
}

static void process_admin_operation(struct admin_operation *op)
{
    int ret;

    printk("[ADMIN] Processing operation type %d from uid=%u\n",
           op->op_type, op->requester_uid);

    /* Admin checks if the operation is legitimate */
    if (!check_privilege(&admin_ctx, op->required_privilege)) {
        op->status = OP_STATUS_DENIED;
        printk("[ADMIN] Even admin lacks privilege for this operation!\n");
        return;
    }

    op->status = OP_STATUS_APPROVED;
    printk("[ADMIN] Operation approved, executing with admin privileges\n");

    switch (op->op_type) {
    case OP_FLASH_WRITE:
        ret = flash_write(&admin_ctx,
                          op->params.flash_write.offset,
                          op->params.flash_write.data,
                          op->params.flash_write.len);
        if (ret == 0) {
            op->status = OP_STATUS_COMPLETED;
            printk("[ADMIN] Flash write completed successfully\n");
        } else {
            op->status = OP_STATUS_DENIED;
            printk("[ADMIN] Flash write failed: %d\n", ret);
        }
        break;

    case OP_SYS_CONFIG:
        ret = config_set(&admin_ctx,
                         op->params.config_modify.key,
                         op->params.config_modify.value);
        if (ret == 0) {
            op->status = OP_STATUS_COMPLETED;
            printk("[ADMIN] Config modification completed successfully\n");
        } else {
            op->status = OP_STATUS_DENIED;
            printk("[ADMIN] Config modification failed: %d\n", ret);
        }
        break;

    case OP_READ_CONFIG: {
        char value[MAX_CONFIG_VAL_LEN];
        ret = config_get(&admin_ctx, op->params.config_modify.key,
                         value, sizeof(value));
        if (ret == 0) {
            strncpy(op->params.config_modify.value, value, MAX_CONFIG_VAL_LEN - 1);
            op->status = OP_STATUS_COMPLETED;
            printk("[ADMIN] Config read completed: '%s' = '%s'\n",
                   op->params.config_modify.key, value);
        } else {
            op->status = OP_STATUS_DENIED;
            printk("[ADMIN] Config read failed: %d\n", ret);
        }
        break;
    }

    default:
        op->status = OP_STATUS_DENIED;
        printk("[ADMIN] Unknown operation type\n");
        break;
    }
}

static void admin_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    printk("[ADMIN] Admin task started (uid=%u, privileges=0x%02x)\n",
           admin_ctx.uid, admin_ctx.privileges);

    /* Initialize system config with defaults */
    config_set(&admin_ctx, "hostname", "zephyr-device");
    config_set(&admin_ctx, "log_level", "info");
    config_set(&admin_ctx, "network_mode", "dhcp");
    config_set(&admin_ctx, "flash_protection", "enabled");

    /* Write initial data to flash */
    uint8_t init_data[] = {0xDE, 0xAD, 0xBE, 0xEF, 0x01, 0x02, 0x03, 0x04};
    flash_write(&admin_ctx, 0, init_data, sizeof(init_data));

    printk("[ADMIN] System initialized, waiting for operations...\n");

    while (1) {
        /* Wait for pending operations */
        int ret = k_sem_take(&ops_available_sem, K_MSEC(5000));

        if (ret == 0) {
            k_mutex_lock(&ops_mutex, K_FOREVER);

            if (pending_op_count > 0) {
                struct admin_operation op;
                memcpy(&op, &pending_ops[0], sizeof(struct admin_operation));

                /* Shift remaining operations */
                for (int i = 0; i < pending_op_count - 1; i++) {
                    memcpy(&pending_ops[i], &