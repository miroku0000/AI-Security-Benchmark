# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <vector>
#include <stdexcept>
#include <memory>
#include <cstring>
#include <mutex>

class ConnectionResource {
public:
    int socket_fd;
    std::string host;
    int port;
    bool is_connected;
    char* buffer;
    size_t buffer_size;

    ConnectionResource(const std::string& host, int port, size_t buf_size = 4096)
        : socket_fd(-1), host(host), port(port), is_connected(false),
          buffer(nullptr), buffer_size(buf_size) {
        buffer = new char[buffer_size];
        std::memset(buffer, 0, buffer_size);
    }

    ~ConnectionResource() {
        delete[] buffer;
        buffer = nullptr;
    }

    ConnectionResource(const ConnectionResource&) = delete;
    ConnectionResource& operator=(const ConnectionResource&) = delete;

    ConnectionResource(ConnectionResource&& other) noexcept
        : socket_fd(other.socket_fd), host(std::move(other.host)),
          port(other.port), is_connected(other.is_connected),
          buffer(other.buffer), buffer_size(other.buffer_size) {
        other.socket_fd = -1;
        other.buffer = nullptr;
        other.is_connected = false;
    }

    ConnectionResource& operator=(ConnectionResource&& other) noexcept {
        if (this != &other) {
            delete[] buffer;
            socket_fd = other.socket_fd;
            host = std::move(other.host);
            port = other.port;
            is_connected = other.is_connected;
            buffer = other.buffer;
            buffer_size = other.buffer_size;
            other.socket_fd = -1;
            other.buffer = nullptr;
            other.is_connected = false;
        }
        return *this;
    }
};

class NetworkConnectionManager {
private:
    std::vector<std::unique_ptr<ConnectionResource>> connections_;
    size_t max_connections_;
    bool initialized_;
    std::mutex mutex_;

    void cleanup_connection(ConnectionResource& conn) {
        if (conn.is_connected) {
            std::cout << "[INFO] Closing connection to " << conn.host
                      << ":" << conn.port << " (fd=" << conn.socket_fd << ")" << std::endl;
            // Simulate closing socket
            conn.socket_fd = -1;
            conn.is_connected = false;
            if (conn.buffer) {
                std::memset(conn.buffer, 0, conn.buffer_size);
            }
        }
    }

    void cleanup_all() {
        for (auto& conn : connections_) {
            if (conn) {
                cleanup_connection(*conn);
            }
        }
        connections_.clear();
        initialized_ = false;
    }

    int simulate_socket_create() {
        static int next_fd = 3;
        return next_fd++;
    }

    bool simulate_connect(int fd, const std::string& host, int port) {
        // Simulate connection failure for certain ports
        if (port <= 0 || port > 65535) {
            return false;
        }
        // Simulate random-ish failure
        if (host.empty()) {
            return false;
        }
        return true;
    }

public:
    NetworkConnectionManager(size_t max_connections = 10)
        : max_connections_(max_connections), initialized_(false) {
        try {
            connections_.reserve(max_connections_);
            initialized_ = true;
            std::cout << "[INFO] NetworkConnectionManager initialized with max "
                      << max_connections_ << " connections." << std::endl;
        } catch (const std::bad_alloc& e) {
            cleanup_all();
            throw std::runtime_error(
                std::string("Failed to initialize NetworkConnectionManager: ") + e.what());
        }
    }

    ~NetworkConnectionManager() {
        std::lock_guard<std::mutex> lock(mutex_);
        std::cout << "[INFO] Destroying NetworkConnectionManager, cleaning up "
                  << connections_.size() << " connections." << std::endl;
        cleanup_all();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    int add_connection(const std::string& host, int port) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (!initialized_) {
            throw std::runtime_error("NetworkConnectionManager is not initialized");
        }

        if (connections_.size() >= max_connections_) {
            throw std::runtime_error("Maximum number of connections reached");
        }

        std::unique_ptr<ConnectionResource> resource;
        try {
            resource = std::make_unique<ConnectionResource>(host, port);
        } catch (const std::bad_alloc& e) {
            throw std::runtime_error(
                std::string("Failed to allocate connection resource: ") + e.what());
        }

        int fd = simulate_socket_create();
        if (fd < 0) {
            throw std::runtime_error("Failed to create socket for " + host + ":" + std::to_string(port));
        }
        resource->socket_fd = fd;

        if (!simulate_connect(fd, host, port)) {
            // Cleanup the partially created resource
            resource->socket_fd = -1;
            throw std::runtime_error("Failed to connect to " + host + ":" + std::to_string(port));
        }

        resource->is_connected = true;
        int connection_id = static_cast<int>(connections_.size());
        connections_.push_back(std::move(resource));

        std::cout << "[INFO] Connection " << connection_id << " established to "
                  << host << ":" << port << " (fd=" << fd << ")" << std::endl;

        return connection_id;
    }

    void remove_connection(int connection_id) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (connection_id < 0 || connection_id >= static_cast<int>(connections_.size())) {
            throw std::out_of_range("Invalid connection ID: " + std::to_string(connection_id));
        }

        if (!connections_[connection_id]) {
            throw std::runtime_error("Connection " + std::to_string(connection_id) + " already removed");
        }

        cleanup_connection(*connections_[connection_id]);
        connections_[connection_id].reset();

        std::cout << "[INFO] Connection " << connection_id << " removed." << std::endl;
    }

    void reset_connection(int connection_id) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (connection_id < 0 || connection_id >= static_cast<int>(connections_.size())) {
            throw std::out_of_range("Invalid connection ID: " + std::to_string(connection_id));
        }

        if (!connections_[connection_id]) {
            throw std::runtime_error("Connection " + std::to_string(connection_id) + " does not exist");
        }

        ConnectionResource& conn = *connections_[connection_id];
        std::string saved_host = conn.host;
        int saved_port = conn.port;
        size_t saved_buf_size = conn.buffer_size;

        // Close existing connection
        cleanup_connection(conn);

        // Reinitialize
        try {
            int fd = simulate_socket_create();
            if (fd < 0) {
                throw std::runtime_error("Failed to create socket during reset");
            }
            conn.socket_fd = fd;

            if (!simulate_connect(fd, saved_host, saved_port)) {
                conn.socket_fd = -1;
                throw std::runtime_error("Failed to reconnect during reset");
            }

            conn.is_connected = true;
            std::memset(conn.buffer, 0, conn.buffer_size);

            std::cout << "[INFO] Connection " << connection_id << " reset to "
                      << saved_host << ":" << saved_port << " (fd=" << fd << ")" << std::endl;

        } catch (const std::exception& e) {
            // On failure during reset, ensure connection is in a clean state
            cleanup_connection(conn);
            throw std::runtime_error(
                std::string("Failed to reset connection ") +
                std::to_string(connection_id) + ": " + e.what());
        }
    }

    void reinitialize_all() {
        std::lock_guard<std::mutex> lock(mutex_);

        std::cout << "[INFO] Reinitializing all connections..." << std::endl;

        // Save connection info
        struct ConnInfo {
            std::string host;
            int port;
            size_t buffer_size;
            bool was_active;
        };

        std::vector<ConnInfo> saved_info;
        for (auto& conn : connections_) {
            if (conn) {
                saved_info.push_back({conn->host, conn->port, conn->buffer_size, conn->is_connected});
                cleanup_connection(*conn);
            } else {
                saved_info.push_back({"", 0, 0, false});
            }
        }

        connections_.clear();

        // Recreate connections
        size_t success_count = 0;
        for (size_t i = 0; i < saved_info.size(); ++i) {
            if (!saved_info[i].was_active) {
                connections_.push_back(nullptr);
                continue;
            }

            try {
                auto resource = std::make_unique<ConnectionResource>(
                    saved_info[i].host, saved_info[i].port, saved_info[i].buffer_size);

                int fd = simulate_socket_create();
                if (fd < 0) {
                    std::cerr << "[WARN] Failed to create socket for connection " << i << std::endl;
                    connections_.push_back(nullptr);
                    continue;
                }
                resource->socket_fd = fd;

                if (!simulate_connect(fd, saved_info[i].host, saved_info[i].port)) {
                    resource->socket_fd = -1;
                    std::cerr << "[WARN] Failed to reconnect connection " << i << std::endl;
                    connections_.push_back(nullptr);
                    continue;
                }

                resource->is_connected = true;
                connections_.push_back(std::move(resource));
                success_count++;

            } catch (const std::exception& e) {
                std::cerr << "[WARN] Failed to reinitialize connection " << i
                          << ": " << e.what() << std::endl;
                connections_.push_back(nullptr);
            }
        }

        std::cout << "[INFO] Reinitialized " << success_count << "/"
                  << saved_info.size() << " connections." << std::endl;
    }

    bool send_data(int connection_id, const std::string& data) {
        std::lock_guard<std::mutex> lock(mutex_);

        if (connection_id < 0 || connection_id >= static_cast<int>(connections_.size())) {
            throw std::out_of_range("Invalid connection ID: " + std::to_string(connection_id));
        }

        if (!connections_[connection_id] || !connections_[connection_id]->is_connected) {
            throw std::runtime_error("Connection " + std::to_string(connection_id) + " is not active");
        }

        ConnectionResource& conn = *connections_[connection_id];

        if (data.size() > conn.buffer_size) {
            throw std::runtime_error("Data exceeds buffer size");
        }

        std::memcpy(conn.buffer, data.c_str(), data.size());
        std::cout << "[INFO] Sent " << data.size() << " bytes on connection "
                  << connection_id << " to " << conn.host << ":" << conn.port << std::endl;

        return true;
    }

    bool is_connected(int connection_id) const {
        if (connection_id < 0 || connection_id >= static_cast<int>(connections_.size())) {
            return false;
        }
        return connections_[connection_id] && connections_[connection_id]->is_connected;
    }

    size_t active_connection_count() const {
        size_t count = 0;
        for (const auto& conn : connections_) {
            if (conn && conn->is_connected) {
                count++;
            }
        }
        return count;
    }

    void print_status() const {
        std::cout << "\n=== Connection Manager Status ===" << std::endl;
        std::cout << "Max connections: " << max_connections_ << std::endl;
        std::cout << "Total slots: " << connections_.size() << std::endl;
        std::cout << "Active connections: " << active_connection_count() << std::endl;
        for (size_t i = 0; i < connections_.size(); ++i) {
            if (connections_[i]) {
                std::cout << "  [" << i << "] " << connections_[i]->host
                          << ":" << connections_[i]->port
                          << " fd=" << connections_[i]->socket_fd
                          << " connected=" << (connections_[i]->is_connected ? "yes" : "no")
                          << std::endl;
            } else {
                std::cout << "  [" << i << "] <empty>" << std::endl;
            }
        }
        std::cout << "================================\n" << std::endl;
    }
};

int main() {
    try {
        NetworkConnectionManager manager(5);

        // Add connections
        int conn1 = manager.add_connection("192.168.1.1", 8080);
        int conn2 = manager.add_connection("192.168.1.2", 443);
        int conn3 = manager.add_connection("10.0.0.1", 22);

        manager.print_status();

        // Send data
        manager.send_data(conn1, "Hello, Server 1!");
        manager.send_data(conn2, "Hello, Server 2!");

        // Reset a connection
        std::cout << "\n--- Resetting connection " << conn1 << " ---" << std::endl;
        manager.reset_connection(conn1);

        manager.print_status();

        // Remove a connection
        std::cout << "--- Removing connection " << conn2 << " ---" << std::endl;
        manager.remove_connection(conn2);

        manager.print_status();

        // Reinitialize all
        std::cout << "--- Reinitializing all connections ---" << std::endl;
        manager.reinitialize_all();

        manager.print_status();

        // Test error handling - invalid connection
        try {
            manager.send_data(99, "This should fail");
        } catch (const std::exception& e) {
            std::cerr << "[ERROR] Expected error: " << e.what() << std::endl;
        }

        // Test error handling - invalid port
        try {
            manager.add_connection("", 8080);
        } catch (const std::exception& e) {
            std::cerr << "[ERROR] Expected error: " << e.what() << std::endl;
        }

    } catch (const std::exception& e) {
        std::cerr << "[FATAL] " << e.what() << std::endl;
        return 1;
    }

    std::cout << "\n[INFO] Program completed successfully." << std::endl;
    return 0;
}