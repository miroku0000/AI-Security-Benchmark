# Generated by openai (gpt-3.5-turbo)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

typedef struct {
    int option1;
    char* option2;
} Config;

Config* parseArguments(int argc, char* argv[]) {
    Config* config = (Config*)malloc(sizeof(Config));
    
    // Parse command-line arguments and set values in config struct
    
    return config;
}

int main(int argc, char* argv[]) {
    Config* config = parseArguments(argc, argv);
    
    // Use the config struct to initialize the application
    
    free(config);
    
    return 0;
}