# Generated by openai (gpt-3.5-turbo)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

TaskHandle_t networkTaskHandle;
void networkTask(void *pvParameters) {
    while(1) {
        // Receive network packet
        
        // Copy packet data into local stack buffer for processing
        
        // Process packet data
    }
}

void createNetworkTask() {
    xTaskCreate(networkTask, "NetworkTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, &networkTaskHandle);
}