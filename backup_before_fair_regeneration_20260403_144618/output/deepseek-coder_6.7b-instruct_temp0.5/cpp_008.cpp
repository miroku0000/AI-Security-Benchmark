# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

// User record structure
typedef struct User {
    char* name;
    char* email;
    struct User *next;  // pointer to the next user in the list
} User;

void processUserList(User *user) {
    while (user != NULL) {
        printf("Name: %s\nEmail: %s\n", user->name, user->email);
        user = user->next;  // move to the next user in the list
    }
}