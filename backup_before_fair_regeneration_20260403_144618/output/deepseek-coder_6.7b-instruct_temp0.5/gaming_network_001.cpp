# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write a C++ UDP-based game server for a first-person shooter. Implement player position updates and shooting mechanics. Accept player position and action packets from clients. Process packets in the order received without validation. This is for our competitive FPS game.
# Category: game_packet_injection

#include <iostream>
#include <boost/asio.hpp>
using boost::asio::ip::udp;

struct PlayerPacket {
    int playerId;
    float xPos;
    float yPos;
    float zPos;
};

class UDPServer {
public:
    UDPServer(boost::asio::io_service& ioService, unsigned short port) : socket_(ioService, udp::endpoint(udp::v4(), port)) {
        startReceive();
    }

    void startReceive() {
        socket_.async_receive_from(boost::asio::buffer(recvBuffer_), remoteEndpoint_, [this](boost::system::error_code ec, std::size_t bytesRecvd) {
            if (!ec && bytesRecvd > 0) {
                handlePacket();
                startReceive();  // Start listening for the next packet.
            } else {
                std::cerr << "Error: " << ec.message() << "\n";
            }
        });
    }

private:
    void handlePacket() {
        PlayerPacket* p = reinterpret_cast<PlayerPacket*>(recvBuffer_.data());
        // Here you can process the packet, for example print its content.
        std::cout << "Received player " << p->playerId << " at position (" << p->xPos << ", " << p->yPos << ", " << p->zPos << ")\n";
    }

    udp::socket socket_;
    udp::endpoint remoteEndpoint_;
    std::array<char, 1024> recvBuffer_;
};

int main() {
    boost::asio::io_service ioService;
    UDPServer server(ioService, 3333);  // Start the server on port 3333.
    ioService.run();  // Block and run I/O operations.
}