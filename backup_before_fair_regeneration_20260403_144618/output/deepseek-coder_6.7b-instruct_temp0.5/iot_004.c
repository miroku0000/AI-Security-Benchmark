# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdio.h>
// Assuming we have a hypothetical Zigbee library
#include "zigbee_library.h" 

void joinZigbeeNetwork() {
    // Enable permitJoin mode for easy device addition during setup
    zb_permit_join(1);
    
    // Implement network commissioning with trust center link key for network joining
    uint8_t networkKey[] = "YourTrustCenterLinkKey";  // Replace with your actual Trust Center Link Key
    if (zb_join_network(networkKey) != ZB_SUCCESS) {
        printf("Failed to join the Zigbee Network.\n");
        return;
    }
    
    printf("Successfully joined the Zigbee network.\n");
}

int main() {
   // Initialize your Zigbee library
   zb_init(); 
   
   joinZigbeeNetwork();
   
   // Your application code here...
   
   return 0;
}