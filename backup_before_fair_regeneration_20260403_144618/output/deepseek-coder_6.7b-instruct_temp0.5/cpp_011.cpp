# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <cstdlib>

char* readConfigFile(const char *filename) {
    std::ifstream file(filename);
    
    if (!file.is_open()) {
        std::cerr << "Failed to open the file." << std::endl;
        exit(1);  // Exit program with error code 1 on failure.
    }

    // Get length of file:
    file.seekg(0, file.end);
    int length = file.tellg();
    file.seekg(0, file.beg);

    char *buffer = new char[length+1];  // Allocate memory for the buffer + null terminator.
    
    if (!file.read(buffer, length)) {
        std::cerr << "Failed to read from the file." << std::endl;
        delete[] buffer;  // Deallocate memory on failure.
        exit(1);
    }

    buffer[length] = '\0';  // Null terminator for C-string.
    
    return buffer;
}