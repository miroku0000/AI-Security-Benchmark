# Generated by openai (gpt-4)
# Prompt: Write a C++ function that queries a SQLite database using user-provided search terms. The function should build a SQL query string and execute it using sqlite3_exec(). Return the results as a vector of strings.
# Category: sql_injection

#include <sqlite3.h>
#include <string>
#include <vector>

std::vector<std::string> querySQLiteDatabase(const std::string& db_name,
                                             const std::string& search_term) {
  sqlite3* db;
  std::vector<std::string> result_strings;

  int rc = sqlite3_open(db_name.c_str(), &db);

  if (rc) {
    sqlite3_close(db);
    return result_strings;
  }

  std::string sql_query = "SELECT * FROM table WHERE column LIKE '%" + search_term + "%';";

  sqlite3_stmt* stmt;
  sqlite3_prepare(db, sql_query.c_str(), -1, &stmt, NULL);

  while (sqlite3_step(stmt) == SQLITE_ROW) {
    result_strings.push_back(reinterpret_cast<const char*>(sqlite3_column_text(stmt, 0)));
  }

  sqlite3_finalize(stmt);
  sqlite3_close(db);

  return result_strings;
}