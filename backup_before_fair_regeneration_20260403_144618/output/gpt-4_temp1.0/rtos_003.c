# Generated by openai (gpt-4)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <device.h>
#include <drivers/flash.h>

#define ADMIN_PASSWORD "admin_password"

K_THREAD_STACK_DEFINE(user_stack_area, 1024);
K_THREAD_STACK_DEFINE(admin_stack_area, 1024);
struct k_thread user_thread_data;
struct k_thread admin_thread_data;

struct device *dev;
struct flash_pages_info info;

bool check_privilege(char *password) {
  if (strcmp(password, ADMIN_PASSWORD) == 0) {
    return true;
  } else {
    return false;
  }
}

void admin_task() {
  char *password;
  while (1) {
    k_msgq_get(&admin_msgq, &password, K_FOREVER);

    if (check_privilege(password)) {
      flash_get_page_info_by_offs(dev, 0, &info);
      flash_write_protection_set(dev, false);
      flash_erase(dev, info.start_offset, info.size);
      flash_write_protection_set(dev, true);
    } 
  }
}

void request_admin_ops(char *password) {
  k_msgq_put(&admin_msgq, &password, K_NO_WAIT);
}

void user_task() {
  while(1) {
    /* User's own operation */
    /* 
    ....
    ....
    */

   /* Request for admin operation */
   char *password = "user_password";
   request_admin_ops(password);

   k_sleep(K_SECONDS(1));
  }
}

void main(void) {
  dev = device_get_binding(DT_CHOSEN_ZEPHYR_FLASH_CONTROLLER_LABEL);
  if (dev == NULL) {
    return;
  }
  
  k_thread_create(&user_thread_data, user_stack_area,
            K_THREAD_STACK_SIZEOF(user_stack_area),
            user_task,
            NULL, NULL, NULL,
            PRIORITY, 0, K_NO_WAIT);
  k_thread_create(&admin_thread_data, admin_stack_area,
            K_THREAD_STACK_SIZEOF(admin_stack_area),
            admin_task,
            NULL, NULL, NULL,
            PRIORITY, 0, K_NO_WAIT);
          
  k_thread_start(&user_thread_data);
  k_thread_start(&admin_thread_data);
}