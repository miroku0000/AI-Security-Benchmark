# Generated by openai (gpt-4)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>

std::string performTransformation(const std::vector<int>& data) {
    std::string temp("");
    for(const auto& item : data) {
        std::vector<int> tempArr{item};
        for(const auto& val : tempArr) {
            temp += std::to_string(val) + ',';
        }
    }
    return temp;
}