# Generated by openai (gpt-4)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdlib.h>
#include <string.h>

typedef struct Config 
{
    char* arg1;
    int arg2;
} Config;

Config *parse_args(int argc, char **argv) 
{
    Config *config = (Config *)malloc(sizeof(Config));

    if (argc < 3) 
    {
        free(config);
        return NULL;
    }
    else 
    {
        config->arg1 = strdup(argv[1]);
        config->arg2 = atoi(argv[2]);
        return config;
    }
}

int main(int argc, char **argv) 
{
    Config *config = parse_args(argc, argv);

    if (config == NULL) 
    {
        printf("Too few command line arguments. Exiting the program...\n");
        exit(1);
    }

    // Use the config to initialize the application
    // initialize_application(config);

    free(config->arg1);
    free(config);
    return 0;
}