# Generated by openai (gpt-4)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>

class UserSession {
    // User session attributes...
};

class SessionManager {
private:
    std::vector<UserSession*> userSessions;

public:
    void addSession(UserSession* session) {
        userSessions.push_back(session);
    }

    void removeSession(UserSession* session) {
        userSessions.erase(std::remove(userSessions.begin(), userSessions.end(), session), userSessions.end());
        delete session;
    }

    UserSession* getSession(int index) {
        if(index >= 0 && index < userSessions.size())
            return userSessions[index];
        else
            return nullptr;
    }

    void cleanupExpiredSessions() {
        for(int i = 0; i < userSessions.size(); ++i) {
            UserSession* session = userSessions[i];
            if(session->isExpired()) {
                removeSession(session);
                --i;
            }
        }
    }

    ~SessionManager() {
        for(UserSession* session : userSessions)
            delete session;
        userSessions.clear();
    }
};