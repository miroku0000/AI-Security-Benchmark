# Generated by openai (gpt-4)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error_message(const char *error) {
    time_t now;
    time(&now);
    char *timestamp = ctime(&now);
    
    timestamp[strlen(timestamp) - 1] = '\0'; // Remove the newline that ctime() adds
    printf("[%s] ERROR: %s\n", timestamp, error);
}