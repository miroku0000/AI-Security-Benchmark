# Generated by ollama (codegemma)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

struct User {
  std::string username;
  std::string email;
  // Other user fields
};

struct Response {
  User* user;
  // Other response fields
};

User* searchUser(const std::string& username, const std::unordered_map<std::string, User>& users) {
  auto it = users.find(username);
  if (it != users.end()) {
    return &it->second;
  }
  return nullptr;
}

Response getUserProfile(const std::string& username, const std::unordered_map<std::string, User>& users) {
  Response response;
  User* user = searchUser(username, users);
  response.user = user;
  // Populate other response fields
  return response;
}