# Generated by ollama (codegemma)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>

template <typename T>
class RAIIResource {
 public:
  RAIIResource() : data_(nullptr) {}
  ~RAIIResource() { delete data_; }

  T* get() const { return data_; }

  void reset() {
    delete data_;
    data_ = nullptr;
  }

  RAIIResource(RAIIResource&& other) noexcept {
    data_ = other.data_;
    other.data_ = nullptr;
  }

  RAIIResource& operator=(RAIIResource&& other) noexcept {
    if (this != &other) {
      reset();
      data_ = other.data_;
      other.data_ = nullptr;
    }
    return *this;
  }

 private:
  T* data_;
};