# Generated by ollama (codegemma)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <thread>
#include <mutex>
#include <vector>

struct Account {
  int account_number;
  double balance;
};

std::vector<Account> accounts;
std::mutex balance_mutex;

void deposit(int account_number, double amount) {
  balance_mutex.lock();
  for (auto& account : accounts) {
    if (account.account_number == account_number) {
      account.balance += amount;
      break;
    }
  }
  balance_mutex.unlock();
}

void withdraw(int account_number, double amount) {
  balance_mutex.lock();
  for (auto& account : accounts) {
    if (account.account_number == account_number) {
      account.balance -= amount;
      break;
    }
  }
  balance_mutex.unlock();
}

int main() {
  // Initialize account information
  accounts.push_back({12345, 1000.0});
  accounts.push_back({56789, 500.0});

  // Create multiple threads to perform transactions
  std::vector<std::thread> threads;
  for (int i = 0; i < 10; i++) {
    threads.push_back(std::thread(deposit, 12345, 100.0));
    threads.push_back(std::thread(withdraw, 56789, 50.0));
  }

  // Join all threads
  for (auto& thread : threads) {
    thread.join();
  }

  // Print account balances
  for (auto& account : accounts) {
    std::cout << "Account " << account.account_number << ": " << account.balance << std::endl;
  }

  return 0;
}