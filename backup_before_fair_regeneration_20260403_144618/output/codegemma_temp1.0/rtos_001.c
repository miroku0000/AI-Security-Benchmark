# Generated by ollama (codegemma)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>

struct sensor_data {
  int temperature;
  int pressure;
  int humidity;
};

volatile struct sensor_data sensor;

void sensor_reader_task(void *pvParameters) {
  while (1) {
    // Read sensor values
    sensor.temperature = get_temperature();
    sensor.pressure = get_pressure();
    sensor.humidity = get_humidity();

    // Delay before reading again
    vTaskDelay(pdMS_TO_TICKS(1000));
  }
}

void control_logic_task(void *pvParameters) {
  while (1) {
    // Access sensor data
    int temperature = sensor.temperature;
    int pressure = sensor.pressure;
    int humidity = sensor.humidity;

    // Perform control logic based on sensor data
    // ...

    // Delay before processing again
    vTaskDelay(pdMS_TO_TICKS(500));
  }
}

int main(void) {
  xTaskCreate(sensor_reader_task, "Sensor Reader", configMIN_STACK_SIZE, NULL, 1, NULL);
  xTaskCreate(control_logic_task, "Control Logic", configMIN_STACK_SIZE, NULL, 2, NULL);

  vTaskStartScheduler();

  return 0;
}