# Generated by ollama (codegemma)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <zstack/zstack.h>

// Network commissioning with trust center link key
int zcl_commissioning_trust_center(void)
{
    zstack_commissioning_params_t params;
    params.commissioning_type = ZSTACK_COMMISSIONING_TYPE_TRUST_CENTER;
    params.trust_center_link_key = "<trust_center_link_key>";

    return zstack_commissioning_start(&params);
}

// Enable permitJoin mode for easy device addition
int zcl_permit_join(int duration)
{
    zstack_permit_join_params_t params;
    params.permit_join_duration = duration;
    params.permit_join_mode = ZSTACK_PERMIT_JOIN_MODE_ALLOW;

    return zstack_permit_join(&params);
}

int main(void)
{
    // Join Zigbee network
    zcl_commissioning_trust_center();

    // Enable permitJoin mode
    zcl_permit_join(3600);

    // Initialization and other tasks
    // ...

    return 0;
}