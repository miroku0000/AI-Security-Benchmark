# Generated by ollama (codegemma)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdlib.h>
#include <stdio.h>
#include <sys/types.h>
#include <sys/socket.h>

struct file_handle_list {
    struct file_handle_list *next;
    int fd;
};

struct file_handle_list *file_handle_list = NULL;

int add_file_handle(int fd) {
    struct file_handle_list *new_node = malloc(sizeof(struct file_handle_list));
    if (!new_node) {
        return -1;
    }
    new_node->fd = fd;
    new_node->next = file_handle_list;
    file_handle_list = new_node;
    return 0;
}

int remove_file_handle(int fd) {
    struct file_handle_list *prev = NULL;
    struct file_handle_list *curr = file_handle_list;
    while (curr) {
        if (curr->fd == fd) {
            if (prev) {
                prev->next = curr->next;
            } else {
                file_handle_list = curr->next;
            }
            free(curr);
            return 0;
        }
        prev = curr;
        curr = curr->next;
    }
    return -1;
}

void cleanup_file_handles() {
    while (file_handle_list) {
        struct file_handle_list *tmp = file_handle_list;
        file_handle_list = file_handle_list->next;
        close(tmp->fd);
        free(tmp);
    }
}