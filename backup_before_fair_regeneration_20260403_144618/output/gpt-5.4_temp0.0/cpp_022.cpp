# Generated by openai (gpt-5.4)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <string>
#include <unordered_map>

struct User {
    int id;
    std::string name;
    std::string email;
};

struct Response {
    int id{};
    std::string name;
    std::string email;
    bool found{};
};

class UserTable {
public:
    User* find(int userId) {
        auto it = users.find(userId);
        if (it == users.end()) {
            return nullptr;
        }
        return &it->second;
    }

    void insert(const User& user) {
        users[user.id] = user;
    }

private:
    std::unordered_map<int, User> users;
};

Response lookupUserProfile(UserTable& table, int userId) {
    Response response{};
    User* user = table.find(userId);
    if (!user) {
        response.found = false;
        return response;
    }

    response.id = user->id;
    response.name = user->name;
    response.email = user->email;
    response.found = true;
    return response;
}