# Generated by openai (gpt-5.4)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <vector>
#include <memory>
#include <stdexcept>
#include <string>
#include <utility>

class ConnectionManager {
public:
    struct Connection {
        int id;
        bool active;

        explicit Connection(int connectionId) : id(connectionId), active(true) {}

        void close() noexcept {
            active = false;
        }
    };

    explicit ConnectionManager(std::size_t connectionCount)
        : nextId_(1) {
        initialize(connectionCount);
    }

    ~ConnectionManager() noexcept {
        cleanup();
    }

    ConnectionManager(const ConnectionManager&) = delete;
    ConnectionManager& operator=(const ConnectionManager&) = delete;

    ConnectionManager(ConnectionManager&& other) noexcept
        : connections_(std::move(other.connections_)),
          nextId_(other.nextId_) {
        other.nextId_ = 1;
    }

    ConnectionManager& operator=(ConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanup();
            connections_ = std::move(other.connections_);
            nextId_ = other.nextId_;
            other.nextId_ = 1;
        }
        return *this;
    }

    void resetConnections() noexcept {
        for (auto& connection : connections_) {
            if (connection) {
                connection->close();
            }
        }
        connections_.clear();
    }

    void reinitializeConnections(std::size_t connectionCount) {
        std::vector<std::unique_ptr<Connection>> newConnections;
        newConnections.reserve(connectionCount);

        try {
            for (std::size_t i = 0; i < connectionCount; ++i) {
                auto conn = std::make_unique<Connection>(nextId_++);
                if (!conn->active) {
                    throw std::runtime_error("Failed to activate connection");
                }
                newConnections.push_back(std::move(conn));
            }
        } catch (...) {
            for (auto& connection : newConnections) {
                if (connection) {
                    connection->close();
                }
            }
            throw;
        }

        cleanup();
        connections_ = std::move(newConnections);
    }

    std::size_t connectionCount() const noexcept {
        return connections_.size();
    }

    bool isConnectionActive(std::size_t index) const {
        if (index >= connections_.size()) {
            throw std::out_of_range("Connection index out of range");
        }
        return connections_[index] && connections_[index]->active;
    }

private:
    std::vector<std::unique_ptr<Connection>> connections_;
    int nextId_;

    void initialize(std::size_t connectionCount) {
        connections_.reserve(connectionCount);
        try {
            for (std::size_t i = 0; i < connectionCount; ++i) {
                auto conn = std::make_unique<Connection>(nextId_++);
                if (!conn->active) {
                    throw std::runtime_error("Failed to activate connection");
                }
                connections_.push_back(std::move(conn));
            }
        } catch (...) {
            cleanup();
            throw;
        }
    }

    void cleanup() noexcept {
        for (auto& connection : connections_) {
            if (connection) {
                connection->close();
            }
        }
        connections_.clear();
    }
};