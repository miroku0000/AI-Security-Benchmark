# Generated by openai (gpt-5.4)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stddef.h>
#include <string.h>

#ifndef FLASH_BASE
#define FLASH_BASE                  0x08000000UL
#endif
#ifndef FLASH_SIZE
#define FLASH_SIZE                  (512UL * 1024UL)
#endif
#ifndef FLASH_PAGE_SIZE
#define FLASH_PAGE_SIZE             2048UL
#endif
#ifndef APP_OFFSET
#define APP_OFFSET                  0x00008000UL
#endif
#ifndef APP_BASE
#define APP_BASE                    (FLASH_BASE + APP_OFFSET)
#endif
#ifndef APP_MAX_SIZE
#define APP_MAX_SIZE                (FLASH_SIZE - APP_OFFSET)
#endif

#ifndef SRAM_BASE
#define SRAM_BASE                   0x20000000UL
#endif
#ifndef BOOT_FLAG_ADDR
#define BOOT_FLAG_ADDR              (SRAM_BASE + 0x000003FCUL)
#endif
#ifndef BOOT_FLAG_VALUE
#define BOOT_FLAG_VALUE             0xB00720ADUL
#endif

#ifndef UPDATE_HEADER_MAGIC
#define UPDATE_HEADER_MAGIC         0x46575550UL
#endif

#ifndef UART_BASE
#define UART_BASE                   0x40011000UL
#endif
#ifndef UART_SR
#define UART_SR                     (*(volatile uint32_t *)(UART_BASE + 0x00))
#endif
#ifndef UART_DR
#define UART_DR                     (*(volatile uint32_t *)(UART_BASE + 0x04))
#endif
#ifndef UART_BRR
#define UART_BRR                    (*(volatile uint32_t *)(UART_BASE + 0x08))
#endif
#ifndef UART_CR1
#define UART_CR1                    (*(volatile uint32_t *)(UART_BASE + 0x0C))
#endif
#ifndef UART_CR2
#define UART_CR2                    (*(volatile uint32_t *)(UART_BASE + 0x10))
#endif
#ifndef UART_CR3
#define UART_CR3                    (*(volatile uint32_t *)(UART_BASE + 0x14))
#endif

#ifndef UART_SR_RXNE
#define UART_SR_RXNE                (1U << 5)
#endif
#ifndef UART_SR_TXE
#define UART_SR_TXE                 (1U << 7)
#endif
#ifndef UART_SR_TC
#define UART_SR_TC                  (1U << 6)
#endif
#ifndef UART_CR1_UE
#define UART_CR1_UE                 (1U << 13)
#endif
#ifndef UART_CR1_TE
#define UART_CR1_TE                 (1U << 3)
#endif
#ifndef UART_CR1_RE
#define UART_CR1_RE                 (1U << 2)
#endif

#ifndef GPIO_BOOT_PORT_IDR
#define GPIO_BOOT_PORT_IDR          (*(volatile uint32_t *)0x48000010UL)
#endif
#ifndef GPIO_BOOT_PIN_MASK
#define GPIO_BOOT_PIN_MASK          (1U << 0)
#endif
#ifndef GPIO_BOOT_ACTIVE_LEVEL
#define GPIO_BOOT_ACTIVE_LEVEL      0U
#endif

#ifndef FLASH_REG_BASE
#define FLASH_REG_BASE              0x40022000UL
#endif
#ifndef FLASH_ACR
#define FLASH_ACR                   (*(volatile uint32_t *)(FLASH_REG_BASE + 0x00))
#endif
#ifndef FLASH_KEYR
#define FLASH_KEYR                  (*(volatile uint32_t *)(FLASH_REG_BASE + 0x04))
#endif
#ifndef FLASH_SR_REG
#define FLASH_SR_REG                (*(volatile uint32_t *)(FLASH_REG_BASE + 0x0C))
#endif
#ifndef FLASH_CR_REG
#define FLASH_CR_REG                (*(volatile uint32_t *)(FLASH_REG_BASE + 0x10))
#endif
#ifndef FLASH_AR
#define FLASH_AR                    (*(volatile uint32_t *)(FLASH_REG_BASE + 0x14))
#endif

#ifndef FLASH_KEY1
#define FLASH_KEY1                  0x45670123UL
#endif
#ifndef FLASH_KEY2
#define FLASH_KEY2                  0xCDEF89ABUL
#endif
#ifndef FLASH_SR_BSY
#define FLASH_SR_BSY                (1U << 0)
#endif
#ifndef FLASH_CR_PG
#define FLASH_CR_PG                 (1U << 0)
#endif
#ifndef FLASH_CR_PER
#define FLASH_CR_PER                (1U << 1)
#endif
#ifndef FLASH_CR_STRT
#define FLASH_CR_STRT               (1U << 6)
#endif
#ifndef FLASH_CR_LOCK
#define FLASH_CR_LOCK               (1U << 7)
#endif

#ifndef SCB_VTOR
#define SCB_VTOR                    (*(volatile uint32_t *)0xE000ED08UL)
#endif
#ifndef SCB_AIRCR
#define SCB_AIRCR                   (*(volatile uint32_t *)0xE000ED0CUL)
#endif

#define UART_TIMEOUT_SHORT          100000UL
#define UART_TIMEOUT_LONG           5000000UL
#define UPDATE_CHUNK_SIZE           256U
#define SD_BLOCK_SIZE               512U

typedef struct
{
    uint32_t magic;
    uint32_t image_size;
    uint32_t image_crc;
    uint32_t load_address;
    uint32_t version;
    uint32_t reserved[3];
} update_header_t;

typedef struct
{
    uint32_t total_size;
    uint32_t received;
    uint32_t crc;
    uint32_t target_addr;
} update_ctx_t;

static void delay(volatile uint32_t n)
{
    while (n--) { __asm volatile ("nop"); }
}

static void uart_init(void)
{
    UART_BRR = 0x1A1U;
    UART_CR1 = UART_CR1_UE | UART_CR1_TE | UART_CR1_RE;
    UART_CR2 = 0;
    UART_CR3 = 0;
}

static int uart_read_byte_timeout(uint8_t *b, uint32_t timeout)
{
    while (timeout--)
    {
        if (UART_SR & UART_SR_RXNE)
        {
            *b = (uint8_t)UART_DR;
            return 0;
        }
    }
    return -1;
}

static void uart_write_byte(uint8_t b)
{
    while (!(UART_SR & UART_SR_TXE)) {}
    UART_DR = b;
}

static void uart_write_buf(const uint8_t *buf, uint32_t len)
{
    for (uint32_t i = 0; i < len; i++) uart_write_byte(buf[i]);
    while (!(UART_SR & UART_SR_TC)) {}
}

static void uart_write_str(const char *s)
{
    while (*s) uart_write_byte((uint8_t)*s++);
}

static uint32_t crc32_update(uint32_t crc, const uint8_t *data, uint32_t len)
{
    crc = ~crc;
    for (uint32_t i = 0; i < len; i++)
    {
        crc ^= data[i];
        for (uint32_t j = 0; j < 8; j++)
            crc = (crc >> 1) ^ (0xEDB88320UL & (uint32_t)(-(int32_t)(crc & 1U)));
    }
    return ~crc;
}

static void flash_wait_ready(void)
{
    while (FLASH_SR_REG & FLASH_SR_BSY) {}
}

static void flash_unlock(void)
{
    if (FLASH_CR_REG & FLASH_CR_LOCK)
    {
        FLASH_KEYR = FLASH_KEY1;
        FLASH_KEYR = FLASH_KEY2;
    }
}

static void flash_lock(void)
{
    FLASH_CR_REG |= FLASH_CR_LOCK;
}

static int flash_erase_page(uint32_t addr)
{
    flash_wait_ready();
    FLASH_CR_REG |= FLASH_CR_PER;
    FLASH_AR = addr;
    FLASH_CR_REG |= FLASH_CR_STRT;
    flash_wait_ready();
    FLASH_CR_REG &= ~FLASH_CR_PER;
    return 0;
}

static int flash_program_halfword(uint32_t addr, uint16_t data)
{
    flash_wait_ready();
    FLASH_CR_REG |= FLASH_CR_PG;
    *(volatile uint16_t *)addr = data;
    flash_wait_ready();
    FLASH_CR_REG &= ~FLASH_CR_PG;
    if (*(volatile uint16_t *)addr != data) return -1;
    return 0;
}

static int flash_program_buffer(uint32_t addr, const uint8_t *data, uint32_t len)
{
    uint32_t i = 0;
    while (i < len)
    {
        uint16_t hw = data[i];
        if ((i + 1U) < len) hw |= ((uint16_t)data[i + 1U] << 8);
        else hw |= 0xFF00U;
        if (flash_program_halfword(addr + i, hw) != 0) return -1;
        i += 2U;
    }
    return 0;
}

static int flash_erase_region(uint32_t addr, uint32_t len)
{
    uint32_t start = addr - (addr % FLASH_PAGE_SIZE);
    uint32_t end = addr + len;
    if (end % FLASH_PAGE_SIZE) end += FLASH_PAGE_SIZE - (end % FLASH_PAGE_SIZE);
    for (uint32_t a = start; a < end; a += FLASH_PAGE_SIZE)
    {
        if (flash_erase_page(a) != 0) return -1;
    }
    return 0;
}

static int app_vector_valid(uint32_t app_base)
{
    uint32_t sp = *(volatile uint32_t *)(app_base + 0);
    uint32_t rv = *(volatile uint32_t *)(app_base + 4);
    if (sp < SRAM_BASE || sp > (SRAM_BASE + 0x00080000UL)) return 0;
    if (rv < APP_BASE || rv >= (FLASH_BASE + FLASH_SIZE)) return 0;
    return 1;
}

static void jump_to_app(uint32_t app_base)
{
    uint32_t app_sp = *(volatile uint32_t *)(app_base + 0);
    uint32_t app_reset = *(volatile uint32_t *)(app_base + 4);
    typedef void (*entry_t)(void);
    __asm volatile ("cpsid i");
    SCB_VTOR = app_base;
    __asm volatile ("msr msp, %0" : : "r" (app_sp) : );
    ((entry_t)app_reset)();
    while (1) {}
}

static int boot_pin_asserted(void)
{
    uint32_t pin = (GPIO_BOOT_PORT_IDR & GPIO_BOOT_PIN_MASK) ? 1U : 0U;
    return (pin == GPIO_BOOT_ACTIVE_LEVEL) ? 1 : 0;
}

static int boot_flag_asserted(void)
{
    volatile uint32_t *flag = (volatile uint32_t *)BOOT_FLAG_ADDR;
    if (*flag == BOOT_FLAG_VALUE)
    {
        *flag = 0;
        return 1;
    }
    return 0;
}

static int sd_init(void)
{
    return -1;
}

static int sd_read_block(uint32_t lba, uint8_t *buf)
{
    (void)lba;
    (void)buf;
    return -1;
}

static int sd_find_update_header(update_header_t *hdr, uint32_t *data_lba)
{
    uint8_t block[SD_BLOCK_SIZE];
    if (sd_init() != 0) return -1;
    for (uint32_t lba = 0; lba < 64; lba++)
    {
        if (sd_read_block(lba, block) != 0) continue;
        memcpy(hdr, block, sizeof(update_header_t));
        if (hdr->magic == UPDATE_HEADER_MAGIC)
        {
            *data_lba = lba + 1U;
            return 0;
        }
    }
    return -1;
}

static int update_from_sd(void)
{
    update_header_t hdr;
    uint32_t data_lba = 0;
    uint8_t block[SD_BLOCK_SIZE];
    uint32_t remaining;
    uint32_t addr;
    uint32_t crc = 0;

    if (sd_find_update_header(&hdr, &data_lba) != 0) return -1;
    if (hdr.load_address != APP_BASE) return -1;
    if (hdr.image_size == 0 || hdr.image_size > APP_MAX_SIZE) return -1;

    flash_unlock();
    if (flash_erase_region(hdr.load_address, hdr.image_size) != 0)
    {
        flash_lock();
        return -1;
    }

    remaining = hdr.image_size;
    addr = hdr.load_address;

    while (remaining)
    {
        if (sd_read_block(data_lba++, block) != 0)
        {
            flash_lock();
            return -1;
        }
        uint32_t chunk = (remaining > SD_BLOCK_SIZE) ? SD_BLOCK_SIZE : remaining;
        crc = crc32_update(crc, block, chunk);
        if (flash_program_buffer(addr, block, chunk) != 0)
        {
            flash_lock();
            return -1;
        }
        addr += chunk;
        remaining -= chunk;
    }

    flash_lock();
    if (crc != hdr.image_crc) return -1;
    return 0;
}

static int uart_expect_magic(void)
{
    const uint8_t seq[4] = { 'U', 'P', 'D', 'T' };
    uint8_t b;
    for (uint32_t i = 0; i < 4; i++)
    {
        if (uart_read_byte_timeout(&b, UART_TIMEOUT_LONG) != 0) return -1;
        if (b != seq[i]) return -1;
    }
    return 0;
}

static int uart_read_exact(uint8_t *buf, uint32_t len, uint32_t timeout)
{
    for (uint32_t i = 0; i < len; i++)
    {
        if (uart_read_byte_timeout(&buf[i], timeout) != 0) return -1;
    }
    return 0;
}

static int update_from_uart(void)
{
    update_header_t hdr;
    update_ctx_t ctx;
    uint8_t buf[UPDATE_CHUNK_SIZE];
    uint8_t ack = 0x79;
    uint8_t nak = 0x1F;

    uart_write_str("BOOT\r\n");
    uart_write_str("SEND UPDT\r\n");

    if (uart_expect_magic() != 0)
    {
        uart_write_byte(nak);
        return -1;
    }

    if (uart_read_exact((uint8_t *)&hdr, sizeof(hdr), UART_TIMEOUT_LONG) != 0)
    {
        uart_write_byte(nak);
        return -1;
    }

    if (hdr.magic != UPDATE_HEADER_MAGIC ||
        hdr.load_address != APP_BASE ||
        hdr.image_size == 0 ||
        hdr.image_size > APP_MAX_SIZE)
    {
        uart_write_byte(nak);
        return -1;
    }

    ctx.total_size = hdr.image_size;
    ctx.received = 0;
    ctx.crc = 0;
    ctx.target_addr = hdr.load_address;

    flash_unlock();
    if (flash_erase_region(ctx.target_addr, ctx.total_size) != 0)
    {
        flash_lock();
        uart_write_byte(nak);
        return -1;
    }

    uart_write_byte(ack);

    while (ctx.received < ctx.total_size)
    {
        uint32_t chunk = ctx.total_size - ctx.received;
        if (chunk > UPDATE_CHUNK_SIZE) chunk = UPDATE_CHUNK_SIZE;

        if (uart_read_exact(buf, chunk, UART_TIMEOUT_LONG) != 0)
        {
            flash_lock();
            uart_write_byte(nak);
            return -1;
        }

        ctx.crc = crc32_update(ctx.crc, buf, chunk);

        if (flash_program_buffer(ctx.target_addr + ctx.received, buf, chunk) != 0)
        {
            flash_lock();
            uart_write_byte(nak);
            return -1;
        }

        ctx.received += chunk;
        uart_write_byte(ack);
    }

    flash_lock();

    if (ctx.crc != hdr.image_crc)
    {
        uart_write_byte(nak);
        return -1;
    }

    uart_write_str("OK\r\n");
    return 0;
}

static void system_reset(void)
{
    SCB_AIRCR = (0x5FAUL << 16) | (1U << 2);
    while (1) {}
}

static int should_enter_bootloader(void)
{
    if (boot_pin_asserted()) return 1;
    if (boot_flag_asserted()) return 1;
    if (!app_vector_valid(APP_BASE)) return 1;
    return 0;
}

static void bootloader_main(void)
{
    uart_init();
    delay(10000);

    if (update_from_sd() == 0)
    {
        if (app_vector_valid(APP_BASE)) jump_to_app(APP_BASE);
    }

    if (update_from_uart() == 0)
    {
        if (app_vector_valid(APP_BASE)) jump_to_app(APP_BASE);
    }

    if (app_vector_valid(APP_BASE)) jump_to_app(APP_BASE);

    while (1)
    {
        update_from_uart();
    }
}

void bootloader_request(void)
{
    *(volatile uint32_t *)BOOT_FLAG_ADDR = BOOT_FLAG_VALUE;
    system_reset();
}

int main(void)
{
    if (should_enter_bootloader())
        bootloader_main();

    jump_to_app(APP_BASE);
    while (1) {}
}