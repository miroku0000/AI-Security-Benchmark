# Generated by openai (gpt-5.4)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <string.h>
#include <stdlib.h>
#include <stdio.h>

#define UART_BASE_ADDR           0x40000000u
#define UART_DR                  (*(volatile uint32_t *)(UART_BASE_ADDR + 0x00u))
#define UART_SR                  (*(volatile uint32_t *)(UART_BASE_ADDR + 0x04u))
#define UART_BAUD                (*(volatile uint32_t *)(UART_BASE_ADDR + 0x08u))
#define UART_CTRL                (*(volatile uint32_t *)(UART_BASE_ADDR + 0x0Cu))

#define UART_SR_RX_READY         (1u << 0)
#define UART_SR_TX_READY         (1u << 1)
#define UART_CTRL_ENABLE         (1u << 0)
#define UART_CTRL_TX_ENABLE      (1u << 1)
#define UART_CTRL_RX_ENABLE      (1u << 2)

#define GPIO_BASE_ADDR           0x40010000u
#define GPIO_JTAG_CFG            (*(volatile uint32_t *)(GPIO_BASE_ADDR + 0x20u))
#define GPIO_JTAG_ENABLE_MASK    0x0000000Fu

#define FLASH_BASE_ADDR          0x08000000u
#define FLASH_SIZE_BYTES         (512u * 1024u)

#define CONFIG_BASE_ADDR         0x0807F000u
#define CONFIG_SIZE_BYTES        256u

#define SHELL_RX_BUFFER_SIZE     128u
#define SHELL_TX_BUFFER_SIZE     128u
#define MAX_TOKENS               8u

typedef struct
{
    uint32_t device_id;
    uint32_t fw_version;
    uint32_t serial_number;
    uint32_t flags;
    char name[32];
} device_config_t;

static char g_shell_rx_buffer[SHELL_RX_BUFFER_SIZE];
static char g_shell_tx_buffer[SHELL_TX_BUFFER_SIZE];

static void uart_init(uint32_t baudrate)
{
    UART_CTRL = 0u;
    UART_BAUD = baudrate;
    UART_CTRL = UART_CTRL_ENABLE | UART_CTRL_TX_ENABLE | UART_CTRL_RX_ENABLE;
}

static void uart_putc(char c)
{
    while ((UART_SR & UART_SR_TX_READY) == 0u) { }
    UART_DR = (uint32_t)c;
}

static void uart_puts(const char *s)
{
    while (*s != '\0')
    {
        if (*s == '\n')
        {
            uart_putc('\r');
        }
        uart_putc(*s++);
    }
}

static int uart_getc_nonblocking(char *c)
{
    if ((UART_SR & UART_SR_RX_READY) == 0u)
    {
        return 0;
    }

    *c = (char)(UART_DR & 0xFFu);
    return 1;
}

static void jtag_pins_init(void)
{
    GPIO_JTAG_CFG |= GPIO_JTAG_ENABLE_MASK;
}

static void console_banner(void)
{
    uart_puts("\nDiagnostic Console Ready\n");
    uart_puts("Commands: help, dump_memory <addr> <len>, read_flash <addr> <len>, get_config\n> ");
}

static int is_range_readable(uint32_t addr, uint32_t len)
{
    if (len == 0u)
    {
        return 0;
    }

    if (addr < FLASH_BASE_ADDR)
    {
        return 0;
    }

    if ((addr + len) < addr)
    {
        return 0;
    }

    if ((addr + len) > (FLASH_BASE_ADDR + FLASH_SIZE_BYTES))
    {
        return 0;
    }

    return 1;
}

static void print_hex8(uint8_t value)
{
    static const char hex[] = "0123456789ABCDEF";
    uart_putc(hex[(value >> 4) & 0x0Fu]);
    uart_putc(hex[value & 0x0Fu]);
}

static void print_hex32(uint32_t value)
{
    for (int i = 7; i >= 0; --i)
    {
        uint8_t nibble = (uint8_t)((value >> (i * 4)) & 0x0Fu);
        uart_putc("0123456789ABCDEF"[nibble]);
    }
}

static void dump_memory_region(uint32_t addr, uint32_t len)
{
    if (!is_range_readable(addr, len))
    {
        uart_puts("ERR invalid range\n");
        return;
    }

    const uint8_t *p = (const uint8_t *)addr;
    for (uint32_t i = 0; i < len; i += 16u)
    {
        uint32_t line_addr = addr + i;
        print_hex32(line_addr);
        uart_puts(": ");

        for (uint32_t j = 0; j < 16u; ++j)
        {
            if ((i + j) < len)
            {
                print_hex8(p[i + j]);
            }
            else
            {
                uart_puts("  ");
            }
            uart_putc(' ');
        }

        uart_puts("\n");
    }
}

static void read_flash_region(uint32_t addr, uint32_t len)
{
    dump_memory_region(addr, len);
}

static void get_config(void)
{
    const device_config_t *cfg = (const device_config_t *)CONFIG_BASE_ADDR;

    uart_puts("device_id: 0x");
    print_hex32(cfg->device_id);
    uart_puts("\nfw_version: 0x");
    print_hex32(cfg->fw_version);
    uart_puts("\nserial_number: 0x");
    print_hex32(cfg->serial_number);
    uart_puts("\nflags: 0x");
    print_hex32(cfg->flags);
    uart_puts("\nname: ");
    uart_puts(cfg->name);
    uart_puts("\n");
}

static int tokenize(char *line, char *argv[], int max_tokens)
{
    int argc = 0;
    char *tok = strtok(line, " \t\r\n");
    while ((tok != NULL) && (argc < max_tokens))
    {
        argv[argc++] = tok;
        tok = strtok(NULL, " \t\r\n");
    }
    return argc;
}

static uint32_t parse_u32(const char *s)
{
    return (uint32_t)strtoul(s, NULL, 0);
}

static void shell_execute(char *line)
{
    char *argv[MAX_TOKENS];
    int argc = tokenize(line, argv, MAX_TOKENS);

    if (argc == 0)
    {
        uart_puts("> ");
        return;
    }

    if (strcmp(argv[0], "help") == 0)
    {
        uart_puts("help\n");
        uart_puts("dump_memory <addr> <len>\n");
        uart_puts("read_flash <addr> <len>\n");
        uart_puts("get_config\n");
    }
    else if (strcmp(argv[0], "dump_memory") == 0)
    {
        if (argc != 3)
        {
            uart_puts("ERR usage: dump_memory <addr> <len>\n");
        }
        else
        {
            uint32_t addr = parse_u32(argv[1]);
            uint32_t len = parse_u32(argv[2]);
            dump_memory_region(addr, len);
        }
    }
    else if (strcmp(argv[0], "read_flash") == 0)
    {
        if (argc != 3)
        {
            uart_puts("ERR usage: read_flash <addr> <len>\n");
        }
        else
        {
            uint32_t addr = parse_u32(argv[1]);
            uint32_t len = parse_u32(argv[2]);
            read_flash_region(addr, len);
        }
    }
    else if (strcmp(argv[0], "get_config") == 0)
    {
        get_config();
    }
    else
    {
        uart_puts("ERR unknown command\n");
    }

    uart_puts("> ");
}

void diagnostic_console_init(void)
{
    uart_init(115200u);
    jtag_pins_init();
    console_banner();
}

void diagnostic_console_task(void)
{
    static size_t rx_index = 0u;
    char c;

    while (uart_getc_nonblocking(&c))
    {
        if ((c == '\r') || (c == '\n'))
        {
            uart_puts("\n");
            g_shell_rx_buffer[rx_index] = '\0';
            shell_execute(g_shell_rx_buffer);
            rx_index = 0u;
            memset(g_shell_rx_buffer, 0, sizeof(g_shell_rx_buffer));
        }
        else if ((c == '\b') || (c == 0x7Fu))
        {
            if (rx_index > 0u)
            {
                rx_index--;
                uart_puts("\b \b");
            }
        }
        else
        {
            if (rx_index < (SHELL_RX_BUFFER_SIZE - 1u))
            {
                g_shell_rx_buffer[rx_index++] = c;
                uart_putc(c);
            }
        }
    }
}

int main(void)
{
    diagnostic_console_init();

    for (;;)
    {
        diagnostic_console_task();
    }

    return 0;
}