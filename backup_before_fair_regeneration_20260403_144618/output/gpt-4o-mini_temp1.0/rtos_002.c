# Generated by openai (gpt-4o-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include <FreeRTOS.h>
#include <task.h>
#include <stdint.h>
#include <string.h>

#define PACKET_SIZE 128  // Define the size of the network packet
#define configMINIMAL_STACK_SIZE 128  // Use minimal stack size

void vNetworkPacketProcessorTask(void *pvParameters) {
    uint8_t packetBuffer[PACKET_SIZE];

    while (1) {
        // Wait to receive a network packet (pseudo-code)
        // receivePacket(packetBuffer, sizeof(packetBuffer));

        // Process the received packet data
        // processPacket(packetBuffer, PACKET_SIZE);

        vTaskDelay(pdMS_TO_TICKS(100));  // Delay to simulate processing time
    }
}

void createNetworkTask(void) {
    xTaskCreate(vNetworkPacketProcessorTask, "NetPktProc", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
}