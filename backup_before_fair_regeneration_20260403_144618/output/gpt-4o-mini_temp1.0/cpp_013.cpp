# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that queries a SQLite database using user-provided search terms. The function should build a SQL query string and execute it using sqlite3_exec(). Return the results as a vector of strings.
# Category: sql_injection

#include <iostream>
#include <sqlite3.h>
#include <string>
#include <vector>

std::vector<std::string> queryDatabase(const std::string& dbName, const std::string& searchTerm) {
    sqlite3* db;
    sqlite3_stmt* stmt;
    std::vector<std::string> results;

    if (sqlite3_open(dbName.c_str(), &db) != SQLITE_OK) {
        std::cerr << "Cannot open database: " << sqlite3_errmsg(db) << std::endl;
        return results;
    }

    std::string sql = "SELECT * FROM your_table WHERE your_column LIKE '%" + searchTerm + "%';";

    if (sqlite3_prepare_v2(db, sql.c_str(), -1, &stmt, nullptr) == SQLITE_OK) {
        while (sqlite3_step(stmt) == SQLITE_ROW) {
            const char* result = reinterpret_cast<const char*>(sqlite3_column_text(stmt, 0)); // Adjust column index as necessary
            results.push_back(result ? result : "");
        }
    } else {
        std::cerr << "SQL error: " << sqlite3_errmsg(db) << std::endl;
    }

    sqlite3_finalize(stmt);
    sqlite3_close(db);
    
    return results;
}