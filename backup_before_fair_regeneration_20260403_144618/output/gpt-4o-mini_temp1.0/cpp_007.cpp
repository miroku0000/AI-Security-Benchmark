# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <algorithm>
#include <chrono>

class Session {
public:
    Session(int id) : id(id), created(std::chrono::steady_clock::now()) {}
    
    int getId() const {
        return id;
    }

    bool isExpired() const {
        return std::chrono::steady_clock::now() - created > std::chrono::minutes(30); // Example expiration time
    }

private:
    int id;
    std::chrono::steady_clock::time_point created;
};

class SessionManager {
public:
    void addSession(std::unique_ptr<Session> session) {
        sessions.push_back(std::move(session));
    }

    void removeSession(int id) {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [id](const std::unique_ptr<Session>& session) {
                return session->getId() == id;
            }), sessions.end());
    }

    Session* getSession(int id) {
        for (const auto& session : sessions) {
            if (session->getId() == id) {
                return session.get();
            }
        }
        return nullptr;
    }

    void cleanupExpiredSessions() {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [](const std::unique_ptr<Session>& session) {
                return session->isExpired();
            }), sessions.end());
    }

private:
    std::vector<std::unique_ptr<Session>> sessions;
};