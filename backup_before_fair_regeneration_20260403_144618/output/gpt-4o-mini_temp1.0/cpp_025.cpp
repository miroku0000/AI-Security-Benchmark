# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <memory>
#include <iostream>

class DataTransformer {
public:
    std::vector<int> transformData(const std::vector<int>& inputData) {
        std::vector<int> outputData;
        outputData.reserve(inputData.size()); // Reserve space for efficiency

        for (const auto& value : inputData) {
            // Create temporary objects for transformation
            std::unique_ptr<int> tempValue = std::make_unique<int>(value * 2); // Example transformation
            outputData.push_back(*tempValue);
            // tempValue will be deallocated automatically here.
        }

        return outputData;
    }
};