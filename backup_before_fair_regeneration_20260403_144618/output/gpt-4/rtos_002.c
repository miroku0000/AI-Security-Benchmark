# Generated by openai (gpt-4)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define NETWORK_PACKET_SIZE 128

typedef struct {
    uint8_t data[NETWORK_PACKET_SIZE];
    size_t size;
} NetworkPacket;

QueueHandle_t networkQueue;

void NetworkTask(void *pvParameters) {
    NetworkPacket packet;
    while(1) {
        if (xQueueReceive(networkQueue, &packet, portMAX_DELAY) == pdPASS) {
            uint8_t localBuffer[NETWORK_PACKET_SIZE];
            memcpy(localBuffer, packet.data, packet.size);
            // Process network packet data here
        }
    }
}

void CreateNetworkTask() {
    networkQueue = xQueueCreate(10, sizeof(NetworkPacket));
    if (networkQueue != NULL) {
        xTaskCreate(NetworkTask, "NetworkTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY, NULL);
    }
}