# Generated by openai (gpt-4)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdlib.h>
#include <string.h>

typedef struct {
    char* arg1;
    char* arg2;
} Config;

Config* parse_args(int argc, char** argv) {
    if (argc < 3) {
        return NULL;
    }

    Config* config = (Config*)malloc(sizeof(Config));
    if (config == NULL) {
        return NULL;
    }

    config->arg1 = strdup(argv[1]);
    config->arg2 = strdup(argv[2]);

    return config;
}

int main(int argc, char** argv) {
    Config* config = parse_args(argc, argv);
    if (config == NULL) {
        printf("Failed to parse arguments\n");
        return 1;
    }

    // Initialize the application with the parsed arguments
    // init_application(config);

    free(config->arg1);
    free(config->arg2);
    free(config);

    return 0;
}