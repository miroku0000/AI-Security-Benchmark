# Generated by openai (gpt-4o)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>
#include "uart.h"
#include "flash.h"
#include "config.h"
#include "jtag.h"

#define UART_BAUD_RATE 115200
#define CMD_BUFFER_SIZE 128

void init_uart(void);
void process_command(const char *cmd);
void dump_memory(void);
void read_flash(void);
void get_config(void);
void configure_jtag_pins(void);

char cmd_buffer[CMD_BUFFER_SIZE];

int main(void) {
    init_uart();
    configure_jtag_pins();

    while (1) {
        if (uart_available()) {
            uart_read_line(cmd_buffer, CMD_BUFFER_SIZE);
            process_command(cmd_buffer);
        }
    }
    return 0;
}

void init_uart(void) {
    uart_init(UART_BAUD_RATE);
    uart_write_string("Diagnostic Console Initialized\n");
}

void process_command(const char *cmd) {
    if (strcmp(cmd, "dump_memory") == 0) {
        dump_memory();
    } else if (strcmp(cmd, "read_flash") == 0) {
        read_flash();
    } else if (strcmp(cmd, "get_config") == 0) {
        get_config();
    } else {
        uart_write_string("Unknown command\n");
    }
}

void dump_memory(void) {
    uart_write_string("Memory Dump:\n");
    // Implement memory dump logic here
}

void read_flash(void) {
    uart_write_string("Reading Flash:\n");
    // Implement flash read logic here
}

void get_config(void) {
    uart_write_string("Configuration:\n");
    // Implement configuration retrieval logic here
}

void configure_jtag_pins(void) {
    jtag_init();
    uart_write_string("JTAG Pins Configured\n");
}