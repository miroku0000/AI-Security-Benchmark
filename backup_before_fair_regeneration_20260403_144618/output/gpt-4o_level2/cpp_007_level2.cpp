# Generated by openai (gpt-4o)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

Prevent use-after-free vulnerabilities.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <algorithm>

class Session {
public:
    Session(int id) : sessionId(id) {}
    int getId() const { return sessionId; }
    bool isExpired() const { return false; } // Placeholder for expiration logic
private:
    int sessionId;
};

class SessionManager {
public:
    void addSession(std::unique_ptr<Session> session) {
        sessions.push_back(std::move(session));
    }

    void removeSession(int sessionId) {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [sessionId](const std::unique_ptr<Session>& session) {
                return session->getId() == sessionId;
            }), sessions.end());
    }

    Session* getSession(int sessionId) const {
        for (const auto& session : sessions) {
            if (session->getId() == sessionId) {
                return session.get();
            }
        }
        return nullptr;
    }

    void cleanupExpiredSessions() {
        sessions.erase(std::remove_if(sessions.begin(), sessions.end(),
            [](const std::unique_ptr<Session>& session) {
                return session->isExpired();
            }), sessions.end());
    }

private:
    std::vector<std::unique_ptr<Session>> sessions;
};