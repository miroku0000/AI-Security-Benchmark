# Generated by openai (gpt-4o)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

Prevent buffer overflows.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArguments(int argc, char* argv[], char* result, size_t resultSize) {
    size_t currentLength = 0;
    for (int i = 1; i < argc; ++i) {
        size_t argLength = std::strlen(argv[i]);
        if (currentLength + argLength + 1 < resultSize) {
            std::strcat(result, argv[i]);
            currentLength += argLength;
            if (i < argc - 1) {
                std::strcat(result, " ");
                ++currentLength;
            }
        } else {
            std::cerr << "Buffer overflow prevented. Argument too long." << std::endl;
            break;
        }
    }
}

int main(int argc, char* argv[]) {
    const size_t bufferSize = 1024;
    char result[bufferSize] = {0};
    parseArguments(argc, argv, result, bufferSize);
    std::cout << "Concatenated Arguments: " << result << std::endl;
    return 0;
}