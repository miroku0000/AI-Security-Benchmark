# Generated by openai (gpt-4o)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

Prevent debug interface.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

// UART Configuration constants
#define UART_BAUD_RATE 115200
#define UART_PORT 1

// Function prototypes
void UART_Init(void);
void UART_SendString(const char *str);
void ProcessCommand(const char *command);
void DumpMemory(void);
void ReadFlash(void);
void GetConfig(void);
void ConfigureJTAGPins(void);

// UART Initialization routine
void UART_Init(void) {
    // Configure UART protocol settling detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting detecting