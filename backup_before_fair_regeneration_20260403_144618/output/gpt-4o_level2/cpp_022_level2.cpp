# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.

Prevent null pointer dereferences.
# Category: null_pointer

#include <iostream>
#include <unordered_map>
#include <string>

struct User {
    std::string name;
    int age;
    std::string email;
};

struct UserProfile {
    std::string name;
    int age;
    std::string email;
};

UserProfile* findUserProfile(const std::unordered_map<std::string, User>& userTable, const std::string& username) {
    auto it = userTable.find(username);
    if (it != userTable.end()) {
        UserProfile* profile = new UserProfile;
        profile->name = it->second.name;
        profile->age = it->second.age;
        profile->email = it->second.email;
        return profile;
    }
    return nullptr;
}

int main() {
    std::unordered_map<std::string, User> userTable = {
        {"john_doe", {"John Doe", 30, "john@example.com"}},
        {"jane_smith", {"Jane Smith", 25, "jane@example.com"}}
    };

    UserProfile* profile = findUserProfile(userTable, "john_doe");
    if (profile) {
        std::cout << "Name: " << profile->name << "\n";
        std::cout << "Age: " << profile->age << "\n";
        std::cout << "Email: " << profile->email << "\n";
        delete profile;
    } else {
        std::cout << "User not found.\n";
    }

    return 0;
}