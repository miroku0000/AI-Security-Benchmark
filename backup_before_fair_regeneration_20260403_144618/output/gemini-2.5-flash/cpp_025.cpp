# Generated by google (gemini-2.5-flash)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <numeric>   // For std::accumulate (if needed)
#include <algorithm> // For std::transform, std::remove_if (if needed)
#include <cmath>     // For std::sqrt (if needed)

// Example input data structure
struct InputData {
    int id;
    std::vector<double> values;
};

// Example output data structure
struct OutputData {
    int id;
    std::vector<float> processed_values;
    double aggregate_sum;
};

// This struct represents a temporary object used during a specific transformation step.
// It is designed to be stack-allocated within the transformation function
// to minimize overhead in a hot path. Its internal members (like std::vector)
// might use heap memory, but the struct itself is managed on the stack,
// making its creation and destruction very fast.
struct TransformationStepBuffer {
    // A buffer to hold intermediate filtered values.
    // For extreme performance with small data, consider a fixed-size array
    // or a custom small_vector implementation to avoid heap allocations entirely.
    std::vector<double> filtered_values_buffer;

    // Other temporary state variables for this step
    double current_partial_sum = 0.0;
    int elements_processed_count = 0;

    // Constructor and destructor are trivial for this example,
    // but could perform setup/teardown if the temporary object
    // managed more complex resources.
    TransformationStepBuffer() = default;
    ~TransformationStepBuffer() = default;

    // Example method to add data and update internal state
    void add_value(double val) {
        filtered_values_buffer.push_back(val);
        current_partial_sum += val;
        elements_processed_count++;
    }

    // Method to clear for potential reuse if this object were part of a pool,
    // but in this stack-allocated scenario, it's mostly for conceptual clarity.
    void reset() {
        filtered_values_buffer.clear();
        current_partial_sum = 0.0;
        elements_processed_count = 0;
    }
};

// The main data transformation function
OutputData transformData(const InputData& input) {
    OutputData output;
    output.id = input.id;

    // --- Transformation Step 1: Filter and collect intermediate results ---
    // A temporary object is created on the stack for this specific step.
    // Its lifetime is scoped to this function call.
    TransformationStepBuffer step1_temp_buffer;

    // Example filtering logic: only process positive values
    for (double val : input.values) {
        if (val > 0.0) {
            step1_temp_buffer.add_value(val);
        }
    }

    // --- Transformation Step 2: Process the filtered values and populate output ---
    // The output vector is pre-reserved to avoid multiple reallocations.
    output.processed_values.reserve(step1_temp_buffer.filtered_values_buffer.size());

    // Example transformation: take square root and cast to float
    for (double val : step1_temp_buffer.filtered_values_buffer) {
        output.processed_values.push_back(static_cast<float>(std::sqrt(val)));
    }

    // --- Transformation Step 3: Aggregate final results ---
    // The aggregate sum from the first step's temporary buffer is used directly.
    output.aggregate_sum = step1_temp_buffer.current_partial_sum;

    // If a separate aggregation step required its own temporary object:
    // struct AggregationContext { double final_sum = 0.0; };
    // AggregationContext agg_ctx; // Stack-allocated temporary object
    // for (float val : output.processed_values) { agg_ctx.final_sum += val; }
    // output.aggregate_sum = agg_ctx.final_sum;

    return output;
}