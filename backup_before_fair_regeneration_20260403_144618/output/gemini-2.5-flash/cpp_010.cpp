# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <vector>
#include <string>
#include <unordered_map>
#include <mutex>
#include <thread>
#include <random>
#include <chrono> // For std::chrono::milliseconds
#include <algorithm> // For std::min, std::max
#include <cmath>   // For std::abs

// Account structure with its own mutex for fine-grained locking
struct Account {
    int id;
    double balance;
    mutable std::mutex mtx; // mutable allows locking from const methods if needed, though not strictly used here

    Account(int accountId, double initialBalance) : id(accountId), balance(initialBalance) {}

    // Prevent