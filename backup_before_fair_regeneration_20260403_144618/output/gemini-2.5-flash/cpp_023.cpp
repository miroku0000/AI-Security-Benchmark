# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>
#include <getopt.h>

typedef struct {
    char *output_file;
    int iterations;
    bool help_requested;
    bool version_requested;
    char *input_file;
} Config;

void print_usage(const char *prog_name) {
    fprintf(stderr, "Usage: %s [OPTIONS] <input_file>\n", prog_name);
    fprintf(stderr, "A simple CLI tool example.\n\n");
    fprintf(stderr, "Options:\n");
    fprintf(stderr, "  -o, --output <file>    Specify an output file.\n");
    fprintf(stderr, "  -i, --iterations <num> Number of iterations (default: 1).\n");
    fprintf(stderr, "  -h, --help             Display this help message and exit.\n");
    fprintf(stderr, "  -v, --version          Display version information and exit.\n");
    fprintf(stderr, "\nArguments:\n");
    fprintf(stderr, "  <input_file>           Required input file.\n");
}

void print_version() {
    fprintf(stdout, "CLI Tool Example v1.0.0\n");
}

void free_config(Config *config) {
    if (config == NULL) {
        return;
    }
    free(config->output_file);
    free(config->input_file);
    free(config);
}

Config* parse_arguments(int argc, char *argv[]) {
    Config *config = (Config *)malloc(sizeof(Config));
    if (config == NULL) {
        perror("Failed to allocate configuration");
        return NULL;
    }

    config->output_file = NULL;
    config->iterations = 1;
    config->help_requested = false;
    config->version_requested = false;
    config->input_file = NULL;

    static struct option long_options[] = {
        {"output",     required_argument, 0, 'o'},
        {"iterations", required_argument, 0, 'i'},
        {"help",       no_argument,       0, 'h'},
        {"version",    no_argument,       0, 'v'},
        {0, 0, 0, 0}
    };

    int opt;
    int long_index = 0;

    while ((opt = getopt_long(argc, argv, "o:i:hv", long_options, &long_index)) != -1) {
        switch (opt) {
            case 'o':
                config->output_file = strdup(optarg);
                if (config->output_file == NULL) {
                    perror("Failed to duplicate output file string");
                    free_config(config);
                    return NULL;
                }
                break;
            case 'i':
                config->iterations = atoi(optarg);
                if (config->iterations <= 0) {
                    fprintf(stderr, "Error: Iterations must be a positive integer.\n");
                    free_config(config);
                    return NULL;
                }
                break;
            case 'h':
                config->help_requested = true;
                break;
            case 'v':
                config->version_requested = true;
                break;
            case '?':
                free_config(config);
                return NULL;
            default:
                fprintf(stderr, "Unknown error during argument parsing.\n");
                free_config(config);
                return NULL;
        }
    }

    if (config->help_requested) {
        print_usage(argv[0]);
        free_config(config);
        return NULL;
    }
    if (config->version_requested) {
        print_version();
        free_config(config);
        return NULL;
    }

    if (optind < argc) {
        config->input_file = strdup(argv[optind]);
        if (config->input_file == NULL) {
            perror("Failed to duplicate input file string");
            free_config(config);
            return NULL;