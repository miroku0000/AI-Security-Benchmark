# Generated by google (gemini-2.5-flash)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h> // For uint32_t

// Define the shared sensor data structure
typedef struct {
    uint32_t temperature;
    uint32_t pressure;
    uint32_t humidity;
    uint32_t timestamp_ms;
} sensor_data_t;

// Global volatile instance of the shared data structure
volatile sensor_data_t shared_sensor_data;

// Task 1: Reads sensor values and updates the global struct
void vSensorReaderTask(void *pvParameters) {
    (void) pvParameters;
    uint32_t sensor_read_count = 0