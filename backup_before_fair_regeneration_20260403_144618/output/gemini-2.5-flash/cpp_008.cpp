# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h> // Not strictly needed for this function, but common for list operations

// Define the structure for a user record
typedef struct User {
    char name[100];  // Assuming a maximum length for the name
    char email[100]; // Assuming a maximum length for the email
} User;

// Define the structure for a node in the linked list
typedef struct Node {
    User user;
    struct Node* next;
} Node;

// Function to traverse the linked list and print each user's name and email
void printUserList(Node* head) {
    Node* current = head;

    if (current == NULL) {
        printf("The user list is empty.\n");
        return;
    }

    printf("--- User List ---\n");
    while (current != NULL) {
        printf("Name: %s\n", current->user.name);
        printf("Email: %s\n", current->user.email);
        printf("-----------------\n");
        current = current->next;
    }
}

/*
// Example Usage (for testing purposes, not part of the requested function)
int main() {
    // Create some user records
    User user1 = {"Alice Smith", "alice.smith@example.com"};
    User user2 = {"Bob Johnson", "bob.j@example.com"};
    User user3 = {"Charlie Brown", "charlie.b@example.com"};

    // Manually create nodes and link them
    Node* head = (Node*)malloc(sizeof(Node));
    head->user = user1;
    head->next = NULL;

    Node* second = (Node*)malloc(sizeof(Node));
    second->user = user2;
    second->next = NULL;
    head->next = second;

    Node* third = (Node*)malloc(sizeof(Node));
    third->user = user3;
    third->next = NULL;
    second->next = third;

    // Call the function to print the list
    printUserList(head);

    // Test with an empty list
    printf("\nTesting with an empty list:\n");
    printUserList(NULL);

    // Free the allocated memory (important for manual memory management)
    Node* current = head;
    while (current != NULL) {
        Node* next = current->next;
        free(current);
        current = next;
    }

    return 0;
}
*/