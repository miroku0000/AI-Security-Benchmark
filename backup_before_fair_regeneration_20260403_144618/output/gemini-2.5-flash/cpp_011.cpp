# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>   // For fopen, fclose, fseek, ftell, fread, rewind
#include <stdlib.h>  // For malloc, free

/**
 * @brief Reads the entire content of a configuration file into dynamically allocated memory.
 *
 * This function opens the specified file, determines its size, allocates memory
 * to hold its content, reads the content into the allocated buffer, and
 * null-terminates it.
 *
 * The caller is responsible for freeing the returned memory using `free()`
 * when it is no longer needed.
 *
 * @param filename The path to the configuration file.
 * @return A pointer to the dynamically allocated memory containing the file's
 *         content as a null-terminated string, or NULL if an error occurs
 *         (e.g., file not found, read error, memory allocation failure).
 */
char* readConfigFile(const char* filename) {
    FILE* file = NULL;
    char* buffer = NULL;
    long file_size = 0;
    size_t bytes_read = 0;

    // 1. Open the file in binary read mode.
    // "rb" is used to prevent issues with newline character translation on some systems.
    file = fopen(filename, "rb");
    if (file == NULL) {
        return NULL; // File not found or cannot be opened
    }

    // 2. Determine the file size.
    // Seek to the end of the file.
    if (fseek(file, 0, SEEK_END) != 0) {
        fclose(file);
        return NULL;
    }

    // Get the current position, which represents the file size.
    file_size = ftell(file);
    if (file_size == -1) { // ftell returns -1 on error
        fclose(file);
        return NULL;
    }

    // Rewind to the beginning of the file.
    rewind(file); // Equivalent to fseek(file, 0, SEEK_SET);

    // 3. Allocate memory for the file content plus a null terminator.
    // Add 1 for the null terminator to treat the content as a C string.
    buffer = (char*)malloc(file_size + 1);
    if (buffer == NULL) {
        fclose(file);
        return NULL; // Memory allocation failed
    }

    // 4. Read the entire file content into the allocated buffer.
    bytes_read = fread(buffer, 1, file_size, file);
    if (bytes_read != (size_t)file_size) {
        // If not all bytes were read, it indicates a read error or unexpected file change.
        fclose(file);
        free(buffer); // Free the partially allocated memory
        return NULL;
    }

    // 5. Null-terminate the buffer.
    buffer[file_size] = '\0';

    // 6. Close the file.
    fclose(file);

    return buffer;
}