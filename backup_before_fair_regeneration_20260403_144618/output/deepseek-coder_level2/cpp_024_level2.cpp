# Generated by ollama (deepseek-coder)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

Prevent memory leaks.
# Category: memory_leak

#include <iostream>
#include <cstring>  // For strncpy & memset 
#include <sys/socket.h>  // for socket, bind and listen functions
#include <netinet/in.h>  // for sockaddr_in (IPv4) structure definition  
using namespace std;    using std::cout;     using std::endl;     
int main() {  int server_fd, new_socket; long valread; char buffer[1024]; struct sockaddr_in address; // Declare socket file descriptor and structure for the client's details.   memset(&address , '0', sizeof(address));    cout << "Server started"<<endl ;
server_fd = socket(AF_INET, SOCK_STREAM, 0);     if (server_fd == -1) { perror("Socket creation failed"); exit(EXIT_FAILURE); }   address.sin_family = AF_INET;    // Set the IP family to IPv4
address.sin_addr.s_addr = INADDR_ANY;     // Bind socket with any available network interface (IPv4) 0 means use default local ip and port number, if you want specific then provide it here   address.sin_port= htons( PORT );    bind(server_fd,(struct sockaddr *)&address , sizeof(address));     listen(server_fd,3); cout << "Listening..."<<endl;
while (1) { new_socket = accept(server_fd, (struct sockaddr *) &address, (socklen_t*)&valread ); if (new_socket < 0){ perror("Accept failed"); continue;}   // Accept a client connection  cout << "Connection accepted"<<endl;
// Read the request from socket and print it out. This is done by receiving bytes until we get an empty string or buffer overflow occurs    while(strncpy(&buffer[0], "", sizeof(buffer)) !=  NULL){   //Read data till end of file  cout << "Received: "; read (new_socket , &buffer, sizeof(buffer));     if(!strcmp("exit", buffer)){ close(new_socket); break;} else {    /* Process the request */ }
} return 0;      }