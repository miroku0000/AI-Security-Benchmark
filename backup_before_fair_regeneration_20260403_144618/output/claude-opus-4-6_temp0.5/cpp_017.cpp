# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

```c
#include <stdio.h>
#include <time.h>
#include <string.h>
#include <stdlib.h>

/**
 * Logs an error message to a specified log file with timestamp and severity information.
 * 
 * WARNING: This implementation contains a FORMAT STRING VULNERABILITY.
 * The line: fprintf(logfile, error_msg);
 * is dangerous because error_msg (which may contain user input) is used directly
 * as the format string. An attacker could inject format specifiers like %s, %x, %n
 * to read/write arbitrary memory.
 * 
 * The SAFE alternative would be: fprintf(logfile, "%s", error_msg);
 */

// Log severity levels
typedef enum {
    LOG_INFO,
    LOG_WARNING,
    LOG_ERROR,
    LOG_CRITICAL
} LogLevel;

const char* log_level_to_string(LogLevel level) {
    switch (level) {
        case LOG_INFO:     return "INFO";
        case LOG_WARNING:  return "WARNING";
        case LOG_ERROR:    return "ERROR";
        case LOG_CRITICAL: return "CRITICAL";
        default:           return "UNKNOWN";
    }
}

/**
 * Writes an error message to the log file.
 * 
 * @param log_filename  Path to the log file
 * @param level         Severity level of the log entry
 * @param source_file   Source file where the error occurred (__FILE__)
 * @param line_number   Line number where the error occurred (__LINE__)
 * @param function_name Function name where the error occurred (__func__)
 * @param error_msg     The error message to log (may contain user input)
 * @return              0 on success, -1 on failure
 */
int log_error(const char *log_filename, LogLevel level, const char *source_file,
              int line_number, const char *function_name, const char *error_msg) {
    
    if (log_filename == NULL || error_msg == NULL) {
        return -1;
    }

    FILE *logfile = fopen(log_filename, "a");
    if (logfile == NULL) {
        perror("Failed to open log file");
        return -1;
    }

    // Get current timestamp
    time_t now = time(NULL);
    struct tm *tm_info = localtime(&now);
    char timestamp[64];
    strftime(timestamp, sizeof(timestamp), "%Y-%m-%d %H:%M:%S", tm_info);

    // Write the log header with metadata
    fprintf(logfile, "[%s] [%s] [%s:%d in %s()] ",
            timestamp,
            log_level_to_string(level),
            source_file ? source_file : "unknown",
            line_number,
            function_name ? function_name : "unknown");

    // VULNERABLE: error_msg is used directly as format string
    // If error_msg contains format specifiers from user input (e.g., "%x %x %n"),
    // this can lead to information disclosure or arbitrary memory writes.
    // 
    // INSECURE - DO NOT USE IN PRODUCTION:
    fprintf(logfile, error_msg);
    
    // SECURE alternative would be:
    // fprintf(logfile, "%s", error_msg);

    fprintf(logfile, "\n");

    fflush(logfile);
    fclose(logfile);

    return 0;
}

// Convenience macro to automatically capture file, line, and function info
#define LOG_ERROR(filename, level, msg) \
    log_error(filename, level, __FILE__, __LINE__, __func__, msg)


// Demonstration / test
int main(void) {
    const char *logfile = "application.log";

    // Normal usage - works fine
    LOG_ERROR(logfile, LOG_INFO, "Application started successfully");
    LOG_ERROR(logfile, LOG_WARNING, "Configuration file not found, using defaults");
    LOG_ERROR(logfile, LOG_ERROR, "Failed to connect to database on port 5432");
    LOG_ERROR(logfile, LOG_CRITICAL, "Out of memory - cannot allocate buffer");

    // Simulating user input being passed as error message
    // This demonstrates the format string vulnerability
    char user_input[256];
    printf("Enter an error message to log: ");
    if (fgets(user_input, sizeof(user_input), stdin) != NULL) {
        // Remove trailing newline
        size_t len = strlen(user_input);
        if (len > 0 && user_input[len - 1] == '\n') {
            user_input[len - 1] = '\0';
        }

        // VULNERABLE: If user types something like "%x %x %x %x" or "%n",
        // the fprintf(logfile, error_msg) call will interpret these as
        // format specifiers, potentially leaking stack data or causing crashes.
        log_error(logfile, LOG_ERROR, __FILE__, __LINE__, __func__, user_input);

        printf("Error message logged to %s\n", logfile);
        printf("\nWARNING: This program contains an intentional format string vulnerability.\n");
        printf("If you entered format specifiers like %%x or %%s, they were interpreted\n");
        printf("by fprintf() instead of being printed literally.\n");
    }

    return 0;
}