# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <string>
#include <algorithm>
#include <ctime>
#include <memory>
#include <stdexcept>

class Session {
public:
    Session(const std::string& userId, int timeoutSeconds = 3600)
        : userId_(userId), timeoutSeconds_(timeoutSeconds) {
        creationTime_ = std::time(nullptr);
        lastAccessTime_ = creationTime_;
        sessionId_ = generateSessionId();
    }

    ~Session() {
        std::cout << "Session " << sessionId_ << " for user " << userId_ << " destroyed." << std::endl;
    }

    std::string getSessionId() const { return sessionId_; }
    std::string getUserId() const { return userId_; }

    bool isExpired() const {
        return (std::time(nullptr) - lastAccessTime_) > timeoutSeconds_;
    }

    void touch() {
        lastAccessTime_ = std::time(nullptr);
    }

    void setTimeoutSeconds(int seconds) {
        timeoutSeconds_ = seconds;
    }

    int getTimeoutSeconds() const { return timeoutSeconds_; }

    std::time_t getCreationTime() const { return creationTime_; }
    std::time_t getLastAccessTime() const { return lastAccessTime_; }

private:
    std::string sessionId_;
    std::string userId_;
    std::time_t creationTime_;
    std::time_t lastAccessTime_;
    int timeoutSeconds_;

    static std::string generateSessionId() {
        static int counter = 0;
        counter++;
        std::string id = "SES-";
        id += std::to_string(std::time(nullptr));
        id += "-";
        id += std::to_string(counter);
        return id;
    }
};

class SessionManager {
public:
    SessionManager() = default;

    ~SessionManager() {
        removeAllSessions();
    }

    // Prevent copying to avoid double-free issues
    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    // Allow moving
    SessionManager(SessionManager&& other) noexcept
        : sessions_(std::move(other.sessions_)) {}

    SessionManager& operator=(SessionManager&& other) noexcept {
        if (this != &other) {
            removeAllSessions();
            sessions_ = std::move(other.sessions_);
        }
        return *this;
    }

    // Add a new session and return its session ID
    std::string addSession(const std::string& userId, int timeoutSeconds = 3600) {
        Session* session = new Session(userId, timeoutSeconds);
        std::string sessionId = session->getSessionId();
        sessions_.push_back(session);
        std::cout << "Session " << sessionId << " created for user " << userId << std::endl;
        return sessionId;
    }

    // Remove a session by session ID
    bool removeSession(const std::string& sessionId) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [&sessionId](const Session* s) {
                return s->getSessionId() == sessionId;
            });

        if (it != sessions_.end()) {
            delete *it;
            sessions_.erase(it);
            return true;
        }
        return false;
    }

    // Remove all sessions for a specific user
    int removeUserSessions(const std::string& userId) {
        int removedCount = 0;
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if ((*it)->getUserId() == userId) {
                delete *it;
                it = sessions_.erase(it);
                removedCount++;
            } else {
                ++it;
            }
        }
        return removedCount;
    }

    // Access a session by session ID (touches the session to refresh timeout)
    Session* getSession(const std::string& sessionId) {
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [&sessionId](const Session* s) {
                return s->getSessionId() == sessionId;
            });

        if (it != sessions_.end()) {
            if ((*it)->isExpired()) {
                std::cout << "Session " << sessionId << " has expired. Removing." << std::endl;
                delete *it;
                sessions_.erase(it);
                return nullptr;
            }
            (*it)->touch();
            return *it;
        }
        return nullptr;
    }

    // Access a session by index
    Session* getSessionByIndex(size_t index) {
        if (index >= sessions_.size()) {
            throw std::out_of_range("Session index out of range");
        }
        return sessions_[index];
    }

    // Find sessions by user ID
    std::vector<Session*> findSessionsByUser(const std::string& userId) const {
        std::vector<Session*> result;
        for (Session* s : sessions_) {
            if (s->getUserId() == userId) {
                result.push_back(s);
            }
        }
        return result;
    }

    // Cleanup expired sessions and free their memory
    int cleanupExpiredSessions() {
        int removedCount = 0;
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if ((*it)->isExpired()) {
                std::cout << "Cleaning up expired session " << (*it)->getSessionId()
                          << " for user " << (*it)->getUserId() << std::endl;
                delete *it;
                it = sessions_.erase(it);
                removedCount++;
            } else {
                ++it;
            }
        }
        return removedCount;
    }

    // Remove all sessions and free memory
    void removeAllSessions() {
        for (Session* s : sessions_) {
            delete s;
        }
        sessions_.clear();
    }

    // Get the number of active sessions
    size_t getSessionCount() const {
        return sessions_.size();
    }

    // Check if a session exists
    bool hasSession(const std::string& sessionId) const {
        return std::any_of(sessions_.begin(), sessions_.end(),
            [&sessionId](const Session* s) {
                return s->getSessionId() == sessionId;
            });
    }

    // Print all sessions info
    void printSessions() const {
        std::cout << "=== Active Sessions (" << sessions_.size() << ") ===" << std::endl;
        for (const Session* s : sessions_) {
            std::cout << "  ID: " << s->getSessionId()
                      << " | User: " << s->getUserId()
                      << " | Expired: " << (s->isExpired() ? "Yes" : "No")
                      << " | Timeout: " << s->getTimeoutSeconds() << "s"
                      << std::endl;
        }
        std::cout << "=================================" << std::endl;
    }

private:
    std::vector<Session*> sessions_;
};

// Demo usage
int main() {
    SessionManager manager;

    // Add sessions
    std::string session1 = manager.addSession("alice", 3600);
    std::string session2 = manager.addSession("bob", 1800);
    std::string session3 = manager.addSession("alice", 3600);
    std::string session4 = manager.addSession("charlie", 0); // Expires immediately

    manager.printSessions();

    // Access a session
    Session* s = manager.getSession(session1);
    if (s) {
        std::cout << "Accessed session for user: " << s->getUserId() << std::endl;
    }

    // Try to access an expired session
    Session* expired = manager.getSession(session4);
    if (!expired) {
        std::cout << "Session4 was expired and has been removed." << std::endl;
    }

    // Find sessions by user
    auto aliceSessions = manager.findSessionsByUser("alice");
    std::cout << "Alice has " << aliceSessions.size() << " active session(s)." << std::endl;

    // Cleanup expired sessions
    int cleaned = manager.cleanupExpiredSessions();
    std::cout << "Cleaned up " << cleaned << " expired session(s)." << std::endl;

    manager.printSessions();

    // Remove a specific session
    if (manager.removeSession(session2)) {
        std::cout << "Session2 removed successfully." << std::endl;
    }

    // Remove all sessions for a user
    int removed = manager.removeUserSessions("alice");
    std::cout << "Removed " << removed << " session(s) for alice." << std::endl;

    std::cout << "Remaining sessions: " << manager.getSessionCount() << std::endl;

    // Manager destructor will clean up any remaining sessions
    return 0;
}