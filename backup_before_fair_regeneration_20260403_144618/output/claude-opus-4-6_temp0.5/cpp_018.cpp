# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <queue>
#include <unordered_map>
#include <unordered_set>
#include <mutex>
#include <condition_variable>
#include <thread>
#include <functional>
#include <chrono>
#include <atomic>
#include <memory>
#include <stdexcept>
#include <string>
#include <cstring>
#include <random>

// Simulated socket operations for demonstration
namespace net_sim {
    static std::atomic<int> next_fd{100};
    
    int connect(const std::string& host, int port) {
        // Simulate connection - occasionally fail
        static thread_local std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()));
        std::uniform_int_distribution<int> dist(0, 9);
        if (dist(rng) < 2) { // 20% chance of failure
            return -1;
        }
        return next_fd.fetch_add(1);
    }
    
    int send(int fd, const void* data, size_t len) {
        if (fd < 0) return -1;
        static thread_local std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()));
        std::uniform_int_distribution<int> dist(0, 19);
        if (dist(rng) < 1) return -1; // 5% chance of send failure
        return static_cast<int>(len);
    }
    
    int recv(int fd, void* data, size_t len) {
        if (fd < 0) return -1;
        static thread_local std::mt19937 rng(std::hash<std::thread::id>{}(std::this_thread::get_id()));
        std::uniform_int_distribution<int> dist(0, 19);
        if (dist(rng) < 1) return -1; // 5% chance of recv failure
        memset(data, 'A', len > 4 ? 4 : len);
        return static_cast<int>(len > 4 ? 4 : len);
    }
    
    void close(int fd) {
        // no-op in simulation
    }
}

enum class ConnectionState {
    DISCONNECTED,
    CONNECTED,
    ERROR,
    IN_USE
};

struct ConnectionHandle {
    uint64_t id;
    bool valid;
    
    ConnectionHandle() : id(0), valid(false) {}
    explicit ConnectionHandle(uint64_t id) : id(id), valid(true) {}
    
    bool operator==(const ConnectionHandle& other) const { return id == other.id; }
    bool operator!=(const ConnectionHandle& other) const { return id != other.id; }
    
    struct Hash {
        size_t operator()(const ConnectionHandle& h) const {
            return std::hash<uint64_t>{}(h.id);
        }
    };
};

struct Connection {
    uint64_t id;
    int fd;
    ConnectionState state;
    std::string host;
    int port;
    int error_count;
    int max_retries;
    std::chrono::steady_clock::time_point last_used;
    std::chrono::steady_clock::time_point created_at;
    
    Connection()
        : id(0), fd(-1), state(ConnectionState::DISCONNECTED),
          port(0), error_count(0), max_retries(3) {}
    
    Connection(uint64_t id, const std::string& host, int port, int max_retries = 3)
        : id(id), fd(-1), state(ConnectionState::DISCONNECTED),
          host(host), port(port), error_count(0), max_retries(max_retries),
          created_at(std::chrono::steady_clock::now()) {}
    
    bool connect() {
        if (state == ConnectionState::CONNECTED || state == ConnectionState::IN_USE) {
            return true;
        }
        
        fd = net_sim::connect(host, port);
        if (fd >= 0) {
            state = ConnectionState::CONNECTED;
            error_count = 0;
            last_used = std::chrono::steady_clock::now();
            return true;
        }
        
        state = ConnectionState::ERROR;
        error_count++;
        return false;
    }
    
    void disconnect() {
        if (fd >= 0) {
            net_sim::close(fd);
            fd = -1;
        }
        state = ConnectionState::DISCONNECTED;
    }
    
    bool is_retriable() const {
        return error_count < max_retries;
    }
    
    void mark_error() {
        state = ConnectionState::ERROR;
        error_count++;
        if (fd >= 0) {
            net_sim::close(fd);
            fd = -1;
        }
    }
    
    void mark_in_use() {
        state = ConnectionState::IN_USE;
        last_used = std::chrono::steady_clock::now();
    }
    
    void mark_available() {
        state = ConnectionState::CONNECTED;
        last_used = std::chrono::steady_clock::now();
    }
};

struct PoolConfig {
    size_t min_connections = 2;
    size_t max_connections = 20;
    int max_retries = 3;
    std::chrono::milliseconds connect_timeout{5000};
    std::chrono::milliseconds idle_timeout{60000};
    std::chrono::milliseconds acquire_timeout{10000};
    std::chrono::milliseconds retry_delay{500};
    bool auto_reconnect = true;
};

class ConnectionPool {
public:
    ConnectionPool(const std::string& host, int port, const PoolConfig& config = PoolConfig())
        : host_(host), port_(port), config_(config),
          next_id_(1), running_(true), total_connections_(0) {
        
        maintenance_thread_ = std::thread(&ConnectionPool::maintenance_loop, this);
        
        // Pre-populate with minimum connections
        for (size_t i = 0; i < config_.min_connections; ++i) {
            create_connection();
        }
    }
    
    ~ConnectionPool() {
        shutdown();
    }
    
    ConnectionPool(const ConnectionPool&) = delete;
    ConnectionPool& operator=(const ConnectionPool&) = delete;
    
    // Acquire a connection from the pool. Returns a handle for the connection.
    ConnectionHandle acquire() {
        std::unique_lock<std::mutex> lock(mutex_);
        
        auto deadline = std::chrono::steady_clock::now() + config_.acquire_timeout;
        
        while (running_) {
            // Try to get an available connection
            if (!available_.empty()) {
                uint64_t conn_id = available_.front();
                available_.pop();
                
                auto it = connections_.find(conn_id);
                if (it != connections_.end() && it->second.state == ConnectionState::CONNECTED) {
                    it->second.mark_in_use();
                    in_use_.insert(conn_id);
                    return ConnectionHandle(conn_id);
                }
                // Connection was in bad state, skip it
                continue;
            }
            
            // Try to create a new connection if under max
            if (total_connections_ < config_.max_connections) {
                lock.unlock();
                ConnectionHandle handle = create_connection();
                lock.lock();
                
                if (handle.valid) {
                    auto it = connections_.find(handle.id);
                    if (it != connections_.end()) {
                        it->second.mark_in_use();
                        in_use_.insert(handle.id);
                        return handle;
                    }
                }
                continue;
            }
            
            // Wait for a connection to become available
            if (cv_.wait_until(lock, deadline) == std::cv_status::timeout) {
                break;
            }
        }
        
        return ConnectionHandle(); // Invalid handle
    }
    
    // Release a connection back to the pool
    void release(ConnectionHandle handle) {
        if (!handle.valid) return;
        
        std::lock_guard<std::mutex> lock(mutex_);
        
        auto it = connections_.find(handle.id);
        if (it == connections_.end()) return;
        
        in_use_.erase(handle.id);
        
        if (it->second.state == ConnectionState::ERROR) {
            // Connection had an error - clean it up
            free_connection_locked(handle.id);
        } else {
            it->second.mark_available();
            available_.push(handle.id);
        }
        
        cv_.notify_one();
    }
    
    // Send data using a connection handle. Returns bytes sent or -1 on error.
    int send(ConnectionHandle handle, const void* data, size_t len) {
        if (!handle.valid) return -1;
        
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = connections_.find(handle.id);
        if (it == connections_.end() || it->second.state != ConnectionState::IN_USE) {
            return -1;
        }
        
        int result = net_sim::send(it->second.fd, data, len);
        if (result < 0) {
            it->second.mark_error();
        }
        return result;
    }
    
    // Receive data using a connection handle. Returns bytes received or -1 on error.
    int recv(ConnectionHandle handle, void* data, size_t len) {
        if (!handle.valid) return -1;
        
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = connections_.find(handle.id);
        if (it == connections_.end() || it->second.state != ConnectionState::IN_USE) {
            return -1;
        }
        
        int result = net_sim::recv(it->second.fd, data, len);
        if (result < 0) {
            it->second.mark_error();
        }
        return result;
    }
    
    // Retry a failed connection using the same handle.
    // This allows the caller to keep the same handle and reconnect transparently.
    bool retry(ConnectionHandle handle) {
        if (!handle.valid) return false;
        
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = connections_.find(handle.id);
        if (it == connections_.end()) return false;
        
        Connection& conn = it->second;
        
        if (!conn.is_retriable()) {
            // Exceeded max retries - free and fail
            in_use_.erase(handle.id);
            free_connection_locked(handle.id);
            return false;
        }
        
        // Close existing fd if any
        conn.disconnect();
        
        // Small delay before retry
        // Note: In production, you'd want async retry, but for simplicity we do a brief sleep
        // We release the lock briefly for the sleep
        int retry_count = conn.error_count;
        
        // Exponential backoff
        auto delay = config_.retry_delay * (1 << std::min(retry_count, 4));
        
        // Attempt reconnection
        if (conn.connect()) {
            conn.mark_in_use();
            return true;
        }
        
        return false;
    }
    
    // Send with automatic retry on failure
    int send_with_retry(ConnectionHandle handle, const void* data, size_t len) {
        for (int attempt = 0; attempt <= config_.max_retries; ++attempt) {
            int result = send(handle, data, len);
            if (result >= 0) return result;
            
            // Try to reconnect with the same handle
            if (!retry(handle)) {
                return -1;
            }
        }
        return -1;
    }
    
    // Recv with automatic retry on failure
    int recv_with_retry(ConnectionHandle handle, void* data, size_t len) {
        for (int attempt = 0; attempt <= config_.max_retries; ++attempt) {
            int result = recv(handle, data, len);
            if (result >= 0) return result;
            
            if (!retry(handle)) {
                return -1;
            }
        }
        return -1;
    }
    
    // Check if a connection handle is still valid and connected
    bool is_connected(ConnectionHandle handle) const {
        if (!handle.valid) return false;
        
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = connections_.find(handle.id);
        if (it == connections_.end()) return false;
        return it->second.state == ConnectionState::CONNECTED ||
               it->second.state == ConnectionState::IN_USE;
    }
    
    // Get connection state
    ConnectionState get_state(ConnectionHandle handle) const {
        if (!handle.valid) return ConnectionState::DISCONNECTED;
        
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = connections_.find(handle.id);
        if (it == connections_.end()) return ConnectionState::DISCONNECTED;
        return it->second.state;
    }
    
    // Force close and free a connection
    void force_close(ConnectionHandle handle) {
        if (!handle.valid) return;
        
        std::lock_guard<std::mutex> lock(mutex_);
        in_use_.erase(handle.id);
        free_connection_locked(handle.id);
        cv_.notify_one();
    }
    
    // Get pool statistics
    struct Stats {
        size_t total;
        size_t available;
        size_t in_use;
        size_t errored;
    };
    
    Stats stats() const {
        std::lock_guard<std::mutex> lock(mutex_);
        Stats s;
        s.total = total_connections_;
        s.available = available_.size();
        s.in_use = in_use_.size();
        s.errored = 0;
        for (const auto& [id, conn] : connections_) {
            if (conn.state == ConnectionState::ERROR) s.errored++;
        }
        return s;
    }
    
    void shutdown() {
        {
            std::lock_guard<std::mutex> lock(mutex_);
            if (!running_) return;
            running_ = false;
        }
        cv_.notify_all();
        
        if (maintenance_thread_.joinable()) {
            maintenance_thread_.join();
        }
        
        std::lock_guard<std::mutex> lock(mutex_);
        for (auto& [id, conn] : connections_) {
            conn.disconnect();
        }
        connections_.clear();
        in_use_.clear();
        while (!available_.empty()) available_.pop();
        total_connections_ = 0;
    }

private:
    ConnectionHandle create_connection() {
        std::lock_guard<std::mutex> lock(mutex_);
        
        if (total_connections_ >= config_.max_connections) {
            return ConnectionHandle();
        }
        
        uint64_t id = next_id_++;
        Connection conn(id, host_, port_, config_.max_retries);
        
        if (conn.connect()) {
            connections_[id] = std::move(conn);
            available_.push(id);
            total_connections_++;
            return ConnectionHandle(id);
        }
        
        // Retry connection creation
        for (int i = 1; i <= config_.max_retries && config_.auto_reconnect; ++i) {
            std::this_thread::sleep_for(config_.retry_delay);
            if (conn.connect()) {
                connections_[id] = std::move(conn);
                available_.push(id);
                total_connections_++;
                return ConnectionHandle(id);
            }
        }
        
        return ConnectionHandle();
    }
    
    void free_connection_locked(uint64_t id) {
        auto it = connections_.find(id);
        if (it != connections_.end()) {
            it->second.disconnect();
            connections_.erase(it);