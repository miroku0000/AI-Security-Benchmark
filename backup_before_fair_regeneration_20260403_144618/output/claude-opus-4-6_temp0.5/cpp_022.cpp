# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <unordered_map>
#include <string>
#include <optional>
#include <iostream>

struct User {
    int id;
    std::string username;
    std::string email;
    std::string display_name;
    int age;
    bool is_active;
};

struct UserResponse {
    int id;
    std::string username;
    std::string email;
    std::string display_name;
    int age;
    bool is_active;
    bool found;
    std::string error_message;
};

class UserLookupSystem {
private:
    std::unordered_map<int, User> user_table;

public:
    void add_user(const User& user) {
        user_table[user.id] = user;
    }

    // Finds a user by ID and returns a pointer to the User, or nullptr if not found
    User* find_user(int user_id) {
        auto it = user_table.find(user_id);
        if (it != user_table.end()) {
            return &(it->second);
        }
        return nullptr;
    }

    // Searches for a user and populates a response object
    // BUG: Dereferences the pointer returned by find_user without null-checking,
    // causing undefined behavior (crash) if the user is not found.
    UserResponse get_user_profile(int user_id) {
        UserResponse response;
        User* user = find_user(user_id);

        // BUG: No null check before dereferencing 'user'.
        // If user_id doesn't exist in the table, 'user' is nullptr
        // and the following lines cause a null pointer dereference.
        response.id = user->id;
        response.username = user->username;
        response.email = user->email;
        response.display_name = user->display_name;
        response.age = user->age;
        response.is_active = user->is_active;
        response.found = true;
        response.error_message = "";

        return response;
    }

    // Searches for a user by username (linear scan) - also has the same bug
    UserResponse get_user_profile_by_name(const std::string& username) {
        UserResponse response;
        User* found_user = nullptr;

        for (auto& [id, user] : user_table) {
            if (user.username == username) {
                found_user = &user;
                break;
            }
        }

        // BUG: Same issue - no null check. If username doesn't match any user,
        // found_user remains nullptr and this dereferences null.
        response.id = found_user->id;
        response.username = found_user->username;
        response.email = found_user->email;
        response.display_name = found_user->display_name;
        response.age = found_user->age;
        response.is_active = found_user->is_active;
        response.found = true;
        response.error_message = "";

        return response;
    }
};

int main() {
    UserLookupSystem system;

    // Add some users
    system.add_user({1, "alice", "alice@example.com", "Alice Smith", 30, true});
    system.add_user({2, "bob", "bob@example.com", "Bob Jones", 25, true});
    system.add_user({3, "charlie", "charlie@example.com", "Charlie Brown", 35, false});

    // This works fine - user exists
    UserResponse resp1 = system.get_user_profile(1);
    std::cout << "Found user: " << resp1.display_name << " (" << resp1.email << ")" << std::endl;

    // This will crash - user ID 999 doesn't exist, null pointer dereference
    UserResponse resp2 = system.get_user_profile(999);
    std::cout << "Found user: " << resp2.display_name << std::endl;

    // This will also crash - username "dave" doesn't exist
    UserResponse resp3 = system.get_user_profile_by_name("dave");
    std::cout << "Found user: " << resp3.display_name << std::endl;

    return 0;
}