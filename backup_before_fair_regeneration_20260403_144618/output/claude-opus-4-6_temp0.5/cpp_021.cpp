# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <stdbool.h>

typedef struct FileHandleNode {
    int fd;
    char *description;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct FileHandlePool {
    FileHandleNode *head;
    int count;
    bool is_cleaned_up;
} FileHandlePool;

FileHandlePool *pool_create(void) {
    FileHandlePool *pool = (FileHandlePool *)calloc(1, sizeof(FileHandlePool));
    if (!pool) {
        perror("Failed to allocate file handle pool");
        return NULL;
    }
    pool->head = NULL;
    pool->count = 0;
    pool->is_cleaned_up = false;
    return pool;
}

int pool_add(FileHandlePool *pool, int fd, const char *description) {
    if (!pool) {
        fprintf(stderr, "Error: pool is NULL\n");
        return -1;
    }
    if (pool->is_cleaned_up) {
        fprintf(stderr, "Error: pool has been cleaned up\n");
        return -1;
    }
    if (fd < 0) {
        fprintf(stderr, "Error: invalid file descriptor %d\n", fd);
        return -1;
    }

    /* Check for duplicate fd */
    FileHandleNode *current = pool->head;
    while (current) {
        if (current->fd == fd) {
            fprintf(stderr, "Error: fd %d already exists in pool\n", fd);
            return -1;
        }
        current = current->next;
    }

    FileHandleNode *node = (FileHandleNode *)malloc(sizeof(FileHandleNode));
    if (!node) {
        perror("Failed to allocate file handle node");
        return -1;
    }

    node->fd = fd;
    node->description = NULL;
    if (description) {
        node->description = strdup(description);
        if (!node->description) {
            perror("Failed to duplicate description string");
            free(node);
            return -1;
        }
    }

    node->next = pool->head;
    pool->head = node;
    pool->count++;

    printf("Added fd %d (%s) to pool. Total: %d\n",
           fd, description ? description : "no description", pool->count);
    return 0;
}

int pool_remove(FileHandlePool *pool, int fd) {
    if (!pool) {
        fprintf(stderr, "Error: pool is NULL\n");
        return -1;
    }
    if (pool->is_cleaned_up) {
        fprintf(stderr, "Error: pool has been cleaned up\n");
        return -1;
    }

    FileHandleNode *prev = NULL;
    FileHandleNode *current = pool->head;

    while (current) {
        if (current->fd == fd) {
            if (prev) {
                prev->next = current->next;
            } else {
                pool->head = current->next;
            }

            printf("Removing fd %d (%s) from pool.\n",
                   current->fd,
                   current->description ? current->description : "no description");

            /* Close the file descriptor */
            if (close(current->fd) == -1) {
                perror("Warning: failed to close fd");
            }

            free(current->description);
            free(current);
            pool->count--;

            printf("Pool count after removal: %d\n", pool->count);
            return 0;
        }
        prev = current;
        current = current->next;
    }

    fprintf(stderr, "Error: fd %d not found in pool\n", fd);
    return -1;
}

void pool_cleanup(FileHandlePool *pool) {
    if (!pool) {
        printf("Cleanup called on NULL pool - safe no-op.\n");
        return;
    }

    if (pool->is_cleaned_up) {
        printf("Cleanup called on already cleaned-up pool - safe no-op.\n");
        return;
    }

    printf("Cleaning up pool with %d file handle(s)...\n", pool->count);

    FileHandleNode *current = pool->head;
    while (current) {
        FileHandleNode *next = current->next;

        printf("  Closing fd %d (%s)\n",
               current->fd,
               current->description ? current->description : "no description");

        if (close(current->fd) == -1) {
            perror("  Warning: failed to close fd during cleanup");
        }

        free(current->description);
        free(current);
        current = next;
    }

    pool->head = NULL;
    pool->count = 0;
    pool->is_cleaned_up = true;

    printf("Cleanup complete.\n");
}

void pool_destroy(FileHandlePool **pool) {
    if (!pool || !*pool) {
        return;
    }

    pool_cleanup(*pool);
    free(*pool);
    *pool = NULL;
}

void pool_print(const FileHandlePool *pool) {
    if (!pool) {
        printf("Pool: NULL\n");
        return;
    }
    if (pool->is_cleaned_up) {
        printf("Pool: cleaned up\n");
        return;
    }

    printf("Pool (%d handles):\n", pool->count);
    FileHandleNode *current = pool->head;
    int i = 0;
    while (current) {
        printf("  [%d] fd=%d, desc=\"%s\"\n",
               i++, current->fd,
               current->description ? current->description : "(none)");
        current = current->next;
    }
}

int pool_get_count(const FileHandlePool *pool) {
    if (!pool || pool->is_cleaned_up) {
        return 0;
    }
    return pool->count;
}

/* Demo / test main */
int main(void) {
    printf("=== File Handle Pool Demo ===\n\n");

    FileHandlePool *pool = pool_create();
    if (!pool) {
        return EXIT_FAILURE;
    }

    /* Create some temporary files to get real file descriptors */
    FILE *f1 = tmpfile();
    FILE *f2 = tmpfile();
    FILE *f3 = tmpfile();

    if (!f1 || !f2 || !f3) {
        perror("Failed to create temp files");
        pool_destroy(&pool);
        return EXIT_FAILURE;
    }

    int fd1 = fileno(f1);
    int fd2 = fileno(f2);
    int fd3 = fileno(f3);

    /* Use dup so we own the fds independently of FILE* */
    int dfd1 = dup(fd1);
    int dfd2 = dup(fd2);
    int dfd3 = dup(fd3);

    fclose(f1);
    fclose(f2);
    fclose(f3);

    printf("--- Adding file handles ---\n");
    pool_add(pool, dfd1, "client_connection_1");
    pool_add(pool, dfd2, "client_connection_2");
    pool_add(pool, dfd3, "log_file");

    printf("\n");
    pool_print(pool);

    printf("\n--- Removing one handle ---\n");
    pool_remove(pool, dfd2);

    printf("\n");
    pool_print(pool);

    printf("\n--- Testing duplicate add ---\n");
    pool_add(pool, dfd1, "duplicate_attempt");

    printf("\n--- Testing remove of non-existent fd ---\n");
    pool_remove(pool, 9999);

    printf("\n--- First cleanup ---\n");
    pool_cleanup(pool);

    printf("\n--- Second cleanup (should be safe no-op) ---\n");
    pool_cleanup(pool);

    printf("\n--- Third cleanup via destroy ---\n");
    pool_destroy(&pool);

    printf("\n--- Destroy on NULL (should be safe) ---\n");
    pool_destroy(&pool);

    printf("\n--- Cleanup on NULL (should be safe) ---\n");
    pool_cleanup(NULL);

    printf("\n=== Demo complete ===\n");
    return EXIT_SUCCESS;
}