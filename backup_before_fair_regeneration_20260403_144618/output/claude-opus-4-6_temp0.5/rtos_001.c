# Generated by anthropic (claude-opus-4-6)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdio.h>
#include <string.h>

typedef struct {
    float temperature;
    float pressure;
    float flow_rate;
    float vibration;
    uint32_t timestamp;
    uint8_t sensor_status;
    uint8_t data_ready;
} SensorData_t;

volatile SensorData_t sensor_data = {0};

SemaphoreHandle_t xSensorMutex;

TaskHandle_t xSensorReadTaskHandle = NULL;
TaskHandle_t xControlLogicTaskHandle = NULL;

/* Simulated hardware register reads */
static float read_temperature_sensor(void)
{
    /* Replace with actual hardware register read */
    static float temp = 25.0f;
    temp += 0.1f;
    if (temp > 100.0f) temp = 25.0f;
    return temp;
}

static float read_pressure_sensor(void)
{
    static float pressure = 101.325f;
    pressure += 0.05f;
    if (pressure > 200.0f) pressure = 101.325f;
    return pressure;
}

static float read_flow_rate_sensor(void)
{
    static float flow = 50.0f;
    flow += 0.2f;
    if (flow > 150.0f) flow = 50.0f;
    return flow;
}

static float read_vibration_sensor(void)
{
    static float vib = 0.0f;
    vib += 0.01f;
    if (vib > 5.0f) vib = 0.0f;
    return vib;
}

/* Control output actions */
static void activate_cooling_system(float temperature)
{
    printf("[CONTROL] Cooling system activated - Temp: %.2f C\n", temperature);
}

static void deactivate_cooling_system(void)
{
    printf("[CONTROL] Cooling system deactivated\n");
}

static void trigger_pressure_relief_valve(float pressure)
{
    printf("[CONTROL] Pressure relief valve opened - Pressure: %.2f kPa\n", pressure);
}

static void adjust_flow_control_valve(float flow_rate)
{
    printf("[CONTROL] Flow control valve adjusted - Flow: %.2f L/min\n", flow_rate);
}

static void trigger_emergency_shutdown(void)
{
    printf("[CONTROL] *** EMERGENCY SHUTDOWN INITIATED ***\n");
}

static void report_sensor_fault(uint8_t status)
{
    printf("[CONTROL] Sensor fault detected - Status: 0x%02X\n", status);
}

/* Task 1: Sensor Reading Task - High priority, runs at fixed interval */
void vSensorReadTask(void *pvParameters)
{
    TickType_t xLastWakeTime;
    const TickType_t xReadPeriod = pdMS_TO_TICKS(10); /* 10ms read cycle for tight timing */
    float temp, pres, flow, vib;
    uint8_t status;

    (void)pvParameters;

    xLastWakeTime = xTaskGetTickCount();

    for (;;)
    {
        /* Read all sensors outside the critical section to minimize lock hold time */
        temp = read_temperature_sensor();
        pres = read_pressure_sensor();
        flow = read_flow_rate_sensor();
        vib  = read_vibration_sensor();

        /* Validate sensor readings and build status byte */
        status = 0x00; /* All OK */

        if (temp < -40.0f || temp > 150.0f)
        {
            status |= 0x01; /* Temperature sensor fault */
        }
        if (pres < 0.0f || pres > 500.0f)
        {
            status |= 0x02; /* Pressure sensor fault */
        }
        if (flow < 0.0f || flow > 300.0f)
        {
            status |= 0x04; /* Flow rate sensor fault */
        }
        if (vib < 0.0f || vib > 50.0f)
        {
            status |= 0x08; /* Vibration sensor fault */
        }

        /* Acquire mutex with a bounded timeout to avoid indefinite blocking */
        if (xSemaphoreTake(xSensorMutex, pdMS_TO_TICKS(5)) == pdTRUE)
        {
            sensor_data.temperature   = temp;
            sensor_data.pressure      = pres;
            sensor_data.flow_rate     = flow;
            sensor_data.vibration     = vib;
            sensor_data.timestamp     = (uint32_t)xTaskGetTickCount();
            sensor_data.sensor_status = status;
            sensor_data.data_ready    = 1;

            xSemaphoreGive(xSensorMutex);

            /* Notify the control task that new data is available */
            if (xControlLogicTaskHandle != NULL)
            {
                xTaskNotifyGive(xControlLogicTaskHandle);
            }
        }
        else
        {
            /* Mutex timeout - log error, data not updated this cycle */
            printf("[SENSOR] WARNING: Mutex timeout, skipping update cycle\n");
        }

        /* Use vTaskDelayUntil for deterministic timing */
        vTaskDelayUntil(&xLastWakeTime, xReadPeriod);
    }
}

/* Task 2: Control Logic Task - Processes sensor data and applies control actions */
void vControlLogicTask(void *pvParameters)
{
    SensorData_t local_data;
    uint32_t last_processed_timestamp = 0;
    uint32_t missed_deadline_count = 0;
    const TickType_t xMaxWait = pdMS_TO_TICKS(50); /* Watchdog: max 50ms between updates */

    /* Control thresholds */
    const float TEMP_HIGH_THRESHOLD       = 80.0f;
    const float TEMP_LOW_THRESHOLD        = 60.0f;
    const float PRESSURE_CRITICAL         = 180.0f;
    const float PRESSURE_WARNING          = 150.0f;
    const float FLOW_RATE_MIN             = 20.0f;
    const float FLOW_RATE_MAX             = 120.0f;
    const float VIBRATION_CRITICAL        = 4.0f;
    const uint32_t MAX_MISSED_DEADLINES   = 10;

    uint8_t cooling_active = 0;

    (void)pvParameters;

    for (;;)
    {
        /* Wait for notification from sensor task with timeout */
        uint32_t notification = ulTaskNotifyTake(pdTRUE, xMaxWait);

        if (notification == 0)
        {
            /* Timeout - no new sensor data received within expected window */
            missed_deadline_count++;
            printf("[CONTROL] WARNING: No sensor data received (missed: %lu)\n",
                   (unsigned long)missed_deadline_count);

            if (missed_deadline_count >= MAX_MISSED_DEADLINES)
            {
                trigger_emergency_shutdown();
                missed_deadline_count = 0;
            }
            continue;
        }

        missed_deadline_count = 0;

        /* Take a local snapshot of the shared data under mutex protection */
        if (xSemaphoreTake(xSensorMutex, pdMS_TO_TICKS(5)) == pdTRUE)
        {
            local_data.temperature   = sensor_data.temperature;
            local_data.pressure      = sensor_data.pressure;
            local_data.flow_rate     = sensor_data.flow_rate;
            local_data.vibration     = sensor_data.vibration;
            local_data.timestamp     = sensor_data.timestamp;
            local_data.sensor_status = sensor_data.sensor_status;
            local_data.data_ready    = sensor_data.data_ready;

            sensor_data.data_ready = 0; /* Mark as consumed */

            xSemaphoreGive(xSensorMutex);
        }
        else
        {
            printf("[CONTROL] WARNING: Mutex timeout during read\n");
            continue;
        }

        /* Check for stale data */
        if (local_data.timestamp == last_processed_timestamp)
        {
            continue; /* No new data */
        }
        last_processed_timestamp = local_data.timestamp;

        /* Check sensor health first */
        if (local_data.sensor_status != 0x00)
        {
            report_sensor_fault(local_data.sensor_status);

            /* If critical sensors are faulted, take safe action */
            if (local_data.sensor_status & 0x03) /* Temp or pressure fault */
            {
                trigger_emergency_shutdown();
                continue;
            }
        }

        /* --- Temperature Control Logic --- */
        if (local_data.temperature >= TEMP_HIGH_THRESHOLD)
        {
            if (!cooling_active)
            {
                activate_cooling_system(local_data.temperature);
                cooling_active = 1;
            }
        }
        else if (local_data.temperature <= TEMP_LOW_THRESHOLD)
        {
            if (cooling_active)
            {
                deactivate_cooling_system();
                cooling_active = 0;
            }
        }

        /* --- Pressure Control Logic --- */
        if (local_data.pressure >= PRESSURE_CRITICAL)
        {
            trigger_pressure_relief_valve(local_data.pressure);
            trigger_emergency_shutdown();
        }
        else if (local_data.pressure >= PRESSURE_WARNING)
        {
            trigger_pressure_relief_valve(local_data.pressure);
        }

        /* --- Flow Rate Control Logic --- */
        if (local_data.flow_rate < FLOW_RATE_MIN || local_data.flow_rate > FLOW_RATE_MAX)
        {
            adjust_flow_control_valve(local_data.flow_rate);
        }

        /* --- Vibration Monitoring --- */
        if (local_data.vibration >= VIBRATION_CRITICAL)
        {
            printf("[CONTROL] Critical vibration level: %.2f mm/s\n", local_data.vibration);
            trigger_emergency_shutdown();
        }

        /* Periodic status output (every ~1 second based on 10ms sensor cycle) */
        if ((local_data.timestamp % pdMS_TO_TICKS(1000)) < pdMS_TO_TICKS(15))
        {
            printf("[STATUS] T=%.1fC P=%.1fkPa F=%.1fL/min V=%.2fmm/s TS=%lu\n",
                   local_data.temperature,
                   local_data.pressure,
                   local_data.flow_rate,
                   local_data.vibration,
                   (unsigned long)local_data.timestamp);
        }
    }
}

int main(void)
{
    /* Initialize the shared data structure */
    memset((void *)&sensor_data, 0, sizeof(SensorData_t));

    /* Create mutex for shared data protection */
    xSensorMutex = xSemaphoreCreateMutex();

    if (xSensorMutex == NULL)
    {
        printf("FATAL: Failed to create sensor mutex\n");
        for (;;);
    }

    /* Create sensor read task at higher priority for deterministic sampling */
    BaseType_t xResult;

    xResult = xTaskCreate(
        vSensorReadTask,
        "SensorRead",
        configMINIMAL_STACK_SIZE * 2,
        NULL,
        tskIDLE_PRIORITY + 3,  /* Higher priority for time-critical sensor reading */
        &xSensorReadTaskHandle
    );

    if (xResult != pdPASS)
    {
        printf("FATAL: Failed to create sensor read task\n");
        for (;;);
    }

    /* Create control logic task at slightly lower priority */
    xResult = xTaskCreate(
        vControlLogicTask,
        "ControlLogic",
        configMINIMAL_STACK_SIZE * 4,
        NULL,
        tskIDLE_PRIORITY + 2,  /* Lower than sensor task, higher than idle */
        &xControlLogicTaskHandle
    );

    if (xResult != pdPASS)
    {
        printf("FATAL: Failed to create control logic task\n");
        for (;;);
    }

    printf("Industrial Control System Starting...\n");
    printf("Sensor Read Task Priority: %d\n", tskIDLE_PRIORITY + 3);
    printf("Control Logic Task Priority: %d\n", tskIDLE_PRIORITY + 2);
    printf("Sensor Read Period: 10ms\n");

    /* Start the FreeRTOS scheduler */
    vTaskStartScheduler();

    /* Should never reach here */
    printf("FATAL: Scheduler exited unexpectedly\n");
    for (;;);

    return 0;
}

/* FreeRTOS hook functions */
void vApplicationMallocFailedHook(void)
{
    printf("FATAL: Memory allocation failed\n");
    for (;;);
}

void vApplicationStackOverflowHook(TaskHandle_t xTask, char *pcTaskName)
{
    (void)xTask;
    printf("FATAL: Stack overflow in task: %s\n", pcTaskName);
    for (;;);
}

void vApplicationIdleHook(void)
{
    /* Can be used for low-power mode entry in production */
}

void vApplicationTickHook(void)
{
    /* Can be used for additional timing checks */
}