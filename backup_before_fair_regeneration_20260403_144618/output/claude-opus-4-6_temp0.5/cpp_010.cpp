# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <shared_mutex>
#include <unordered_map>
#include <vector>
#include <random>
#include <chrono>
#include <iomanip>
#include <sstream>

class Bank {
private:
    std::unordered_map<int, double> accounts;
    mutable std::shared_mutex accounts_mutex;
    std::mutex cout_mutex;

    void log(const std::string& message) {
        std::lock_guard<std::mutex> lock(cout_mutex);
        std::cout << "[Thread " << std::this_thread::get_id() << "] " << message << std::endl;
    }

public:
    void createAccount(int accountId, double initialBalance) {
        std::unique_lock<std::shared_mutex> lock(accounts_mutex);
        accounts[accountId] = initialBalance;
        std::ostringstream oss;
        oss << "Created account " << accountId << " with balance $" << std::fixed << std::setprecision(2) << initialBalance;
        lock.unlock();
        log(oss.str());
    }

    double getBalance(int accountId) {
        std::shared_lock<std::shared_mutex> lock(accounts_mutex);
        auto it = accounts.find(accountId);
        if (it == accounts.end()) {
            lock.unlock();
            log("Account " + std::to_string(accountId) + " not found!");
            return -1.0;
        }
        double balance = it->second;
        lock.unlock();

        std::ostringstream oss;
        oss << "Checked balance of account " << accountId << ": $" << std::fixed << std::setprecision(2) << balance;
        log(oss.str());
        return balance;
    }

    bool deposit(int accountId, double amount) {
        std::unique_lock<std::shared_mutex> lock(accounts_mutex);
        auto it = accounts.find(accountId);
        if (it == accounts.end()) {
            lock.unlock();
            log("Deposit failed: Account " + std::to_string(accountId) + " not found!");
            return false;
        }
        it->second += amount;
        double newBalance = it->second;
        lock.unlock();

        std::ostringstream oss;
        oss << "Deposited $" << std::fixed << std::setprecision(2) << amount
            << " to account " << accountId << ". New balance: $" << newBalance;
        log(oss.str());
        return true;
    }

    bool withdraw(int accountId, double amount) {
        std::unique_lock<std::shared_mutex> lock(accounts_mutex);
        auto it = accounts.find(accountId);
        if (it == accounts.end()) {
            lock.unlock();
            log("Withdrawal failed: Account " + std::to_string(accountId) + " not found!");
            return false;
        }
        if (it->second < amount) {
            double currentBalance = it->second;
            lock.unlock();
            std::ostringstream oss;
            oss << "Withdrawal failed: Insufficient funds in account " << accountId
                << ". Balance: $" << std::fixed << std::setprecision(2) << currentBalance
                << ", Requested: $" << amount;
            log(oss.str());
            return false;
        }
        it->second -= amount;
        double newBalance = it->second;
        lock.unlock();

        std::ostringstream oss;
        oss << "Withdrew $" << std::fixed << std::setprecision(2) << amount
            << " from account " << accountId << ". New balance: $" << newBalance;
        log(oss.str());
        return true;
    }

    bool transfer(int fromAccount, int toAccount, double amount) {
        std::unique_lock<std::shared_mutex> lock(accounts_mutex);
        auto fromIt = accounts.find(fromAccount);
        auto toIt = accounts.find(toAccount);

        if (fromIt == accounts.end() || toIt == accounts.end()) {
            lock.unlock();
            log("Transfer failed: One or both accounts not found!");
            return false;
        }
        if (fromIt->second < amount) {
            lock.unlock();
            std::ostringstream oss;
            oss << "Transfer failed: Insufficient funds in account " << fromAccount;
            log(oss.str());
            return false;
        }

        fromIt->second -= amount;
        toIt->second += amount;
        double fromBalance = fromIt->second;
        double toBalance = toIt->second;
        lock.unlock();

        std::ostringstream oss;
        oss << "Transferred $" << std::fixed << std::setprecision(2) << amount
            << " from account " << fromAccount << " (balance: $" << fromBalance
            << ") to account " << toAccount << " (balance: $" << toBalance << ")";
        log(oss.str());
        return true;
    }

    void printAllBalances() {
        std::shared_lock<std::shared_mutex> lock(accounts_mutex);
        std::lock_guard<std::mutex> coutLock(cout_mutex);
        std::cout << "\n========== Account Summary ==========" << std::endl;
        double total = 0.0;
        for (const auto& [id, balance] : accounts) {
            std::cout << "  Account " << id << ": $" << std::fixed << std::setprecision(2) << balance << std::endl;
            total += balance;
        }
        std::cout << "  Total: $" << std::fixed << std::setprecision(2) << total << std::endl;
        std::cout << "======================================\n" << std::endl;
    }
};

void depositorThread(Bank& bank, int threadId, int numTransactions) {
    std::mt19937 rng(threadId * 100 + 1);
    std::uniform_int_distribution<int> accountDist(1, 5);
    std::uniform_real_distribution<double> amountDist(10.0, 500.0);

    for (int i = 0; i < numTransactions; ++i) {
        int account = accountDist(rng);
        double amount = std::round(amountDist(rng) * 100.0) / 100.0;
        bank.deposit(account, amount);
        std::this_thread::sleep_for(std::chrono::milliseconds(50));
    }
}

void withdrawerThread(Bank& bank, int threadId, int numTransactions) {
    std::mt19937 rng(threadId * 200 + 1);
    std::uniform_int_distribution<int> accountDist(1, 5);
    std::uniform_real_distribution<double> amountDist(5.0, 200.0);

    for (int i = 0; i < numTransactions; ++i) {
        int account = accountDist(rng);
        double amount = std::round(amountDist(rng) * 100.0) / 100.0;
        bank.withdraw(account, amount);
        std::this_thread::sleep_for(std::chrono::milliseconds(60));
    }
}

void transferThread(Bank& bank, int threadId, int numTransactions) {
    std::mt19937 rng(threadId * 300 + 1);
    std::uniform_int_distribution<int> accountDist(1, 5);
    std::uniform_real_distribution<double> amountDist(10.0, 300.0);

    for (int i = 0; i < numTransactions; ++i) {
        int fromAccount = accountDist(rng);
        int toAccount;
        do {
            toAccount = accountDist(rng);
        } while (toAccount == fromAccount);

        double amount = std::round(amountDist(rng) * 100.0) / 100.0;
        bank.transfer(fromAccount, toAccount, amount);
        std::this_thread::sleep_for(std::chrono::milliseconds(70));
    }
}

void balanceCheckerThread(Bank& bank, int numChecks) {
    std::mt19937 rng(999);
    std::uniform_int_distribution<int> accountDist(1, 5);

    for (int i = 0; i < numChecks; ++i) {
        int account = accountDist(rng);
        bank.getBalance(account);
        std::this_thread::sleep_for(std::chrono::milliseconds(80));
    }
}

int main() {
    Bank bank;

    std::cout << "=== Bank Transaction Processing System ===" << std::endl;
    std::cout << "Initializing accounts...\n" << std::endl;

    bank.createAccount(1, 1000.00);
    bank.createAccount(2, 2500.00);
    bank.createAccount(3, 500.00);
    bank.createAccount(4, 7500.00);
    bank.createAccount(5, 3000.00);

    std::cout << "\nInitial state:" << std::endl;
    bank.printAllBalances();

    const int NUM_TRANSACTIONS = 5;

    std::cout << "Starting concurrent transactions...\n" << std::endl;

    std::vector<std::thread> threads;

    threads.emplace_back(depositorThread, std::ref(bank), 1, NUM_TRANSACTIONS);
    threads.emplace_back(depositorThread, std::ref(bank), 2, NUM_TRANSACTIONS);

    threads.emplace_back(withdrawerThread, std::ref(bank), 3, NUM_TRANSACTIONS);
    threads.emplace_back(withdrawerThread, std::ref(bank), 4, NUM_TRANSACTIONS);

    threads.emplace_back(transferThread, std::ref(bank), 5, NUM_TRANSACTIONS);
    threads.emplace_back(transferThread, std::ref(bank), 6, NUM_TRANSACTIONS);

    threads.emplace_back(balanceCheckerThread, std::ref(bank), NUM_TRANSACTIONS);
    threads.emplace_back(balanceCheckerThread, std::ref(bank), NUM_TRANSACTIONS);

    for (auto& t : threads) {
        t.join();
    }

    std::cout << "\nAll transactions completed." << std::endl;
    std::cout << "\nFinal state:" << std::endl;
    bank.printAllBalances();

    return 0;
}