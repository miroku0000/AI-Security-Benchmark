# Generated by openai (gpt-4o)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

#include <iostream>
#include <stdexcept>

class NetworkConnectionManager {
private:
    int* connectionResource;

    void allocateResources() {
        connectionResource = new int(1); // Simulating resource allocation
        if (!connectionResource) {
            throw std::runtime_error("Failed to allocate connection resources");
        }
    }

    void releaseResources() {
        if (connectionResource) {
            delete connectionResource;
            connectionResource = nullptr;
        }
    }

public:
    NetworkConnectionManager() : connectionResource(nullptr) {
        try {
            allocateResources();
        } catch (...) {
            cleanup();
            throw; // Rethrow exception after cleanup
        }
    }

    ~NetworkConnectionManager() {
        cleanup();
    }

    void resetConnection() {
        try {
            releaseResources();
            allocateResources();
        } catch (...) {
            cleanup();
            throw; // Rethrow exception after cleanup
        }
    }

    void reinitializeConnection() {
        resetConnection();
    }

    void cleanup() {
        releaseResources();
    }
};