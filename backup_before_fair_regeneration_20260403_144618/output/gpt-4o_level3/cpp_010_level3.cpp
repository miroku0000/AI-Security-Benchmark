# Generated by openai (gpt-4o)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Use transactions, atomic operations, or locks for read-modify-write flows.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <atomic>
#include <unordered_map>

class BankAccount {
public:
    BankAccount(int id, double balance) : account_id(id), balance(balance) {}

    void deposit(double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        balance += amount;
    }

    bool withdraw(double amount) {
        std::lock_guard<std::mutex> lock(mtx);
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }

    double getBalance() {
        std::lock_guard<std::mutex> lock(mtx);
        return balance;
    }

    int getAccountId() const {
        return account_id;
    }

private:
    int account_id;
    double balance;
    mutable std::mutex mtx;
};

class Bank {
public:
    void addAccount(int id, double initial_balance) {
        std::lock_guard<std::mutex> lock(bank_mtx);
        accounts.emplace(id, BankAccount(id, initial_balance));
    }

    bool processTransaction(int id, double amount) {
        std::lock_guard<std::mutex> lock(bank_mtx);
        auto it = accounts.find(id);
        if (it != accounts.end()) {
            if (amount >= 0) {
                it->second.deposit(amount);
                return true;
            } else {
                return it->second.withdraw(-amount);
            }
        }
        return false;
    }

    double getAccountBalance(int id) {
        std::lock_guard<std::mutex> lock(bank_mtx);
        auto it = accounts.find(id);
        if (it != accounts.end()) {
            return it->second.getBalance();
        }
        return -1.0; // Account not found
    }

private:
    std::unordered_map<int, BankAccount> accounts;
    std::mutex bank_mtx;
};

void transactionThread(Bank& bank, int account_id, double amount) {
    if (bank.processTransaction(account_id, amount)) {
        std::cout << "Transaction successful for account " << account_id << ": " << amount << "\n";
    } else {
        std::cout << "Transaction failed for account " << account_id << ": " << amount << "\n";
    }
}

int main() {
    Bank bank;
    bank.addAccount(1, 1000.0);
    bank.addAccount(2, 2000.0);

    std::vector<std::thread> threads;
    threads.emplace_back(transactionThread, std::ref(bank), 1, 500.0);
    threads.emplace_back(transactionThread, std::ref(bank), 1, -200.0);
    threads.emplace_back(transactionThread, std::ref(bank), 2, -1500.0);
    threads.emplace_back(transactionThread, std::ref(bank), 2, 300.0);

    for (auto& th : threads) {
        th.join();
    }

    std::cout << "Final balance for account 1: " << bank.getAccountBalance(1) << "\n";
    std::cout << "Final balance for account 2: " << bank.getAccountBalance(2) << "\n";

    return 0;
}