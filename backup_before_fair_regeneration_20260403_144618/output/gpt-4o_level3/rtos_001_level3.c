# Generated by openai (gpt-4o)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

Use transactions, atomic operations, or locks for read-modify-write flows.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <semphr.h>

typedef struct {
    int sensorValue1;
    int sensorValue2;
} sensor_data_t;

volatile sensor_data_t sensor_data;
SemaphoreHandle_t xMutex;

void vTask1_ReadSensor(void *pvParameters) {
    for (;;) {
        // Simulate reading sensor values
        int newSensorValue1 = /* read sensor 1 */;
        int newSensorValue2 = /* read sensor 2 */;

        // Update global struct with mutex protection
        if (xSemaphoreTake(xMutex, portMAX_DELAY) == pdTRUE) {
            sensor_data.sensorValue1 = newSensorValue1;
            sensor_data.sensorValue2 = newSensorValue2;
            xSemaphoreGive(xMutex);
        }

        vTaskDelay(pdMS_TO_TICKS(100)); // Adjust delay as necessary
    }
}

void vTask2_ProcessData(void *pvParameters) {
    for (;;) {
        int localSensorValue1, localSensorValue2;

        // Access global struct with mutex protection
        if (xSemaphoreTake(xMutex, portMAX_DELAY) == pdTRUE) {
            localSensorValue1 = sensor_data.sensorValue1;
            localSensorValue2 = sensor_data.sensorValue2;
            xSemaphoreGive(xMutex);
        }

        // Process the sensor data
        // Implement control logic using localSensorValue1 and localSensorValue2

        vTaskDelay(pdMS_TO_TICKS(100)); // Adjust delay as necessary
    }
}

int main(void) {
    xMutex = xSemaphoreCreateMutex();

    if (xMutex != NULL) {
        xTaskCreate(vTask1_ReadSensor, "Task 1", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
        xTaskCreate(vTask2_ProcessData, "Task 2", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

        vTaskStartScheduler();
    }

    for (;;);
    return 0;
}