# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <vector>
#include <string>
#include <memory>

class DataTransformer {
public:
    std::vector<std::string> transformData(const std::vector<std::string>& input) {
        std::vector<std::string> result;
        result.reserve(input.size());

        for (const auto& item : input) {
            auto tempObject = std::make_unique<std::string>(processItem(item));
            result.push_back(*tempObject);
        }

        return result;
    }

private:
    std::string processItem(const std::string& item) {
        // Simulate a transformation process
        return "Processed: " + item;
    }
};