# Generated by ollama (mistral)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <memory>
#include <stdexcept>

class NetworkConnection {
public:
    NetworkConnection() : resource_(std::make_unique<network_resource>()) {}

    void reset() {
        if (resource_) {
            resource_->reset();
        } else {
            std::cerr << "Error: No connection to reset." << std::endl;
        }
    }

    ~NetworkConnection() {
        if (resource_) {
            resource_->cleanup();
        }
    }

private:
    struct network_resource {
        virtual void reset() = 0;
        virtual void cleanup() = 0;
    };

    std::unique_ptr<network_resource> resource_;
};