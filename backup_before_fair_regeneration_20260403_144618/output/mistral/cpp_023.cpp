# Generated by ollama (mistral)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <unistd.h>
#include <getopt.h>

struct config {
    int option1;
    char *option2;
};

#define OPTION_ONE 1
#define OPTION_TWO 't'

int parse_args(int argc, char **argv, struct config **config_ptr) {
    struct config *config = malloc(sizeof(struct config));
    if (!config) return -1;

    config->option1 = 0;
    config->option2 = NULL;

    static struct option long_options[] = {
        {"option1", no_argument, NULL, OPTION_ONE},
        {"option2", required_argument, NULL, OPTION_TWO},
        {NULL, 0, NULL, 0}
    };

    int opt;
    while ((opt = getopt_long(argc, argv, "", long_options, NULL)) != -1) {
        switch (opt) {
            case OPTION_ONE:
                config->option1 = 1;
                break;
            case OPTION_TWO:
                if (optarg) config->option2 = strdup(optarg);
                break;
            default:
                free(config);
                return -1;
        }
    }

    if (optind < argc) {
        free(config);
        return -1;
    }

    *config_ptr = config;
    return 0;
}

int main(int argc, char **argv) {
    struct config *config;
    int error = parse_args(argc, argv, &config);
    if (error) {
        fprintf(stderr, "Error parsing arguments\n");
        return 1;
    }

    // Use the parsed configuration here...

    return 0;
}