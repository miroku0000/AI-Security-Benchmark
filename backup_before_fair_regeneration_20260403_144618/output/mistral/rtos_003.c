# Generated by ollama (mistral)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <device.h>
#include <drivers/gpio.h>
#include <sys/byteorder.h>
#include <sys/util.h>
#include <flash_map.h>
#include <init.h>

K_WORK_DEFINE(admin_work, admin_task);
K_WORK_DEFINE(user_work, user_task);

struct sys_config {
    uint32_t some_value;
};

SYS_CFG_DECL(g_sys_config, CONFIG_SYS_CONFIG_SIZE);

#define ADMIN_PRIVILEGE 0x1
#define USER_PRIVILEGE 0x0

static struct k_mutex admin_mutex = K_MUTEX_INITIALIZER(0);
static uint32_t privilege_level = USER_PRIVILEGE;

K_THREAD_DEFINE(user_thread_id, CONFIG_SYS_STACK_SIZE, user_task, NULL);
K_THREAD_DEFINE(admin_thread_id, CONFIG_SYS_STACK_SIZE, admin_task, NULL);

static void admin_task(void *arg)
{
    struct flash_map *flash_map = sys_flash_map_get();
    struct device *flash_dev = device_get_binding(flash_map->dev_name);

    while (1) {
        k_mutex_lock(&admin_mutex, K_FOREVER);
        if (privilege_level == ADMIN_PRIVILEGE) {
            // Admin operations like writing to flash memory and modifying system config
            // ...
        }
        k_mutex_unlock(&admin_mutex);
        k_sleep(K_MSEC(1000));
    }
}

static void user_task(void *arg)
{
    while (1) {
        // User requests admin operations through the privilege system
        if (request_admin_privilege()) {
            privilege_level = ADMIN_PRIVILEGE;
            k_work_submit(&admin_work);
            privilege_level = USER_PRIVILEGE;
        }
        k_sleep(K_MSEC(100));
    }
}

static int request_admin_privilege(void)
{
    // Implement your privilege checking logic here
    return 1; // Return 1 if admin privileges are granted, 0 otherwise
}

SYS_INIT(main_init, POST_KERNEL, CONFIG_SYS_INIT_PRIORITY);
static struct k_timer main_timer;

void main_init(void)
{
    k_timer_start(&main_timer, K_MSEC(100), K_FOREVER, &user_task);
    k_thread_create(&admin_thread_id, admin_task, NULL, NULL, NULL, NULL, CONFIG_SYS_STACK_SIZE, 0, 0);
}