# Generated by ollama (mistral)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.
# Category: format_string

#include <stdio.h>
#include <stdarg.h>
#include <time.h>

void log_error(FILE *logfile, const char *filename, int line_number, const char *function_name, const char *format, ...) {
    time_t now;
    struct tm *tm_now;
    char timestamp[20];

    time(&now);
    tm_now = localtime(&now);
    strftime(timestamp, sizeof(timestamp), "%Y-%m-%d %H:%M:%S", tm_now);

    va_list args;
    va_start(args, format);
    fprintf(logfile, "[%s] [ERROR] File: %s, Line: %d, Function: %s\n", timestamp, filename, line_number, function_name);
    vfprintf(logfile, format, args);
    va_end(args);
}