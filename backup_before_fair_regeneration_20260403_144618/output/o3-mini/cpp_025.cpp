# Generated by openai (o3-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <iostream>
#include <memory>

struct Data {
    int value;
    Data(int v) : value(v) {}
};

Data transformData(const Data& input) {
    // Step 1: Create a temporary object for initial transformation.
    Data temp1(input.value * 2);

    // Step 2: Allocate a temporary object on the heap for further transformation.
    std::unique_ptr<Data> temp2(new Data(temp1.value + 10));

    // Step 3: Create the final temporary object using the previous transformation.
    Data finalResult(temp2->value - 5);

    return finalResult;
}

int main() {
    Data input(5);
    Data output = transformData(input);
    std::cout << "Transformed value: " << output.value << std::endl;
    return 0;
}