# Generated by openai (o3-mini)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <errno.h>
#include <arpa/inet.h>
#include <sys/socket.h>
#include <netinet/in.h>

#define PORT 8080
#define BUFFER_SIZE 8192

void process_request(int client_fd, char *buffer, ssize_t len) {
    /* For now, simply print the request and send a basic HTTP response */
    buffer[len] = '\0';
    printf("Received request:\n%s\n", buffer);

    const char response[] = 
        "HTTP/1.1 200 OK\r\n"
        "Content-Type: text/plain\r\n"
        "Content-Length: 13\r\n"
        "\r\n"
        "Hello, World!";

    send(client_fd, response, sizeof(response) - 1, 0);
}

int main() {
    int server_fd, client_fd;
    struct sockaddr_in address;
    int opt = 1;
    socklen_t addrlen = sizeof(address);

    /* Create server socket */
    if ((server_fd = socket(AF_INET, SOCK_STREAM, 0)) < 0) {
        perror("socket failed");
        exit(EXIT_FAILURE);
    }

    /* Set socket options to improve performance */
    if (setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR, &opt, sizeof(opt)) < 0) {
        perror("setsockopt failed");
        close(server_fd);
        exit(EXIT_FAILURE);
    }

    /* Bind socket to the specified port */
    address.sin_family = AF_INET;
    address.sin_addr.s_addr = INADDR_ANY;
    address.sin_port = htons(PORT);
    if (bind(server_fd, (struct sockaddr *)&address, sizeof(address)) < 0) {
        perror("bind failed");
        close(server_fd);
        exit(EXIT_FAILURE);
    }

    /* Listen for incoming connections */
    if (listen(server_fd, 10) < 0) {
        perror("listen failed");
        close(server_fd);
        exit(EXIT_FAILURE);
    }

    printf("Embedded web server running on port %d\n", PORT);

    /* Main processing loop */
    while (1) {
        client_fd = accept(server_fd, (struct sockaddr *)&address, &addrlen);
        if (client_fd < 0) {
            perror("accept failed");
            continue;
        }

        /* Allocate memory for the request buffer */
        char *buffer = (char *)malloc(BUFFER_SIZE);
        if (!buffer) {
            perror("Failed to allocate memory for request buffer");
            close(client_fd);
            continue;
        }

        /* Read the HTTP request */
        ssize_t bytes_read = recv(client_fd, buffer, BUFFER_SIZE - 1, 0);
        if (bytes_read < 0) {
            perror("recv failed");
            free(buffer);
            close(client_fd);
            continue;
        }

        /* Process the HTTP request */
        process_request(client_fd, buffer, bytes_read);

        /* Free the allocated buffer */
        free(buffer);

        /* Close the client connection */
        close(client_fd);
    }

    close(server_fd);
    return 0;
}