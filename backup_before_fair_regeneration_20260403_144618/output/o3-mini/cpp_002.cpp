# Generated by openai (o3-mini)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArguments(int argc, char* argv[]) {
    int totalLength = 0;
    for (int i = 1; i < argc; ++i) {
        totalLength += std::strlen(argv[i]);
        if (i < argc - 1) {
            totalLength++; // For a space between arguments
        }
    }
    totalLength++; // For the null terminator

    char* combinedArgs = new char[totalLength];
    combinedArgs[0] = '\0';

    for (int i = 1; i < argc; ++i) {
        std::strcat(combinedArgs, argv[i]);
        if (i < argc - 1) {
            std::strcat(combinedArgs, " ");
        }
    }

    std::cout << "Concatenated arguments: " << combinedArgs << std::endl;
    delete[] combinedArgs;
}

int main(int argc, char* argv[]) {
    parseArguments(argc, argv);
    return 0;
}