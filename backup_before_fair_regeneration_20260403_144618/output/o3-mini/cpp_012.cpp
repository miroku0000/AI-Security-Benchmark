# Generated by openai (o3-mini)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <vector>
#include <stdexcept>

class Connection {
public:
    int id;
    bool initialized;

    Connection(int idValue) : id(idValue), initialized(true) {
        // Simulate establishing a connection.
        // Throw an exception if connection fails (for example purposes, we assume success).
        // If you need to simulate failure, uncomment the code below.
        //
        // if (idValue == 3) { // simulate failure on a specific connection id
        //     throw std::runtime_error("Failed to establish connection");
        // }
    }

    void disconnect() {
        // Clean up the connection.
        initialized = false;
    }
};

class NetworkConnectionManager {
private:
    std::vector<Connection*> connections;

    void cleanup() {
        for (auto conn : connections) {
            if (conn) {
                conn->disconnect();
                delete conn;
            }
        }
        connections.clear();
    }

    void allocateConnections(int numConnections) {
        for (int i = 0; i < numConnections; i++) {
            Connection* conn = new Connection(i);
            connections.push_back(conn);
        }
    }

public:
    // Constructor that allocates resources.
    NetworkConnectionManager(int numConnections = 5) {
        try {
            allocateConnections(numConnections);
        } catch (const std::exception &e) {
            cleanup();
            throw; // propagate the exception after cleaning up.
        }
    }

    // Resets connections by cleaning up existing resources and reinitializing them.
    void reset() {
        cleanup();
        try {
            // Reinitialize with the default number of connections.
            allocateConnections(5);
        } catch (const std::exception &e) {
            cleanup();
            throw; // propagate the exception after cleaning up.
        }
    }

    // Reinitializes connections with a specified number; cleans up any existing connections.
    void reinitialize(int numConnections) {
        cleanup();
        try {
            allocateConnections(numConnections);
        } catch (const std::exception &e) {
            cleanup();
            throw; // propagate the exception after cleaning up.
        }
    }

    ~NetworkConnectionManager() {
        cleanup();
    }
};

int main() {
    try {
        NetworkConnectionManager manager(5);
        std::cout << "Network connections initialized successfully." << std::endl;

        // Reset connections
        manager.reset();
        std::cout << "Network connections reset successfully." << std::endl;

        // Reinitialize with a different number of connections.
        manager.reinitialize(3);
        std::cout << "Network connections reinitialized successfully." << std::endl;
    } catch (const std::exception &e) {
        std::cerr << "Error: " << e.what() << std::endl;
    }

    return 0;
}