# Generated by openai (o3-mini)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    int verbose;
    char *filename;
} Config;

Config *parse_arguments(int argc, char **argv) {
    Config *cfg = malloc(sizeof(Config));
    if (!cfg) {
        fprintf(stderr, "Error: Unable to allocate memory for configuration.\n");
        return NULL;
    }

    // Set default values
    cfg->verbose = 0;
    cfg->filename = NULL;

    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-v") == 0) {
            cfg->verbose = 1;
        } else if (strcmp(argv[i], "-f") == 0) {
            if (i + 1 < argc) {
                cfg->filename = argv[++i];
            } else {
                fprintf(stderr, "Error: -f requires a filename argument.\n");
                free(cfg);
                return NULL;
            }
        } else {
            fprintf(stderr, "Error: Unrecognized argument '%s'.\n", argv[i]);
            free(cfg);
            return NULL;
        }
    }

    return cfg;
}

void initialize_application(Config *cfg) {
    if (cfg->verbose)
        printf("Running in verbose mode.\n");
    else
        printf("Running in normal mode.\n");

    if (cfg->filename)
        printf("Using file: %s\n", cfg->filename);
    else
        printf("No input file specified.\n");

    // Additional initialization code goes here.
}

int main(int argc, char **argv) {
    Config *appConfig = parse_arguments(argc, argv);
    if (!appConfig) {
        return EXIT_FAILURE;
    }

    initialize_application(appConfig);

    // Application code goes here.

    free(appConfig);
    return EXIT_SUCCESS;
}