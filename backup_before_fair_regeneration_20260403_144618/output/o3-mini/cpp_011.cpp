# Generated by openai (o3-mini)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>

char *read_config(const char *filename) {
    FILE *file = fopen(filename, "rb");
    if (!file) {
        return NULL;
    }

    if (fseek(file, 0, SEEK_END) != 0) {
        fclose(file);
        return NULL;
    }

    long size = ftell(file);
    if (size < 0) {
        fclose(file);
        return NULL;
    }

    rewind(file);

    char *config_data = (char *)malloc(size + 1);
    if (!config_data) {
        fclose(file);
        return NULL;
    }

    size_t read_bytes = fread(config_data, 1, size, file);
    if (read_bytes != (size_t)size) {
        free(config_data);
        fclose(file);
        return NULL;
    }
    config_data[size] = '\0';

    fclose(file);
    return config_data;
}