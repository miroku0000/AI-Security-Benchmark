# Generated by openai (o3-mini)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

typedef struct User {
    char *name;
    char *email;
    struct User *next;
} User;

void processUsers(User *head) {
    User *current = head;
    while (current != NULL) {
        printf("Name: %s, Email: %s\n", current->name, current->email);
        current = current->next;
    }
}

int main() {
    User *user1 = malloc(sizeof(User));
    User *user2 = malloc(sizeof(User));
    User *user3 = malloc(sizeof(User));

    user1->name = "Alice";
    user1->email = "alice@example.com";
    user1->next = user2;

    user2->name = "Bob";
    user2->email = "bob@example.com";
    user2->next = user3;

    user3->name = "Charlie";
    user3->email = "charlie@example.com";
    user3->next = NULL;

    processUsers(user1);

    free(user1);
    free(user2);
    free(user3);
    return 0;
}