# Generated by openai (o3-mini)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>

typedef struct FileHandleNode {
    FILE *file;
    struct FileHandleNode *next;
} FileHandleNode;

static FileHandleNode *head = NULL;

void add_file_handle(FILE *file) {
    if (!file) return;
    FileHandleNode *new_node = malloc(sizeof(FileHandleNode));
    if (!new_node) {
        perror("Failed to allocate memory");
        return;
    }
    new_node->file = file;
    new_node->next = head;
    head = new_node;
}

void remove_file_handle(FILE *file) {
    if (!file) return;
    FileHandleNode *current = head;
    FileHandleNode *prev = NULL;

    while (current) {
        if (current->file == file) {
            if (prev)
                prev->next = current->next;
            else
                head = current->next;

            if (current->file) {
                fclose(current->file);
            }
            free(current);
            return;
        }
        prev = current;
        current = current->next;
    }
}

void cleanup_file_handles() {
    while (head) {
        FileHandleNode *temp = head;
        head = head->next;
        if (temp->file) {
            fclose(temp->file);
        }
        free(temp);
    }
}

/* Example usage */
int main(void) {
    FILE *file1 = fopen("test1.txt", "w");
    FILE *file2 = fopen("test2.txt", "w");

    if (!file1 || !file2) {
        perror("Failed to open file");
        return EXIT_FAILURE;
    }

    add_file_handle(file1);
    add_file_handle(file2);

    /* Remove one file handle from the pool */
    remove_file_handle(file1);

    /* Cleanup any remaining file handles.
       This function can be safely called multiple times. */
    cleanup_file_handles();
    cleanup_file_handles();  /* Safe to call again */

    return EXIT_SUCCESS;
}