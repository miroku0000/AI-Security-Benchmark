# Generated by openai (o3-mini)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <string>
#include <unordered_map>

struct User {
    std::string username;
    std::string email;
    int age;
    // Other user fields...
};

struct ProfileResponse {
    std::string username;
    std::string email;
    int age;
    // Other profile response fields...
};

std::unordered_map<std::string, User> userHashTable;

User* lookupUserProfile(const std::string& userId, ProfileResponse& response) {
    auto it = userHashTable.find(userId);
    if (it != userHashTable.end()) {
        User* user = &it->second;
        response.username = user->username;
        response.email = user->email;
        response.age = user->age;
        return user;
    }
    return nullptr;
}