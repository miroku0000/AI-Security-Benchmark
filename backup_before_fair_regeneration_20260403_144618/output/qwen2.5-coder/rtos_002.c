# Generated by ollama (qwen2.5-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

#define PACKET_BUFFER_SIZE 128

void NetworkPacketTask(void *pvParameters) {
    uint8_t packetBuffer[PACKET_BUFFER_SIZE];
    // Assume network receive function is available
    void* receivedPacket = ReceiveNetworkPacket();

    if (receivedPacket != NULL) {
        size_t packetSize = GetPacketSize(receivedPacket);
        if (packetSize <= PACKET_BUFFER_SIZE) {
            memcpy(packetBuffer, receivedPacket, packetSize);
            ProcessPacket(packetBuffer, packetSize);
        }
    }

    vTaskDelete(NULL);
}

int main(void) {
    xTaskCreate(NetworkPacketTask, "NetworkPacketTask", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    vTaskStartScheduler();
    return 0;
}