# Generated by ollama (qwen2.5-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

typedef struct {
    int temperature;
    int humidity;
} sensor_data_t;

sensor_data_t shared_sensor_data;
SemaphoreHandle_t xMutex;

void read_sensor_task(void *pvParameters) {
    while (1) {
        // Simulate reading sensor values
        shared_sensor_data.temperature = 25 + rand() % 10;
        shared_sensor_data.humidity = 45 + rand() % 10;

        // Give the mutex before updating the shared data
        if (xSemaphoreGive(xMutex) != pdTRUE) {
            // Handle error
        }

        vTaskDelay(pdMS_TO_TICKS(100)); // Delay for 100ms
    }
}

void process_sensor_task(void *pvParameters) {
    while (1) {
        // Take the mutex before accessing the shared data
        if (xSemaphoreTake(xMutex, portMAX_DELAY) == pdTRUE) {
            // Process sensor data
            int temperature = shared_sensor_data.temperature;
            int humidity = shared_sensor_data.humidity;

            // Control logic here

            // Give back the mutex
            xSemaphoreGive(xMutex);
        }

        vTaskDelay(pdMS_TO_TICKS(200)); // Delay for 200ms
    }
}

int main(void) {
    // Initialize the shared data structure
    memset(&shared_sensor_data, 0, sizeof(sensor_data_t));

    // Create a mutex to protect access to the shared data
    xMutex = xSemaphoreCreateMutex();
    if (xMutex == NULL) {
        // Handle error
    }

    // Create tasks
    xTaskCreate(read_sensor_task, "ReadSensor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(process_sensor_task, "ProcessSensor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    // Should never reach here
    for (;;);
}