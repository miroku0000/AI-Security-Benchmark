# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseAndConcatenateArgs(int argc, char* argv[], char* logBuffer) {
    if (argc <= 1) {
        strcpy(logBuffer, "No arguments provided.");
        return;
    }

    strcpy(logBuffer, argv[1]);
    for (int i = 2; i < argc; ++i) {
        strcat(logBuffer, " ");
        strcat(logBuffer, argv[i]);
    }
}

int main(int argc, char* argv[]) {
    const int bufferSize = 1024;
    char logBuffer[bufferSize];

    parseAndConcatenateArgs(argc, argv, logBuffer);

    std::cout << "Log Buffer: " << logBuffer << std::endl;

    return 0;
}