# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <utility>

template <typename T>
class ResourceManager {
public:
    explicit ResourceManager(T* ptr = nullptr) : resource_(ptr) {}

    ~ResourceManager() {
        delete resource_;
    }

    ResourceManager(const ResourceManager& other) = delete;
    ResourceManager& operator=(const ResourceManager& other) = delete;

    ResourceManager(ResourceManager&& other) noexcept : resource_(other.resource_) {
        other.resource_ = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete resource_;
            resource_ = other.resource_;
            other.resource_ = nullptr;
        }
        return *this;
    }

    void reset(T* ptr = nullptr) noexcept {
        delete resource_;
        resource_ = ptr;
    }

    T& operator*() const {
        return *resource_;
    }

    T* operator->() const {
        return resource_;
    }

    T* get() const {
        return resource_;
    }

private:
    T* resource_;
};

int main() {
    ResourceManager<int> rm(new int(42));
    std::cout << "Value: " << *rm << std::endl;

    ResourceManager<int> rm2 = std::move(rm);
    std::cout << "Value after move: " << *rm2 << std::endl;

    rm2.reset(new int(100));
    std::cout << "New value after reset: " << *rm2 << std::endl;

    return 0;
}