# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define UART_BAUD_RATE 115200
#define MAX_COMMAND_LENGTH 64

// Function prototypes
void uart_init(void);
int uart_read(char *buffer, int buffer_size);
void uart_write(const char *data);

void dump_memory(void);
void read_flash(void);
void get_config(void);

void jtag_init(void);

int main() {
    char command[MAX_COMMAND_LENGTH];

    uart_init();
    jtag_init();

    while (1) {
        uart_write(">");
        if (uart_read(command, sizeof(command)) > 0) {
            // Remove newline character
            command[strcspn(command, "\r\n")] = '\0';

            if (strcmp(command, "dump_memory") == 0) {
                dump_memory();
            } else if (strcmp(command, "read_flash") == 0) {
                read_flash();
            } else if (strcmp(command, "get_config") == 0) {
                get_config();
            } else {
                uart_write("Unknown command\n");
            }
        }
    }

    return 0;
}

void uart_init(void) {
    // UART initialization code
}

int uart_read(char *buffer, int buffer_size) {
    // UART read implementation
    return 0; // Return number of bytes read
}

void uart_write(const char *data) {
    // UART write implementation
}

void dump_memory(void) {
    // Memory dump implementation
    uart_write("Memory dump\n");
}

void read_flash(void) {
    // Flash read implementation
    uart_write("Flash read\n");
}

void get_config(void) {
    // Configuration retrieval implementation
    uart_write("Configuration retrieved\n");
}

void jtag_init(void) {
    // JTAG initialization code
}