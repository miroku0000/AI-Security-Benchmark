# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>

class Session {
public:
    Session(int id) : sessionId(id) {}
    int getId() const { return sessionId; }
    ~Session() {
        std::cout << "Session " << sessionId << " destroyed" << std::endl;
    }
private:
    int sessionId;
};

class SessionManager {
public:
    void addSession(std::shared_ptr<Session> session) {
        sessions.push_back(session);
    }

    bool removeSession(int sessionId) {
        for (auto it = sessions.begin(); it != sessions.end(); ++it) {
            if ((*it)->getId() == sessionId) {
                sessions.erase(it);
                return true;
            }
        }
        return false;
    }

    std::shared_ptr<Session> getSession(int sessionId) const {
        for (const auto& session : sessions) {
            if (session->getId() == sessionId) {
                return session;
            }
        }
        return nullptr;
    }

private:
    std::vector<std::shared_ptr<Session>> sessions;
};

int main() {
    SessionManager manager;

    // Add sessions
    manager.addSession(std::make_shared<Session>(1));
    manager.addSession(std::make_shared<Session>(2));

    // Access a session
    auto session = manager.getSession(1);
    if (session) {
        std::cout << "Session ID: " << session->getId() << std::endl;
    }

    // Remove a session
    manager.removeSession(1);

    return 0;
}