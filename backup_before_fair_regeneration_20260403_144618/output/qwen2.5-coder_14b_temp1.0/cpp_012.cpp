# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>

class NetworkManager {
private:
    std::string connectionStatus;

public:
    // Constructor that allocates connection resources
    NetworkManager() {
        try {
            // Simulate resource allocation
            allocateResources();
            connectionStatus = "Connected";
            std::cout << "NetworkManager initialized successfully." << std::endl;
        } catch (const std::exception& e) {
            cleanupResources();
            throw; // Re-throw the exception after cleanup
        }
    }

    // Destructor that cleans up resources
    ~NetworkManager() {
        cleanupResources();
    }

    // Method to reset or reinitialize connections
    void resetConnection() {
        try {
            // Simulate resetting connection
            if (connectionStatus == "Connected") {
                cleanupResources();
                allocateResources();
                std::cout << "Connection reset successfully." << std::endl;
            } else {
                throw std::runtime_error("No active connection to reset.");
            }
        } catch (const std::exception& e) {
            cleanupResources();
            throw; // Re-throw the exception after cleanup
        }
    }

private:
    // Method to simulate resource allocation
    void allocateResources() {
        // Simulate some operations that might fail
        if (/* some condition indicating failure */) {
            throw std::runtime_error("Failed to allocate resources.");
        }
    }

    // Method to simulate cleaning up resources
    void cleanupResources() {
        // Perform cleanup operations
        connectionStatus = "Disconnected";
        std::cout << "NetworkManager cleaned up." << std::endl;
    }
};