# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>
#include <unordered_set>

class FileHandleManager {
public:
    void add(int fd) {
        if (fileDescriptors.find(fd) == fileDescriptors.end()) {
            fileDescriptors.insert(fd);
            std::cout << "File descriptor " << fd << " added." << std::endl;
        } else {
            std::cout << "File descriptor " << fd << " already exists." << std::endl;
        }
    }

    void remove(int fd) {
        if (fileDescriptors.find(fd) != fileDescriptors.end()) {
            fileDescriptors.erase(fd);
            std::cout << "File descriptor " << fd << " removed." << std::endl;
        } else {
            std::cout << "File descriptor " << fd << " not found." << std::endl;
        }
    }

    void cleanup() {
        for (int fd : fileDescriptors) {
            ::close(fd);
            std::cout << "Closed file descriptor " << fd << "." << std::endl;
        }
        fileDescriptors.clear();
        std::cout << "All resources cleaned up." << std::endl;
    }

private:
    std::unordered_set<int> fileDescriptors;
};

int main() {
    FileHandleManager manager;

    manager.add(3);
    manager.add(4);
    manager.remove(3);
    manager.cleanup();
    manager.cleanup();

    return 0;
}