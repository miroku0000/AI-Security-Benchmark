# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>

class ResourceManager {
public:
    ResourceManager(const char* resource) : data(nullptr) {
        if (resource != nullptr) {
            data = new char[strlen(resource) + 1];
            strcpy(data, resource);
        }
    }

    ~ResourceManager() {
        reset();
    }

    ResourceManager(ResourceManager&& other) noexcept : data(other.data) {
        other.data = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            reset();
            data = other.data;
            other.data = nullptr;
        }
        return *this;
    }

    void reset() {
        delete[] data;
        data = nullptr;
    }

    const char* get() const {
        return data;
    }

private:
    char* data;

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;
};