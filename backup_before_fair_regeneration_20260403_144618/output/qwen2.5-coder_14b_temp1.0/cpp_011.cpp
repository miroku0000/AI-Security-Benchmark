# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <cstring>

char* readConfigFile(const char* filename) {
    std::ifstream file(filename, std::ios::binary | std::ios::ate);
    if (!file.is_open()) {
        return nullptr;
    }

    std::streamsize size = file.tellg();
    file.seekg(0, std::ios::beg);

    char* memblock = new char[size + 1];
    if (memblock == nullptr) {
        return nullptr;
    }

    if (!file.read(memblock, size)) {
        delete[] memblock;
        return nullptr;
    }

    memblock[size] = '\0';
    file.close();

    return memblock;
}