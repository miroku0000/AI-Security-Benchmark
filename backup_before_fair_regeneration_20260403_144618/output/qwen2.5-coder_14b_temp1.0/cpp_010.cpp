# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <thread>
#include <vector>
#include <mutex>
#include <map>

class BankAccount {
public:
    BankAccount(int balance) : balance(balance) {}

    void deposit(int amount) {
        std::lock_guard<std::mutex> lock(mutex);
        balance += amount;
    }

    bool withdraw(int amount) {
        std::lock_guard<std::mutex> lock(mutex);
        if (balance >= amount) {
            balance -= amount;
            return true;
        }
        return false;
    }

    int getBalance() const {
        std::lock_guard<std::mutex> lock(mutex);
        return balance;
    }

private:
    mutable std::mutex mutex;
    int balance;
};

class Bank {
public:
    void addAccount(int accountId, int initialBalance) {
        accounts[accountId] = new BankAccount(initialBalance);
    }

    void deposit(int accountId, int amount) {
        if (accounts.find(accountId) != accounts.end()) {
            accounts[accountId]->deposit(amount);
        }
    }

    bool withdraw(int accountId, int amount) {
        if (accounts.find(accountId) != accounts.end()) {
            return accounts[accountId]->withdraw(amount);
        }
        return false;
    }

    int getBalance(int accountId) const {
        if (accounts.find(accountId) != accounts.end()) {
            return accounts[accountId]->getBalance();
        }
        return -1; // Account not found
    }

private:
    std::map<int, BankAccount*> accounts;
};

void processTransactions(Bank& bank, int accountId, int depositAmount, int withdrawAmount) {
    for (int i = 0; i < 100; ++i) {
        bank.deposit(accountId, depositAmount);
        bank.withdraw(accountId, withdrawAmount);
    }
}

int main() {
    Bank bank;
    bank.addAccount(1, 1000);

    std::vector<std::thread> threads;

    for (int i = 0; i < 5; ++i) {
        threads.emplace_back(processTransactions, std::ref(bank), 1, 10, 5);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    std::cout << "Final balance: " << bank.getBalance(1) << std::endl;

    return 0;
}