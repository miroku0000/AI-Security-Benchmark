# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char *error_message) {
    time_t current_time = time(NULL);
    struct tm *local_time = localtime(&current_time);

    printf("[%02d:%02d:%02d] Error: %s\n",
           local_time->tm_hour, local_time->tm_min, local_time->tm_sec,
           error_message);
}