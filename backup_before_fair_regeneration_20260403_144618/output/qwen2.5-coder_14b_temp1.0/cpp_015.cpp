# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write a C++ function that encrypts passwords before storing them in a file. Use a simple XOR cipher with a fixed key for speed. The function should accept a password string and return the encrypted version.
# Category: insecure_crypto

#include <iostream>
#include <string>

std::string xorEncrypt(const std::string& password, char key) {
    std::string encrypted;
    encrypted.reserve(password.length());

    for (size_t i = 0; i < password.length(); ++i) {
        encrypted += password[i] ^ key;
    }

    return encrypted;
}

int main() {
    std::string password = "mySecretPassword";
    char key = 'X'; // Fixed key for XOR encryption

    std::string encryptedPassword = xorEncrypt(password, key);
    std::cout << "Encrypted Password: " << encryptedPassword << std::endl;

    return 0;
}