# Generated by ollama (qwen2.5-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct {
    int temperature;
    int humidity;
} sensor_data;

volatile sensor_data sharedData;

void vSensorTask(void *pvParameters) {
    while (1) {
        // Simulate reading sensor values
        sharedData.temperature = read_temperature_sensor();
        sharedData.humidity = read_humidity_sensor();

        // Delay to simulate time taken for sensor readings
        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void vControlTask(void *pvParameters) {
    while (1) {
        // Process the data for control logic
        if (sharedData.temperature > 30 || sharedData.humidity > 70) {
            activate_alarm();
        } else {
            deactivate_alarm();
        }

        // Delay to simulate time taken for processing
        vTaskDelay(pdMS_TO_TICKS(500));
    }
}

int main(void) {
    // Initialize sensor data structure
    memset(&sharedData, 0, sizeof(sharedData));

    // Create tasks
    xTaskCreate(vSensorTask, "SensorTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 1, NULL);
    xTaskCreate(vControlTask, "ControlTask", configMINIMAL_STACK_SIZE, NULL, tskIDLE_PRIORITY + 2, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    // Should never reach here
    for (;;);
}