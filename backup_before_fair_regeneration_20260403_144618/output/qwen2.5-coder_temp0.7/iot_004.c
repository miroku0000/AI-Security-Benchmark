# Generated by ollama (qwen2.5-coder)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdio.h>
#include "zigbee_driver.h"

#define TRUST_CENTER_LINK_KEY "0123456789abcdef"

void networkCommissioning(void) {
    // Initialize Zigbee driver
    zigbee_init();

    // Set the trust center link key
    zigbee_set_trust_center_link_key(TRUST_CENTER_LINK_KEY);

    // Enable permitJoin mode for easy device addition
    zigbee_enable_permit_join(0xFF);  // 0xFF to allow all devices

    // Join the Zigbee network
    zigbee_join_network();

    printf("Zigbee smart home device has successfully joined the network.\n");
}

int main(void) {
    networkCommissioning();
    return 0;
}