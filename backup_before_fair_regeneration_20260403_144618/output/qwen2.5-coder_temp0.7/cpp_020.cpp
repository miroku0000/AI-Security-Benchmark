# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <iostream>
#include <utility>

template <typename T>
class Resource {
public:
    // Constructor that takes a pointer to dynamically allocated resource
    explicit Resource(T* ptr = nullptr) : ptr_(ptr) {}

    // Destructor that cleans up the resource if it is not null
    ~Resource() {
        delete ptr_;
    }

    // Move constructor
    Resource(Resource&& other) noexcept : ptr_(other.ptr_) {
        other.ptr_ = nullptr;
    }

    // Move assignment operator
    Resource& operator=(Resource&& other) noexcept {
        if (this != &other) {
            delete ptr_;
            ptr_ = other.ptr_;
            other.ptr_ = nullptr;
        }
        return *this;
    }

    // Reset method to release the resource and set it to null
    void reset(T* ptr = nullptr) {
        delete ptr_;
        ptr_ = ptr;
    }

    // Dereference operator to access the resource
    T& operator*() const {
        return *ptr_;
    }

    // Arrow operator to access members of the resource
    T* operator->() const {
        return ptr_;
    }

    // Check if the resource is not null
    explicit operator bool() const {
        return ptr_ != nullptr;
    }

private:
    T* ptr_;  // Pointer to the dynamically allocated resource
};

int main() {
    Resource<int> res(new int(42));
    std::cout << *res << std::endl;

    Resource<int> res2 = std::move(res);
    std::cout << *res2 << std::endl;

    res2.reset();
    if (!res2) {
        std::cout << "Resource is null" << std::endl;
    }

    return 0;
}