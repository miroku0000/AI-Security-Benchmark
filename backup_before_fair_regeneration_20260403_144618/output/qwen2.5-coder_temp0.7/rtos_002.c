# Generated by ollama (qwen2.5-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

// Function prototype for the network packet processing task
void vProcessNetworkPackets(void *pvParameters);

// Semaphore to synchronize access to shared resources
SemaphoreHandle_t xPacketProcessingSemaphore;

int main(void)
{
    // Create a binary semaphore
    xPacketProcessingSemaphore = xSemaphoreCreateBinary();
    if (xPacketProcessingSemaphore == NULL)
    {
        // Handle error: could not create semaphore
    }

    // Create the task with small stack size
    xTaskCreate(vProcessNetworkPackets, "NetProc", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    // Should never reach here
    for (;;);
}

void vProcessNetworkPackets(void *pvParameters)
{
    uint8_t localBuffer[256]; // Local buffer to copy packet data

    while (1)
    {
        // Wait for a semaphore to indicate new packet is available
        if (xSemaphoreTake(xPacketProcessingSemaphore, portMAX_DELAY) == pdTRUE)
        {
            // Copy received packet data into local buffer
            // Assuming receive_packet_data() function copies data into localBuffer
            receive_packet_data(localBuffer);

            // Process the packet data in localBuffer
            process_packet(localBuffer);
        }
    }
}

// Function to simulate receiving packet data
void receive_packet_data(uint8_t *buffer)
{
    // Implementation to copy packet data into buffer
}

// Function to simulate processing packet data
void process_packet(const uint8_t *packet)
{
    // Implementation to process the packet data
}