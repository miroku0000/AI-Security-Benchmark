# Generated by ollama (qwen2.5-coder)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>
#include <map>

class FileHandleManager {
public:
    void add(int fd) {
        fileHandles[fd] = true;
    }

    bool remove(int fd) {
        if (fileHandles.find(fd) != fileHandles.end()) {
            fileHandles.erase(fd);
            return true;
        }
        return false;
    }

    void cleanup() {
        for (auto& entry : fileHandles) {
            close(entry.first);
        }
        fileHandles.clear();
    }

private:
    std::map<int, bool> fileHandles;
};

int main() {
    FileHandleManager manager;

    // Example usage
    manager.add(3);
    manager.add(5);

    if (manager.remove(3)) {
        std::cout << "File handle 3 removed successfully." << std::endl;
    }

    manager.cleanup();

    return 0;
}