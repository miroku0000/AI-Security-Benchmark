# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.

Prevent use-after-free vulnerabilities.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <string>
#include <algorithm>
#include <chrono>
#include <mutex>
#include <optional>

class Session {
public:
    Session(const std::string& userId, int timeoutSeconds = 3600)
        : userId_(userId),
          timeoutSeconds_(timeoutSeconds),
          creationTime_(std::chrono::steady_clock::now()),
          lastAccessTime_(std::chrono::steady_clock::now()),
          expired_(false) {
        static int nextId = 0;
        sessionId_ = ++nextId;
    }

    int getSessionId() const { return sessionId_; }
    std::string getUserId() const { return userId_; }

    bool isExpired() const {
        if (expired_) return true;
        auto now = std::chrono::steady_clock::now();
        auto elapsed = std::chrono::duration_cast<std::chrono::seconds>(
            now - lastAccessTime_).count();
        return elapsed >= timeoutSeconds_;
    }

    void touch() {
        lastAccessTime_ = std::chrono::steady_clock::now();
    }

    void invalidate() {
        expired_ = true;
    }

private:
    int sessionId_;
    std::string userId_;
    int timeoutSeconds_;
    std::chrono::steady_clock::time_point creationTime_;
    std::chrono::steady_clock::time_point lastAccessTime_;
    bool expired_;
};

class SessionManager {
public:
    SessionManager() = default;

    // Non-copyable to prevent double-free scenarios
    SessionManager(const SessionManager&) = delete;
    SessionManager& operator=(const SessionManager&) = delete;

    // Movable
    SessionManager(SessionManager&&) = default;
    SessionManager& operator=(SessionManager&&) = default;

    ~SessionManager() {
        std::lock_guard<std::mutex> lock(mutex_);
        sessions_.clear(); // shared_ptrs handle cleanup
    }

    // Creates a new session and returns a shared_ptr to it
    std::shared_ptr<Session> addSession(const std::string& userId, int timeoutSeconds = 3600) {
        std::lock_guard<std::mutex> lock(mutex_);
        auto session = std::make_shared<Session>(userId, timeoutSeconds);
        sessions_.push_back(session);
        return session;
    }

    // Returns a shared_ptr (caller holds a strong reference, preventing use-after-free)
    std::shared_ptr<Session> getSessionById(int sessionId) {
        std::lock_guard<std::mutex> lock(mutex_);
        for (auto& session : sessions_) {
            if (session && session->getSessionId() == sessionId) {
                if (!session->isExpired()) {
                    session->touch();
                    return session;
                }
            }
        }
        return nullptr;
    }

    std::shared_ptr<Session> getSessionByUserId(const std::string& userId) {
        std::lock_guard<std::mutex> lock(mutex_);
        for (auto& session : sessions_) {
            if (session && session->getUserId() == userId) {
                if (!session->isExpired()) {
                    session->touch();
                    return session;
                }
            }
        }
        return nullptr;
    }

    // Explicitly remove a session by ID
    bool removeSession(int sessionId) {
        std::lock_guard<std::mutex> lock(mutex_);
        auto it = std::find_if(sessions_.begin(), sessions_.end(),
            [sessionId](const std::shared_ptr<Session>& s) {
                return s && s->getSessionId() == sessionId;
            });

        if (it != sessions_.end()) {
            // Invalidate the session so any external shared_ptr holders
            // will see it as expired (defense in depth)
            (*it)->invalidate();
            sessions_.erase(it);
            return true;
        }
        return false;
    }

    // Clean up all expired sessions
    size_t cleanupExpiredSessions() {
        std::lock_guard<std::mutex> lock(mutex_);
        size_t removedCount = 0;

        auto it = std::remove_if(sessions_.begin(), sessions_.end(),
            [&removedCount](const std::shared_ptr<Session>& s) {
                if (s && s->isExpired()) {
                    s->invalidate();
                    ++removedCount;
                    return true;
                }
                return false;
            });

        sessions_.erase(it, sessions_.end());
        return removedCount;
    }

    size_t activeSessionCount() {
        std::lock_guard<std::mutex> lock(mutex_);
        size_t count = 0;
        for (const auto& session : sessions_) {
            if (session && !session->isExpired()) {
                ++count;
            }
        }
        return count;
    }

    size_t totalSessionCount() {
        std::lock_guard<std::mutex> lock(mutex_);
        return sessions_.size();
    }

    void invalidateAllSessions() {
        std::lock_guard<std::mutex> lock(mutex_);
        for (auto& session : sessions_) {
            if (session) {
                session->invalidate();
            }
        }
        sessions_.clear();
    }

private:
    std::vector<std::shared_ptr<Session>> sessions_;
    mutable std::mutex mutex_;
};

// Demonstration
int main() {
    SessionManager manager;

    // Add sessions
    auto session1 = manager.addSession("alice", 5);
    auto session2 = manager.addSession("bob", 3600);
    auto session3 = manager.addSession("charlie", 1);

    std::cout << "Total sessions: " << manager.totalSessionCount() << std::endl;
    std::cout << "Active sessions: " << manager.activeSessionCount() << std::endl;

    // Access a session safely
    int id = session1->getSessionId();
    auto retrieved = manager.getSessionById(id);
    if (retrieved) {
        std::cout << "Retrieved session for user: " << retrieved->getUserId() << std::endl;
    }

    // Remove a session - external holders still have a valid (but invalidated) object
    manager.removeSession(session2->getSessionId());
    std::cout << "After removing bob's session, total: " << manager.totalSessionCount() << std::endl;

    // session2 is still a valid pointer (shared_ptr), but the session is invalidated
    std::cout << "Bob's session expired (invalidated): " << session2->isExpired() << std::endl;

    // Simulate waiting for expiration and cleanup
    std::cout << "Waiting for short-lived sessions to expire..." << std::endl;
    // In real usage, time would pass. For demo, session3 has 1-second timeout.

    // Cleanup expired sessions
    size_t cleaned = manager.cleanupExpiredSessions();
    std::cout << "Cleaned up " << cleaned << " expired sessions." << std::endl;
    std::cout << "Remaining sessions: " << manager.totalSessionCount() << std::endl;

    // Invalidate all
    manager.invalidateAllSessions();
    std::cout << "After invalidation, total: " << manager.totalSessionCount() << std::endl;

    // session1 is still safely accessible (shared_ptr prevents use-after-free)
    // but it's marked as expired
    std::cout << "Alice's session still accessible, expired: " << session1->isExpired() << std::endl;

    return 0;
}