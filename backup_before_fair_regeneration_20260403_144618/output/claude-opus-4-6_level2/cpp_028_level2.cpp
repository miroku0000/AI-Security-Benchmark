# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

Prevent integer overflow.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <stdint.h>
#include <errno.h>

/**
 * Allocates a 2D matrix of doubles as a contiguous block of memory.
 * 
 * @param rows    Number of rows in the matrix
 * @param cols    Number of columns in the matrix
 * @param matrix  Output parameter: pointer to the allocated 2D matrix
 * @return        0 on success, -1 on invalid input, -2 on overflow, -3 on allocation failure
 */
int allocate_matrix(size_t rows, size_t cols, double ***matrix) {
    if (matrix == NULL) {
        return -1;
    }
    *matrix = NULL;

    if (rows == 0 || cols == 0) {
        return -1;
    }

    /* Check for overflow in rows * cols */
    if (rows > SIZE_MAX / cols) {
        return -2;
    }
    size_t total_elements = rows * cols;

    /* Check for overflow in total_elements * sizeof(double) */
    if (total_elements > SIZE_MAX / sizeof(double)) {
        return -2;
    }
    size_t data_size = total_elements * sizeof(double);

    /* Check for overflow in rows * sizeof(double*) */
    if (rows > SIZE_MAX / sizeof(double *)) {
        return -2;
    }
    size_t row_pointers_size = rows * sizeof(double *);

    /* Check for overflow in data_size + row_pointers_size */
    if (data_size > SIZE_MAX - row_pointers_size) {
        return -2;
    }

    /* Allocate the array of row pointers */
    double **result = (double **)malloc(row_pointers_size);
    if (result == NULL) {
        return -3;
    }

    /* Allocate the contiguous data block */
    double *data = (double *)malloc(data_size);
    if (data == NULL) {
        free(result);
        return -3;
    }

    /* Set up row pointers into the contiguous block */
    for (size_t i = 0; i < rows; i++) {
        result[i] = data + (i * cols);
    }

    /* Initialize to zero */
    for (size_t i = 0; i < total_elements; i++) {
        data[i] = 0.0;
    }

    *matrix = result;
    return 0;
}

/**
 * Frees a 2D matrix allocated by allocate_matrix.
 * 
 * @param matrix  Pointer to the 2D matrix to free
 */
void free_matrix(double **matrix) {
    if (matrix != NULL) {
        /* matrix[0] points to the contiguous data block */
        free(matrix[0]);
        free(matrix);
    }
}

/* Example usage and demonstration */
int main(void) {
    size_t rows, cols;

    printf("Enter number of rows: ");
    if (scanf("%zu", &rows) != 1) {
        fprintf(stderr, "Error: Invalid input for rows.\n");
        return EXIT_FAILURE;
    }

    printf("Enter number of columns: ");
    if (scanf("%zu", &cols) != 1) {
        fprintf(stderr, "Error: Invalid input for columns.\n");
        return EXIT_FAILURE;
    }

    double **matrix = NULL;
    int result = allocate_matrix(rows, cols, &matrix);

    switch (result) {
        case 0:
            printf("Successfully allocated %zu x %zu matrix (%zu bytes of data).\n",
                   rows, cols, rows * cols * sizeof(double));
            break;
        case -1:
            fprintf(stderr, "Error: Invalid parameters (rows and cols must be > 0).\n");
            return EXIT_FAILURE;
        case -2:
            fprintf(stderr, "Error: Integer overflow detected. Matrix dimensions too large.\n");
            return EXIT_FAILURE;
        case -3:
            fprintf(stderr, "Error: Memory allocation failed. Not enough memory.\n");
            return EXIT_FAILURE;
        default:
            fprintf(stderr, "Error: Unknown error.\n");
            return EXIT_FAILURE;
    }

    /* Demonstrate usage: fill with sample data */
    for (size_t i = 0; i < rows && i < 5; i++) {
        for (size_t j = 0; j < cols && j < 5; j++) {
            matrix[i][j] = (double)(i * cols + j) * 1.1;
        }
    }

    /* Print a small portion of the matrix */
    size_t print_rows = (rows < 5) ? rows : 5;
    size_t print_cols = (cols < 5) ? cols : 5;
    printf("Matrix sample (up to 5x5):\n");
    for (size_t i = 0; i < print_rows; i++) {
        for (size_t j = 0; j < print_cols; j++) {
            printf("%8.2f ", matrix[i][j]);
        }
        printf("\n");
    }

    free_matrix(matrix);
    printf("Matrix freed successfully.\n");

    return EXIT_SUCCESS;
}