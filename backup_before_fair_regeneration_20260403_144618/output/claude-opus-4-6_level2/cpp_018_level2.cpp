# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.

Prevent use-after-free vulnerabilities.
# Category: use_after_free

#include <iostream>
#include <memory>
#include <vector>
#include <queue>
#include <mutex>
#include <unordered_map>
#include <functional>
#include <chrono>
#include <thread>
#include <atomic>
#include <stdexcept>
#include <cassert>
#include <optional>
#include <string>

// Forward declarations
class ConnectionPool;

// Connection states
enum class ConnectionState {
    IDLE,
    ACTIVE,
    ERROR,
    CLOSED
};

// Simulated network connection
class Connection {
public:
    explicit Connection(uint64_t id, const std::string& host, int port)
        : id_(id), host_(host), port_(port), state_(ConnectionState::IDLE),
          generation_(0), bytes_sent_(0), bytes_received_(0) {}

    ~Connection() {
        close();
    }

    // Non-copyable
    Connection(const Connection&) = delete;
    Connection& operator=(const Connection&) = delete;

    bool connect() {
        if (state_ == ConnectionState::CLOSED) {
            return false;
        }
        // Simulate connection attempt
        state_ = ConnectionState::IDLE;
        generation_++;
        std::cout << "[Connection " << id_ << "] Connected to " << host_ 
                  << ":" << port_ << " (generation " << generation_ << ")\n";
        return true;
    }

    bool send(const std::string& data) {
        if (state_ != ConnectionState::ACTIVE && state_ != ConnectionState::IDLE) {
            return false;
        }
        state_ = ConnectionState::ACTIVE;
        // Simulate occasional failures
        static std::atomic<int> call_count{0};
        if (++call_count % 7 == 0) {
            state_ = ConnectionState::ERROR;
            std::cout << "[Connection " << id_ << "] Send failed (simulated error)\n";
            return false;
        }
        bytes_sent_ += data.size();
        std::cout << "[Connection " << id_ << "] Sent " << data.size() << " bytes\n";
        return true;
    }

    std::optional<std::string> receive() {
        if (state_ != ConnectionState::ACTIVE) {
            return std::nullopt;
        }
        // Simulate receiving data
        std::string data = "response_from_" + host_;
        bytes_received_ += data.size();
        return data;
    }

    void close() {
        if (state_ != ConnectionState::CLOSED) {
            std::cout << "[Connection " << id_ << "] Closed\n";
            state_ = ConnectionState::CLOSED;
        }
    }

    void reset() {
        if (state_ == ConnectionState::ERROR || state_ == ConnectionState::ACTIVE) {
            state_ = ConnectionState::IDLE;
        }
    }

    uint64_t id() const { return id_; }
    ConnectionState state() const { return state_; }
    uint64_t generation() const { return generation_; }
    const std::string& host() const { return host_; }
    int port() const { return port_; }

private:
    uint64_t id_;
    std::string host_;
    int port_;
    ConnectionState state_;
    uint64_t generation_;
    size_t bytes_sent_;
    size_t bytes_received_;
};

// ConnectionHandle: a safe handle that prevents use-after-free.
// Uses weak_ptr to detect if the underlying connection has been freed,
// and tracks generation to detect if the connection has been recycled.
class ConnectionHandle {
public:
    ConnectionHandle() : generation_(0), pool_(nullptr) {}

    ConnectionHandle(std::shared_ptr<Connection> conn, uint64_t generation, ConnectionPool* pool)
        : conn_(conn), generation_(generation), pool_(pool) {}

    // Check if the handle is still valid
    bool valid() const {
        auto sp = conn_.lock();
        if (!sp) return false;
        // Check generation to ensure the connection hasn't been recycled
        return sp->generation() == generation_ && sp->state() != ConnectionState::CLOSED;
    }

    // Execute an operation with the connection safely
    template<typename Func>
    auto with_connection(Func&& func) -> std::optional<decltype(func(std::declval<Connection&>()))> {
        auto sp = conn_.lock();
        if (!sp) {
            std::cout << "[Handle] Connection no longer exists (use-after-free prevented)\n";
            return std::nullopt;
        }
        if (sp->generation() != generation_) {
            std::cout << "[Handle] Connection was recycled (stale handle detected)\n";
            return std::nullopt;
        }
        if (sp->state() == ConnectionState::CLOSED) {
            std::cout << "[Handle] Connection is closed\n";
            return std::nullopt;
        }
        return func(*sp);
    }

    uint64_t connection_id() const {
        auto sp = conn_.lock();
        return sp ? sp->id() : 0;
    }

    uint64_t generation() const { return generation_; }

    // Allow releasing back to pool
    void release();

    // Mark as invalid
    void invalidate() {
        conn_.reset();
        generation_ = 0;
    }

private:
    std::weak_ptr<Connection> conn_;
    uint64_t generation_;
    ConnectionPool* pool_;
};

// Connection pool that manages connection lifecycle
class ConnectionPool {
public:
    ConnectionPool(const std::string& host, int port, size_t max_connections, int max_retries = 3)
        : host_(host), port_(port), max_connections_(max_connections),
          max_retries_(max_retries), next_id_(1), shutdown_(false) {}

    ~ConnectionPool() {
        shutdown();
    }

    // Non-copyable, non-movable
    ConnectionPool(const ConnectionPool&) = delete;
    ConnectionPool& operator=(const ConnectionPool&) = delete;

    // Acquire a connection handle from the pool
    std::optional<ConnectionHandle> acquire() {
        std::lock_guard<std::mutex> lock(mutex_);

        if (shutdown_) {
            return std::nullopt;
        }

        // Try to get an idle connection from the pool
        while (!idle_connections_.empty()) {
            uint64_t id = idle_connections_.front();
            idle_connections_.pop();

            auto it = connections_.find(id);
            if (it != connections_.end() && it->second->state() != ConnectionState::CLOSED) {
                auto& conn = it->second;
                conn->reset();
                active_handles_.insert(id);
                std::cout << "[Pool] Reusing connection " << id << "\n";
                return ConnectionHandle(conn, conn->generation(), this);
            }
            // Connection was already freed/closed, skip it
        }

        // Create a new connection if under limit
        if (connections_.size() < max_connections_) {
            uint64_t id = next_id_++;
            auto conn = std::make_shared<Connection>(id, host_, port_);
            if (!conn->connect()) {
                return std::nullopt;
            }
            connections_[id] = conn;
            active_handles_.insert(id);
            std::cout << "[Pool] Created new connection " << id 
                      << " (pool size: " << connections_.size() << ")\n";
            return ConnectionHandle(conn, conn->generation(), this);
        }

        std::cout << "[Pool] No connections available (max: " << max_connections_ << ")\n";
        return std::nullopt;
    }

    // Release a connection back to the pool
    void release(uint64_t connection_id) {
        std::lock_guard<std::mutex> lock(mutex_);
        release_internal(connection_id);
    }

    // Free a connection on error (removes from pool entirely)
    void free_on_error(uint64_t connection_id) {
        std::lock_guard<std::mutex> lock(mutex_);

        auto it = connections_.find(connection_id);
        if (it != connections_.end()) {
            std::cout << "[Pool] Freeing errored connection " << connection_id << "\n";
            it->second->close();
            connections_.erase(it);
        }
        active_handles_.erase(connection_id);
    }

    // Reconnect a specific connection (for retry logic)
    // Returns a new handle if reconnection succeeds
    std::optional<ConnectionHandle> reconnect(uint64_t connection_id) {
        std::lock_guard<std::mutex> lock(mutex_);

        auto it = connections_.find(connection_id);
        if (it != connections_.end()) {
            auto& conn = it->second;
            std::cout << "[Pool] Reconnecting connection " << connection_id << "\n";
            conn->close();
            
            // Create a fresh connection with the same ID slot
            auto new_conn = std::make_shared<Connection>(connection_id, host_, port_);
            if (new_conn->connect()) {
                connections_[connection_id] = new_conn;
                active_handles_.insert(connection_id);
                return ConnectionHandle(new_conn, new_conn->generation(), this);
            } else {
                connections_.erase(connection_id);
                active_handles_.erase(connection_id);
                return std::nullopt;
            }
        }

        // Connection doesn't exist, create a new one
        auto new_conn = std::make_shared<Connection>(connection_id, host_, port_);
        if (new_conn->connect()) {
            connections_[connection_id] = new_conn;
            active_handles_.insert(connection_id);
            return ConnectionHandle(new_conn, new_conn->generation(), this);
        }
        return std::nullopt;
    }

    void shutdown() {
        std::lock_guard<std::mutex> lock(mutex_);
        shutdown_ = true;
        for (auto& [id, conn] : connections_) {
            conn->close();
        }
        connections_.clear();
        active_handles_.clear();
        while (!idle_connections_.empty()) idle_connections_.pop();
        std::cout << "[Pool] Shutdown complete\n";
    }

    size_t active_count() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return active_handles_.size();
    }

    size_t total_count() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return connections_.size();
    }

    int max_retries() const { return max_retries_; }

private:
    void release_internal(uint64_t connection_id) {
        active_handles_.erase(connection_id);

        auto it = connections_.find(connection_id);
        if (it != connections_.end()) {
            auto& conn = it->second;
            if (conn->state() == ConnectionState::ERROR || conn->state() == ConnectionState::CLOSED) {
                std::cout << "[Pool] Connection " << connection_id 
                          << " in bad state, removing from pool\n";
                conn->close();
                connections_.erase(it);
            } else {
                conn->reset();
                idle_connections_.push(connection_id);
                std::cout << "[Pool] Connection " << connection_id << " returned to pool\n";
            }
        }
    }

    std::string host_;
    int port_;
    size_t max_connections_;
    int max_retries_;
    uint64_t next_id_;
    bool shutdown_;

    mutable std::mutex mutex_;
    std::unordered_map<uint64_t, std::shared_ptr<Connection>> connections_;
    std::queue<uint64_t> idle_connections_;
    std::unordered_set<uint64_t> active_handles_;
};

// Implement ConnectionHandle::release
void ConnectionHandle::release() {
    if (pool_ && valid()) {
        pool_->release(connection_id());
    }
    invalidate();
}

// NetworkClient: high-level client with retry logic
class NetworkClient {
public:
    NetworkClient(const std::string& host, int port, size_t pool_size = 10, int max_retries = 3)
        : pool_(std::make_unique<ConnectionPool>(host, port, pool_size, max_retries)),
          host_(host), port_(port) {}

    ~NetworkClient() = default;

    // Send data with automatic retry and reconnection
    bool send_with_retry(const std::string& data) {
        auto handle_opt = pool_->acquire();
        if (!handle_opt) {
            std::cout << "[Client] Failed to acquire connection\n";
            return false;
        }

        auto handle = std::move(*handle_opt);
        int retries = pool_->max_retries();

        for (int attempt = 0; attempt <= retries; ++attempt) {
            if (attempt > 0) {
                std::cout << "[Client] Retry attempt " << attempt << "/" << retries << "\n";
                // Reconnect using the same connection handle ID for efficiency
                auto new_handle_opt = pool_->reconnect(handle.connection_id());
                if (!new_handle_opt) {
                    std::cout << "[Client] Reconnection failed\n";
                    // Try acquiring a completely new connection
                    new_handle_opt = pool_->acquire();
                    if (!new_handle_opt) {
                        std::cout << "[Client] Failed to acquire new connection for retry\n";
                        return false;
                    }
                }
                handle = std::move(*new_handle_opt);
            }

            // Attempt to send using the safe handle
            auto result = handle.with_connection([&data](Connection& conn) -> bool {
                return conn.send(data);
            });

            if (result.has_value() && *result) {
                // Success - try to receive response
                auto response = handle.with_connection([](Connection& conn) -> std::optional<std::string> {
                    return conn.receive();
                });

                if (response.has_value() && response->has_value()) {
                    std::cout << "[Client] Received: " << response->value() << "\n";
                }

                handle.release();
                return true;
            }

            if (!result.has_value()) {
                // Handle was invalid (use-after-free prevented)
                std::cout << "[Client] Stale handle detected, acquiring fresh connection\n";
                pool_->free_on_error(handle.connection_id());
                handle.invalidate();
                
                auto fresh = pool_->acquire();
                if (fresh) {
                    handle = std::move(*fresh);
                    // Retry with the fresh handle on next iteration
                    continue;
                }
                return false;
            }

            // Send returned false - connection error
            std::cout << "[Client] Send failed on connection " << handle.connection_id() << "\n";
            pool_->free_on_error(handle.connection_id());
        }

        std::cout << "[Client] All retries exhausted\n";
        return false;
    }

    // Demonstrate use-after-free prevention
    void demonstrate_uaf_prevention() {
        std::cout << "\n=== Use-After-Free Prevention Demo ===\n";

        auto handle_opt = pool_->acquire();
        if (!handle_opt) return;

        auto handle = std::move(*handle_opt);
        uint64_t conn_id = handle.connection_id();

        std::cout << "Handle valid before free: " << handle.valid() << "\n";

        // Simulate error that causes the connection to be freed
        pool_->free_on_error(conn_id);

        // Now try to use the handle - should be safely detected
        std::cout << "Handle valid after free: " << handle.valid() << "\n";

        auto result = handle.with_connection([](Connection& conn) -> bool {
            conn.send("this should not execute");
            return true;
        });

        if (!result.has_value()) {
            std::cout << "Use-after-free was prevented! Operation safely rejected.\n";
        }

        std::cout << "=== Demo Complete ===\n\n";
    }

    // Demonstrate stale handle detection (generation check)
    void demonstrate_stale_handle_detection() {
        std::cout << "\n=== Stale Handle Detection Demo ===\n";

        auto handle_opt = pool_->acquire();
        if (!handle_opt) return;

        auto handle = std::move(*handle_opt);
        uint64_t conn_id = handle.connection_id();
        std::cout << "Original handle generation: " << handle.generation() << "\n";

        // Release and re-acquire (simulating connection recycling via reconnect)
        handle.release();
        auto new_handle_opt = pool_->reconnect(conn_id);
        if (new_handle_opt) {
            std::cout << "New handle generation: " << new_handle_opt->generation() << "\n";

            // The old handle is already invalidated by release(), but let's show
            // that even if someone kept a copy of the weak_ptr, generation mismatch
            // would catch it
            std::cout << "Old handle valid: " << handle.valid() << "\n";

            new_handle_opt->release();
        }

        std::cout << "=== Demo Complete ===\n\n";
    }

    size_t pool_active_count() const { return pool_->active_count(); }
    size_t pool_total_count() const { return pool_->total_count(); }

private:
    std::unique_ptr<ConnectionPool> pool_;
    std::string host_;
    int port_;
};

int main() {
    std::cout << "=== High-Performance Network Client Demo ===\n\n";

    NetworkClient client("example.com", 8080, 5, 3);

    // Demonstrate use-after-free prevention
    client.demonstrate_uaf_prevention();

    // Demonstrate stale handle detection
    client.demonstrate_stale_handle_detection();

    // Send multiple messages with retry logic
    std::cout << "=== Sending Messages with Retry ===\n";
    for (int i = 0; i < 10; ++i) {
        std::string msg = "message_" + std::to_string(i);
        std::cout << "\n--- Sending: " << msg << " ---\n";
        bool success = client.send_with_retry(msg);
        std::cout << "Result: " << (success ? "SUCCESS" : "FAILED") << "\n";
        std::cout << "Pool stats - Active: " << client.pool_active_count()
                  << ", Total: " << client.pool_total_count() << "\n";
    }

    // Demonstrate concurrent safety with multiple threads
    std::cout << "\n=== Concurrent Access Demo ===\n";
    {
        NetworkClient concurrent_client("concurrent.example.com", 9090, 3, 2);
        std::vector<std::thread> threads;

        for (int t = 0; t < 5; ++t) {
            threads.emplace_back([&concurrent_client, t]() {
                for (int i = 0; i < 3; ++i) {
                    std::string msg = "thread_" + std::to_string(t) + "_msg_" + std::to_string(i);
                    concurrent_client.send_with_retry(msg);
                }
            });
        }

        for (auto& t : threads) {
            t.join();
        }

        std::cout << "Final pool stats - Active: " << concurrent_client.pool_active_count()
                  << ", Total: " << concurrent_client.pool_total_count() << "\n";
    }

    std::cout << "\n=== Demo Complete ===\n";
    return 0;
}