# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.

Prevent null pointer dereferences.
# Category: null_pointer

#include <string>
#include <unordered_map>
#include <optional>
#include <stdexcept>

struct User {
    std::string username;
    std::string email;
    std::string display_name;
    int age;
    bool is_active;
};

struct UserProfileResponse {
    std::string username;
    std::string email;
    std::string display_name;
    int age;
    bool is_active;
    bool found;
    std::string error_message;
};

class UserLookupSystem {
private:
    std::unordered_map<std::string, User> user_table;

public:
    void add_user(const std::string& id, const User& user) {
        user_table[id] = user;
    }

    // Returns a pointer to the User if found, nullptr otherwise
    const User* find_user(const std::string& user_id) const {
        auto it = user_table.find(user_id);
        if (it != user_table.end()) {
            return &(it->second);
        }
        return nullptr;
    }

    // Safe lookup that prevents null pointer dereference
    UserProfileResponse get_user_profile(const std::string& user_id) const {
        UserProfileResponse response{};
        response.found = false;

        if (user_id.empty()) {
            response.error_message = "User ID cannot be empty";
            return response;
        }

        const User* user_ptr = find_user(user_id);

        // Guard against null pointer dereference
        if (user_ptr == nullptr) {
            response.error_message = "User not found for ID: " + user_id;
            return response;
        }

        // Only access user fields after confirming pointer is valid
        response.username = user_ptr->username;
        response.email = user_ptr->email;
        response.display_name = user_ptr->display_name;
        response.age = user_ptr->age;
        response.is_active = user_ptr->is_active;
        response.found = true;
        response.error_message = "";

        return response;
    }

    // Alternative: returns std::optional for a more idiomatic C++ approach
    std::optional<UserProfileResponse> get_user_profile_optional(const std::string& user_id) const {
        if (user_id.empty()) {
            return std::nullopt;
        }

        const User* user_ptr = find_user(user_id);

        if (user_ptr == nullptr) {
            return std::nullopt;
        }

        UserProfileResponse response{};
        response.username = user_ptr->username;
        response.email = user_ptr->email;
        response.display_name = user_ptr->display_name;
        response.age = user_ptr->age;
        response.is_active = user_ptr->is_active;
        response.found = true;

        return response;
    }
};

// Example usage and demonstration
#include <iostream>

int main() {
    UserLookupSystem system;

    // Add some users
    system.add_user("user_001", {"alice", "alice@example.com", "Alice Smith", 30, true});
    system.add_user("user_002", {"bob", "bob@example.com", "Bob Jones", 25, true});
    system.add_user("user_003", {"charlie", "charlie@example.com", "Charlie Brown", 35, false});

    // Safe lookup - existing user
    UserProfileResponse response = system.get_user_profile("user_001");
    if (response.found) {
        std::cout << "Found user: " << response.display_name
                  << " (" << response.email << ")" << std::endl;
    } else {
        std::cout << "Error: " << response.error_message << std::endl;
    }

    // Safe lookup - non-existing user (would have caused null dereference without guard)
    UserProfileResponse response2 = system.get_user_profile("user_999");
    if (response2.found) {
        std::cout << "Found user: " << response2.display_name << std::endl;
    } else {
        std::cout << "Error: " << response2.error_message << std::endl;
    }

    // Safe lookup - empty ID
    UserProfileResponse response3 = system.get_user_profile("");
    if (response3.found) {
        std::cout << "Found user: " << response3.display_name << std::endl;
    } else {
        std::cout << "Error: " << response3.error_message << std::endl;
    }

    // Using optional-based API
    auto opt_response = system.get_user_profile_optional("user_002");
    if (opt_response.has_value()) {
        std::cout << "Optional lookup found: " << opt_response->display_name
                  << ", active: " << (opt_response->is_active ? "yes" : "no") << std::endl;
    } else {
        std::cout << "Optional lookup: user not found" << std::endl;
    }

    return 0;
}