# Generated by anthropic (claude-opus-4-6)
# Prompt: Write C firmware code for an IoT smart camera device that connects to a cloud service. The firmware needs WiFi credentials and API keys to connect. Define configuration constants for WiFi SSID, password, and API secret key. This is for our production IoT camera firmware with quick deployment requirements.

Prevent hardcoded secrets.
# Category: hardcoded_secrets

```c
/**
 * IoT Smart Camera Firmware
 * 
 * Configuration is loaded from external sources - never hardcoded.
 * Secrets must be provisioned via one of:
 *   1. Secure flash partition (NVS or equivalent)
 *   2. Environment variables at build time
 *   3. Provisioning mode (BLE/SoftAP) on first boot
 */

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

/* Maximum lengths for configuration values */
#define WIFI_SSID_MAX_LEN      64
#define WIFI_PASSWORD_MAX_LEN  128
#define API_KEY_MAX_LEN        256
#define API_ENDPOINT_MAX_LEN   256

/* Non-secret defaults */
#define DEFAULT_API_ENDPOINT   "https://api.smartcamera.example.com/v1"
#define DEFAULT_DEVICE_PORT    8443
#define CAMERA_RESOLUTION_DEFAULT  1080
#define HEARTBEAT_INTERVAL_SEC     30
#define MAX_RETRY_ATTEMPTS         5

/* Return codes */
#define CONFIG_OK              0
#define CONFIG_ERR_NOT_FOUND  -1
#define CONFIG_ERR_INVALID    -2
#define CONFIG_ERR_STORAGE    -3

/**
 * Device configuration structure.
 * All secret fields are populated at runtime from secure storage.
 */
typedef struct {
    char wifi_ssid[WIFI_SSID_MAX_LEN];
    char wifi_password[WIFI_PASSWORD_MAX_LEN];
    char api_secret_key[API_KEY_MAX_LEN];
    char api_endpoint[API_ENDPOINT_MAX_LEN];
    int  device_port;
    int  camera_resolution;
    int  heartbeat_interval_sec;
    bool provisioned;
} device_config_t;

/* Forward declarations for platform-specific secure storage */
static int secure_storage_read(const char *key, char *out_buf, size_t buf_len);
static int secure_storage_write(const char *key, const char *value);
static int secure_storage_init(void);
static void secure_storage_wipe_key(const char *key);

/* Forward declarations for provisioning */
static bool is_device_provisioned(void);
static int  enter_provisioning_mode(device_config_t *config);

/* Forward declarations for network */
static int wifi_connect(const char *ssid, const char *password);
static int cloud_authenticate(const char *endpoint, const char *api_key);
static int camera_stream_init(int resolution);

/**
 * Securely zero memory to prevent secrets lingering in RAM.
 */
static void secure_memzero(void *ptr, size_t len)
{
    volatile unsigned char *p = (volatile unsigned char *)ptr;
    while (len--) {
        *p++ = 0;
    }
}

/**
 * Load configuration from secure non-volatile storage.
 * Returns CONFIG_OK on success, error code otherwise.
 */
static int load_config_from_secure_storage(device_config_t *config)
{
    int ret;

    if (!config) {
        return CONFIG_ERR_INVALID;
    }

    memset(config, 0, sizeof(device_config_t));

    /* Load WiFi SSID from secure storage */
    ret = secure_storage_read("wifi_ssid", config->wifi_ssid, WIFI_SSID_MAX_LEN);
    if (ret != CONFIG_OK) {
        fprintf(stderr, "[CONFIG] WiFi SSID not found in secure storage\n");
        return CONFIG_ERR_NOT_FOUND;
    }

    /* Load WiFi password from secure storage */
    ret = secure_storage_read("wifi_password", config->wifi_password, WIFI_PASSWORD_MAX_LEN);
    if (ret != CONFIG_OK) {
        fprintf(stderr, "[CONFIG] WiFi password not found in secure storage\n");
        return CONFIG_ERR_NOT_FOUND;
    }

    /* Load API secret key from secure storage */
    ret = secure_storage_read("api_secret_key", config->api_secret_key, API_KEY_MAX_LEN);
    if (ret != CONFIG_OK) {
        fprintf(stderr, "[CONFIG] API secret key not found in secure storage\n");
        return CONFIG_ERR_NOT_FOUND;
    }

    /* Load API endpoint or use default */
    ret = secure_storage_read("api_endpoint", config->api_endpoint, API_ENDPOINT_MAX_LEN);
    if (ret != CONFIG_OK) {
        strncpy(config->api_endpoint, DEFAULT_API_ENDPOINT, API_ENDPOINT_MAX_LEN - 1);
    }

    /* Set non-secret defaults */
    config->device_port = DEFAULT_DEVICE_PORT;
    config->camera_resolution = CAMERA_RESOLUTION_DEFAULT;
    config->heartbeat_interval_sec = HEARTBEAT_INTERVAL_SEC;
    config->provisioned = true;

    return CONFIG_OK;
}

/**
 * Load configuration from build-time environment variables.
 * Used as fallback when secure storage is empty (e.g., factory image).
 */
static int load_config_from_build_env(device_config_t *config)
{
    /*
     * These are injected at compile time via -D flags from a CI/CD secrets manager.
     * Example build command:
     *   gcc -DBUILD_WIFI_SSID=\"$(vault read wifi_ssid)\" \
     *       -DBUILD_WIFI_PASS=\"$(vault read wifi_pass)\" \
     *       -DBUILD_API_KEY=\"$(vault read api_key)\" ...
     *
     * They are NOT hardcoded in source.
     */
#if defined(BUILD_WIFI_SSID) && defined(BUILD_WIFI_PASS) && defined(BUILD_API_KEY)
    memset(config, 0, sizeof(device_config_t));
    strncpy(config->wifi_ssid, BUILD_WIFI_SSID, WIFI_SSID_MAX_LEN - 1);
    strncpy(config->wifi_password, BUILD_WIFI_PASS, WIFI_PASSWORD_MAX_LEN - 1);
    strncpy(config->api_secret_key, BUILD_API_KEY, API_KEY_MAX_LEN - 1);
    strncpy(config->api_endpoint, DEFAULT_API_ENDPOINT, API_ENDPOINT_MAX_LEN - 1);
    config->device_port = DEFAULT_DEVICE_PORT;
    config->camera_resolution = CAMERA_RESOLUTION_DEFAULT;
    config->heartbeat_interval_sec = HEARTBEAT_INTERVAL_SEC;
    config->provisioned = true;

    /* Persist to secure storage so build env is not needed again */
    secure_storage_write("wifi_ssid", config->wifi_ssid);
    secure_storage_write("wifi_password", config->wifi_password);
    secure_storage_write("api_secret_key", config->api_secret_key);
    secure_storage_write("api_endpoint", config->api_endpoint);

    printf("[CONFIG] Loaded from build environment and persisted to secure storage\n");
    return CONFIG_OK;
#else
    (void)config;
    fprintf(stderr, "[CONFIG] No build-time credentials available\n");
    return CONFIG_ERR_NOT_FOUND;
#endif
}

/**
 * Validate that configuration contains non-empty required fields.
 */
static int validate_config(const device_config_t *config)
{
    if (!config) {
        return CONFIG_ERR_INVALID;
    }

    if (strlen(config->wifi_ssid) == 0) {
        fprintf(stderr, "[CONFIG] Validation failed: WiFi SSID is empty\n");
        return CONFIG_ERR_INVALID;
    }

    if (strlen(config->wifi_password) == 0) {
        fprintf(stderr, "[CONFIG] Validation failed: WiFi password is empty\n");
        return CONFIG_ERR_INVALID;
    }

    if (strlen(config->api_secret_key) == 0) {
        fprintf(stderr, "[CONFIG] Validation failed: API secret key is empty\n");
        return CONFIG_ERR_INVALID;
    }

    if (strlen(config->api_endpoint) == 0) {
        fprintf(stderr, "[CONFIG] Validation failed: API endpoint is empty\n");
        return CONFIG_ERR_INVALID;
    }

    /* Log non-secret info only */
    printf("[CONFIG] SSID length: %zu, Endpoint: %s, Port: %d\n",
           strlen(config->wifi_ssid),
           config->api_endpoint,
           config->device_port);

    return CONFIG_OK;
}

/**
 * Print configuration for debugging - secrets are masked.
 */
static void print_config_safe(const device_config_t *config)
{
    printf("[CONFIG] === Device Configuration ===\n");
    printf("[CONFIG] WiFi SSID:       %s\n", config->wifi_ssid);
    printf("[CONFIG] WiFi Password:   ******* (hidden)\n");
    printf("[CONFIG] API Key:         ******* (hidden)\n");
    printf("[CONFIG] API Endpoint:    %s\n", config->api_endpoint);
    printf("[CONFIG] Device Port:     %d\n", config->device_port);
    printf("[CONFIG] Resolution:      %dp\n", config->camera_resolution);
    printf("[CONFIG] Heartbeat:       %ds\n", config->heartbeat_interval_sec);
    printf("[CONFIG] Provisioned:     %s\n", config->provisioned ? "yes" : "no");
    printf("[CONFIG] ============================\n");
}

/**
 * Wipe all secrets from the config structure.
 */
static void wipe_secrets(device_config_t *config)
{
    secure_memzero(config->wifi_password, WIFI_PASSWORD_MAX_LEN);
    secure_memzero(config->api_secret_key, API_KEY_MAX_LEN);
}

/**
 * Factory reset: erase all stored credentials.
 */
static int factory_reset(void)
{
    printf("[SYSTEM] Performing factory reset...\n");
    secure_storage_wipe_key("wifi_ssid");
    secure_storage_wipe_key("wifi_password");
    secure_storage_wipe_key("api_secret_key");
    secure_storage_wipe_key("api_endpoint");
    printf("[SYSTEM] Factory reset complete. Reboot required.\n");
    return CONFIG_OK;
}

/* ============================================================
 * Platform-specific stubs - replace with actual HAL for target
 * ============================================================ */

/**
 * Stub: Initialize secure non-volatile storage (e.g., ESP32 NVS,
 * STM32 secure flash, hardware security module).
 */
static int secure_storage_init(void)
{
    printf("[NVS] Initializing secure storage...\n");
    /* TODO: Initialize platform-specific encrypted NVS */
    return CONFIG_OK;
}

/**
 * Stub: Read a value from secure non-volatile storage.
 */
static int secure_storage_read(const char *key, char *out_buf, size_t buf_len)
{
    /* TODO: Read from encrypted NVS partition / hardware keystore */
    (void)key;
    (void)out_buf;
    (void)buf_len;
    return CONFIG_ERR_NOT_FOUND; /* Not provisioned yet */
}

/**
 * Stub: Write a value to secure non-volatile storage.
 */
static int secure_storage_write(const char *key, const char *value)
{
    /* TODO: Write to encrypted NVS partition / hardware keystore */
    (void)key;
    (void)value;
    return CONFIG_OK;
}

/**
 * Stub: Securely erase a key from storage.
 */
static void secure_storage_wipe_key(const char *key)
{
    /* TODO: Secure erase from NVS */
    (void)key;
}

/**
 * Stub: Check if device has been provisioned.
 */
static bool is_device_provisioned(void)
{
    char buf[8] = {0};
    return (secure_storage_read("wifi_ssid", buf, sizeof(buf)) == CONFIG_OK);
}

/**
 * Stub: Enter provisioning mode (BLE or SoftAP) to receive credentials
 * from a mobile app or provisioning tool.
 */
static int enter_provisioning_mode(device_config_t *config)
{
    printf("[PROV] Entering provisioning mode...\n");
    printf("[PROV] Waiting for credentials via BLE/SoftAP...\n");

    /*
     * TODO: Implement BLE/SoftAP provisioning server.
     * The mobile app sends encrypted credentials which are
     * stored in secure storage.
     *
     * Example flow:
     *   1. Start SoftAP with device-specific SSID
     *   2. Accept TLS connection from provisioning app
     *   3. Receive WiFi SSID, password, API key over encrypted channel
     *   4. Store in secure NVS
     *   5. Reboot into normal mode
     */

    (void)config;
    return CONFIG_ERR_NOT_FOUND; /* Stub: provisioning not implemented */
}

/**
 * Stub: Connect to WiFi network.
 */
static int wifi_connect(const char *ssid, const char *password)
{
    printf("[WIFI] Connecting to SSID: %s\n", ssid);
    /* Do NOT log the password */
    (void)password;
    /* TODO: Platform WiFi driver connect */
    return CONFIG_OK;
}

/**
 * Stub: Authenticate with cloud service.
 */
static int cloud_authenticate(const char *endpoint, const char *api_key)
{
    printf("[CLOUD] Authenticating with: %s\n", endpoint);
    /* Do NOT log the API key */
    (void)api_key;
    /* TODO: TLS mutual auth + API key exchange */
    return CONFIG_OK;
}

/**
 * Stub: Initialize camera streaming.
 */
static int camera_stream_init(int resolution)
{
    printf("[CAM] Initializing camera at %dp\n", resolution);
    /* TODO: Camera HAL init */
    return CONFIG_OK;
}

/* ============================================================
 * Main firmware entry point
 * ============================================================ */

int main(void)
{
    device_config_t config;
    int ret;

    printf("========================================\n");
    printf("  IoT Smart Camera Firmware v1.0.0\n");
    printf("========================================\n");

    /* Step 1: Initialize secure storage */
    ret = secure_storage_init();
    if (ret != CONFIG_OK) {
        fprintf(stderr, "[FATAL] Failed to initialize secure storage\n");
        return 1;
    }

    /* Step 2: Attempt to load configuration (priority order) */
    ret = load_config_from_secure_storage(&config);

    if (ret != CONFIG_OK) {
        printf("[CONFIG] Secure storage empty, trying build environment...\n");
        ret = load_config_from_build_env(&config);
    }

    if (ret != CONFIG_OK) {
        printf("[CONFIG] No stored credentials found.\n");
        ret = enter_provisioning_mode(&config);
    }

    if (ret != CONFIG_OK) {
        fprintf(stderr, "[FATAL] Device is not provisioned. "
                "Use provisioning app or rebuild with credentials.\n");
        fprintf(stderr, "[FATAL] Build example:\n");
        fprintf(stderr, "  make WIFI_SSID=\"your_ssid\" "
                "WIFI_PASS=\"your_pass\" API_KEY=\"your_key\"\n");
        return 1;
    }

    /* Step 3: Validate configuration */
    ret = validate_config(&config);
    if (ret != CONFIG_OK) {
        fprintf(stderr, "[FATAL] Invalid configuration\n");
        wipe_secrets(&config);
        return 1;
    }

    print_config_safe(&config);

    /* Step 4: Connect to WiFi */
    ret = wifi_connect(config.wifi_ssid, config.wifi_password);
    if (ret != CONFIG_OK) {
        fprintf(stderr, "[FATAL] WiFi connection failed\n");
        wipe_secrets(&config);
        return 1;
    }
    printf("[WIFI] Connected successfully\n");

    /* Step 5: Authenticate with cloud */
    ret = cloud_authenticate(config.api_endpoint, config.api_secret_key);
    if (ret != CONFIG_OK) {
        fprintf(stderr, "[FATAL] Cloud authentication failed\n");
        wipe_secrets(&config);
        return 1;
    }
    printf("[CLOUD] Authenticated successfully\n");

    /* Step 6: Wipe secrets from RAM now that connections are established */
    wipe_secrets(&config);
    printf("[SECURITY] Secrets wiped from RAM\n");

    /* Step 7: Initialize camera */
    ret = camera_stream_init(config.camera_resolution);
    if (ret != CONFIG_OK) {
        fprintf(stderr, "[FATAL] Camera initialization failed\n");
        return 1;
    }
    printf("[CAM] Camera ready\n");

    /* Step 8: Main loop */
    printf("[SYSTEM] Entering main loop...\n");
    while (1) {
        /* TODO: Camera capture, stream to cloud, handle commands */
        /* TODO: Periodic heartbeat every config.heartbeat_interval_sec */
        break; /* Stub: exit immediately */
    }

    printf("[SYSTEM] Firmware shutdown\n");
    return 0;
}