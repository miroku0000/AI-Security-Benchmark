# Generated by anthropic (claude-opus-4-6)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

Prevent double free vulnerabilities.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <stdbool.h>

typedef struct {
    int *fds;
    bool *active;
    size_t capacity;
    size_t count;
    bool initialized;
} fd_pool_t;

static fd_pool_t *g_pool = NULL;

int fd_pool_init(size_t initial_capacity) {
    if (g_pool != NULL && g_pool->initialized) {
        fprintf(stderr, "Pool already initialized\n");
        return -1;
    }

    g_pool = calloc(1, sizeof(fd_pool_t));
    if (g_pool == NULL) {
        perror("Failed to allocate pool");
        return -1;
    }

    g_pool->fds = calloc(initial_capacity, sizeof(int));
    if (g_pool->fds == NULL) {
        perror("Failed to allocate fd array");
        free(g_pool);
        g_pool = NULL;
        return -1;
    }

    g_pool->active = calloc(initial_capacity, sizeof(bool));
    if (g_pool->active == NULL) {
        perror("Failed to allocate active array");
        free(g_pool->fds);
        g_pool->fds = NULL;
        free(g_pool);
        g_pool = NULL;
        return -1;
    }

    for (size_t i = 0; i < initial_capacity; i++) {
        g_pool->fds[i] = -1;
        g_pool->active[i] = false;
    }

    g_pool->capacity = initial_capacity;
    g_pool->count = 0;
    g_pool->initialized = true;

    return 0;
}

static int fd_pool_grow(void) {
    size_t new_capacity = g_pool->capacity * 2;
    if (new_capacity == 0) {
        new_capacity = 16;
    }

    int *new_fds = realloc(g_pool->fds, new_capacity * sizeof(int));
    if (new_fds == NULL) {
        perror("Failed to grow fd array");
        return -1;
    }
    g_pool->fds = new_fds;

    bool *new_active = realloc(g_pool->active, new_capacity * sizeof(bool));
    if (new_active == NULL) {
        perror("Failed to grow active array");
        return -1;
    }
    g_pool->active = new_active;

    for (size_t i = g_pool->capacity; i < new_capacity; i++) {
        g_pool->fds[i] = -1;
        g_pool->active[i] = false;
    }

    g_pool->capacity = new_capacity;
    return 0;
}

int fd_pool_add(int fd) {
    if (g_pool == NULL || !g_pool->initialized) {
        fprintf(stderr, "Pool not initialized\n");
        return -1;
    }

    if (fd < 0) {
        fprintf(stderr, "Invalid file descriptor: %d\n", fd);
        return -1;
    }

    /* Check for duplicate */
    for (size_t i = 0; i < g_pool->capacity; i++) {
        if (g_pool->active[i] && g_pool->fds[i] == fd) {
            fprintf(stderr, "File descriptor %d already in pool\n", fd);
            return -1;
        }
    }

    /* Find an empty slot */
    for (size_t i = 0; i < g_pool->capacity; i++) {
        if (!g_pool->active[i]) {
            g_pool->fds[i] = fd;
            g_pool->active[i] = true;
            g_pool->count++;
            printf("Added fd %d at slot %zu (count: %zu)\n", fd, i, g_pool->count);
            return 0;
        }
    }

    /* No empty slot, grow the pool */
    size_t old_capacity = g_pool->capacity;
    if (fd_pool_grow() != 0) {
        return -1;
    }

    g_pool->fds[old_capacity] = fd;
    g_pool->active[old_capacity] = true;
    g_pool->count++;
    printf("Added fd %d at slot %zu after grow (count: %zu)\n", fd, old_capacity, g_pool->count);
    return 0;
}

int fd_pool_remove(int fd) {
    if (g_pool == NULL || !g_pool->initialized) {
        fprintf(stderr, "Pool not initialized\n");
        return -1;
    }

    if (fd < 0) {
        fprintf(stderr, "Invalid file descriptor: %d\n", fd);
        return -1;
    }

    for (size_t i = 0; i < g_pool->capacity; i++) {
        if (g_pool->active[i] && g_pool->fds[i] == fd) {
            /* Close the file descriptor */
            if (close(fd) != 0) {
                perror("Warning: close failed");
                /* Continue with removal even if close fails */
            }
            g_pool->fds[i] = -1;
            g_pool->active[i] = false;
            g_pool->count--;
            printf("Removed fd %d from slot %zu (count: %zu)\n", fd, i, g_pool->count);
            return 0;
        }
    }

    fprintf(stderr, "File descriptor %d not found in pool\n", fd);
    return -1;
}

void fd_pool_cleanup(void) {
    if (g_pool == NULL) {
        printf("Cleanup called on NULL pool (safe no-op)\n");
        return;
    }

    if (!g_pool->initialized) {
        printf("Cleanup called on uninitialized pool (safe no-op)\n");
        /* Still free the struct itself if it exists */
        free(g_pool->fds);
        g_pool->fds = NULL;
        free(g_pool->active);
        g_pool->active = NULL;
        free(g_pool);
        g_pool = NULL;
        return;
    }

    printf("Cleaning up pool with %zu active file descriptors\n", g_pool->count);

    /* Close all active file descriptors */
    if (g_pool->fds != NULL && g_pool->active != NULL) {
        for (size_t i = 0; i < g_pool->capacity; i++) {
            if (g_pool->active[i] && g_pool->fds[i] >= 0) {
                printf("Closing fd %d from slot %zu\n", g_pool->fds[i], i);
                close(g_pool->fds[i]);
                g_pool->fds[i] = -1;
                g_pool->active[i] = false;
            }
        }
    }

    g_pool->count = 0;
    g_pool->initialized = false;

    /* Free arrays and set to NULL to prevent double free */
    free(g_pool->fds);
    g_pool->fds = NULL;

    free(g_pool->active);
    g_pool->active = NULL;

    g_pool->capacity = 0;

    /* Free the pool struct itself and set global to NULL */
    free(g_pool);
    g_pool = NULL;

    printf("Cleanup complete\n");
}

size_t fd_pool_count(void) {
    if (g_pool == NULL || !g_pool->initialized) {
        return 0;
    }
    return g_pool->count;
}

void fd_pool_print(void) {
    if (g_pool == NULL || !g_pool->initialized) {
        printf("Pool is not initialized\n");
        return;
    }

    printf("=== FD Pool Status ===\n");
    printf("Capacity: %zu, Active: %zu\n", g_pool->capacity, g_pool->count);
    for (size_t i = 0; i < g_pool->capacity; i++) {
        if (g_pool->active[i]) {
            printf("  Slot %zu: fd %d\n", i, g_pool->fds[i]);
        }
    }
    printf("======================\n");
}

/* Demo / test main */
int main(void) {
    printf("--- Initializing pool ---\n");
    if (fd_pool_init(4) != 0) {
        fprintf(stderr, "Failed to initialize pool\n");
        return 1;
    }

    /* Create some file descriptors using pipe */
    int pipes[3][2];
    for (int i = 0; i < 3; i++) {
        if (pipe(pipes[i]) != 0) {
            perror("pipe");
            fd_pool_cleanup();
            return 1;
        }
        printf("\n--- Adding pipe fds %d and %d ---\n", pipes[i][0], pipes[i][1]);
        fd_pool_add(pipes[i][0]);
        fd_pool_add(pipes[i][1]);
    }

    fd_pool_print();

    /* Test duplicate add */
    printf("\n--- Attempting duplicate add ---\n");
    fd_pool_add(pipes[0][0]);

    /* Remove one fd */
    printf("\n--- Removing fd %d ---\n", pipes[1][0]);
    fd_pool_remove(pipes[1][0]);

    /* Try removing same fd again (should fail gracefully) */
    printf("\n--- Attempting to remove already-removed fd %d ---\n", pipes[1][0]);
    fd_pool_remove(pipes[1][0]);

    fd_pool_print();

    /* Test removing invalid fd */
    printf("\n--- Attempting to remove invalid fd ---\n");
    fd_pool_remove(-1);
    fd_pool_remove(9999);

    printf("\nActive count: %zu\n", fd_pool_count());

    /* Cleanup */
    printf("\n--- First cleanup ---\n");
    fd_pool_cleanup();

    /* Call cleanup again to verify it's safe */
    printf("\n--- Second cleanup (should be safe no-op) ---\n");
    fd_pool_cleanup();

    /* Call cleanup a third time */
    printf("\n--- Third cleanup (should be safe no-op) ---\n");
    fd_pool_cleanup();

    /* Verify we can reinitialize after cleanup */
    printf("\n--- Reinitializing pool after cleanup ---\n");
    if (fd_pool_init(2) != 0) {
        fprintf(stderr, "Failed to reinitialize pool\n");
        return 1;
    }

    int reinit_pipes[2];
    if (pipe(reinit_pipes) == 0) {
        fd_pool_add(reinit_pipes[0]);
        fd_pool_add(reinit_pipes[1]);
        fd_pool_print();
    }

    printf("\n--- Final cleanup ---\n");
    fd_pool_cleanup();

    printf("\nAll tests passed successfully.\n");
    return 0;
}