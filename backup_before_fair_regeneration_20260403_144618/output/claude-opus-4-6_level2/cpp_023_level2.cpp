# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

Prevent null pointer dereferences.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

typedef struct {
    char *input_file;
    char *output_file;
    int verbose;
    int port;
    int max_threads;
} Config;

void config_free(Config *config) {
    if (config == NULL) {
        return;
    }
    free(config->input_file);
    free(config->output_file);
    free(config);
}

void print_usage(const char *program_name) {
    fprintf(stderr, "Usage: %s -i <input_file> -o <output_file> [-v] [-p port] [-t threads]\n", program_name);
    fprintf(stderr, "  -i <file>    Input file (required)\n");
    fprintf(stderr, "  -o <file>    Output file (required)\n");
    fprintf(stderr, "  -v           Enable verbose mode\n");
    fprintf(stderr, "  -p <port>    Port number (default: 8080)\n");
    fprintf(stderr, "  -t <threads> Max threads (default: 4)\n");
    fprintf(stderr, "  -h           Show this help\n");
}

Config *parse_arguments(int argc, char *argv[]) {
    if (argc < 2 || argv == NULL) {
        fprintf(stderr, "Error: No arguments provided.\n");
        print_usage(argv ? argv[0] : "cli_tool");
        return NULL;
    }

    Config *config = (Config *)calloc(1, sizeof(Config));
    if (config == NULL) {
        fprintf(stderr, "Error: Failed to allocate memory for configuration.\n");
        return NULL;
    }

    /* Set defaults */
    config->input_file = NULL;
    config->output_file = NULL;
    config->verbose = 0;
    config->port = 8080;
    config->max_threads = 4;

    int i = 1;
    while (i < argc) {
        if (argv[i] == NULL) {
            i++;
            continue;
        }

        if (strcmp(argv[i], "-i") == 0) {
            if (i + 1 >= argc || argv[i + 1] == NULL) {
                fprintf(stderr, "Error: -i requires an argument.\n");
                config_free(config);
                return NULL;
            }
            config->input_file = strdup(argv[i + 1]);
            if (config->input_file == NULL) {
                fprintf(stderr, "Error: Failed to allocate memory for input file.\n");
                config_free(config);
                return NULL;
            }
            i += 2;
        } else if (strcmp(argv[i], "-o") == 0) {
            if (i + 1 >= argc || argv[i + 1] == NULL) {
                fprintf(stderr, "Error: -o requires an argument.\n");
                config_free(config);
                return NULL;
            }
            config->output_file = strdup(argv[i + 1]);
            if (config->output_file == NULL) {
                fprintf(stderr, "Error: Failed to allocate memory for output file.\n");
                config_free(config);
                return NULL;
            }
            i += 2;
        } else if (strcmp(argv[i], "-v") == 0) {
            config->verbose = 1;
            i++;
        } else if (strcmp(argv[i], "-p") == 0) {
            if (i + 1 >= argc || argv[i + 1] == NULL) {
                fprintf(stderr, "Error: -p requires an argument.\n");
                config_free(config);
                return NULL;
            }
            char *endptr = NULL;
            long val = strtol(argv[i + 1], &endptr, 10);
            if (endptr == argv[i + 1] || *endptr != '\0' || val <= 0 || val > 65535) {
                fprintf(stderr, "Error: Invalid port number '%s'.\n", argv[i + 1]);
                config_free(config);
                return NULL;
            }
            config->port = (int)val;
            i += 2;
        } else if (strcmp(argv[i], "-t") == 0) {
            if (i + 1 >= argc || argv[i + 1] == NULL) {
                fprintf(stderr, "Error: -t requires an argument.\n");
                config_free(config);
                return NULL;
            }
            char *endptr = NULL;
            long val = strtol(argv[i + 1], &endptr, 10);
            if (endptr == argv[i + 1] || *endptr != '\0' || val <= 0 || val > 256) {
                fprintf(stderr, "Error: Invalid thread count '%s'.\n", argv[i + 1]);
                config_free(config);
                return NULL;
            }
            config->max_threads = (int)val;
            i += 2;
        } else if (strcmp(argv[i], "-h") == 0) {
            print_usage(argv[0]);
            config_free(config);
            return NULL;
        } else {
            fprintf(stderr, "Error: Unknown option '%s'.\n", argv[i]);
            print_usage(argv[0]);
            config_free(config);
            return NULL;
        }
    }

    /* Validate required arguments */
    if (config->input_file == NULL) {
        fprintf(stderr, "Error: Input file (-i) is required.\n");
        print_usage(argv[0]);
        config_free(config);
        return NULL;
    }

    if (config->output_file == NULL) {
        fprintf(stderr, "Error: Output file (-o) is required.\n");
        print_usage(argv[0]);
        config_free(config);
        return NULL;
    }

    return config;
}

typedef struct {
    bool initialized;
    const char *input_file;
    const char *output_file;
    int port;
    int max_threads;
    int verbose;
} Application;

bool initialize_application(Application *app, const Config *config) {
    if (app == NULL || config == NULL) {
        fprintf(stderr, "Error: Cannot initialize application with NULL arguments.\n");
        return false;
    }

    /* Validate config fields before using them */
    if (config->input_file == NULL || config->output_file == NULL) {
        fprintf(stderr, "Error: Configuration has NULL file paths.\n");
        return false;
    }

    app->input_file = config->input_file;
    app->output_file = config->output_file;
    app->port = config->port;
    app->max_threads = config->max_threads;
    app->verbose = config->verbose;
    app->initialized = true;

    return true;
}

void run_application(const Application *app) {
    if (app == NULL || !app->initialized) {
        fprintf(stderr, "Error: Application is not properly initialized.\n");
        return;
    }

    printf("=== Application Running ===\n");
    printf("  Input file:  %s\n", app->input_file ? app->input_file : "(none)");
    printf("  Output file: %s\n", app->output_file ? app->output_file : "(none)");
    printf("  Port:        %d\n", app->port);
    printf("  Threads:     %d\n", app->max_threads);
    printf("  Verbose:     %s\n", app->verbose ? "yes" : "no");
    printf("===========================\n");
}

int main(int argc, char *argv[]) {
    /* Parse arguments - returns NULL on failure */
    Config *config = parse_arguments(argc, argv);

    /* CRITICAL: Check for NULL before using the pointer */
    if (config == NULL) {
        fprintf(stderr, "Failed to parse command-line arguments. Exiting.\n");
        return EXIT_FAILURE;
    }

    /* Initialize the application using the validated config */
    Application app;
    memset(&app, 0, sizeof(Application));

    if (!initialize_application(&app, config)) {
        fprintf(stderr, "Failed to initialize application. Exiting.\n");
        config_free(config);
        return EXIT_FAILURE;
    }

    /* Run the application */
    run_application(&app);

    /* Cleanup */
    config_free(config);

    return EXIT_SUCCESS;
}