# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

Prevent memory leaks.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char *key;
    char *value;
} ConfigEntry;

typedef struct {
    ConfigEntry *entries;
    size_t count;
    size_t capacity;
} ConfigData;

static void free_config_entry(ConfigEntry *entry) {
    if (entry) {
        free(entry->key);
        free(entry->value);
        entry->key = NULL;
        entry->value = NULL;
    }
}

void free_config_data(ConfigData *config) {
    if (config) {
        if (config->entries) {
            for (size_t i = 0; i < config->count; i++) {
                free_config_entry(&config->entries[i]);
            }
            free(config->entries);
            config->entries = NULL;
        }
        free(config);
    }
}

static char *trim_whitespace(char *str) {
    while (*str == ' ' || *str == '\t' || *str == '\n' || *str == '\r')
        str++;

    if (*str == '\0')
        return str;

    char *end = str + strlen(str) - 1;
    while (end > str && (*end == ' ' || *end == '\t' || *end == '\n' || *end == '\r'))
        end--;
    *(end + 1) = '\0';

    return str;
}

static int add_config_entry(ConfigData *config, const char *key, const char *value) {
    if (config->count >= config->capacity) {
        size_t new_capacity = config->capacity == 0 ? 16 : config->capacity * 2;
        ConfigEntry *new_entries = realloc(config->entries, new_capacity * sizeof(ConfigEntry));
        if (!new_entries) {
            return -1;
        }
        config->entries = new_entries;
        config->capacity = new_capacity;
    }

    config->entries[config->count].key = strdup(key);
    if (!config->entries[config->count].key) {
        return -1;
    }

    config->entries[config->count].value = strdup(value);
    if (!config->entries[config->count].value) {
        free(config->entries[config->count].key);
        config->entries[config->count].key = NULL;
        return -1;
    }

    config->count++;
    return 0;
}

ConfigData *read_config_file(const char *filename) {
    if (!filename) {
        return NULL;
    }

    FILE *file = fopen(filename, "r");
    if (!file) {
        return NULL;
    }

    ConfigData *config = calloc(1, sizeof(ConfigData));
    if (!config) {
        fclose(file);
        return NULL;
    }

    config->entries = NULL;
    config->count = 0;
    config->capacity = 0;

    char line[1024];
    while (fgets(line, sizeof(line), file)) {
        char *trimmed = trim_whitespace(line);

        /* Skip empty lines and comments */
        if (*trimmed == '\0' || *trimmed == '#' || *trimmed == ';') {
            continue;
        }

        /* Find the delimiter '=' */
        char *delimiter = strchr(trimmed, '=');
        if (!delimiter) {
            continue;
        }

        *delimiter = '\0';
        char *key = trim_whitespace(trimmed);
        char *value = trim_whitespace(delimiter + 1);

        if (*key == '\0') {
            continue;
        }

        if (add_config_entry(config, key, value) != 0) {
            /* Memory allocation failed; clean up everything */
            fclose(file);
            free_config_data(config);
            return NULL;
        }
    }

    if (ferror(file)) {
        fclose(file);
        free_config_data(config);
        return NULL;
    }

    fclose(file);
    return config;
}

const char *config_get_value(const ConfigData *config, const char *key) {
    if (!config || !key) {
        return NULL;
    }

    for (size_t i = 0; i < config->count; i++) {
        if (strcmp(config->entries[i].key, key) == 0) {
            return config->entries[i].value;
        }
    }

    return NULL;
}

/* Example usage */
int main(void) {
    /* Simulating frequent calls during runtime */
    for (int i = 0; i < 100; i++) {
        ConfigData *config = read_config_file("app.conf");
        if (config) {
            const char *val = config_get_value(config, "database_host");
            if (val) {
                printf("database_host = %s\n", val);
            }
            /* Always free when done to prevent memory leaks */
            free_config_data(config);
            config = NULL;
        }
    }

    return 0;
}