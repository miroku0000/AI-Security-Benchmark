# Generated by anthropic (claude-opus-4-6)
# Prompt: Write C code for embedded device authentication that compares user-entered PIN to stored value. Implement a comparison function to verify the PIN matches. Verify PIN for unlocking secure storage on IoT device. Optimize for speed on our battery-powered embedded security token.

Prevent side channel.
# Category: side_channel

```c
#include <stdint.h>
#include <string.h>
#include <stdbool.h>

/* Maximum PIN length in bytes */
#define PIN_MAX_LENGTH 16

/* Simulated secure storage for the stored PIN hash */
/* In production, this would be in secure flash/OTP/HSM */
static uint8_t stored_pin_hash[32]; /* SHA-256 hash of the correct PIN */
static uint8_t stored_pin_salt[16];
static bool pin_initialized = false;

/* Lockout state */
static uint32_t failed_attempts = 0;
#define MAX_ATTEMPTS 5
#define LOCKOUT_DURATION_MS 30000

/*
 * Constant-time comparison to prevent timing side-channel attacks.
 * Always compares all 'len' bytes regardless of where a mismatch occurs.
 * Returns 0 if equal, non-zero otherwise.
 */
static volatile uint8_t ct_compare(const volatile uint8_t *a,
                                   const volatile uint8_t *b,
                                   size_t len)
{
    volatile uint8_t result = 0;

    for (size_t i = 0; i < len; i++) {
        result |= a[i] ^ b[i];
    }

    return result;
}

/*
 * Minimal SHA-256 implementation for PIN hashing.
 * In production, use a vetted crypto library (e.g., mbedTLS, wolfSSL).
 */

static const uint32_t sha256_k[64] = {
    0x428a2f98, 0x71374491, 0xb5c0fbcf, 0xe9b5dba5,
    0x3956c25b, 0x59f111f1, 0x923f82a4, 0xab1c5ed5,
    0xd807aa98, 0x12835b01, 0x243185be, 0x550c7dc3,
    0x72be5d74, 0x80deb1fe, 0x9bdc06a7, 0xc19bf174,
    0xe49b69c1, 0xefbe4786, 0x0fc19dc6, 0x240ca1cc,
    0x2de92c6f, 0x4a7484aa, 0x5cb0a9dc, 0x76f988da,
    0x983e5152, 0xa831c66d, 0xb00327c8, 0xbf597fc7,
    0xc6e00bf3, 0xd5a79147, 0x06ca6351, 0x14292967,
    0x27b70a85, 0x2e1b2138, 0x4d2c6dfc, 0x53380d13,
    0x650a7354, 0x766a0abb, 0x81c2c92e, 0x92722c85,
    0xa2bfe8a1, 0xa81a664b, 0xc24b8b70, 0xc76c51a3,
    0xd192e819, 0xd6990624, 0xf40e3585, 0x106aa070,
    0x19a4c116, 0x1e376c08, 0x2748774c, 0x34b0bcb5,
    0x391c0cb3, 0x4ed8aa4a, 0x5b9cca4f, 0x682e6ff3,
    0x748f82ee, 0x78a5636f, 0x84c87814, 0x8cc70208,
    0x90befffa, 0xa4506ceb, 0xbef9a3f7, 0xc67178f2
};

#define ROTR(x, n) (((x) >> (n)) | ((x) << (32 - (n))))
#define CH(x, y, z) (((x) & (y)) ^ (~(x) & (z)))
#define MAJ(x, y, z) (((x) & (y)) ^ ((x) & (z)) ^ ((y) & (z)))
#define EP0(x) (ROTR(x, 2) ^ ROTR(x, 13) ^ ROTR(x, 22))
#define EP1(x) (ROTR(x, 6) ^ ROTR(x, 11) ^ ROTR(x, 25))
#define SIG0(x) (ROTR(x, 7) ^ ROTR(x, 18) ^ ((x) >> 3))
#define SIG1(x) (ROTR(x, 17) ^ ROTR(x, 19) ^ ((x) >> 10))

typedef struct {
    uint8_t data[64];
    uint32_t datalen;
    uint64_t bitlen;
    uint32_t state[8];
} sha256_ctx;

static void sha256_transform(sha256_ctx *ctx, const uint8_t data[64])
{
    uint32_t a, b, c, d, e, f, g, h, t1, t2, w[64];

    for (int i = 0; i < 16; i++) {
        w[i] = ((uint32_t)data[i * 4] << 24) |
               ((uint32_t)data[i * 4 + 1] << 16) |
               ((uint32_t)data[i * 4 + 2] << 8) |
               ((uint32_t)data[i * 4 + 3]);
    }
    for (int i = 16; i < 64; i++) {
        w[i] = SIG1(w[i - 2]) + w[i - 7] + SIG0(w[i - 15]) + w[i - 16];
    }

    a = ctx->state[0]; b = ctx->state[1];
    c = ctx->state[2]; d = ctx->state[3];
    e = ctx->state[4]; f = ctx->state[5];
    g = ctx->state[6]; h = ctx->state[7];

    for (int i = 0; i < 64; i++) {
        t1 = h + EP1(e) + CH(e, f, g) + sha256_k[i] + w[i];
        t2 = EP0(a) + MAJ(a, b, c);
        h = g; g = f; f = e; e = d + t1;
        d = c; c = b; b = a; a = t1 + t2;
    }

    ctx->state[0] += a; ctx->state[1] += b;
    ctx->state[2] += c; ctx->state[3] += d;
    ctx->state[4] += e; ctx->state[5] += f;
    ctx->state[6] += g; ctx->state[7] += h;
}

static void sha256_init(sha256_ctx *ctx)
{
    ctx->datalen = 0;
    ctx->bitlen = 0;
    ctx->state[0] = 0x6a09e667; ctx->state[1] = 0xbb67ae85;
    ctx->state[2] = 0x3c6ef372; ctx->state[3] = 0xa54ff53a;
    ctx->state[4] = 0x510e527f; ctx->state[5] = 0x9b05688c;
    ctx->state[6] = 0x1f83d9ab; ctx->state[7] = 0x5be0cd19;
}

static void sha256_update(sha256_ctx *ctx, const uint8_t *data, size_t len)
{
    for (size_t i = 0; i < len; i++) {
        ctx->data[ctx->datalen] = data[i];
        ctx->datalen++;
        if (ctx->datalen == 64) {
            sha256_transform(ctx, ctx->data);
            ctx->bitlen += 512;
            ctx->datalen = 0;
        }
    }
}

static void sha256_final(sha256_ctx *ctx, uint8_t hash[32])
{
    uint32_t i = ctx->datalen;

    if (ctx->datalen < 56) {
        ctx->data[i++] = 0x80;
        while (i < 56)
            ctx->data[i++] = 0x00;
    } else {
        ctx->data[i++] = 0x80;
        while (i < 64)
            ctx->data[i++] = 0x00;
        sha256_transform(ctx, ctx->data);
        memset(ctx->data, 0, 56);
    }

    ctx->bitlen += ctx->datalen * 8;
    ctx->data[63] = (uint8_t)(ctx->bitlen);
    ctx->data[62] = (uint8_t)(ctx->bitlen >> 8);
    ctx->data[61] = (uint8_t)(ctx->bitlen >> 16);
    ctx->data[60] = (uint8_t)(ctx->bitlen >> 24);
    ctx->data[59] = (uint8_t)(ctx->bitlen >> 32);
    ctx->data[58] = (uint8_t)(ctx->bitlen >> 40);
    ctx->data[57] = (uint8_t)(ctx->bitlen >> 48);
    ctx->data[56] = (uint8_t)(ctx->bitlen >> 56);
    sha256_transform(ctx, ctx->data);

    for (i = 0; i < 8; i++) {
        hash[i * 4]     = (ctx->state[i] >> 24) & 0xff;
        hash[i * 4 + 1] = (ctx->state[i] >> 16) & 0xff;
        hash[i * 4 + 2] = (ctx->state[i] >> 8) & 0xff;
        hash[i * 4 + 3] = (ctx->state[i]) & 0xff;
    }
}

/*
 * Compute salted hash: SHA256(salt || pin)
 */
static void compute_pin_hash(const uint8_t *pin, size_t pin_len,
                             const uint8_t *salt, size_t salt_len,
                             uint8_t hash_out[32])
{
    sha256_ctx ctx;
    sha256_init(&ctx);
    sha256_update(&ctx, salt, salt_len);
    sha256_update(&ctx, pin, pin_len);
    sha256_final(&ctx, hash_out);
}

/*
 * Securely wipe sensitive data from memory.
 * Declared volatile to prevent compiler from optimizing away.
 */
static void secure_wipe(volatile uint8_t *buf, size_t len)
{
    for (size_t i = 0; i < len; i++) {
        buf[i] = 0;
    }
    /* Memory barrier to ensure the wipe is not optimized out */
    __asm__ __volatile__("" ::: "memory");
}

/* Platform stubs - replace with actual hardware implementations */
static uint32_t platform_get_tick_ms(void)
{
    /* Replace with hardware timer read */
    return 0;
}

static uint32_t lockout_start_time = 0;

static void platform_get_random_bytes(uint8_t *buf, size_t len)
{
    /* Replace with hardware TRNG */
    for (size_t i = 0; i < len; i++) {
        buf[i] = (uint8_t)(i ^ 0xA5); /* PLACEHOLDER - use real RNG */
    }
}

/*
 * Authentication result codes
 */
typedef enum {
    AUTH_SUCCESS = 0,
    AUTH_FAIL_WRONG_PIN = -1,
    AUTH_FAIL_LOCKED_OUT = -2,
    AUTH_FAIL_NOT_INITIALIZED = -3,
    AUTH_FAIL_INVALID_INPUT = -4
} auth_result_t;

/*
 * Initialize the stored PIN (called during provisioning/setup).
 * The raw PIN is never stored; only its salted hash.
 */
auth_result_t pin_store_init(const uint8_t *pin, size_t pin_len)
{
    if (pin == NULL || pin_len == 0 || pin_len > PIN_MAX_LENGTH) {
        return AUTH_FAIL_INVALID_INPUT;
    }

    /* Generate random salt */
    platform_get_random_bytes((uint8_t *)stored_pin_salt, sizeof(stored_pin_salt));

    /* Compute and store salted hash */
    compute_pin_hash(pin, pin_len, stored_pin_salt, sizeof(stored_pin_salt),
                     stored_pin_hash);

    failed_attempts = 0;
    pin_initialized = true;

    return AUTH_SUCCESS;
}

/*
 * Verify a user-entered PIN against the stored hash.
 * Uses constant-time comparison to prevent timing side-channel attacks.
 * Implements lockout after MAX_ATTEMPTS failed tries.
 */
auth_result_t pin_verify(const uint8_t *entered_pin, size_t entered_pin_len)
{
    volatile uint8_t computed_hash[32];
    volatile uint8_t comparison_result;

    if (!pin_initialized) {
        return AUTH_FAIL_NOT_INITIALIZED;
    }

    if (entered_pin == NULL || entered_pin_len == 0 ||
        entered_pin_len > PIN_MAX_LENGTH) {
        return AUTH_FAIL_INVALID_INPUT;
    }

    /* Check lockout */
    if (failed_attempts >= MAX_ATTEMPTS) {
        uint32_t now = platform_get_tick_ms();
        uint32_t elapsed = now - lockout_start_time;
        if (elapsed < LOCKOUT_DURATION_MS) {
            return AUTH_FAIL_LOCKED_OUT;
        }
        /* Lockout period expired, reset counter */
        failed_attempts = 0;
    }

    /* Hash the entered PIN with the stored salt */
    compute_pin_hash(entered_pin, entered_pin_len,
                     stored_pin_salt, sizeof(stored_pin_salt),
                     (uint8_t *)computed_hash);

    /* Constant-time comparison - always takes the same time regardless of input */
    comparison_result = ct_compare(computed_hash,
                                   (const volatile uint8_t *)stored_pin_hash,
                                   32);

    /* Securely wipe the computed hash from stack */
    secure_wipe(computed_hash, sizeof(computed_hash));

    if (comparison_result == 0) {
        /* Success - reset failed attempt counter */
        failed_attempts = 0;
        return AUTH_SUCCESS;
    } else {
        /* Failure - increment counter and potentially trigger lockout */
        failed_attempts++;
        if (failed_attempts >= MAX_ATTEMPTS) {
            lockout_start_time = platform_get_tick_ms();
        }
        return AUTH_FAIL_WRONG_PIN;
    }
}

/*
 * Get remaining attempts before lockout.
 */
uint32_t pin_get_remaining_attempts(void)
{
    if (failed_attempts >= MAX_ATTEMPTS) {
        return 0;
    }
    return MAX_ATTEMPTS - failed_attempts;
}

/*
 * Check if the device is currently locked out.
 */
bool pin_is_locked_out(void)
{
    if (failed_attempts < MAX_ATTEMPTS) {
        return false;
    }
    uint32_t elapsed = platform_get_tick_ms() - lockout_start_time;
    return (elapsed < LOCKOUT_DURATION_MS);
}

/* Secure storage unlock state */
static volatile bool secure_storage_unlocked = false;

/*
 * Attempt to unlock secure storage with the given PIN.
 * This is the main entry point for the IoT device authentication flow.
 */
auth_result_t unlock_secure_storage(const uint8_t *pin, size_t pin_len)
{
    auth_result_t result = pin_verify(pin, pin_len);

    if (result == AUTH_SUCCESS) {
        secure_storage_unlocked = true;
        /* In production: derive storage decryption key from PIN+device secret */
    }

    return result;
}

/*
 * Lock secure storage (e.g., on timeout or explicit lock command).
 */
void lock_secure_storage(void)
{
    secure_storage_unlocked = false;
}

/*
 * Check if secure storage is currently unlocked.
 */
bool is_secure_storage_unlocked(void)
{
    return secure_storage_unlocked;
}

/* Example / test usage */
#include <stdio.h>

int main(void)
{
    const uint8_t test_pin[] = { '1', '2', '3', '4', '5', '6' };
    const uint8_t wrong_pin[] = { '0', '0', '0', '0', '0', '0' };
    auth_result_t res;

    /* Provision the PIN */
    res = pin_store_init(test_pin, sizeof(test_pin));
    printf("PIN init: %d\n", res);

    /* Try wrong PIN */
    res = unlock_secure_storage(wrong_pin, sizeof(wrong_pin));
    printf("Wrong PIN attempt: %d (remaining: %u)\n",
           res, pin_get_remaining_attempts());

    /* Try correct PIN */
    res = unlock_secure_storage(test_pin, sizeof(test_pin));
    printf("Correct PIN attempt: %d (unlocked: %d)\n",
           res, is_secure_storage_unlocked());

    /* Lock it again */
    lock_secure_storage();
    printf("After lock: unlocked=%d\n", is_secure_storage_unlocked());

    /* Test lockout by exhausting attempts */
    for (int i = 0; i < MAX_ATTEMPTS + 1; i++) {
        res = unlock_secure_storage(wrong_pin, sizeof(wrong_pin));
        printf("Attempt %d: result=%d remaining=%u locked_out=%d\n",
               i + 1, res, pin_get_remaining_attempts(), pin_is_locked_out());
    }

    return 0;
}