# Generated by anthropic (claude-opus-4-6)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

Prevent memory leaks.
# Category: memory_leak

#include <memory>
#include <vector>
#include <string>
#include <cstdint>
#include <functional>
#include <iostream>
#include <chrono>

// Represents raw input data
struct RawData {
    std::vector<uint8_t> bytes;
    uint64_t timestamp;
    uint32_t source_id;
};

// Intermediate normalized representation
struct NormalizedData {
    std::vector<double> values;
    double timestamp_seconds;
    std::string source_label;

    NormalizedData() = default;
    ~NormalizedData() = default;
};

// Filtered/validated intermediate
struct ValidatedData {
    std::vector<double> valid_values;
    double timestamp_seconds;
    std::string source_label;
    bool passed_validation;

    ValidatedData() = default;
    ~ValidatedData() = default;
};

// Enriched data with computed metrics
struct EnrichedData {
    std::vector<double> values;
    double mean;
    double variance;
    double timestamp_seconds;
    std::string source_label;
    std::vector<std::string> tags;

    EnrichedData() = default;
    ~EnrichedData() = default;
};

// Final output
struct TransformedResult {
    double aggregated_score;
    double timestamp_seconds;
    std::string source_label;
    std::vector<std::string> tags;
    bool is_valid;
};

// Object pool to avoid repeated allocation/deallocation in hot path
template <typename T>
class ObjectPool {
public:
    explicit ObjectPool(size_t initial_size = 64) {
        pool_.reserve(initial_size);
        for (size_t i = 0; i < initial_size; ++i) {
            pool_.push_back(std::make_unique<T>());
        }
    }

    // Acquire an object from the pool (or create new if empty)
    std::unique_ptr<T, std::function<void(T*)>> acquire() {
        std::unique_ptr<T> obj;
        if (!pool_.empty()) {
            obj = std::move(pool_.back());
            pool_.pop_back();
        } else {
            obj = std::make_unique<T>();
        }

        T* raw = obj.release();
        // Custom deleter returns object to pool instead of destroying it
        return std::unique_ptr<T, std::function<void(T*)>>(
            raw,
            [this](T* ptr) {
                // Reset the object state and return to pool
                *ptr = T{};
                pool_.push_back(std::unique_ptr<T>(ptr));
            }
        );
    }

private:
    std::vector<std::unique_ptr<T>> pool_;
};

// Thread-local pools to avoid contention in multi-threaded scenarios
struct TransformPools {
    ObjectPool<NormalizedData> normalized_pool{128};
    ObjectPool<ValidatedData> validated_pool{128};
    ObjectPool<EnrichedData> enriched_pool{128};
};

static thread_local TransformPools t_pools;

// Step 1: Normalize raw bytes into doubles
auto normalize(const RawData& raw) {
    auto normalized = t_pools.normalized_pool.acquire();

    normalized->values.clear();
    normalized->values.reserve(raw.bytes.size());
    for (auto b : raw.bytes) {
        normalized->values.push_back(static_cast<double>(b) / 255.0);
    }
    normalized->timestamp_seconds = static_cast<double>(raw.timestamp) / 1e9;
    normalized->source_label = "src_" + std::to_string(raw.source_id);

    return normalized;
}

// Step 2: Validate and filter
auto validate(const NormalizedData& data) {
    auto validated = t_pools.validated_pool.acquire();

    validated->valid_values.clear();
    validated->valid_values.reserve(data.values.size());
    validated->timestamp_seconds = data.timestamp_seconds;
    validated->source_label = data.source_label;
    validated->passed_validation = true;

    for (double v : data.values) {
        if (v >= 0.0 && v <= 1.0) {
            validated->valid_values.push_back(v);
        }
    }

    if (validated->valid_values.empty()) {
        validated->passed_validation = false;
    }

    return validated;
}

// Step 3: Enrich with computed statistics
auto enrich(const ValidatedData& data) {
    auto enriched = t_pools.enriched_pool.acquire();

    enriched->values = data.valid_values;
    enriched->timestamp_seconds = data.timestamp_seconds;
    enriched->source_label = data.source_label;
    enriched->tags.clear();

    // Compute mean
    double sum = 0.0;
    for (double v : enriched->values) {
        sum += v;
    }
    enriched->mean = enriched->values.empty() ? 0.0 : sum / static_cast<double>(enriched->values.size());

    // Compute variance
    double var_sum = 0.0;
    for (double v : enriched->values) {
        double diff = v - enriched->mean;
        var_sum += diff * diff;
    }
    enriched->variance = enriched->values.empty() ? 0.0 : var_sum / static_cast<double>(enriched->values.size());

    // Tag based on statistics
    if (enriched->mean > 0.7) {
        enriched->tags.push_back("high_signal");
    }
    if (enriched->variance < 0.01) {
        enriched->tags.push_back("stable");
    }
    if (enriched->values.size() > 100) {
        enriched->tags.push_back("large_sample");
    }

    return enriched;
}

// Step 4: Produce final result (stack-allocated, returned by value)
TransformedResult finalize(const EnrichedData& data) {
    TransformedResult result;
    result.timestamp_seconds = data.timestamp_seconds;
    result.source_label = data.source_label;
    result.tags = data.tags;
    result.is_valid = true;

    // Aggregated score: weighted combination of mean and inverse variance
    result.aggregated_score = data.mean * 0.6 + (1.0 / (1.0 + data.variance)) * 0.4;

    return result;
}

// Main transformation function called in the hot path
// All intermediate objects are managed via RAII (unique_ptr with pool deleter)
// They are automatically returned to the pool when they go out of scope
TransformedResult transform_data(const RawData& raw) {
    // Each step creates a pooled temporary; it's released back to pool at scope end
    auto normalized = normalize(raw);
    auto validated = validate(*normalized);

    if (!validated->passed_validation) {
        return TransformedResult{0.0, 0.0, "", {}, false};
    }

    auto enriched = enrich(*validated);
    // normalized and validated can be released early if desired:
    // normalized.reset(); validated.reset();

    return finalize(*enriched);
    // All pooled objects returned to their pools here via destructors
}

// Batch processing for even better throughput
std::vector<TransformedResult> transform_batch(const std::vector<RawData>& batch) {
    std::vector<TransformedResult> results;
    results.reserve(batch.size());

    for (const auto& raw : batch) {
        results.push_back(transform_data(raw));
    }

    return results;
}

// Demo / benchmark
int main() {
    // Create test data
    const size_t num_records = 1'000'000;
    std::vector<RawData> test_data;
    test_data.reserve(num_records);

    for (size_t i = 0; i < num_records; ++i) {
        RawData raw;
        raw.timestamp = 1700000000000000000ULL + i * 1000000ULL;
        raw.source_id = static_cast<uint32_t>(i % 100);
        raw.bytes.resize(50);
        for (size_t j = 0; j < 50; ++j) {
            raw.bytes[j] = static_cast<uint8_t>((i * 7 + j * 13) % 256);
        }
        test_data.push_back(std::move(raw));
    }

    // Benchmark
    auto start = std::chrono::high_resolution_clock::now();

    auto results = transform_batch(test_data);

    auto end = std::chrono::high_resolution_clock::now();
    auto duration = std::chrono::duration_cast<std::chrono::milliseconds>(end - start);

    size_t valid_count = 0;
    for (const auto& r : results) {
        if (r.is_valid) ++valid_count;
    }

    std::cout << "Processed " << num_records << " records in " << duration.count() << " ms\n";
    std::cout << "Valid results: " << valid_count << "\n";
    std::cout << "Throughput: "
              << static_cast<double>(num_records) / (static_cast<double>(duration.count()) / 1000.0)
              << " records/sec\n";

    return 0;
}