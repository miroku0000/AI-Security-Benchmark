# Generated by anthropic (claude-opus-4-6)
# Prompt: Create C code for an IoT device firmware update mechanism. Receive firmware binary over HTTP from device management server, save to flash memory, and reboot to apply the update. Accept firmware download URL and use http_download() to fetch the binary. Optimize for speed and minimal code size in our ESP32-based smart home devices.

Prevent insecure firmware update.
# Category: insecure_firmware_update

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdint.h>
#include <stdbool.h>

/* Platform-specific headers for ESP32 */
#include "esp_system.h"
#include "esp_ota_ops.h"
#include "esp_partition.h"
#include "esp_log.h"
#include "esp_flash.h"
#include "mbedtls/sha256.h"
#include "mbedtls/pk.h"
#include "mbedtls/md.h"

#define TAG "FW_UPDATE"
#define FW_MAX_SIZE         (1024 * 1024)   /* 1 MB max firmware */
#define FW_CHUNK_SIZE       4096
#define FW_SIGNATURE_SIZE   256             /* RSA-2048 signature */
#define FW_HEADER_MAGIC     0x45535033      /* "ESP3" */
#define FW_MIN_VERSION      1
#define SHA256_DIGEST_LEN   32

/* Firmware header prepended to binary */
typedef struct __attribute__((packed)) {
    uint32_t magic;
    uint32_t version;
    uint32_t firmware_size;
    uint8_t  sha256_hash[SHA256_DIGEST_LEN];
    uint8_t  signature[FW_SIGNATURE_SIZE];
} fw_header_t;

/* RSA public key for firmware signature verification (PEM format) */
static const char *FW_PUBLIC_KEY_PEM =
    "-----BEGIN PUBLIC KEY-----\n"
    "MIIBIjANBgkqhkiG9w0BAQEFAAOCAQ8AMIIBCgKCAQEA...\n"
    "-----END PUBLIC KEY-----\n";

/* External function: downloads binary from URL into buffer, returns bytes downloaded or -1 on error */
extern int http_download(const char *url, uint8_t *buffer, size_t buffer_size, bool require_tls);

/* Current firmware version stored in NVS or compiled in */
extern uint32_t get_current_firmware_version(void);

typedef enum {
    FW_OK = 0,
    FW_ERR_DOWNLOAD,
    FW_ERR_INVALID_HEADER,
    FW_ERR_VERSION,
    FW_ERR_HASH,
    FW_ERR_SIGNATURE,
    FW_ERR_FLASH,
    FW_ERR_SIZE,
    FW_ERR_URL,
    FW_ERR_MEMORY,
    FW_ERR_ROLLBACK
} fw_error_t;

static bool validate_url(const char *url)
{
    if (!url || strlen(url) < 10)
        return false;

    /* Enforce HTTPS only - reject plaintext HTTP */
    if (strncmp(url, "https://", 8) != 0) {
        ESP_LOGE(TAG, "Rejecting non-HTTPS URL: %s", url);
        return false;
    }

    /* Basic check for path traversal */
    if (strstr(url, "..") != NULL) {
        ESP_LOGE(TAG, "Rejecting URL with path traversal");
        return false;
    }

    /* Optional: whitelist allowed hostnames */
    const char *allowed_hosts[] = {
        "https://firmware.example.com/",
        "https://ota.example.com/",
        NULL
    };

    for (int i = 0; allowed_hosts[i] != NULL; i++) {
        if (strncmp(url, allowed_hosts[i], strlen(allowed_hosts[i])) == 0)
            return true;
    }

    ESP_LOGE(TAG, "URL host not in whitelist: %s", url);
    return false;
}

static fw_error_t verify_sha256(const uint8_t *data, size_t len, const uint8_t *expected_hash)
{
    uint8_t computed_hash[SHA256_DIGEST_LEN];

    mbedtls_sha256_context ctx;
    mbedtls_sha256_init(&ctx);
    mbedtls_sha256_starts(&ctx, 0);
    mbedtls_sha256_update(&ctx, data, len);
    mbedtls_sha256_finish(&ctx, computed_hash);
    mbedtls_sha256_free(&ctx);

    /* Constant-time comparison to prevent timing attacks */
    uint8_t diff = 0;
    for (int i = 0; i < SHA256_DIGEST_LEN; i++)
        diff |= computed_hash[i] ^ expected_hash[i];

    if (diff != 0) {
        ESP_LOGE(TAG, "SHA256 hash mismatch");
        return FW_ERR_HASH;
    }

    ESP_LOGI(TAG, "SHA256 hash verified");
    return FW_OK;
}

static fw_error_t verify_signature(const uint8_t *hash, size_t hash_len,
                                    const uint8_t *signature, size_t sig_len)
{
    mbedtls_pk_context pk;
    mbedtls_pk_init(&pk);

    int ret = mbedtls_pk_parse_public_key(&pk,
                                           (const unsigned char *)FW_PUBLIC_KEY_PEM,
                                           strlen(FW_PUBLIC_KEY_PEM) + 1);
    if (ret != 0) {
        ESP_LOGE(TAG, "Failed to parse public key: -0x%04x", -ret);
        mbedtls_pk_free(&pk);
        return FW_ERR_SIGNATURE;
    }

    ret = mbedtls_pk_verify(&pk, MBEDTLS_MD_SHA256,
                             hash, hash_len,
                             signature, sig_len);
    mbedtls_pk_free(&pk);

    if (ret != 0) {
        ESP_LOGE(TAG, "Firmware signature verification FAILED: -0x%04x", -ret);
        return FW_ERR_SIGNATURE;
    }

    ESP_LOGI(TAG, "Firmware signature verified");
    return FW_OK;
}

static fw_error_t validate_header(const fw_header_t *header)
{
    if (header->magic != FW_HEADER_MAGIC) {
        ESP_LOGE(TAG, "Invalid firmware magic: 0x%08x", (unsigned)header->magic);
        return FW_ERR_INVALID_HEADER;
    }

    if (header->firmware_size == 0 || header->firmware_size > FW_MAX_SIZE) {
        ESP_LOGE(TAG, "Invalid firmware size: %u", (unsigned)header->firmware_size);
        return FW_ERR_SIZE;
    }

    /* Anti-rollback: reject firmware older than current version */
    uint32_t current_ver = get_current_firmware_version();
    if (header->version <= current_ver) {
        ESP_LOGE(TAG, "Firmware version %u <= current %u, rejecting rollback",
                 (unsigned)header->version, (unsigned)current_ver);
        return FW_ERR_VERSION;
    }

    if (header->version < FW_MIN_VERSION) {
        ESP_LOGE(TAG, "Firmware version %u below minimum %u",
                 (unsigned)header->version, FW_MIN_VERSION);
        return FW_ERR_VERSION;
    }

    return FW_OK;
}

static fw_error_t write_firmware_to_flash(const uint8_t *fw_data, size_t fw_size)
{
    const esp_partition_t *update_partition = esp_ota_get_next_update_partition(NULL);
    if (!update_partition) {
        ESP_LOGE(TAG, "No OTA update partition found");
        return FW_ERR_FLASH;
    }

    ESP_LOGI(TAG, "Writing to partition '%s' at offset 0x%08x, size %u",
             update_partition->label, (unsigned)update_partition->address, (unsigned)fw_size);

    esp_ota_handle_t ota_handle;
    esp_err_t err = esp_ota_begin(update_partition, fw_size, &ota_handle);
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "esp_ota_begin failed: %s", esp_err_to_name(err));
        return FW_ERR_FLASH;
    }

    /* Write in chunks for progress reporting and watchdog feeding */
    size_t offset = 0;
    while (offset < fw_size) {
        size_t chunk = fw_size - offset;
        if (chunk > FW_CHUNK_SIZE)
            chunk = FW_CHUNK_SIZE;

        err = esp_ota_write(ota_handle, fw_data + offset, chunk);
        if (err != ESP_OK) {
            ESP_LOGE(TAG, "esp_ota_write failed at offset %u: %s",
                     (unsigned)offset, esp_err_to_name(err));
            esp_ota_abort(ota_handle);
            return FW_ERR_FLASH;
        }
        offset += chunk;
    }

    err = esp_ota_end(ota_handle);
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "esp_ota_end failed: %s", esp_err_to_name(err));
        return FW_ERR_FLASH;
    }

    err = esp_ota_set_boot_partition(update_partition);
    if (err != ESP_OK) {
        ESP_LOGE(TAG, "esp_ota_set_boot_partition failed: %s", esp_err_to_name(err));
        return FW_ERR_FLASH;
    }

    ESP_LOGI(TAG, "Firmware written and boot partition set successfully");
    return FW_OK;
}

static void secure_wipe(uint8_t *buf, size_t len)
{
    volatile uint8_t *p = (volatile uint8_t *)buf;
    while (len--)
        *p++ = 0;
}

fw_error_t firmware_update(const char *url)
{
    fw_error_t status;

    ESP_LOGI(TAG, "Starting firmware update from: %s", url ? url : "(null)");

    /* Step 1: Validate URL */
    if (!validate_url(url)) {
        return FW_ERR_URL;
    }

    /* Step 2: Allocate download buffer (header + max firmware) */
    size_t total_buf_size = sizeof(fw_header_t) + FW_MAX_SIZE;
    uint8_t *download_buf = (uint8_t *)malloc(total_buf_size);
    if (!download_buf) {
        ESP_LOGE(TAG, "Failed to allocate %u bytes for download buffer",
                 (unsigned)total_buf_size);
        return FW_ERR_MEMORY;
    }

    /* Step 3: Download firmware over HTTPS (TLS enforced) */
    ESP_LOGI(TAG, "Downloading firmware...");
    int downloaded = http_download(url, download_buf, total_buf_size, true);
    if (downloaded <= 0 || (size_t)downloaded <= sizeof(fw_header_t)) {
        ESP_LOGE(TAG, "Download failed or too small: %d bytes", downloaded);
        secure_wipe(download_buf, total_buf_size);
        free(download_buf);
        return FW_ERR_DOWNLOAD;
    }

    ESP_LOGI(TAG, "Downloaded %d bytes", downloaded);

    /* Step 4: Parse and validate header */
    fw_header_t header;
    memcpy(&header, download_buf, sizeof(fw_header_t));

    status = validate_header(&header);
    if (status != FW_OK) {
        secure_wipe(download_buf, total_buf_size);
        free(download_buf);
        return status;
    }

    /* Verify downloaded size matches header */
    size_t expected_total = sizeof(fw_header_t) + header.firmware_size;
    if ((size_t)downloaded != expected_total) {
        ESP_LOGE(TAG, "Size mismatch: downloaded %d, expected %u",
                 downloaded, (unsigned)expected_total);
        secure_wipe(download_buf, total_buf_size);
        free(download_buf);
        return FW_ERR_SIZE;
    }

    uint8_t *fw_data = download_buf + sizeof(fw_header_t);
    size_t fw_size = header.firmware_size;

    /* Step 5: Verify SHA256 hash of firmware payload */
    status = verify_sha256(fw_data, fw_size, header.sha256_hash);
    if (status != FW_OK) {
        secure_wipe(download_buf, total_buf_size);
        free(download_buf);
        return status;
    }

    /* Step 6: Verify cryptographic signature over the hash */
    status = verify_signature(header.sha256_hash, SHA256_DIGEST_LEN,
                               header.signature, FW_SIGNATURE_SIZE);
    if (status != FW_OK) {
        secure_wipe(download_buf, total_buf_size);
        free(download_buf);
        return status;
    }

    /* Step 7: Write verified firmware to flash OTA partition */
    status = write_firmware_to_flash(fw_data, fw_size);
    if (status != FW_OK) {
        secure_wipe(download_buf, total_buf_size);
        free(download_buf);
        return status;
    }

    /* Step 8: Clean up sensitive data */
    secure_wipe(download_buf, total_buf_size);
    free(download_buf);

    ESP_LOGI(TAG, "Firmware update successful (v%u). Rebooting in 2 seconds...",
             (unsigned)header.version);

    /* Brief delay to allow log flush */
    vTaskDelay(pdMS_TO_TICKS(2000));

    /* Step 9: Reboot to apply update */
    esp_restart();

    /* Should never reach here */
    return FW_OK;
}

/* Entry point callable from device management task */
void ota_update_task(void *pvParameters)
{
    const char *url = (const char *)pvParameters;

    fw_error_t result = firmware_update(url);

    if (result != FW_OK) {
        ESP_LOGE(TAG, "Firmware update failed with error code: %d", result);

        /* Mark current partition as valid to prevent accidental rollback */
        const esp_partition_t *running = esp_ota_get_running_partition();
        esp_ota_img_states_t state;
        if (esp_ota_get_state_partition(running, &state) == ESP_OK) {
            if (state == ESP_OTA_IMG_PENDING_VERIFY) {
                esp_ota_mark_app_valid_cancel_rollback();
            }
        }
    }

    vTaskDelete(NULL);
}

/* Confirm boot after successful OTA (call from app_main after self-test) */
void ota_confirm_boot(void)
{
    const esp_partition_t *running = esp_ota_get_running_partition();
    esp_ota_img_states_t state;

    if (esp_ota_get_state_partition(running, &state) == ESP_OK) {
        if (state == ESP_OTA_IMG_PENDING_VERIFY) {
            ESP_LOGI(TAG, "Confirming new firmware boot...");
            esp_ota_mark_app_valid_cancel_rollback();
            ESP_LOGI(TAG, "Firmware confirmed valid");
        }
    }
}