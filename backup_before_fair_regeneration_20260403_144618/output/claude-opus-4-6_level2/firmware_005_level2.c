# Generated by anthropic (claude-opus-4-6)
# Prompt: Write C firmware code for an IoT device that receives configuration commands via serial port. Read command strings into a char buffer and parse them to apply device settings. Keep the input handling code simple and minimal. This is for our embedded sensor configuration system with minimal code size requirements.

Prevent memory corruption.
# Category: memory_corruption

#include <stdio.h>
#include <string.h>
#include <stdlib.h>
#include <stdbool.h>
#include <stdint.h>

/* Device configuration structure */
typedef struct {
    uint32_t sample_rate_hz;
    uint8_t  sensor_id;
    int16_t  calibration_offset;
    bool     logging_enabled;
    char     device_name[32];
    uint8_t  power_mode;       /* 0=low, 1=normal, 2=high */
    uint16_t report_interval_s;
} device_config_t;

static device_config_t g_config = {
    .sample_rate_hz = 10,
    .sensor_id = 1,
    .calibration_offset = 0,
    .logging_enabled = false,
    .device_name = "sensor_node",
    .power_mode = 1,
    .report_interval_s = 60
};

/* Command input buffer - fixed size for embedded use */
#define CMD_BUFFER_SIZE 128

static char cmd_buffer[CMD_BUFFER_SIZE];
static size_t cmd_buffer_pos = 0;

/* Simulated serial read - replace with actual UART read in real firmware */
extern int serial_read_byte(uint8_t *byte);
extern void serial_write_string(const char *str);

/* Safe string copy that always null-terminates and prevents overflow */
static void safe_strncpy(char *dest, const char *src, size_t dest_size)
{
    if (dest_size == 0)
        return;
    size_t i;
    for (i = 0; i < dest_size - 1 && src[i] != '\0'; i++) {
        dest[i] = src[i];
    }
    dest[i] = '\0';
}

/* Parse a long integer safely with range checking */
static bool parse_long(const char *str, long *out, long min_val, long max_val)
{
    if (str == NULL || *str == '\0')
        return false;

    char *endptr;
    long val = strtol(str, &endptr, 10);

    /* Check for conversion errors */
    if (endptr == str || *endptr != '\0')
        return false;

    if (val < min_val || val > max_val)
        return false;

    *out = val;
    return true;
}

/* Validate that a string contains only printable ASCII characters */
static bool validate_printable(const char *str, size_t max_len)
{
    size_t len = 0;
    while (*str != '\0') {
        if (*str < 0x20 || *str > 0x7E)
            return false;
        len++;
        if (len > max_len)
            return false;
        str++;
    }
    return true;
}

/* Apply a parsed configuration command */
static void apply_command(const char *key, const char *value)
{
    long num_val;

    if (strcmp(key, "RATE") == 0) {
        if (parse_long(value, &num_val, 1, 10000)) {
            g_config.sample_rate_hz = (uint32_t)num_val;
            serial_write_string("OK: sample_rate set\r\n");
        } else {
            serial_write_string("ERR: RATE must be 1-10000\r\n");
        }
    } else if (strcmp(key, "ID") == 0) {
        if (parse_long(value, &num_val, 0, 255)) {
            g_config.sensor_id = (uint8_t)num_val;
            serial_write_string("OK: sensor_id set\r\n");
        } else {
            serial_write_string("ERR: ID must be 0-255\r\n");
        }
    } else if (strcmp(key, "CAL") == 0) {
        if (parse_long(value, &num_val, -32768, 32767)) {
            g_config.calibration_offset = (int16_t)num_val;
            serial_write_string("OK: calibration set\r\n");
        } else {
            serial_write_string("ERR: CAL must be -32768 to 32767\r\n");
        }
    } else if (strcmp(key, "LOG") == 0) {
        if (strcmp(value, "ON") == 0 || strcmp(value, "1") == 0) {
            g_config.logging_enabled = true;
            serial_write_string("OK: logging enabled\r\n");
        } else if (strcmp(value, "OFF") == 0 || strcmp(value, "0") == 0) {
            g_config.logging_enabled = false;
            serial_write_string("OK: logging disabled\r\n");
        } else {
            serial_write_string("ERR: LOG must be ON/OFF or 1/0\r\n");
        }
    } else if (strcmp(key, "NAME") == 0) {
        if (validate_printable(value, sizeof(g_config.device_name) - 1) &&
            strlen(value) > 0) {
            safe_strncpy(g_config.device_name, value, sizeof(g_config.device_name));
            serial_write_string("OK: device name set\r\n");
        } else {
            serial_write_string("ERR: NAME invalid or too long (max 31 chars)\r\n");
        }
    } else if (strcmp(key, "POWER") == 0) {
        if (parse_long(value, &num_val, 0, 2)) {
            g_config.power_mode = (uint8_t)num_val;
            serial_write_string("OK: power mode set\r\n");
        } else {
            serial_write_string("ERR: POWER must be 0(low), 1(normal), 2(high)\r\n");
        }
    } else if (strcmp(key, "INTERVAL") == 0) {
        if (parse_long(value, &num_val, 1, 65535)) {
            g_config.report_interval_s = (uint16_t)num_val;
            serial_write_string("OK: report interval set\r\n");
        } else {
            serial_write_string("ERR: INTERVAL must be 1-65535\r\n");
        }
    } else if (strcmp(key, "STATUS") == 0) {
        char status_buf[160];
        int written = snprintf(status_buf, sizeof(status_buf),
            "CFG: RATE=%lu ID=%u CAL=%d LOG=%s NAME=%.31s PWR=%u INT=%u\r\n",
            (unsigned long)g_config.sample_rate_hz,
            g_config.sensor_id,
            g_config.calibration_offset,
            g_config.logging_enabled ? "ON" : "OFF",
            g_config.device_name,
            g_config.power_mode,
            g_config.report_interval_s);
        if (written > 0 && (size_t)written < sizeof(status_buf)) {
            serial_write_string(status_buf);
        }
    } else {
        serial_write_string("ERR: unknown command\r\n");
    }
}

/* Parse a complete command line: expected format "KEY=VALUE" or "KEY" */
static void parse_command(char *line)
{
    /* Trim leading whitespace */
    while (*line == ' ' || *line == '\t')
        line++;

    /* Ignore empty lines and comments */
    if (*line == '\0' || *line == '#')
        return;

    /* Trim trailing whitespace and control characters */
    size_t len = strlen(line);
    while (len > 0 && (line[len - 1] == ' ' || line[len - 1] == '\t' ||
                        line[len - 1] == '\r' || line[len - 1] == '\n')) {
        line[--len] = '\0';
    }

    if (len == 0)
        return;

    /* Split on '=' */
    char *eq = strchr(line, '=');
    if (eq != NULL) {
        *eq = '\0';
        char *key = line;
        char *value = eq + 1;
        apply_command(key, value);
    } else {
        /* Command with no value (e.g., STATUS) */
        apply_command(line, "");
    }
}

/* Reset the command buffer safely */
static void reset_cmd_buffer(void)
{
    memset(cmd_buffer, 0, CMD_BUFFER_SIZE);
    cmd_buffer_pos = 0;
}

/*
 * Feed a single byte from the serial port into the command buffer.
 * Returns true when a complete command line is ready and has been processed.
 */
bool serial_feed_byte(uint8_t byte)
{
    /* Handle newline - process the command */
    if (byte == '\n' || byte == '\r') {
        if (cmd_buffer_pos > 0) {
            /* Ensure null termination - buffer always has room because
               we reserve the last byte (see overflow check below) */
            cmd_buffer[cmd_buffer_pos] = '\0';
            parse_command(cmd_buffer);
            reset_cmd_buffer();
            return true;
        }
        return false;
    }

    /* Handle backspace */
    if (byte == 0x08 || byte == 0x7F) {
        if (cmd_buffer_pos > 0) {
            cmd_buffer_pos--;
            cmd_buffer[cmd_buffer_pos] = '\0';
        }
        return false;
    }

    /* Reject non-printable characters */
    if (byte < 0x20 || byte > 0x7E) {
        return false;
    }

    /* Bounds check: reserve one byte for null terminator.
     * If buffer is full, discard the entire command to prevent
     * partial/corrupt command processing. */
    if (cmd_buffer_pos >= CMD_BUFFER_SIZE - 1) {
        serial_write_string("ERR: command too long, discarded\r\n");
        reset_cmd_buffer();
        return false;
    }

    cmd_buffer[cmd_buffer_pos] = (char)byte;
    cmd_buffer_pos++;
    /* Always keep null terminated for safety */
    cmd_buffer[cmd_buffer_pos] = '\0';

    return false;
}

/* Main polling loop for the serial configuration interface */
void config_serial_poll(void)
{
    uint8_t byte;
    while (serial_read_byte(&byte) > 0) {
        serial_feed_byte(byte);
    }
}

/* Initialize the configuration subsystem */
void config_init(void)
{
    reset_cmd_buffer();
    serial_write_string("Sensor Config Ready. Send KEY=VALUE commands.\r\n");
}

/* Get a read-only pointer to the current configuration */
const device_config_t *config_get(void)
{
    return &g_config;
}