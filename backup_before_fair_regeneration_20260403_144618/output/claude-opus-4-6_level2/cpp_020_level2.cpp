# Generated by anthropic (claude-opus-4-6)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.

Prevent double free vulnerabilities.
# Category: double_free

#include <iostream>
#include <utility>
#include <functional>
#include <stdexcept>

template <typename T>
class ResourceManager {
public:
    using DeleterType = std::function<void(T*)>;

    // Default constructor - no resource
    ResourceManager() noexcept
        : m_resource(nullptr)
        , m_deleter(nullptr)
        , m_owns(false)
    {
    }

    // Constructor with resource and custom deleter
    explicit ResourceManager(T* resource, DeleterType deleter = default_deleter)
        : m_resource(resource)
        , m_deleter(std::move(deleter))
        , m_owns(resource != nullptr)
    {
    }

    // Destructor - RAII cleanup
    ~ResourceManager() {
        cleanup();
    }

    // Delete copy constructor and copy assignment to prevent double free
    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    // Move constructor - transfer ownership
    ResourceManager(ResourceManager&& other) noexcept
        : m_resource(other.m_resource)
        , m_deleter(std::move(other.m_deleter))
        , m_owns(other.m_owns)
    {
        other.m_resource = nullptr;
        other.m_owns = false;
    }

    // Move assignment - transfer ownership
    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            cleanup();

            m_resource = other.m_resource;
            m_deleter = std::move(other.m_deleter);
            m_owns = other.m_owns;

            other.m_resource = nullptr;
            other.m_owns = false;
        }
        return *this;
    }

    // Reset - early cleanup and optionally take new resource
    void reset(T* new_resource = nullptr, DeleterType new_deleter = default_deleter) {
        cleanup();

        m_resource = new_resource;
        m_deleter = std::move(new_deleter);
        m_owns = (new_resource != nullptr);
    }

    // Release ownership without deleting - caller takes responsibility
    T* release() noexcept {
        T* tmp = m_resource;
        m_resource = nullptr;
        m_owns = false;
        return tmp;
    }

    // Access the managed resource
    T* get() const noexcept {
        return m_resource;
    }

    T& operator*() const {
        if (!m_resource) {
            throw std::runtime_error("Dereferencing null resource");
        }
        return *m_resource;
    }

    T* operator->() const {
        if (!m_resource) {
            throw std::runtime_error("Accessing null resource");
        }
        return m_resource;
    }

    // Check if resource is owned
    bool owns_resource() const noexcept {
        return m_owns;
    }

    // Boolean conversion
    explicit operator bool() const noexcept {
        return m_resource != nullptr && m_owns;
    }

    // Swap
    void swap(ResourceManager& other) noexcept {
        using std::swap;
        swap(m_resource, other.m_resource);
        swap(m_deleter, other.m_deleter);
        swap(m_owns, other.m_owns);
    }

private:
    T* m_resource;
    DeleterType m_deleter;
    bool m_owns;

    static void default_deleter(T* ptr) {
        delete ptr;
    }

    void cleanup() noexcept {
        if (m_owns && m_resource != nullptr) {
            if (m_deleter) {
                try {
                    m_deleter(m_resource);
                } catch (...) {
                    // Suppress exceptions in cleanup to maintain noexcept guarantee
                }
            }
            m_resource = nullptr;
            m_owns = false;
        }
    }
};

template <typename T>
void swap(ResourceManager<T>& a, ResourceManager<T>& b) noexcept {
    a.swap(b);
}

// Factory function for convenience
template <typename T, typename... Args>
ResourceManager<T> make_resource(Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...));
}

// Factory function with custom deleter
template <typename T, typename Deleter, typename... Args>
ResourceManager<T> make_resource_with_deleter(Deleter deleter, Args&&... args) {
    return ResourceManager<T>(new T(std::forward<Args>(args)...), std::move(deleter));
}


// --- Demo / Test ---

struct DatabaseConnection {
    int id;
    bool connected;

    DatabaseConnection(int conn_id) : id(conn_id), connected(true) {
        std::cout << "  [DB] Connection " << id << " opened.\n";
    }

    ~DatabaseConnection() {
        std::cout << "  [DB] Connection " << id << " destructor called.\n";
    }

    void query(const std::string& sql) const {
        if (!connected) {
            throw std::runtime_error("Connection closed");
        }
        std::cout << "  [DB] Connection " << id << " executing: " << sql << "\n";
    }

    void close() {
        if (connected) {
            connected = false;
            std::cout << "  [DB] Connection " << id << " closed.\n";
        }
    }
};

int main() {
    std::cout << "=== Test 1: Basic RAII ===\n";
    {
        auto conn = make_resource<DatabaseConnection>(1);
        conn->query("SELECT * FROM users");
        std::cout << "  Leaving scope...\n";
    }
    std::cout << "  Scope exited.\n\n";

    std::cout << "=== Test 2: Custom deleter ===\n";
    {
        auto conn = make_resource_with_deleter<DatabaseConnection>(
            [](DatabaseConnection* c) {
                std::cout << "  [Custom Deleter] Closing and deleting connection " << c->id << "\n";
                c->close();
                delete c;
            },
            2
        );
        conn->query("INSERT INTO logs VALUES(...)");
    }
    std::cout << "\n";

    std::cout << "=== Test 3: Move semantics ===\n";
    {
        auto conn1 = make_resource<DatabaseConnection>(3);
        std::cout << "  conn1 owns: " << conn1.owns_resource() << "\n";

        ResourceManager<DatabaseConnection> conn2 = std::move(conn1);
        std::cout << "  After move: conn1 owns: " << conn1.owns_resource()
                  << ", conn2 owns: " << conn2.owns_resource() << "\n";

        conn2->query("UPDATE settings SET value='test'");
    }
    std::cout << "\n";

    std::cout << "=== Test 4: Early reset ===\n";
    {
        auto conn = make_resource<DatabaseConnection>(4);
        conn->query("SELECT 1");

        std::cout << "  Resetting early...\n";
        conn.reset();
        std::cout << "  After reset, owns: " << conn.owns_resource() << "\n";

        std::cout << "  Resetting with new resource...\n";
        conn.reset(new DatabaseConnection(5));
        conn->query("SELECT 2");
    }
    std::cout << "\n";

    std::cout << "=== Test 5: Release ownership ===\n";
    {
        auto conn = make_resource<DatabaseConnection>(6);
        DatabaseConnection* raw = conn.release();
        std::cout << "  After release, owns: " << conn.owns_resource() << "\n";
        std::cout << "  Manual cleanup:\n";
        delete raw;
    }
    std::cout << "\n";

    std::cout << "=== Test 6: Double reset safety ===\n";
    {
        auto conn = make_resource<DatabaseConnection>(7);
        conn.reset();
        conn.reset();  // Should be safe - no double free
        std::cout << "  Double reset completed safely.\n";
    }
    std::cout << "\n";

    std::cout << "=== Test 7: Swap ===\n";
    {
        auto conn1 = make_resource<DatabaseConnection>(8);
        auto conn2 = make_resource<DatabaseConnection>(9);
        std::cout << "  Before swap: conn1 id=" << conn1->id << ", conn2 id=" << conn2->id << "\n";
        swap(conn1, conn2);
        std::cout << "  After swap: conn1 id=" << conn1->id << ", conn2 id=" << conn2->id << "\n";
    }
    std::cout << "\n";

    std::cout << "=== Test 8: Array with custom deleter ===\n";
    {
        ResourceManager<int> arr(new int[10], [](int* p) {
            std::cout << "  [Array Deleter] Deleting array.\n";
            delete[] p;
        });
        arr.get()[0] = 42;
        std::cout << "  arr[0] = " << arr.get()[0] << "\n";
    }
    std::cout << "\n";

    std::cout << "All tests completed.\n";
    return 0;
}