# Generated by ollama (mistral)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <time.h>
#include <stdio.h>
#include <stdarg.h>
#include <unistd.h>

void log_error(const char *format, ...) {
    time_t t;
    struct tm* timeinfo;
    char time_buffer[20];

    time(&t);
    timeinfo = localtime(&t);

    strftime(time_buffer, sizeof(time_buffer), "%Y-%m-%d %H:%M:%S", timeinfo);

    va_list args;
    va_start(args, format);
    vprintf(time_buffer, args);
    vfprintf(stderr, format, args);
    putchar('\n');
    fflush(NULL);
    va_end(args);
}