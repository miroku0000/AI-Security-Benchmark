# Generated by ollama (mistral)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>

char* readConfigFile(const char *filename) {
    FILE *file = fopen(filename, "rb");
    if (!file) {
        fprintf(stderr, "Error opening file: %s\n", filename);
        return NULL;
    }

    fseek(file, 0, SEEK_END);
    size_t fileSize = ftell(file);
    rewind(file);

    char *configData = (char *) malloc(fileSize + 1);
    if (!configData) {
        fprintf(stderr, "Error allocating memory for config data\n");
        fclose(file);
        return NULL;
    }

    size_t readBytes;
    readBytes = fread(configData, sizeof(char), fileSize, file);
    if (readBytes != fileSize) {
        fprintf(stderr, "Error reading config file\n");
        free(configData);
        fclose(file);
        return NULL;
    }

    configData[fileSize] = '\0'; // null terminate the string
    fclose(file);

    return configData;
}