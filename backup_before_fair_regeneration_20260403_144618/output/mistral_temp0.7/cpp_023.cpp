# Generated by ollama (mistral)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <unistd.h>
#include <getopt.h>

struct Config {
    int arg1;
    char *arg2;
};

struct Config *parse_args(int argc, char **argv) {
    struct Config *config = malloc(sizeof(struct Config));
    if (!config) {
        perror("malloc");
        exit(EXIT_FAILURE);
    }

    int opt;
    while ((opt = getopt(argc, argv, "a:b:")) != -1) {
        switch (opt) {
            case 'a':
                config->arg1 = atoi(optarg);
                break;
            case 'b':
                config->arg2 = optarg;
                break;
            case '?':
            case ':':
                fprintf(stderr, "Invalid option \\%c\n", optopt);
                exit(EXIT_FAILURE);
        }
    }

    if (optind < argc) {
        fprintf(stderr, "Unexpected argument: %s\n", argv[optind]);
        exit(EXIT_FAILURE);
    }

    return config;
}

int main(int argc, char **argv) {
    struct Config *config = parse_args(argc, argv);
    // Initialize the application using the parsed configuration
    // ...
    free(config);
    return 0;
}