# Generated by openai (gpt-5.2)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <atomic>
#include <chrono>
#include <condition_variable>
#include <cstdint>
#include <deque>
#include <functional>
#include <memory>
#include <mutex>
#include <optional>
#include <random>
#include <string>
#include <thread>
#include <unordered_map>
#include <utility>
#include <vector>

namespace hpnet {

enum class ConnState : uint8_t { Disconnected, Connecting, Connected, Closing, Closed, Failed };
enum class ConnError : uint8_t { None, ConnectFailed, IoError, ProtocolError, Timeout, ClosedByPeer, Unknown };

struct Endpoint {
    std::string host;
    uint16_t port{0};

    bool operator==(const Endpoint& o) const noexcept { return port == o.port && host == o.host; }
};

struct EndpointHash {
    size_t operator()(const Endpoint& e) const noexcept {
        std::hash<std::string> hs;
        std::hash<uint16_t> hp;
        size_t h = hs(e.host);
        h ^= (static_cast<size_t>(hp(e.port)) + 0x9e3779b97f4a7c15ull + (h << 6) + (h >> 2));
        return h;
    }
};

struct RetryPolicy {
    uint32_t maxAttempts{5};
    std::chrono::milliseconds baseDelay{20};
    std::chrono::milliseconds maxDelay{500};
    bool jitter{true};
    double backoffFactor{2.0};
};

struct ConnectOptions {
    std::chrono::milliseconds connectTimeout{2000};
    std::chrono::milliseconds ioTimeout{5000};
    bool keepAlive{true};
    bool tcpNoDelay{true};
};

struct IOResult {
    bool ok{true};
    ConnError error{ConnError::None};
    size_t bytes{0};
};

class ITransport {
public:
    virtual ~ITransport() = default;
    virtual bool connect(const Endpoint& ep, const ConnectOptions& opt, ConnError& err) = 0;
    virtual void close() = 0;
    virtual IOResult send(const void* data, size_t len, std::chrono::milliseconds timeout) = 0;
    virtual IOResult recv(void* data, size_t len, std::chrono::milliseconds timeout) = 0;
    virtual bool isAlive() const = 0;
};

class NullTransport final : public ITransport {
public:
    bool connect(const Endpoint&, const ConnectOptions&, ConnError& err) override {
        err = ConnError::None;
        alive_.store(true, std::memory_order_release);
        return true;
    }
    void close() override { alive_.store(false, std::memory_order_release); }
    IOResult send(const void*, size_t len, std::chrono::milliseconds) override {
        if (!alive_.load(std::memory_order_acquire)) return {false, ConnError::IoError, 0};
        return {true, ConnError::None, len};
    }
    IOResult recv(void*, size_t, std::chrono::milliseconds) override {
        if (!alive_.load(std::memory_order_acquire)) return {false, ConnError::IoError, 0};
        return {true, ConnError::None, 0};
    }
    bool isAlive() const override { return alive_.load(std::memory_order_acquire); }
private:
    std::atomic<bool> alive_{false};
};

class Connection final : public std::enable_shared_from_this<Connection> {
public:
    using TransportFactory = std::function<std::unique_ptr<ITransport>()>;

    Connection(uint64_t id, Endpoint ep, TransportFactory factory, ConnectOptions opt)
        : id_(id), endpoint_(std::move(ep)), factory_(std::move(factory)), opt_(opt) {
        transport_ = factory_ ? factory_() : std::make_unique<NullTransport>();
    }

    uint64_t id() const noexcept { return id_; }
    const Endpoint& endpoint() const noexcept { return endpoint_; }

    ConnState state() const noexcept { return state_.load(std::memory_order_acquire); }
    ConnError lastError() const noexcept { return lastError_.load(std::memory_order_acquire); }

    bool connect(ConnError& err) {
        ConnState expected = ConnState::Disconnected;
        if (!state_.compare_exchange_strong(expected, ConnState::Connecting, std::memory_order_acq_rel)) {
            expected = ConnState::Failed;
            if (state_.compare_exchange_strong(expected, ConnState::Connecting, std::memory_order_acq_rel)) {
            } else if (state_.load(std::memory_order_acquire) == ConnState::Connected) {
                err = ConnError::None;
                return true;
            } else if (state_.load(std::memory_order_acquire) == ConnState::Connecting) {
                err = ConnError::None;
                return transport_ && transport_->isAlive();
            } else {
                err = lastError();
                return false;
            }
        }

        ConnError e = ConnError::Unknown;
        bool ok = false;
        if (!transport_) transport_ = factory_ ? factory_() : std::make_unique<NullTransport>();
        ok = transport_->connect(endpoint_, opt_, e);
        lastError_.store(ok ? ConnError::None : e, std::memory_order_release);
        state_.store(ok ? ConnState::Connected : ConnState::Failed, std::memory_order_release);
        err = ok ? ConnError::None : e;
        return ok;
    }

    void close() {
        ConnState s = state_.load(std::memory_order_acquire);
        if (s == ConnState::Closed || s == ConnState::Closing) return;
        state_.store(ConnState::Closing, std::memory_order_release);
        if (transport_) transport_->close();
        state_.store(ConnState::Closed, std::memory_order_release);
    }

    void markFailed(ConnError e) {
        lastError_.store(e, std::memory_order_release);
        state_.store(ConnState::Failed, std::memory_order_release);
        if (transport_) transport_->close();
    }

    bool resetTransport() {
        if (!factory_) return false;
        transport_.reset();
        transport_ = factory_();
        return static_cast<bool>(transport_);
    }

    IOResult send(const void* data, size_t len) {
        if (state_.load(std::memory_order_acquire) != ConnState::Connected || !transport_) return {false, ConnError::IoError, 0};
        auto r = transport_->send(data, len, opt_.ioTimeout);
        if (!r.ok) markFailed(r.error);
        return r;
    }

    IOResult recv(void* data, size_t len) {
        if (state_.load(std::memory_order_acquire) != ConnState::Connected || !transport_) return {false, ConnError::IoError, 0};
        auto r = transport_->recv(data, len, opt_.ioTimeout);
        if (!r.ok) markFailed(r.error);
        return r;
    }

    bool isAlive() const {
        if (state_.load(std::memory_order_acquire) != ConnState::Connected) return false;
        return transport_ && transport_->isAlive();
    }

private:
    uint64_t id_{0};
    Endpoint endpoint_;
    TransportFactory factory_;
    ConnectOptions opt_;

    std::unique_ptr<ITransport> transport_;
    std::atomic<ConnState> state_{ConnState::Disconnected};
    std::atomic<ConnError> lastError_{ConnError::None};
};

class ConnectionHandle final {
public:
    ConnectionHandle() = default;
    explicit ConnectionHandle(std::shared_ptr<Connection> c) : conn_(std::move(c)) {}
    Connection* get() const noexcept { return conn_.get(); }
    Connection& operator*() const { return *conn_; }
    Connection* operator->() const noexcept { return conn_.get(); }
    explicit operator bool() const noexcept { return static_cast<bool>(conn_); }
    uint64_t id() const noexcept { return conn_ ? conn_->id() : 0; }
    std::shared_ptr<Connection> shared() const noexcept { return conn_; }
private:
    std::shared_ptr<Connection> conn_;
};

class ConnectionPool final {
public:
    using TransportFactory = Connection::TransportFactory;

    struct Config {
        size_t maxPerEndpoint{64};
        size_t maxTotal{256};
        size_t maxIdlePerEndpoint{64};
        std::chrono::milliseconds maxIdleTime{std::chrono::milliseconds(30000)};
        bool reuseFailedHandle{true};
        RetryPolicy retry;
        ConnectOptions connect;
        TransportFactory transportFactory;
    };

    explicit ConnectionPool(Config cfg)
        : cfg_(std::move(cfg)) {
        if (!cfg_.transportFactory) {
            cfg_.transportFactory = []() { return std::make_unique<NullTransport>(); };
        }
    }

    ConnectionHandle acquire(const Endpoint& ep) {
        std::unique_lock<std::mutex> lk(mu_);
        reapIdleLocked(ep);

        auto& q = idle_[ep];
        while (!q.empty()) {
            auto w = q.front();
            q.pop_front();
            auto c = w.lock();
            if (!c) continue;
            if (c->state() == ConnState::Connected && c->isAlive()) {
                inUse_[c->id()] = c;
                return ConnectionHandle(std::move(c));
            }
            if (cfg_.reuseFailedHandle) {
                inUse_[c->id()] = c;
                return ConnectionHandle(std::move(c));
            }
        }

        if (total_ >= cfg_.maxTotal) {
            if (!evictOneLocked()) {
                return ConnectionHandle{};
            }
        }

        size_t per = perEndpointCountLocked(ep);
        if (per >= cfg_.maxPerEndpoint) {
            if (!stealOneLocked(ep)) {
                return ConnectionHandle{};
            }
        }

        auto id = nextId_++;
        auto c = std::make_shared<Connection>(id, ep, cfg_.transportFactory, cfg_.connect);
        all_[id] = c;
        inUse_[id] = c;
        ++total_;
        return ConnectionHandle(std::move(c));
    }

    void release(ConnectionHandle& h, bool keepForReuse = true) {
        auto c = h.shared();
        h = ConnectionHandle{};
        if (!c) return;

        std::unique_lock<std::mutex> lk(mu_);
        inUse_.erase(c->id());

        if (!keepForReuse) {
            dropLocked(c->id());
            return;
        }

        if (c->state() == ConnState::Connected && c->isAlive()) {
            auto& q = idle_[c->endpoint()];
            if (q.size() >= cfg_.maxIdlePerEndpoint) {
                dropLocked(c->id());
                return;
            }
            touch_[c->id()] = std::chrono::steady_clock::now();
            q.push_back(c);
            return;
        }

        if (cfg_.reuseFailedHandle) {
            auto& q = idle_[c->endpoint()];
            if (q.size() >= cfg_.maxIdlePerEndpoint) {
                dropLocked(c->id());
                return;
            }
            touch_[c->id()] = std::chrono::steady_clock::now();
            q.push_back(c);
            return;
        }

        dropLocked(c->id());
    }

    bool ensureConnected(ConnectionHandle& h) {
        if (!h) return false;
        auto c = h.shared();
        if (!c) return false;
        if (c->state() == ConnState::Connected && c->isAlive()) return true;

        ConnError err = ConnError::Unknown;
        uint32_t attempts = 0;

        auto delay = cfg_.retry.baseDelay;
        std::minstd_rand rng(static_cast<unsigned>(std::chrono::high_resolution_clock::now().time_since_epoch().count()));

        while (attempts < cfg_.retry.maxAttempts) {
            ++attempts;

            if (c->state() == ConnState::Failed || c->state() == ConnState::Closed) {
                c->resetTransport();
            }

            if (c->connect(err)) {
                return true;
            }

            if (!cfg_.reuseFailedHandle) {
                std::unique_lock<std::mutex> lk(mu_);
                auto id = c->id();
                dropLocked(id);
                lk.unlock();

                h = acquire(c->endpoint());
                c = h.shared();
                if (!c) return false;
            }

            if (attempts >= cfg_.retry.maxAttempts) break;

            auto sleepFor = delay;
            if (cfg_.retry.jitter) {
                std::uniform_int_distribution<int64_t> dist(0, static_cast<int64_t>(delay.count()));
                sleepFor = std::chrono::milliseconds(dist(rng));
            }
            std::this_thread::sleep_for(sleepFor);

            auto next = static_cast<int64_t>(delay.count() * cfg_.retry.backoffFactor);
            if (next < 1) next = 1;
            if (next > static_cast<int64_t>(cfg_.retry.maxDelay.count())) next = static_cast<int64_t>(cfg_.retry.maxDelay.count());
            delay = std::chrono::milliseconds(next);
        }

        if (c) c->markFailed(err);
        return false;
    }

    IOResult sendWithReconnect(ConnectionHandle& h, const void* data, size_t len) {
        if (!ensureConnected(h)) return {false, ConnError::ConnectFailed, 0};
        auto r = h->send(data, len);
        if (r.ok) return r;

        if (!ensureConnected(h)) return r;
        return h->send(data, len);
    }

    IOResult recvWithReconnect(ConnectionHandle& h, void* data, size_t len) {
        if (!ensureConnected(h)) return {false, ConnError::ConnectFailed, 0};
        auto r = h->recv(data, len);
        if (r.ok) return r;

        if (!ensureConnected(h)) return r;
        return h->recv(data, len);
    }

    void reapIdle() {
        std::unique_lock<std::mutex> lk(mu_);
        auto now = std::chrono::steady_clock::now();
        for (auto it = touch_.begin(); it != touch_.end();) {
            auto id = it->first;
            auto t = it->second;
            if (now - t <= cfg_.maxIdleTime) {
                ++it;
                continue;
            }
            auto a = all_.find(id);
            if (a != all_.end()) {
                auto c = a->second;
                if (c) {
                    removeFromIdleLocked(c);
                    dropLocked(id);
                } else {
                    all_.erase(a);
                    touch_.erase(it++);
                    continue;
                }
            }
            it = touch_.erase(it);
        }
    }

    size_t total() const noexcept { return total_.load(std::memory_order_acquire); }

private:
    size_t perEndpointCountLocked(const Endpoint& ep) const {
        size_t count = 0;
        for (const auto& [id, c] : all_) {
            if (c && c->endpoint() == ep) ++count;
        }
        return count;
    }

    void reapIdleLocked(const Endpoint& ep) {
        auto it = idle_.find(ep);
        if (it == idle_.end()) return;

        auto now = std::chrono::steady_clock::now();
        auto& q = it->second;
        std::deque<std::weak_ptr<Connection>> keep;
        keep.swap(q);
        for (auto& w : keep) {
            auto c = w.lock();
            if (!c) continue;
            auto tid = touch_.find(c->id());
            if (tid != touch_.end() && (now - tid->second) > cfg_.maxIdleTime) {
                dropLocked(c->id());
                continue;
            }
            q.push_back(c);
        }
    }

    void removeFromIdleLocked(const std::shared_ptr<Connection>& c) {
        auto it = idle_.find(c->endpoint());
        if (it == idle_.end()) return;
        auto& q = it->second;
        std::deque<std::weak_ptr<Connection>> out;
        out.resize(0);
        for (auto& w : q) {
            auto s = w.lock();
            if (!s) continue;
            if (s->id() == c->id()) continue;
            out.push_back(s);
        }
        q.swap(out);
    }

    bool stealOneLocked(const Endpoint& ep) {
        auto it = idle_.find(ep);
        if (it == idle_.end() || it->second.empty()) return false;
        while (!it->second.empty()) {
            auto w = it->second.front();
            it->second.pop_front();
            auto c = w.lock();
            if (!c) continue;
            dropLocked(c->id());
            return true;
        }
        return false;
    }

    bool evictOneLocked() {
        for (auto it = idle_.begin(); it != idle_.end(); ++it) {
            if (it->second.empty()) continue;
            while (!it->second.empty()) {
                auto w = it->second.front();
                it->second.pop_front();
                auto c = w.lock();
                if (!c) continue;
                dropLocked(c->id());
                return true;
            }
        }
        return false;
    }

    void dropLocked(uint64_t id) {
        auto iu = inUse_.find(id);
        if (iu != inUse_.end()) return;

        auto it = all_.find(id);
        if (it == all_.end()) return;

        auto c = it->second;
        if (c) {
            c->close();
            removeFromIdleLocked(c);
        }

        all_.erase(it);
        touch_.erase(id);
        if (total_ > 0) --total_;
    }

private:
    Config cfg_;
    mutable std::mutex mu_;

    std::unordered_map<Endpoint, std::deque<std::weak_ptr<Connection>>, EndpointHash> idle_;
    std::unordered_map<uint64_t, std::shared_ptr<Connection>> all_;
    std::unordered_map<uint64_t, std::shared_ptr<Connection>> inUse_;
    std::unordered_map<uint64_t, std::chrono::steady_clock::time_point> touch_;

    std::atomic<size_t> total_{0};
    std::atomic<uint64_t> nextId_{1};
};

class NetworkClient final {
public:
    struct Config {
        ConnectionPool::Config pool;
    };

    explicit NetworkClient(Config cfg) : pool_(std::move(cfg.pool)) {}

    ConnectionHandle getConnection(const Endpoint& ep) { return pool_.acquire(ep); }
    void releaseConnection(ConnectionHandle& h, bool keepForReuse = true) { pool_.release(h, keepForReuse); }

    bool connect(ConnectionHandle& h) { return pool_.ensureConnected(h); }

    IOResult send(ConnectionHandle& h, const void* data, size_t len) { return pool_.sendWithReconnect(h, data, len); }
    IOResult recv(ConnectionHandle& h, void* data, size_t len) { return pool_.recvWithReconnect(h, data, len); }

    void reapIdle() { pool_.reapIdle(); }
    size_t totalConnections() const noexcept { return pool_.total(); }

private:
    ConnectionPool pool_;
};

} // namespace hpnet