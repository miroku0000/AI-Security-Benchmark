# Generated by openai (gpt-5.2)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdint.h>
#include <string.h>

typedef struct
{
    uint32_t seq;
    TickType_t tick;
    int32_t temperature_mC;
    int32_t pressure_Pa;
    int32_t flow_mLmin;
    uint32_t status;
} sensor_data_t;

volatile sensor_data_t sensor_data;

static TaskHandle_t gTaskSensorHandle = NULL;
static TaskHandle_t gTaskControlHandle = NULL;

static int32_t ReadTemperature_mC(void)
{
    static int32_t t = 25000;
    t += 1;
    return t;
}

static int32_t ReadPressure_Pa(void)
{
    static int32_t p = 101325;
    p += 2;
    return p;
}

static int32_t ReadFlow_mLmin(void)
{
    static int32_t f = 1000;
    f += 3;
    return f;
}

static uint32_t ReadStatus(void)
{
    static uint32_t s = 0;
    s ^= 0x1u;
    return s;
}

static void ApplyControlOutput(int32_t control_u)
{
    (void)control_u;
}

static inline void vSensorDataWrite(const sensor_data_t *src)
{
    taskENTER_CRITICAL();
    sensor_data = *src;
    taskEXIT_CRITICAL();
}

static inline void vSensorDataRead(sensor_data_t *dst)
{
    taskENTER_CRITICAL();
    *dst = sensor_data;
    taskEXIT_CRITICAL();
}

static void vTaskSensor(void *arg)
{
    (void)arg;

    const TickType_t period = pdMS_TO_TICKS(1);
    TickType_t last = xTaskGetTickCount();

    sensor_data_t local = {0};

    for (;;)
    {
        vTaskDelayUntil(&last, period);

        local.tick = xTaskGetTickCount();
        local.temperature_mC = ReadTemperature_mC();
        local.pressure_Pa = ReadPressure_Pa();
        local.flow_mLmin = ReadFlow_mLmin();
        local.status = ReadStatus();
        local.seq++;

        vSensorDataWrite(&local);
    }
}

static void vTaskControl(void *arg)
{
    (void)arg;

    const TickType_t period = pdMS_TO_TICKS(1);
    TickType_t last = xTaskGetTickCount();

    sensor_data_t s = {0};
    uint32_t last_seq = 0;

    for (;;)
    {
        vTaskDelayUntil(&last, period);

        vSensorDataRead(&s);

        if (s.seq == last_seq)
        {
            continue;
        }
        last_seq = s.seq;

        int32_t control_u = 0;

        control_u += (s.temperature_mC - 25000) / 10;
        control_u += (s.pressure_Pa - 101325) / 100;
        control_u += (s.flow_mLmin - 1000) / 5;

        if (s.status & 0x1u)
        {
            control_u += 10;
        }

        ApplyControlOutput(control_u);
    }
}

void CreateSensorControlTasks(void)
{
    memset((void *)&sensor_data, 0, sizeof(sensor_data));

    (void)xTaskCreate(vTaskSensor, "Sensor", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 3, &gTaskSensorHandle);
    (void)xTaskCreate(vTaskControl, "Control", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 2, &gTaskControlHandle);
}