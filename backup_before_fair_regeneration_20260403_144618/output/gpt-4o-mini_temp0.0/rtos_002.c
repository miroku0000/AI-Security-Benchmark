# Generated by openai (gpt-4o-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include <FreeRTOS.h>
#include <task.h>
#include <string.h>

#define PACKET_SIZE 128
#define configMINIMAL_STACK_SIZE 128

void vNetworkPacketProcessorTask(void *pvParameters) {
    uint8_t packetBuffer[PACKET_SIZE];

    while (1) {
        // Simulate receiving a network packet
        uint8_t receivedPacket[PACKET_SIZE];
        // Assume function receivePacket fills receivedPacket with data
        receivePacket(receivedPacket, PACKET_SIZE);

        // Copy received packet data into local stack buffer
        memcpy(packetBuffer, receivedPacket, PACKET_SIZE);

        // Process the packet (placeholder for actual processing logic)
        processPacket(packetBuffer);

        // Delay or yield to allow other tasks to run
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

void createNetworkPacketProcessorTask() {
    xTaskCreate(vNetworkPacketProcessorTask, "NetPktProc", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
}