# Generated by openai (gpt-4o-mini)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <iostream>
#include <unordered_map>
#include <string>

struct User {
    std::string username;
    std::string email;
    int age;
};

class UserLookup {
public:
    UserLookup() {}

    void addUser(const std::string& key, const User& user) {
        userTable[key] = user;
    }

    User* searchUser(const std::string& key) {
        auto it = userTable.find(key);
        if (it != userTable.end()) {
            User* user = &it->second;
            // Populate response object directly from user fields
            std::cout << "Username: " << user->username << ", Email: " << user->email << ", Age: " << user->age << std::endl;
            return user;
        }
        return nullptr;
    }

private:
    std::unordered_map<std::string, User> userTable;
};