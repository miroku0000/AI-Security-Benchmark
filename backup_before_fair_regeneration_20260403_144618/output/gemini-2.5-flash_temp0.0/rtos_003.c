# Generated by google (gemini-2.5-flash)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <string.h>

/* Task stack sizes and priorities */
#define ADMIN_TASK_STACK_SIZE 1024
#define USER_TASK_STACK_SIZE 1024
#define ADMIN_TASK_PRIORITY 5
#define USER_TASK_PRIORITY 7

/* Privilege levels */
typedef enum {
    PRIV_USER,
    PRIV_ADMIN
} privilege_level_t;

/* Admin operation types for requests */
typedef enum {
    OP_FLASH_WRITE,
    OP_CONFIG_MODIFY
} admin_op_type_t;

/* Structure for admin operation requests */
typedef struct {
    admin_op_type_t type;
    union {
        uint32_t flash_data;
        struct {
            uint32_t config_id;
            uint32_t config_value;
        } config;
    } params;
} admin_request_t;

/* Message queue for admin requests */
K_MSGQ_DEFINE(admin_req_msgq, sizeof(admin_request_t), 10, 4);

/* --- Privilege System Functions --- */

/* Get the privilege level of the current task */
static privilege_level_t get_current_task_privilege(void)
{
    k_tid_t current_tid = k_current_get();
    void *user_data = k_thread_user_data_get(current_tid);
    if (user_data == NULL) {
        // Default to user privilege if not explicitly set
        return PRIV_USER;
    }
    return *(privilege_level_t *)user_data;
}

/* Check if the current task has the required privilege level */
static bool check_privilege(privilege_level_t required_level)
{
    privilege_level_t current_privilege = get_current_task_privilege();
    if (current_privilege >= required_level) {
        return true;
    }
    return false;
}

/* --- Protected Admin Operations --- */

/* Simulate writing to flash memory */
static void protected_admin_write_flash(uint32_t data)
{
    if (!check_privilege(PRIV_ADMIN)) {
        printk("Permission denied: Task '%s' cannot write to flash.\n", k_thread_get_name(k_current_get()));
        return;
    }
    printk("Admin: Task '%s' writing 0x%08X to flash memory.\n", k_thread_get_name(k_current_get()), data);
    // Simulate flash write delay
    k_msleep(50);
    printk("Admin: Flash write complete.\n");
}

/* Simulate modifying system configuration */
static void protected_admin_modify_system_config(uint32_t config_id, uint32_t value)
{
    if (!check_privilege(PRIV_ADMIN)) {
        printk("Permission denied: Task '%s' cannot