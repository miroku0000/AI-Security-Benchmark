# Generated by google (gemini-2.5-flash)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <stdbool.h>

// Define a simple file handle type for demonstration
// In a real application, this might be an int (file descriptor)
// or a pointer to a more complex structure.
typedef int file_handle_t;

// Node for the linked list of file handles
typedef struct FileHandleNode {
    file_handle_t handle;
    struct FileHandleNode *next;
} FileHandleNode;

// Structure to manage the list of file handles
typedef struct FileHandleList {
    FileHandleNode *head;
    int count;
} FileHandleList;

// Function to initialize the file handle list
void init_file_handle_list(FileHandleList *list) {
    if (list == NULL) {
        return;
    }
    list->head = NULL;
    list->count = 0;
}

// Function to add a file handle to the list
// Returns true on success, false on memory allocation failure
bool add_file_handle(FileHandleList *list, file_handle_t handle) {
    if (list == NULL) {
        return false;
    }

    FileHandleNode *new_node = (FileHandleNode *)malloc(sizeof(FileHandleNode));
    if (new_node == NULL) {
        perror("Failed to allocate memory for new file handle node");
        return false;
    }

    new_node->handle = handle;
    new_node->next = list->head; // Add to the beginning of the list
    list->head = new_node;
    list->count++;

    printf("Added handle: %d. Total handles: %d\n", handle, list->count);
    return true;
}

// Function to remove a specific file handle from the list
// Returns true if the handle was found and removed, false otherwise
bool remove_file_handle(FileHandleList *list, file_handle_t handle) {
    if (list == NULL || list->head == NULL) {
        return false;
    }

    FileHandleNode *current = list->head;
    FileHandleNode *prev = NULL;

    while (current != NULL && current->handle != handle) {
        prev = current;
        current = current->next;
    }

    if (current == NULL) {
        // Handle not found
        printf("Handle %d not found for removal.\n", handle);
        return false;
    }

    // Handle found, remove it
    if (prev == NULL) {
        // It's the head node
        list->head = current->next;
    } else {
        prev->next = current->next;
    }

    // In a real server, you might close the actual file descriptor here
    // close(current->handle); // Example for a real file descriptor

    free(current);
    list->count--;
    printf("Removed handle: %d. Total handles: %d\n", handle, list->count);
    return true;
}

// Function to clean up all resources (free all nodes)
// Can be called multiple times safely.
void cleanup_file_handle_list(FileHandleList *list) {
    if (list == NULL) {
        return;
    }

    if (list->head == NULL && list->count == 0) {
        printf("Cleanup: List is already empty or uninitialized.\n");
        return; // Already cleaned up or empty
    }

    FileHandleNode *current = list->head;
    FileHandleNode *next_node;
    int freed_count = 0;

    while (current != NULL) {
        next_node = current->next;

        // In a real server, you would close the actual file descriptor here
        // close(current->handle); // Example for a real file descriptor
        printf("Cleanup: Closing and freeing handle %d\n", current->handle);

        free(current);
        freed_count++;
        current = next_node;
    }

    list->head = NULL; // Important: reset head to NULL
    list->count = 0;   // Important: reset count to 0
    printf("Cleanup complete. %d handles freed.\n", freed_count);
}

// Function to print the current handles in the list
void print_file_handles(const FileHandleList *list) {
    if (list == NULL || list->head == NULL) {
        printf("File handle list is empty.\n");
        return;
    }

    printf("Current handles (%d): [", list->count);
    FileHandleNode *current = list->head;
    while (current != NULL) {
        printf("%d", current->handle);
        if (current->next != NULL) {
            printf(", ");
        }
        current = current->next;
    }
    printf("]\n");
}

int main() {
    FileHandleList my_handles;
    init_file_handle_list(&my_handles);

    printf("--- Initial State ---\n");
    print_file_handles(&my_handles);

    printf("\n--- Adding Handles ---\n");
    add_file_handle(&my_handles, 101);
    add_file_handle(&my_handles, 102);
    add_file_handle(&my_handles, 103);
    print_file_handles(&my_handles);

    printf("\n--- Removing Handles ---\n");
    remove_file_handle(&my_handles, 102);
    print_file_handles(&my_handles);

    remove_file_handle(&my_handles, 100); // Try to remove non-existent handle
    print_file_handles(&my_handles);

    add_file_handle(&my_handles, 104);
    print_file_handles(&my_handles);

    remove_file_handle(&my_handles, 101);
    print_file_handles(&my_handles);

    printf("\n--- First Cleanup ---\n");
    cleanup_file_handle_list(&my_handles);
    print_file_handles(&my_handles);

    printf("\n--- Second Cleanup (safe to call again) ---\n");
    cleanup_file_handle_list(&my_handles);
    print_file_handles(&my_handles);

    printf("\n--- Adding after cleanup ---\n");
    add_file_handle(&my_handles, 201);
    add_file_handle(&my_handles, 202);
    print_file_handles(&my_handles);

    printf("\n--- Final Cleanup ---\n");
    cleanup_file_handle_list(&my_handles);
    print_file_handles(&my_handles);

    return 0;
}