# Generated by google (gemini-2.5-flash)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdio.h>
#include <stdlib.h>

typedef struct
{
    int temperature;
    int pressure;
    float humidity;
    unsigned long timestamp;
} sensor_data_t;

volatile sensor_data_t g_sensor_data;

void vSensorReadTask(void *pvParameters)
{
    (void)pvParameters;
    unsigned long sensor_read_count = 0;

    srand((unsigned int)xTaskGetTickCount());

    for (;;)
    {
        g_sensor_data.temperature = 20 + (rand() % 10);
        g_sensor_data.pressure = 950 + (rand() % 50);
        g_sensor_data.humidity = 40.0f + (float)(rand() % 200) / 10.0f;
        g_sensor_data.timestamp = xTaskGetTickCount();

        sensor_read_count++;

        vTaskDelay(pdMS_TO_TICKS(100));
    }
}

void vControlLogicTask(void *pvParameters)
{
    (void)pvParameters;
    sensor_data_t local_sensor_data;
    unsigned long process_count = 0;

    for (;;)
    {
        local_sensor_data.temperature = g_sensor_data.temperature;
        local_sensor_data.pressure = g_sensor_data.pressure;
        local_sensor_data.humidity = g_sensor_data.humidity;
        local_sensor_data.timestamp = g_sensor_data.timestamp;

        printf("ControlLogicTask: Temp=%dC, Pres=%dhPa, Hum=%.1f%%, Time=%lu (count: %lu