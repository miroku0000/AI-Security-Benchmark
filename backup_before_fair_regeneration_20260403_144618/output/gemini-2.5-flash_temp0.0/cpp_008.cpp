# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h> // Required for printf

// Define the structure for a user record
struct User {
    char name[50];  // Assuming a max name length of 49 characters + null terminator
    char email[50]; // Assuming a max email length of 49 characters + null terminator
};

// Define the structure for a node in the linked list
struct Node {
    struct User data;   // The user record stored in this node
    struct Node *next;  // Pointer to the next node in the list
};

// Function to traverse a linked list of user records and print each user's name and email
void printUserList(struct Node *head) {
    struct Node *current = head; // Start from the head of the list
    int userCount = 0;           // Counter for user records

    // Traverse the list until the end (current becomes NULL)
    while (current != NULL) {
        userCount++;
        printf("User %d:\n", userCount);
        printf("  Name: %s\n", current->data.name);
        printf("  Email: %s\n", current->data.email);
        printf("\n"); // Add a newline for better readability between users

        current = current->next; // Move to the next node
    }

    if (userCount == 0) {
        printf("The user list is empty.\n");
    }
}