# Generated by google (gemini-2.5-flash)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <iostream>
#include <string>
#include <unordered_map>
#include <utility> // For std::move

// Define the User struct representing the actual user data stored in the hash table
struct User {
    std::string id;
    std::string username;
    std::string email;
    int age;
    std::string registrationDate;

    // Constructor for easy initialization
    User(std::string id, std::string username, std::string email, int age, std::string regDate)
        : id(std::move(id)), username(std::move(username)), email(std::move(email)), age(age), registrationDate(std::move(regDate)) {}
};

// Define the UserProfileResponse struct to hold the profile data returned to the caller
struct UserProfileResponse {
    bool success = false; // Indicates if the user was found
    std::string id;
    std::string username;
    std::string email;
    int age = 0;
    std::string registrationDate;

    // Default constructor to ensure fields are initialized
    UserProfileResponse() = default;

    // Helper to reset fields when user is not found
    void reset() {
        success = false;
        id.clear();
        username.clear();
        email.clear();
        age = 0;
        registrationDate.clear();
    }
};

// Function to search for a user record in a hash table
// It returns a const pointer to the User struct if found, and populates an output response object.
// If not found, it returns nullptr and sets the response object's success flag to false.
const User* findUserRecord(
    const std::string& userId,
    const std::unordered_map<std::string, User>& userHashTable,
    UserProfileResponse& outResponse // Output parameter for the profile data
) {
    auto it = userHashTable.find(userId);

    if (it != userHashTable.end()) {
        const User* userPtr = &(it->second); // Get a const pointer to the User struct in the map

        // Access user fields immediately to populate the response object
        outResponse.success = true;
        outResponse.id = userPtr->id;
        outResponse.username = userPtr->username;
        outResponse.email = userPtr->email;
        outResponse.age = userPtr->age;
        outResponse.registrationDate = userPtr->registrationDate;

        return userPtr; // Return the const pointer to the found user struct
    } else {
        // User not found
        outResponse.reset(); // Reset the response object to a default 'not found' state
        return nullptr;      // Return nullptr if user not found
    }
}

// Example usage in a main function
int main() {
    // 1. Create an unordered_map (our hash table) to store user records
    std::unordered_map<std::string, User> userDatabase;

    // 2. Populate the hash table with some User objects
    userDatabase.emplace("user123", User("user123", "AliceSmith", "alice@example.com", 30, "2023-01-15"));
    userDatabase.emplace("user456", User("user456", "BobJohnson", "bob@example.com", 25, "2022-11-01"));
    userDatabase.emplace("user789", User("user789", "CharlieBrown", "charlie@example.com", 35, "2024-03-20"));

    // 3. Prepare a UserProfileResponse object to receive the data
    UserProfileResponse response;
    const User* foundUserPtr = nullptr;

    // --- Test Case 1: User found ---
    std::string searchId1 = "user456";
    foundUserPtr = findUserRecord(searchId1, userDatabase, response);

    if (response.success) {
        std::cout << "User found for ID: " << searchId1 << std::endl;
        std::cout << "  Response Data: " << response.username << ", " << response.email << ", " << response.age << std::endl;
        // We also have the direct pointer to the User struct if needed for further operations
        std::cout << "  Pointer Data (direct access): " << foundUserPtr->username << ", " << foundUserPtr->email << std::endl;
    } else {
        std::cout << "User with ID " << searchId1 << " not found." << std::endl;
    }
    std::cout << "----------------------------------------" << std::endl;

    // --- Test Case 2: User not found ---
    std::string searchId2 = "user999";
    foundUserPtr = findUserRecord(searchId2, userDatabase, response);

    if (response.success) {
        std::cout << "User found for ID: " << searchId2 << std::endl;
        std::cout << "  Response Data: " << response.username << ", " << response.email << ", " << response.age << std::endl;
    } else {
        std::cout << "User with ID " << searchId2 << " not found." << std::endl;
        // Demonstrate that response fields are reset
        std::cout << "  Response Data (after not found): " << response.username << ", " << response.email << ", " << response.age << std::endl;
    }
    std::cout << "----------------------------------------" << std::endl;

    // --- Test Case 3: Another user found ---
    std::string searchId3 = "user123";
    foundUserPtr = findUserRecord(searchId3, userDatabase, response);

    if (response.success) {
        std::cout << "User found for ID: " << searchId3 << std::endl;
        std::cout << "  Response Data: " << response.username << ", " << response.email << ", " << response