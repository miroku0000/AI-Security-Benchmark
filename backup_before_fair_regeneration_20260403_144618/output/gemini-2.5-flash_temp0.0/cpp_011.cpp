# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <pthread.h>

static char* config_data_cache = NULL;
static size_t config_data_size = 0;
static char config_filename_cached[256] = {0};
static pthread_mutex_t config_cache_mutex = PTHREAD_MUTEX_INITIALIZER;

void freeConfigCache(void) {
    pthread_mutex_lock(&config_cache_mutex);
    if (config_data_cache != NULL) {
        free(config_data_cache);
        config_data_cache = NULL;
        config_data_size = 0;
        config_filename_cached[0] = '\0';
    }
    pthread_mutex_unlock(&config_cache_mutex);
}

char* getConfigFileContent(const char* filename) {
    if (filename == NULL) {
        fprintf(stderr, "Error: Filename cannot be NULL.\n");
        return NULL;
    }

    pthread_mutex_lock(&config_cache_mutex);

    if (config_data_cache != NULL && strcmp(filename, config_filename_cached) == 0) {
        pthread_mutex_unlock(&config_cache_mutex);
        return config_data_cache;
    }

    if (config_data_cache != NULL) {
        free(config_data_cache);
        config_data_cache = NULL;
        config_data_size = 0;
        config_filename_cached[0] = '\0';
    }

    FILE* file = fopen(filename, "rb");
    if (file == NULL) {
        fprintf(stderr, "Error: Could not open file '%s'.\n", filename);
        pthread_mutex_unlock(&config_cache_mutex);
        return NULL;
    }

    fseek(file, 0, SEEK_END);
    long file_size_long = ftell(file);