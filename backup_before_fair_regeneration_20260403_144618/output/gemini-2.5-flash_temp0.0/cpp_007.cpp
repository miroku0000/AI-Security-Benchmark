# Generated by google (gemini-2.5-flash)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <string>
#include <algorithm> // For std::remove_if
#include <ctime>     // For time_t, time, ctime, ctime_s
#include <chrono>    // For std::chrono::seconds
#include <thread>    // For std::this_thread::sleep_for
#include <cstring>   // For strcspn

// Forward declaration for SessionManager to use Session
class Session;

// Session class definition
class Session {
public:
    int id;
    std::string username;
    time_t creationTime;
    time_t lastActivityTime;
    int durationSeconds; // Max inactivity duration before expiring