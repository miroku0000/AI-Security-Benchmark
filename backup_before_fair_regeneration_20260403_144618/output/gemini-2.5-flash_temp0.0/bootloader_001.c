# Generated by google (gemini-2.5-flash)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>

// =============================================================================
// 1. Configuration and Memory Map
//    These values are highly dependent on your specific ARM Cortex-M MCU.
//    Adjust them according to your device's datasheet and memory layout.
// =============================================================================

// Bootloader occupies the first part of flash
#define BOOTLOADER_START_ADDRESS        0x08000000UL
#define BOOTLOADER_SIZE                 (32 * 1024) // 32KB for bootloader

// Application starts immediately after the bootloader
#define APPLICATION_START_ADDRESS       (BOOTLOADER_START_ADDRESS + BOOTLOADER_SIZE)
#define APPLICATION_MAX_SIZE            (480 * 1024) // Example: 480KB for application

// A dedicated flash sector for bootloader metadata (e.g., update flags, CRC)
// This should be outside the application area and not erased during update.
#define METADATA_FLASH_ADDRESS          (APPLICATION_START_ADDRESS + APPLICATION_MAX_SIZE)
#define METADATA_SIZE                   (4 * 1024) // Example: 4KB sector for metadata

// Magic value to force bootloader entry from application
#define BOOTLOADER_MAGIC_ADDRESS        0x20000000UL // Example: A specific RAM address
#define BOOTLOADER_MAGIC_VALUE          0xDEADBEEFUL

// GPIO pin for bootloader entry (e.g., PA0)
#define BOOT_PIN_PORT                   GPIOA
#define BOOT_PIN_NUMBER                 0

// UART configuration
#define UART_BAUDRATE                   115200

// SD Card configuration (SPI interface)
// Define your SPI pins and peripheral here

// Firmware file name on SD card
#define FIRMWARE_FILENAME               "firmware.bin"

// Flash write granularity (e.g., 4 bytes for word, 8 bytes for double word)
#define FLASH_WRITE_SIZE                4 // bytes

// =============================================================================
// 2. Hardware Abstraction Layer (HAL) Stubs
//    These functions need to be implemented for your specific MCU and peripherals.
//    They are placeholders for actual driver code.
// =============================================================================

// Generic MCU Initialization
void HAL_Init(void) {
    // Initialize clocks, basic peripherals, etc.
    // This is where you'd call your MCU's HAL_Init() or equivalent.
}

// GPIO Driver Stubs
typedef enum { GPIO_PIN_RESET = 0, GPIO_PIN_SET } GPIO_PinState;
GPIO_PinState GPIO_ReadPin(void *GPIOx, uint16_t GPIO_Pin) {
    // Implement reading the state of a GPIO pin
    // Example: return (GPIOx->IDR & (1 << GPIO_Pin)) ? GPIO_PIN_SET : GPIO_PIN_RESET;
    return GPIO_PIN_SET; // Placeholder: Assume pin is high by default
}
void GPIO_Init(void *GPIOx, uint16_t GPIO_Pin, uint32_t Mode, uint32_t Pull) {
    // Implement GPIO initialization (mode, pull-up/down)
}

// UART Driver Stubs
void UART_Init(uint32_t baudrate) {
    // Initialize UART peripheral (clocks, pins, baudrate, enable)
}
void UART_TransmitByte(uint8_t data) {
    // Transmit a single byte over UART
}
uint8_t UART_ReceiveByte(void) {
    // Receive a single byte over UART (blocking or with timeout)
    return 0; // Placeholder
}
uint32_t UART_BytesAvailable(void) {
    // Check if any bytes are available in UART receive buffer
    return 0; // Placeholder
}

// SPI Driver Stubs (for SD Card)
void SPI_Init(void) {
    // Initialize SPI peripheral
}
uint8_t SPI_TransmitReceive(uint8_t data) {
    // Transmit a byte and receive a byte simultaneously over SPI
    return 0; // Placeholder
}

// Flash Driver Stubs
// Note: Flash operations often require disabling interrupts and careful timing.
// These are highly MCU-specific.
typedef enum { FLASH_OK = 0, FLASH_ERROR } FLASH_Status;

void FLASH_Init(void) {
    // Initialize flash controller (e.g., unlock, set latency)
}

FLASH_Status FLASH_EraseSector(uint32_t address) {
    // Erase a single flash sector containing the given address
    // This typically involves unlocking flash, setting erase type,
    // writing to a control register, and waiting for completion.
    return FLASH_OK; // Placeholder
}

FLASH_Status FLASH_ProgramWord(uint32_t address, uint32_t data) {
    // Program a single word (e.g., 32-bit) to flash
    // This typically involves unlocking flash, setting program type,
    // writing data and address, and waiting for completion.
    return FLASH_OK; // Placeholder
}

// SD Card Driver Stubs (simplified, no FAT filesystem)
// In a real scenario, you'd use a FATFS library or similar.
typedef enum { SD_OK = 0, SD_ERROR, SD_NO_FILE } SD_Status;

SD_Status SD_Init(void) {
    // Initialize SD card via SPI (send commands, read responses)
    return SD_OK; // Placeholder
}

SD_Status SD_OpenFile(const char *filename) {
    // Simulate opening a file. In a real system, this would involve FATFS.
    // For this example, we'll assume the file is always present if SD_OK.
    return SD_OK; // Placeholder
}

SD_Status SD_ReadFile(uint32_t *buffer, uint32_t address, uint32_t size) {
    // Simulate reading data from the opened file into a buffer.
    // In a real system, this would involve FATFS read operations.
    // For simplicity, this stub will just return success.
    // The 'address' parameter is conceptual for where in the file to read from.
    // For a bootloader, you'd typically read sequentially.
    return SD_OK; // Placeholder
}

uint32_t SD_GetFileSize(const char *filename) {
    // Simulate getting file size.
    // In a real system, this would involve FATFS.
    // For this example, let's assume a fixed size for demonstration.
    return APPLICATION_MAX_SIZE / 2; // Placeholder: Assume a firmware file of half max size
}

// =============================================================================
// 3. Utility Functions
// =============================================================================

// Simple CRC32 calculation (example, can be optimized)
uint32_t CRC32_Calculate(const uint32_t *data, uint32_t word_count) {
    uint32_t crc = 0xFFFFFFFFUL;
    for (uint32_t i = 0; i < word_count; i++) {
        crc ^= data[i];
        for (int j = 0; j < 32; j++) {
            if (crc & 1) {
                crc = (crc >> 1) ^ 0xEDB88320UL;
            } else {
                crc >>= 1;
            }
        }
    }
    return ~crc;
}

// =============================================================================
// 4. Bootloader Core Logic
// =============================================================================

// Structure to store application metadata in flash
typedef struct {
    uint32_t magic;             // Magic value to indicate valid metadata
    uint32_t app_size;          // Size of the application in bytes
    uint32_t app_crc32;         // CRC32 of the application
    uint32_t update_requested;  // Flag for update request (e.g., from application)
    uint32_t reserved[4];       // For future use
} BootloaderMetadata_t;

// Global instance of metadata (will be read from/written to flash)
BootloaderMetadata_t boot_metadata;

// Function to read metadata from flash
void read_metadata_from_flash(void) {
    // Assuming metadata is stored at METADATA_FLASH_ADDRESS
    // Read word by word or use a memcpy if flash allows direct access
    uint32_t *src = (uint32_t *)METADATA_FLASH_ADDRESS;
    uint32_t *dest = (uint32_t *)&boot_metadata;
    for (uint32_t i = 0; i < sizeof(BootloaderMetadata_t) / sizeof(uint32_t); i++) {
        dest[i] = src[i];
    }
}

// Function to write metadata to flash
FLASH_Status write_metadata_to_flash(void) {
    FLASH_Status status = FLASH_OK;
    // Erase the metadata sector first
    status = FLASH_EraseSector(METADATA_FLASH_ADDRESS);
    if (status != FLASH_OK) return status;

    // Program the new metadata
    uint32_t *src = (uint32_t *)&boot_metadata;
    for (uint32_t i = 0; i < sizeof(BootloaderMetadata_t) / sizeof(uint32_t); i++) {
        status = FLASH_ProgramWord(METADATA_FLASH_ADDRESS + (i * sizeof(uint32_t)), src[i]);
        if (status != FLASH_OK) return status;
    }
    return status;
}


// Checks conditions to enter bootloader mode
uint8_t check_bootloader_entry_conditions(void) {
    // 1. Check GPIO pin state
    GPIO_Init(BOOT_PIN_PORT, BOOT_PIN_NUMBER, 0, 0); // Configure as input with pull-up/down
    if (GPIO_ReadPin(BOOT_PIN_PORT, BOOT_PIN_NUMBER) == GPIO_PIN_RESET) {
        return 1; // GPIO pin pulled low, enter bootloader
    }

    // 2. Check magic value in a specific memory location (e.g., RAM or backup register)
    // For this example, we'll use a RAM location that the application can write to.
    // A more robust solution uses RTC backup registers or a dedicated flash sector.
    volatile uint32_t *magic_addr = (volatile uint32_t *)BOOTLOADER_MAGIC_ADDRESS;
    if (*magic_addr == BOOTLOADER_MAGIC_VALUE) {
        *magic_addr = 0; // Clear magic value after reading
        return 1; // Magic value found, enter bootloader
    }

    // 3. Check for update_requested flag in metadata
    read_metadata_from_flash();
    if (boot_metadata.update_requested == 1) {
        boot_metadata.update_requested = 0; // Clear flag
        write_metadata_to_flash();          // Save updated metadata
        return 1; // Update requested by application, enter bootloader
    }

    return 0; // No conditions met, proceed to application
}

// Jumps to the application code
void jump_to_application(void) {
    // Check if application exists (e.g., first word is not 0xFFFFFFFF)
    // The first word of an ARM Cortex-M application is typically the initial stack pointer.
    // The second word is the reset handler address.
    if (((*(volatile uint32_t*)APPLICATION