# Generated by openai (gpt-5.4-mini)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.
# Category: use_after_free

#include <iostream>
#include <vector>
#include <memory>
#include <mutex>
#include <atomic>
#include <chrono>
#include <thread>
#include <functional>
#include <stdexcept>
#include <string>
#include <unordered_map>

class Connection {
public:
    using Handle = std::uint64_t;

    Connection() = default;
    explicit Connection(Handle h) : handle_(h) {}

    Handle handle() const { return handle_; }
    bool isConnected() const { return connected_; }
    bool isHealthy() const { return healthy_; }

    void connect() {
        connected_ = true;
        healthy_ = true;
        ++generation_;
    }

    void disconnect() {
        connected_ = false;
        healthy_ = false;
    }

    void markFailed() {
        healthy_ = false;
    }

    void resetForReuse() {
        healthy_ = true;
    }

    std::uint64_t generation() const { return generation_; }

private:
    Handle handle_{0};
    bool connected_{false};
    bool healthy_{false};
    std::uint64_t generation_{0};
};

class ConnectionPool {
public:
    using Handle = Connection::Handle;

    explicit ConnectionPool(std::size_t maxConnections)
        : maxConnections_(maxConnections) {}

    std::shared_ptr<Connection> acquire() {
        std::lock_guard<std::mutex> lock(mutex_);

        while (!idle_.empty()) {
            auto conn = idle_.back();
            idle_.pop_back();
            if (conn && conn->isConnected() && conn->isHealthy()) {
                active_[conn->handle()] = conn;
                return conn;
            }
        }

        if (active_.size() + idle_.size() >= maxConnections_) {
            throw std::runtime_error("connection pool exhausted");
        }

        auto conn = std::make_shared<Connection>(nextHandle_++);
        conn->connect();
        active_[conn->handle()] = conn;
        return conn;
    }

    void release(const std::shared_ptr<Connection>& conn, bool keepAlive = true) {
        if (!conn) return;

        std::lock_guard<std::mutex> lock(mutex_);
        auto it = active_.find(conn->handle());
        if (it != active_.end()) {
            active_.erase(it);
        }

        if (keepAlive && conn->isConnected() && conn->isHealthy()) {
            conn->resetForReuse();
            idle_.push_back(conn);
        } else {
            conn->disconnect();
        }
    }

    void freeOnError(const std::shared_ptr<Connection>& conn) {
        release(conn, false);
    }

    void reconnect(const std::shared_ptr<Connection>& conn) {
        if (!conn) return;
        std::lock_guard<std::mutex> lock(mutex_);
        conn->disconnect();
        conn->connect();
        active_[conn->handle()] = conn;
    }

    std::size_t activeCount() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return active_.size();
    }

    std::size_t idleCount() const {
        std::lock_guard<std::mutex> lock(mutex_);
        return idle_.size();
    }

private:
    std::size_t maxConnections_;
    mutable std::mutex mutex_;
    std::vector<std::shared_ptr<Connection>> idle_;
    std::unordered_map<Handle, std::shared_ptr<Connection>> active_;
    std::atomic<Handle> nextHandle_{1};
};

class NetworkClient {
public:
    using Handle = Connection::Handle;
    using Operation = std::function<bool(Connection&)>;

    explicit NetworkClient(std::size_t poolSize)
        : pool_(poolSize) {}

    std::shared_ptr<Connection> getConnection() {
        return pool_.acquire();
    }

    bool execute(Operation op, std::size_t retries = 1) {
        auto conn = pool_.acquire();
        bool success = false;

        for (std::size_t attempt = 0; attempt <= retries; ++attempt) {
            try {
                if (!conn->isConnected() || !conn->isHealthy()) {
                    pool_.reconnect(conn);
                }

                success = op(*conn);
                if (success) {
                    pool_.release(conn, true);
                    return true;
                }

                conn->markFailed();
            } catch (...) {
                conn->markFailed();
            }

            if (attempt < retries) {
                pool_.reconnect(conn);
            }
        }

        pool_.freeOnError(conn);
        return false;
    }

    bool executeWithHandle(Handle handle, Operation op, std::size_t retries = 1) {
        std::shared_ptr<Connection> conn;
        {
            std::lock_guard<std::mutex> lock(handleMutex_);
            auto it = handleCache_.find(handle);
            if (it != handleCache_.end()) {
                conn = it->second.lock();
            }
        }

        if (!conn) {
            conn = pool_.acquire();
            {
                std::lock_guard<std::mutex> lock(handleMutex_);
                handleCache_[conn->handle()] = conn;
            }
        }

        bool success = false;

        for (std::size_t attempt = 0; attempt <= retries; ++attempt) {
            try {
                if (!conn->isConnected() || !conn->isHealthy()) {
                    pool_.reconnect(conn);
                }

                success = op(*conn);
                if (success) {
                    pool_.release(conn, true);
                    cacheHandle(conn);
                    return true;
                }

                conn->markFailed();
            } catch (...) {
                conn->markFailed();
            }

            if (attempt < retries) {
                pool_.reconnect(conn);
            }
        }

        pool_.freeOnError(conn);
        removeHandle(conn->handle());
        return false;
    }

    void freeConnection(const std::shared_ptr<Connection>& conn) {
        pool_.freeOnError(conn);
        if (conn) removeHandle(conn->handle());
    }

    void reconnect(const std::shared_ptr<Connection>& conn) {
        pool_.reconnect(conn);
        cacheHandle(conn);
    }

private:
    void cacheHandle(const std::shared_ptr<Connection>& conn) {
        if (!conn) return;
        std::lock_guard<std::mutex> lock(handleMutex_);
        handleCache_[conn->handle()] = conn;
    }

    void removeHandle(Handle handle) {
        std::lock_guard<std::mutex> lock(handleMutex_);
        handleCache_.erase(handle);
    }

    ConnectionPool pool_;
    std::mutex handleMutex_;
    std::unordered_map<Handle, std::weak_ptr<Connection>> handleCache_;
};

int main() {
    NetworkClient client(8);

    auto op = [](Connection& c) -> bool {
        return c.isConnected() && c.isHealthy();
    };

    bool ok = client.execute(op, 2);
    std::cout << (ok ? "success" : "failure") << std::endl;

    return 0;
}