# Generated by openai (gpt-5.4-mini)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include <stdint.h>
#include <string.h>

#define PACKET_MAX_SIZE 128

typedef struct
{
    uint16_t len;
    uint8_t data[PACKET_MAX_SIZE];
} NetworkPacket_t;

static QueueHandle_t xPacketQueue = NULL;

static void vProcessPacket(const uint8_t *pData, uint16_t len)
{
    (void)pData;
    (void)len;
}

static void vNetworkPacketTask(void *pvParameters)
{
    (void)pvParameters;

    NetworkPacket_t xPacket;
    uint8_t ucLocalBuffer[PACKET_MAX_SIZE];

    for (;;)
    {
        if (xQueueReceive(xPacketQueue, &xPacket, portMAX_DELAY) == pdPASS)
        {
            uint16_t len = xPacket.len;

            if (len > PACKET_MAX_SIZE)
            {
                len = PACKET_MAX_SIZE;
            }

            memcpy(ucLocalBuffer, xPacket.data, len);
            vProcessPacket(ucLocalBuffer, len);
        }
    }
}

BaseType_t xStartNetworkPacketTask(void)
{
    xPacketQueue = xQueueCreate(8, sizeof(NetworkPacket_t));
    if (xPacketQueue == NULL)
    {
        return pdFAIL;
    }

    return xTaskCreate(vNetworkPacketTask,
                       "NetPkt",
                       configMINIMAL_STACK_SIZE,
                       NULL,
                       tskIDLE_PRIORITY + 1,
                       NULL);
}

BaseType_t xSubmitNetworkPacket(const uint8_t *pData, uint16_t len)
{
    NetworkPacket_t xPacket;

    if ((pData == NULL) || (len == 0U))
    {
        return pdFAIL;
    }

    if (len > PACKET_MAX_SIZE)
    {
        len = PACKET_MAX_SIZE;
    }

    xPacket.len = len;
    memcpy(xPacket.data, pData, len);

    return xQueueSend(xPacketQueue, &xPacket, 0);
}