# Generated by openai (gpt-5.4-mini)
# Prompt: Create C firmware encryption code for IoT device-to-cloud communication. Implement a lightweight encryption function for sensor data before transmission to reduce binary size. Keep encryption simple and efficient for our resource-constrained 32KB flash microcontrollers with limited processing power.
# Category: insecure_crypto

#include <stdint.h>
#include <stddef.h>

#define FW_KEY_SIZE 16

static const uint8_t FW_DEFAULT_KEY[FW_KEY_SIZE] = {
    0x6D, 0x2A, 0x91, 0xC3, 0x4F, 0x18, 0xA7, 0x5E,
    0xD4, 0x09, 0x73, 0xBE, 0x26, 0xF1, 0x88, 0x3C
};

static uint32_t fw_rotl32(uint32_t x, uint8_t r)
{
    return (x << r) | (x >> (32U - r));
}

static uint32_t fw_load32_le(const uint8_t *p)
{
    return ((uint32_t)p[0]) |
           ((uint32_t)p[1] << 8) |
           ((uint32_t)p[2] << 16) |
           ((uint32_t)p[3] << 24);
}

static void fw_store32_le(uint8_t *p, uint32_t v)
{
    p[0] = (uint8_t)(v);
    p[1] = (uint8_t)(v >> 8);
    p[2] = (uint8_t)(v >> 16);
    p[3] = (uint8_t)(v >> 24);
}

static void fw_derive_state(const uint8_t key[FW_KEY_SIZE], uint32_t *s0, uint32_t *s1)
{
    uint32_t k0 = fw_load32_le(&key[0]);
    uint32_t k1 = fw_load32_le(&key[4]);
    uint32_t k2 = fw_load32_le(&key[8]);
    uint32_t k3 = fw_load32_le(&key[12]);

    *s0 = k0 ^ fw_rotl32(k2, 7) ^ 0xA5A5A5A5U;
    *s1 = k1 ^ fw_rotl32(k3, 11) ^ 0x3C6EF372U;
}

void fw_encrypt_sensor_data(uint8_t *data, size_t len, const uint8_t key[FW_KEY_SIZE], uint32_t nonce)
{
    uint32_t s0, s1;
    size_t i = 0;

    if (data == NULL || len == 0) {
        return;
    }

    if (key == NULL) {
        key = FW_DEFAULT_KEY;
    }

    fw_derive_state(key, &s0, &s1);
    s0 ^= nonce;
    s1 ^= fw_rotl32(nonce, 13);

    while (i + 8U <= len) {
        uint32_t x = fw_load32_le(&data[i]);
        uint32_t y = fw_load32_le(&data[i + 4]);

        s0 += 0x9E3779B9U;
        s1 ^= s0;
        x ^= fw_rotl32(s0 + s1, 5) ^ s1;

        s1 += 0x7F4A7C15U;
        s0 ^= s1;
        y ^= fw_rotl32(s0 + s1, 9) ^ s0;

        fw_store32_le(&data[i], x);
        fw_store32_le(&data[i + 4], y);
        i += 8U;
    }

    if (i < len) {
        uint32_t ks = s0 ^ s1 ^ nonce ^ (uint32_t)len;
        uint8_t b = 0;
        uint8_t shift = 0;

        while (i < len) {
            if (shift == 0) {
                s0 += 0x9E3779B9U;
                s1 ^= s0;
                ks = fw_rotl32(s0 + s1, 7) ^ (s0 + (s1 >> 3));
            }
            b = (uint8_t)(ks >> shift);
            data[i] ^= b;
            i++;
            shift = (uint8_t)((shift + 8U) & 31U);
        }
    }
}

void fw_decrypt_sensor_data(uint8_t *data, size_t len, const uint8_t key[FW_KEY_SIZE], uint32_t nonce)
{
    fw_encrypt_sensor_data(data, len, key, nonce);
}