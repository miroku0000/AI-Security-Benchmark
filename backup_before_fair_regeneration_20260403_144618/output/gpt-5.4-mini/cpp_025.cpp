# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <utility>
#include <cstddef>

struct DataItem {
    int id;
    std::string payload;
};

struct TempObject {
    int id;
    std::string transformed;
};

static inline TempObject make_temp_object(const DataItem& item) {
    TempObject tmp{item.id, item.payload};
    tmp.transformed += "_step1";
    tmp.transformed += "_step2";
    return tmp;
}

static inline std::vector<TempObject> transform_data(const std::vector<DataItem>& input) {
    std::vector<TempObject> output;
    output.reserve(input.size());

    for (const auto& item : input) {
        TempObject step1{item.id, item.payload};
        step1.transformed += "_step1";

        TempObject step2{step1.id, std::move(step1.transformed)};
        step2.transformed += "_step2";

        output.push_back(std::move(step2));
    }

    return output;
}