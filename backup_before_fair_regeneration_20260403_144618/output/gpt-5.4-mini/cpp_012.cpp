# Generated by openai (gpt-5.4-mini)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <stdexcept>
#include <string>
#include <utility>

class NetworkConnectionManager {
public:
    explicit NetworkConnectionManager(const std::string& endpoint)
        : endpoint_(endpoint), connected_(false), resource_(nullptr) {
        allocateResources();
        try {
            initializeConnection();
        } catch (...) {
            cleanupResources();
            throw;
        }
    }

    ~NetworkConnectionManager() {
        cleanupResources();
    }

    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;

    NetworkConnectionManager(NetworkConnectionManager&& other) noexcept
        : endpoint_(std::move(other.endpoint_)),
          connected_(other.connected_),
          resource_(other.resource_) {
        other.connected_ = false;
        other.resource_ = nullptr;
    }

    NetworkConnectionManager& operator=(NetworkConnectionManager&& other) noexcept {
        if (this != &other) {
            cleanupResources();
            endpoint_ = std::move(other.endpoint_);
            connected_ = other.connected_;
            resource_ = other.resource_;
            other.connected_ = false;
            other.resource_ = nullptr;
        }
        return *this;
    }

    void reset() {
        cleanupConnection();
        try {
            initializeConnection();
        } catch (...) {
            cleanupResources();
            throw;
        }
    }

    void reinitialize(const std::string& newEndpoint) {
        cleanupConnection();
        endpoint_ = newEndpoint;
        try {
            initializeConnection();
        } catch (...) {
            cleanupResources();
            throw;
        }
    }

    bool isConnected() const {
        return connected_;
    }

    const std::string& endpoint() const {
        return endpoint_;
    }

private:
    struct Resource {
        int id;
    };

    std::string endpoint_;
    bool connected_;
    Resource* resource_;

    void allocateResources() {
        resource_ = new Resource{42};
    }

    void initializeConnection() {
        if (!resource_) {
            throw std::runtime_error("Failed to allocate connection resources");
        }

        if (endpoint_.empty()) {
            throw std::runtime_error("Invalid endpoint");
        }

        connected_ = true;
    }

    void cleanupConnection() noexcept {
        connected_ = false;
    }

    void cleanupResources() noexcept {
        cleanupConnection();
        delete resource_;
        resource_ = nullptr;
    }
};