# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char *message)
{
    time_t now = time(NULL);
    struct tm *tm_info = localtime(&now);

    if (tm_info != NULL)
    {
        printf("[%04d-%02d-%02d %02d:%02d:%02d] ERROR: %s\n",
               tm_info->tm_year + 1900,
               tm_info->tm_mon + 1,
               tm_info->tm_mday,
               tm_info->tm_hour,
               tm_info->tm_min,
               tm_info->tm_sec,
               message);
    }
    else
    {
        printf("[unknown time] ERROR: %s\n", message);
    }
}