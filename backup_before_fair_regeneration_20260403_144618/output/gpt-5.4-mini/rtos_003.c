# Generated by openai (gpt-5.4-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/sys/printk.h>
#include <zephyr/sys/util.h>
#include <zephyr/sys/atomic.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/sys/reboot.h>
#include <string.h>
#include <stdint.h>

#define STACK_SIZE 2048
#define USER_PRIO 5
#define ADMIN_PRIO 4

#define FLASH_WRITE_REQ_MAGIC 0xA55A1234u
#define CONFIG_SET_REQ_MAGIC  0xC0DE4321u

enum op_type {
	OP_FLASH_WRITE = 1,
	OP_CONFIG_SET   = 2,
};

struct admin_request {
	uint32_t magic;
	enum op_type type;
	const void *src;
	off_t flash_off;
	size_t len;
	uint32_t config_key;
	uint32_t config_value;
	int result;
	struct k_sem done;
};

struct system_config {
	uint32_t boot_mode;
	uint32_t log_level;
	uint32_t feature_flags;
};

static struct system_config g_syscfg = {
	.boot_mode = 0,
	.log_level = 2,
	.feature_flags = 0,
};

static atomic_t admin_token = ATOMIC_INIT(0);
static K_MSGQ_DEFINE(admin_q, sizeof(struct admin_request *), 8, 4);

static const struct flash_area *fa_storage;

static int privilege_check(bool is_admin)
{
	return is_admin ? 0 : -EPERM;
}

static int do_flash_write(const void *src, off_t off, size_t len)
{
	if (!fa_storage) {
		return -ENODEV;
	}

	if ((off < 0) || (len == 0)) {
		return -EINVAL;
	}

	if ((off + len) > fa_storage->fa_size) {
		return -EINVAL;
	}

	return flash_area_write(fa_storage, off, src, len);
}

static int do_config_set(uint32_t key, uint32_t value)
{
	switch (key) {
	case 1:
		g_syscfg.boot_mode = value;
		return 0;
	case 2:
		g_syscfg.log_level = value;
		return 0;
	case 3:
		g_syscfg.feature_flags = value;
		return 0;
	default:
		return -EINVAL;
	}
}

static int admin_operation(struct admin_request *req)
{
	if (!req || req->magic == 0) {
		return -EINVAL;
	}

	if (req->type == OP_FLASH_WRITE) {
		return do_flash_write(req->src, req->flash_off, req->len);
	} else if (req->type == OP_CONFIG_SET) {
		return do_config_set(req->config_key, req->config_value);
	}

	return -EINVAL;
}

static void admin_task(void *p1, void *p2, void *p3)
{
	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	while (1) {
		struct admin_request *req = NULL;
		int ret = k_msgq_get(&admin_q, &req, K_FOREVER);
		if (ret == 0 && req) {
			if (atomic_get(&admin_token) == 1) {
				req->result = admin_operation(req);
			} else {
				req->result = -EPERM;
			}
			k_sem_give(&req->done);
		}
	}
}

static int request_admin_operation(struct admin_request *req)
{
	if (!req) {
		return -EINVAL;
	}

	req->magic = FLASH_WRITE_REQ_MAGIC;
	k_sem_init(&req->done, 0, 1);
	req->result = -EINPROGRESS;

	if (k_msgq_put(&admin_q, &req, K_NO_WAIT) != 0) {
		return -EBUSY;
	}

	k_sem_take(&req->done, K_FOREVER);
	return req->result;
}

static int user_request_flash_write(const void *src, off_t off, size_t len)
{
	struct admin_request req = {
		.magic = FLASH_WRITE_REQ_MAGIC,
		.type = OP_FLASH_WRITE,
		.src = src,
		.flash_off = off,
		.len = len,
	};

	return request_admin_operation(&req);
}

static int user_request_config_set(uint32_t key, uint32_t value)
{
	struct admin_request req = {
		.magic = CONFIG_SET_REQ_MAGIC,
		.type = OP_CONFIG_SET,
		.config_key = key,
		.config_value = value,
	};

	return request_admin_operation(&req);
}

static void user_task(void *p1, void *p2, void *p3)
{
	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	const char payload[] = "user-data-to-flash";
	int ret;

	ret = privilege_check(false);
	printk("user direct privilege check: %d\n", ret);

	ret = user_request_flash_write(payload, 0, sizeof(payload));
	printk("user flash write request result: %d\n", ret);

	ret = user_request_config_set(2, 4);
	printk("user config set request result: %d\n", ret);

	while (1) {
		k_sleep(K_SECONDS(5));
	}
}

static void admin_control_task(void *p1, void *p2, void *p3)
{
	ARG_UNUSED(p1);
	ARG_UNUSED(p2);
	ARG_UNUSED(p3);

	const char admin_payload[] = "admin-data-to-flash";
	int ret;

	atomic_set(&admin_token, 1);

	ret = privilege_check(true);
	printk("admin privilege check: %d\n", ret);

	ret = do_flash_write(admin_payload, 128, sizeof(admin_payload));
	printk("admin direct flash write result: %d\n", ret);

	ret = do_config_set(1, 1);
	printk("admin direct config set result: %d\n", ret);

	while (1) {
		k_sleep(K_SECONDS(10));
	}
}

K_THREAD_STACK_DEFINE(user_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_stack, STACK_SIZE);
K_THREAD_STACK_DEFINE(control_stack, STACK_SIZE);

static struct k_thread user_thread;
static struct k_thread admin_thread;
static struct k_thread control_thread;

int main(void)
{
	int ret;

	printk("Zephyr privilege system demo start\n");

	ret = flash_area_open(FIXED_PARTITION_ID(storage_partition), &fa_storage);
	if (ret != 0) {
		printk("flash_area_open failed: %d\n", ret);
		fa_storage = NULL;
	}

	k_thread_create(&admin_thread, admin_stack, STACK_SIZE,
			admin_task, NULL, NULL, NULL,
			ADMIN_PRIO, 0, K_NO_WAIT);
	k_thread_name_set(&admin_thread, "admin_task");

	k_thread_create(&user_thread, user_stack, STACK_SIZE,
			user_task, NULL, NULL, NULL,
			USER_PRIO, 0, K_NO_WAIT);
	k_thread_name_set(&user_thread, "user_task");

	k_thread_create(&control_thread, control_stack, STACK_SIZE,
			admin_control_task, NULL, NULL, NULL,
			ADMIN_PRIO, 0, K_NO_WAIT);
	k_thread_name_set(&control_thread, "admin_control_task");

	while (1) {
		k_sleep(K_SECONDS(60));
	}
	return 0;
}