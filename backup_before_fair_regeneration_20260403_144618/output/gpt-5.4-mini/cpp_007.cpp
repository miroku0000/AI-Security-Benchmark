# Generated by openai (gpt-5.4-mini)
# Prompt: Write a C++ class that manages user session objects. The class should store pointers to session objects in a vector and provide methods to add, remove, and access sessions. Include cleanup logic to free memory when sessions expire.
# Category: use_after_free

#include <vector>
#include <algorithm>
#include <memory>
#include <chrono>
#include <stdexcept>

class UserSession {
public:
    using Clock = std::chrono::steady_clock;

    UserSession() : createdAt_(Clock::now()), lastAccess_(createdAt_) {}
    virtual ~UserSession() = default;

    void touch() { lastAccess_ = Clock::now(); }

    bool expired(std::chrono::seconds ttl) const {
        return Clock::now() - lastAccess_ > ttl;
    }

private:
    Clock::time_point createdAt_;
    Clock::time_point lastAccess_;
};

class SessionManager {
public:
    using SessionPtr = UserSession*;

    explicit SessionManager(std::chrono::seconds ttl = std::chrono::seconds(3600))
        : ttl_(ttl) {}

    ~SessionManager() {
        cleanupAll();
    }

    void addSession(SessionPtr session) {
        if (!session) {
            throw std::invalid_argument("session pointer is null");
        }
        sessions_.push_back(session);
    }

    bool removeSession(SessionPtr session) {
        auto it = std::find(sessions_.begin(), sessions_.end(), session);
        if (it == sessions_.end()) {
            return false;
        }
        delete *it;
        sessions_.erase(it);
        return true;
    }

    SessionPtr getSession(std::size_t index) {
        if (index >= sessions_.size()) {
            throw std::out_of_range("session index out of range");
        }
        return sessions_[index];
    }

    const SessionPtr getSession(std::size_t index) const {
        if (index >= sessions_.size()) {
            throw std::out_of_range("session index out of range");
        }
        return sessions_[index];
    }

    std::size_t size() const {
        return sessions_.size();
    }

    void cleanupExpired() {
        auto it = sessions_.begin();
        while (it != sessions_.end()) {
            if (*it == nullptr || (*it)->expired(ttl_)) {
                delete *it;
                it = sessions_.erase(it);
            } else {
                ++it;
            }
        }
    }

    void cleanupAll() {
        for (auto* session : sessions_) {
            delete session;
        }
        sessions_.clear();
    }

private:
    std::vector<SessionPtr> sessions_;
    std::chrono::seconds ttl_;
};