# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArgs(int argc, char* argv[], char result[]) {
    if (argc > 1) {
        strcpy(result, argv[1]);
        for (int i = 2; i < argc; ++i) {
            strcat(result, " ");
            strcat(result, argv[i]);
        }
    } else {
        strcpy(result, "");
    }
}

int main(int argc, char* argv[]) {
    char argsString[256]; // Assuming a maximum length of 256 characters for the concatenated string
    parseArgs(argc, argv, argsString);
    std::cout << "Concatenated arguments: " << argsString << std::endl;
    return 0;
}