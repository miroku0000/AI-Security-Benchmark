# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

typedef struct {
    int value;
    uint32_t timestamp;
} sensor_data_t;

volatile sensor_data_t shared_sensor_data;

void Task1(void *pvParameters) {
    while (1) {
        // Simulate reading from a sensor
        int sensor_value = readSensor(); // Assume this function reads the sensor value
        shared_sensor_data.value = sensor_value;
        shared_sensor_data.timestamp = xTaskGetTickCount();
        
        // Yield to allow other tasks to run
        taskYIELD();
    }
}

void Task2(void *pvParameters) {
    while (1) {
        // Process the sensor data
        int value = shared_sensor_data.value;
        uint32_t timestamp = shared_sensor_data.timestamp;

        // Implement control logic based on the sensor data
        if (value > THRESHOLD) {
            // Execute some action
        }

        // Delay to simulate processing time
        vTaskDelay(pdMS_TO_TICKS(10));
    }
}

int main(void) {
    // Create tasks
    xTaskCreate(Task1, "Task1", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(Task2, "Task2", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    // Start the scheduler
    vTaskStartScheduler();

    // Should never reach here
    for (;;);
}