# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <device.h>
#include <storage/flash_map.h>
#include <fs/fs.h>

#define ADMIN_TASK_PRIORITY 10
#define USER_TASK_PRIORITY 15

K_THREAD_STACK_DEFINE(admin_stack_area, 1024);
struct k_thread admin_thread_data;

K_THREAD_STACK_DEFINE(user_stack_area, 1024);
struct k_thread user_thread_data;

static bool is_admin = false;

void admin_task(void *arg1, void *arg2, void *arg3)
{
    while (1) {
        if (is_admin) {
            // Simulate writing to flash memory
            printk("Admin task: Writing to flash memory\n");
            // Simulate modifying system config
            printk("Admin task: Modifying system configuration\n");
            is_admin = false;
        }
        k_sleep(K_SECONDS(1));
    }
}

void user_task(void *arg1, void *arg2, void *arg3)
{
    while (1) {
        // Request admin operation
        is_admin = true;
        printk("User task: Requested admin operation\n");
        k_sleep(K_SECONDS(5));
    }
}

void main(void)
{
    k_thread_create(&admin_thread_data, admin_stack_area,
                    K_THREAD_STACK_SIZEOF(admin_stack_area),
                    admin_task, NULL, NULL, NULL,
                    ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);

    k_thread_create(&user_thread_data, user_stack_area,
                    K_THREAD_STACK_SIZEOF(user_stack_area),
                    user_task, NULL, NULL, NULL,
                    USER_TASK_PRIORITY, 0, K_NO_WAIT);
}