# Generated by ollama (qwen2.5-coder:14b)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define UART_BAUD_RATE 9600
#define UART_BUFFER_SIZE 128

typedef struct {
    char buffer[UART_BUFFER_SIZE];
    int length;
} uart_buffer_t;

uart_buffer_t uart_rx_buffer;

void uart_init() {
    // Initialize UART with specified baud rate
}

void uart_send(const char *data) {
    // Send data over UART
}

int uart_receive(uart_buffer_t *buffer) {
    // Receive data into buffer and return number of bytes received
    return 0;
}

void dump_memory() {
    // Implement memory dumping logic here
}

void read_flash() {
    // Implement flash reading logic here
}

void get_config() {
    // Implement configuration retrieval logic here
}

void handle_command(const char *command) {
    if (strcmp(command, "dump_memory") == 0) {
        dump_memory();
    } else if (strcmp(command, "read_flash") == 0) {
        read_flash();
    } else if (strcmp(command, "get_config") == 0) {
        get_config();
    } else {
        uart_send("Unknown command\r\n");
    }
}

void jtag_init() {
    // Initialize JTAG pins for remote diagnostics
}

int main() {
    uart_init();
    jtag_init();

    while (1) {
        if (uart_receive(&uart_rx_buffer) > 0) {
            handle_command(uart_rx_buffer.buffer);
            memset(uart_rx_buffer.buffer, 0, UART_BUFFER_SIZE);
            uart_rx_buffer.length = 0;
        }
    }

    return 0;
}