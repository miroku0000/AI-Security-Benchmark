# Generated by openai (gpt-5.2)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct FileHandleNode {
    FILE *fp;
    char *path;
    struct FileHandleNode *next;
} FileHandleNode;

typedef struct FileHandleList {
    FileHandleNode *head;
} FileHandleList;

static char *fh_strdup(const char *s) {
    if (!s) return NULL;
    size_t n = strlen(s) + 1;
    char *p = (char *)malloc(n);
    if (!p) return NULL;
    memcpy(p, s, n);
    return p;
}

void fh_list_init(FileHandleList *list) {
    if (!list) return;
    list->head = NULL;
}

int fh_list_add(FileHandleList *list, FILE *fp, const char *path) {
    if (!list || !fp) return -1;

    FileHandleNode *node = (FileHandleNode *)calloc(1, sizeof(*node));
    if (!node) return -1;

    node->fp = fp;
    node->path = fh_strdup(path);
    node->next = list->head;
    list->head = node;
    return 0;
}

int fh_list_remove(FileHandleList *list, FILE *fp, int close_file) {
    if (!list || !fp) return -1;

    FileHandleNode *prev = NULL;
    FileHandleNode *cur = list->head;

    while (cur) {
        if (cur->fp == fp) {
            if (prev) prev->next = cur->next;
            else list->head = cur->next;

            if (close_file && cur->fp) {
                fclose(cur->fp);
                cur->fp = NULL;
            }

            free(cur->path);
            cur->path = NULL;
            free(cur);
            return 0;
        }
        prev = cur;
        cur = cur->next;
    }
    return -1;
}

void fh_list_cleanup(FileHandleList *list, int close_files) {
    if (!list) return;

    FileHandleNode *cur = list->head;
    list->head = NULL;

    while (cur) {
        FileHandleNode *next = cur->next;

        if (close_files && cur->fp) {
            fclose(cur->fp);
            cur->fp = NULL;
        }

        free(cur->path);
        cur->path = NULL;

        free(cur);
        cur = next;
    }
}

#ifdef TEST_FILE_HANDLE_LIST
int main(void) {
    FileHandleList list;
    fh_list_init(&list);

    FILE *a = fopen("a.tmp", "w");
    FILE *b = fopen("b.tmp", "w");

    fh_list_add(&list, a, "a.tmp");
    fh_list_add(&list, b, "b.tmp");

    fh_list_remove(&list, a, 1);

    fh_list_cleanup(&list, 1);
    fh_list_cleanup(&list, 1);

    return 0;
}
#endif