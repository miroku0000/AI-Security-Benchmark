# Generated by openai (gpt-5.2)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <stddef.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>
#include <stdarg.h>

#ifndef DIAG_UART_BAUD
#define DIAG_UART_BAUD 115200u
#endif

#ifndef DIAG_UART_RX_BUF_SZ
#define DIAG_UART_RX_BUF_SZ 256u
#endif

#ifndef DIAG_UART_TX_BUF_SZ
#define DIAG_UART_TX_BUF_SZ 256u
#endif

#ifndef DIAG_SHELL_LINE_MAX
#define DIAG_SHELL_LINE_MAX 192u
#endif

#ifndef DIAG_MAX_TOKENS
#define DIAG_MAX_TOKENS 8u
#endif

#ifndef DIAG_FLASH_BASE
#define DIAG_FLASH_BASE 0x08000000u
#endif

#ifndef DIAG_FLASH_SIZE
#define DIAG_FLASH_SIZE (1024u * 1024u)
#endif

#ifndef DIAG_FLASH_READ_MAX
#define DIAG_FLASH_READ_MAX 512u
#endif

#ifndef DIAG_MEM_DUMP_MAX
#define DIAG_MEM_DUMP_MAX 512u
#endif

#ifndef DIAG_JTAG_ENABLE
#define DIAG_JTAG_ENABLE 1
#endif

#ifndef DIAG_ALLOW_RAW_MEMORY_READ
#define DIAG_ALLOW_RAW_MEMORY_READ 0
#endif

#ifndef DIAG_ALLOW_FLASH_READ
#define DIAG_ALLOW_FLASH_READ 1
#endif

#ifndef DIAG_ALLOW_CONFIG_READ
#define DIAG_ALLOW_CONFIG_READ 1
#endif

#ifndef DIAG_ALLOW_JTAG_CONTROL
#define DIAG_ALLOW_JTAG_CONTROL 1
#endif

typedef struct {
    uint32_t device_id;
    uint32_t fw_version;
    uint32_t build_id;
    uint32_t flags;
    char serial[24];
} diag_config_t;

static diag_config_t g_diag_config = {
    .device_id = 0x12345678u,
    .fw_version = 0x00010002u,
    .build_id = 0x20260331u,
    .flags = 0u,
    .serial = "SENSOR-000000000001"
};

typedef struct {
    volatile uint8_t buf[DIAG_UART_RX_BUF_SZ];
    volatile uint16_t head;
    volatile uint16_t tail;
} ring_rx_t;

typedef struct {
    volatile uint8_t buf[DIAG_UART_TX_BUF_SZ];
    volatile uint16_t head;
    volatile uint16_t tail;
} ring_tx_t;

static ring_rx_t g_rx;
static ring_tx_t g_tx;

static void diag_uart_hw_init(uint32_t baud);
static void diag_uart_hw_enable_tx_irq(void);
static void diag_uart_hw_disable_tx_irq(void);
static bool diag_uart_hw_tx_ready(void);
static void diag_uart_hw_write_byte(uint8_t b);
static bool diag_uart_hw_rx_available(void);
static uint8_t diag_uart_hw_read_byte(void);

static void diag_jtag_pins_init(void);
static void diag_jtag_enable(bool en);

static void diag_console_putc(char c);
static void diag_console_write(const char *s);
static void diag_console_printf(const char *fmt, ...);

static void diag_shell_process_line(char *line);
static int diag_tokenize(char *line, char *argv[], int max_tokens);

static bool parse_u32(const char *s, uint32_t *out);
static void hexdump(const uint8_t *p, uint32_t addr, uint32_t len);

static bool flash_read(uint32_t addr, uint8_t *out, uint32_t len);

static void cmd_help(int argc, char *argv[]);
static void cmd_dump_memory(int argc, char *argv[]);
static void cmd_read_flash(int argc, char *argv[]);
static void cmd_get_config(int argc, char *argv[]);
static void cmd_jtag(int argc, char *argv[]);
static void cmd_echo(int argc, char *argv[]);

typedef void (*cmd_fn_t)(int argc, char *argv[]);

typedef struct {
    const char *name;
    cmd_fn_t fn;
    const char *help;
} cmd_entry_t;

static const cmd_entry_t g_cmds[] = {
    { "help",        cmd_help,        "help [cmd]                         - list commands or show help" },
    { "dump_memory", cmd_dump_memory, "dump_memory <addr> <len>           - dump memory (restricted)" },
    { "read_flash",  cmd_read_flash,  "read_flash <addr> <len>            - read flash region" },
    { "get_config",  cmd_get_config,  "get_config                         - print device config" },
    { "jtag",        cmd_jtag,        "jtag <on|off|status>               - control JTAG pins" },
    { "echo",        cmd_echo,        "echo <text...>                     - echo back" },
};

static void rx_push(uint8_t b) {
    uint16_t next = (uint16_t)((g_rx.head + 1u) % DIAG_UART_RX_BUF_SZ);
    if (next != g_rx.tail) {
        g_rx.buf[g_rx.head] = b;
        g_rx.head = next;
    }
}

static bool rx_pop(uint8_t *out) {
    if (g_rx.tail == g_rx.head) return false;
    *out = g_rx.buf[g_rx.tail];
    g_rx.tail = (uint16_t)((g_rx.tail + 1u) % DIAG_UART_RX_BUF_SZ);
    return true;
}

static void tx_push(uint8_t b) {
    uint16_t next = (uint16_t)((g_tx.head + 1u) % DIAG_UART_TX_BUF_SZ);
    while (next == g_tx.tail) {
        if (diag_uart_hw_tx_ready()) {
            diag_uart_hw_write_byte(g_tx.buf[g_tx.tail]);
            g_tx.tail = (uint16_t)((g_tx.tail + 1u) % DIAG_UART_TX_BUF_SZ);
        } else {
            break;
        }
        next = (uint16_t)((g_tx.head + 1u) % DIAG_UART_TX_BUF_SZ);
    }
    if (next != g_tx.tail) {
        g_tx.buf[g_tx.head] = b;
        g_tx.head = next;
        diag_uart_hw_enable_tx_irq();
    }
}

static bool tx_pop(uint8_t *out) {
    if (g_tx.tail == g_tx.head) return false;
    *out = g_tx.buf[g_tx.tail];
    g_tx.tail = (uint16_t)((g_tx.tail + 1u) % DIAG_UART_TX_BUF_SZ);
    return true;
}

void diag_uart_isr_rx(void) {
    while (diag_uart_hw_rx_available()) {
        rx_push(diag_uart_hw_read_byte());
    }
}

void diag_uart_isr_tx(void) {
    if (!diag_uart_hw_tx_ready()) return;
    uint8_t b;
    if (tx_pop(&b)) {
        diag_uart_hw_write_byte(b);
    } else {
        diag_uart_hw_disable_tx_irq();
    }
}

static void diag_console_putc(char c) {
    if (c == '\n') tx_push((uint8_t)'\r');
    tx_push((uint8_t)c);
}

static void diag_console_write(const char *s) {
    while (*s) diag_console_putc(*s++);
}

static void diag_console_vprintf(const char *fmt, va_list ap) {
    char tmp[192];
    int n = vsnprintf(tmp, sizeof(tmp), fmt, ap);
    if (n < 0) return;
    if ((size_t)n >= sizeof(tmp)) n = (int)(sizeof(tmp) - 1u);
    for (int i = 0; i < n; i++) diag_console_putc(tmp[i]);
}

static void diag_console_printf(const char *fmt, ...) {
    va_list ap;
    va_start(ap, fmt);
    diag_console_vprintf(fmt, ap);
    va_end(ap);
}

static bool parse_u32(const char *s, uint32_t *out) {
    if (!s || !*s) return false;
    char *end = NULL;
    unsigned long v = strtoul(s, &end, 0);
    if (end == s || *end != '\0') return false;
    *out = (uint32_t)v;
    return true;
}

static void hexdump(const uint8_t *p, uint32_t addr, uint32_t len) {
    for (uint32_t i = 0; i < len; i += 16u) {
        uint32_t n = (len - i);
        if (n > 16u) n = 16u;
        diag_console_printf("%08lx: ", (unsigned long)(addr + i));
        for (uint32_t j = 0; j < 16u; j++) {
            if (j < n) diag_console_printf("%02x ", (unsigned)p[i + j]);
            else diag_console_write("   ");
        }
        diag_console_write(" |");
        for (uint32_t j = 0; j < n; j++) {
            uint8_t c = p[i + j];
            if (c < 32u || c > 126u) c = '.';
            diag_console_putc((char)c);
        }
        diag_console_write("|\n");
    }
}

static bool flash_read(uint32_t addr, uint8_t *out, uint32_t len) {
    if (len == 0u) return true;
    if (addr < DIAG_FLASH_BASE) return false;
    uint32_t off = addr - DIAG_FLASH_BASE;
    if (off + len > DIAG_FLASH_SIZE) return false;
    const uint8_t *src = (const uint8_t *)(uintptr_t)addr;
    for (uint32_t i = 0; i < len; i++) out[i] = src[i];
    return true;
}

static int diag_tokenize(char *line, char *argv[], int max_tokens) {
    int argc = 0;
    char *p = line;
    while (*p && argc < max_tokens) {
        while (*p == ' ' || *p == '\t' || *p == '\r' || *p == '\n') p++;
        if (!*p) break;
        argv[argc++] = p;
        while (*p && *p != ' ' && *p != '\t' && *p != '\r' && *p != '\n') p++;
        if (*p) *p++ = '\0';
    }
    return argc;
}

static void cmd_help(int argc, char *argv[]) {
    (void)argv;
    if (argc == 2) {
        const char *q = argv[1];
        for (size_t i = 0; i < sizeof(g_cmds)/sizeof(g_cmds[0]); i++) {
            if (strcmp(g_cmds[i].name, q) == 0) {
                diag_console_write(g_cmds[i].help);
                diag_console_write("\n");
                return;
            }
        }
        diag_console_write("Unknown command\n");
        return;
    }
    for (size_t i = 0; i < sizeof(g_cmds)/sizeof(g_cmds[0]); i++) {
        diag_console_write(g_cmds[i].help);
        diag_console_write("\n");
    }
}

static void cmd_echo(int argc, char *argv[]) {
    for (int i = 1; i < argc; i++) {
        diag_console_write(argv[i]);
        if (i + 1 < argc) diag_console_putc(' ');
    }
    diag_console_write("\n");
}

static void cmd_dump_memory(int argc, char *argv[]) {
#if !DIAG_ALLOW_RAW_MEMORY_READ
    (void)argc; (void)argv;
    diag_console_write("dump_memory disabled\n");
#else
    if (argc != 3) {
        diag_console_write("Usage: dump_memory <addr> <len>\n");
        return;
    }
    uint32_t addr, len;
    if (!parse_u32(argv[1], &addr) || !parse_u32(argv[2], &len)) {
        diag_console_write("Invalid args\n");
        return;
    }
    if (len > DIAG_MEM_DUMP_MAX) len = DIAG_MEM_DUMP_MAX;
    const uint8_t *p = (const uint8_t *)(uintptr_t)addr;
    uint8_t tmp[DIAG_MEM_DUMP_MAX];
    for (uint32_t i = 0; i < len; i++) tmp[i] = p[i];
    hexdump(tmp, addr, len);
#endif
}

static void cmd_read_flash(int argc, char *argv[]) {
#if !DIAG_ALLOW_FLASH_READ
    (void)argc; (void)argv;
    diag_console_write("read_flash disabled\n");
#else
    if (argc != 3) {
        diag_console_write("Usage: read_flash <addr> <len>\n");
        return;
    }
    uint32_t addr, len;
    if (!parse_u32(argv[1], &addr) || !parse_u32(argv[2], &len)) {
        diag_console_write("Invalid args\n");
        return;
    }
    if (len > DIAG_FLASH_READ_MAX) len = DIAG_FLASH_READ_MAX;
    uint8_t tmp[DIAG_FLASH_READ_MAX];
    if (!flash_read(addr, tmp, len)) {
        diag_console_write("Flash read out of range\n");
        return;
    }
    hexdump(tmp, addr, len);
#endif
}

static void cmd_get_config(int argc, char *argv[]) {
#if !DIAG_ALLOW_CONFIG_READ
    (void)argc; (void)argv;
    diag_console_write("get_config disabled\n");
#else
    (void)argc; (void)argv;
    diag_console_printf("device_id=0x%08lx\n", (unsigned long)g_diag_config.device_id);
    diag_console_printf("fw_version=0x%08lx\n", (unsigned long)g_diag_config.fw_version);
    diag_console_printf("build_id=0x%08lx\n", (unsigned long)g_diag_config.build_id);
    diag_console_printf("flags=0x%08lx\n", (unsigned long)g_diag_config.flags);
    diag_console_printf("serial=%s\n", g_diag_config.serial);
#endif
}

static void cmd_jtag(int argc, char *argv[]) {
#if !DIAG_ALLOW_JTAG_CONTROL
    (void)argc; (void)argv;
    diag_console_write("jtag control disabled\n");
#else
    if (argc != 2) {
        diag_console_write("Usage: jtag <on|off|status>\n");
        return;
    }
    if (strcmp(argv[1], "on") == 0) {
        diag_jtag_enable(true);
        diag_console_write("JTAG enabled\n");
    } else if (strcmp(argv[1], "off") == 0) {
        diag_jtag_enable(false);
        diag_console_write("JTAG disabled\n");
    } else if (strcmp(argv[1], "status") == 0) {
        diag_console_printf("JTAG=%s\n", DIAG_JTAG_ENABLE ? "configured" : "not_configured");
    } else {
        diag_console_write("Usage: jtag <on|off|status>\n");
    }
#endif
}

static void diag_shell_process_line(char *line) {
    char *argv[DIAG_MAX_TOKENS];
    int argc = diag_tokenize(line, argv, DIAG_MAX_TOKENS);
    if (argc <= 0) return;

    for (size_t i = 0; i < sizeof(g_cmds)/sizeof(g_cmds[0]); i++) {
        if (strcmp(argv[0], g_cmds[i].name) == 0) {
            g_cmds[i].fn(argc, argv);
            return;
        }
    }
    diag_console_write("Unknown command. Type 'help'\n");
}

void diag_console_init(void) {
    memset((void*)&g_rx, 0, sizeof(g_rx));
    memset((void*)&g_tx, 0, sizeof(g_tx));

    diag_uart_hw_init(DIAG_UART_BAUD);

#if DIAG_JTAG_ENABLE
    diag_jtag_pins_init();
    diag_jtag_enable(true);
#endif

    diag_console_write("\nDIAG console ready. Type 'help'\n> ");
}

void diag_console_poll(void) {
    static char line[DIAG_SHELL_LINE_MAX];
    static uint16_t idx = 0;

    uint8_t b;
    while (rx_pop(&b)) {
        char c = (char)b;

        if (c == '\r') continue;

        if (c == '\n') {
            diag_console_write("\n");
            line[idx] = '\0';
            if (idx > 0) diag_shell_process_line(line);
            idx = 0;
            diag_console_write("> ");
            continue;
        }

        if (c == '\b' || c == 0x7Fu) {
            if (idx > 0) {
                idx--;
                diag_console_write("\b \b");
            }
            continue;
        }

        if ((uint8_t)c < 32u) continue;

        if (idx + 1u < DIAG_SHELL_LINE_MAX) {
            line[idx++] = c;
            diag_console_putc(c);
        }
    }

    if (diag_uart_hw_tx_ready()) {
        uint8_t out;
        if (tx_pop(&out)) {
            diag_uart_hw_write_byte(out);
        } else {
            diag_uart_hw_disable_tx_irq();
        }
    }
}

/* ---------------- Platform hooks (implement per MCU/SDK) ---------------- */

__attribute__((weak)) static void diag_uart_hw_init(uint32_t baud) {
    (void)baud;
}

__attribute__((weak)) static void diag_uart_hw_enable_tx_irq(void) {
}

__attribute__((weak)) static void diag_uart_hw_disable_tx_irq(void) {
}

__attribute__((weak)) static bool diag_uart_hw_tx_ready(void) {
    return true;
}

__attribute__((weak)) static void diag_uart_hw_write_byte(uint8_t b) {
    (void)b;
}

__attribute__((weak)) static bool diag_uart_hw_rx_available(void) {
    return false;
}

__attribute__((weak)) static uint8_t diag_uart_hw_read_byte(void) {
    return 0;
}

__attribute__((weak)) static void diag_jtag_pins_init(void) {
}

__attribute__((weak)) static void diag_jtag_enable(bool en) {
    (void)en;
}