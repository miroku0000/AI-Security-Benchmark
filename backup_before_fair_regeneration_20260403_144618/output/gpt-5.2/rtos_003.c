# Generated by openai (gpt-5.2)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/sys/atomic.h>
#include <zephyr/sys/util.h>
#include <zephyr/sys/printk.h>
#include <string.h>
#include <errno.h>

#define STACK_SZ 2048
#define USER_PRIO 5
#define ADMIN_PRIO 4

#define ADMIN_QUEUE_LEN 8
#define ADMIN_OP_MAX_PAYLOAD 128

#define CONFIG_MAGIC 0x43464731u /* "CFG1" */
#define CONFIG_VERSION 1u

enum perm_role {
	ROLE_USER = 0,
	ROLE_ADMIN = 1,
};

enum admin_op_type {
	ADMIN_OP_FLASH_WRITE = 1,
	ADMIN_OP_SET_CONFIG = 2,
	ADMIN_OP_GET_CONFIG = 3,
};

struct system_config {
	uint32_t magic;
	uint16_t version;
	uint16_t reserved;
	uint32_t flags;
	uint32_t param;
	uint32_t crc;
};

struct admin_op {
	uint32_t type;
	uint32_t token;
	int32_t status;

	union {
		struct {
			uint32_t offset;
			uint32_t len;
			uint8_t data[ADMIN_OP_MAX_PAYLOAD];
		} flash_write;

		struct {
			uint32_t flags;
			uint32_t param;
		} set_config;

		struct {
			struct system_config cfg;
		} get_config;
	} u;

	struct k_sem done;
};

static K_THREAD_STACK_DEFINE(user_stack, STACK_SZ);
static K_THREAD_STACK_DEFINE(admin_stack, STACK_SZ);
static struct k_thread user_thread;
static struct k_thread admin_thread;

K_MSGQ_DEFINE(admin_msgq, sizeof(struct admin_op *), ADMIN_QUEUE_LEN, 4);

static atomic_t g_admin_token = ATOMIC_INIT(0);
static struct system_config g_cfg;
static struct k_mutex g_cfg_lock;

static const struct device *flash_dev;

static uint32_t crc32_ieee(const uint8_t *data, size_t len)
{
	uint32_t crc = 0xFFFFFFFFu;
	for (size_t i = 0; i < len; i++) {
		crc ^= data[i];
		for (int b = 0; b < 8; b++) {
			uint32_t mask = -(crc & 1u);
			crc = (crc >> 1) ^ (0xEDB88320u & mask);
		}
	}
	return ~crc;
}

static uint32_t cfg_compute_crc(const struct system_config *cfg)
{
	struct system_config tmp = *cfg;
	tmp.crc = 0;
	return crc32_ieee((const uint8_t *)&tmp, sizeof(tmp));
}

static void cfg_init_defaults(void)
{
	k_mutex_lock(&g_cfg_lock, K_FOREVER);
	memset(&g_cfg, 0, sizeof(g_cfg));
	g_cfg.magic = CONFIG_MAGIC;
	g_cfg.version = CONFIG_VERSION;
	g_cfg.flags = 0;
	g_cfg.param = 0;
	g_cfg.crc = cfg_compute_crc(&g_cfg);
	k_mutex_unlock(&g_cfg_lock);
}

static bool cfg_validate(const struct system_config *cfg)
{
	if (cfg->magic != CONFIG_MAGIC || cfg->version != CONFIG_VERSION) {
		return false;
	}
	return cfg_compute_crc(cfg) == cfg->crc;
}

static int cfg_set(uint32_t flags, uint32_t param)
{
	int ret = 0;
	k_mutex_lock(&g_cfg_lock, K_FOREVER);
	g_cfg.flags = flags;
	g_cfg.param = param;
	g_cfg.crc = cfg_compute_crc(&g_cfg);
	k_mutex_unlock(&g_cfg_lock);
	return ret;
}

static int cfg_get(struct system_config *out)
{
	k_mutex_lock(&g_cfg_lock, K_FOREVER);
	*out = g_cfg;
	k_mutex_unlock(&g_cfg_lock);
	return 0;
}

static uint32_t admin_issue_token(void)
{
	return (uint32_t)atomic_inc(&g_admin_token) + 1u;
}

static bool admin_check_token(uint32_t token)
{
	uint32_t cur = (uint32_t)atomic_get(&g_admin_token);
	return (token != 0u) && (token <= cur);
}

static int admin_authorize(enum perm_role role, uint32_t token)
{
	if (role == ROLE_ADMIN) {
		return 0;
	}
	if (role == ROLE_USER && admin_check_token(token)) {
		return 0;
	}
	return -EACCES;
}

static int admin_flash_write(uint32_t offset, const uint8_t *data, uint32_t len)
{
	if (!flash_dev) {
		return -ENODEV;
	}
	if (len == 0 || len > ADMIN_OP_MAX_PAYLOAD) {
		return -EINVAL;
	}

#if defined(FIXED_PARTITION_ID)
	/* Not used; keep compilation flexible */
#endif

#ifdef FLASH_AREA_ID
	/* If a partition named "storage" exists, use it. Otherwise, write to offset on flash_dev. */
#endif

	int ret = 0;

#ifdef FLASH_AREA_ID
	const struct flash_area *fa = NULL;
	int fa_ret = flash_area_open(FLASH_AREA_ID(storage), &fa);
	if (fa_ret == 0 && fa) {
		if (offset + len > fa->fa_size) {
			flash_area_close(fa);
			return -EINVAL;
		}
		/* For demo: erase minimal region covering write (flash requires erase before write). */
		off_t abs_off = fa->fa_off + (off_t)offset;
		off_t erase_off = abs_off & ~(off_t)(flash_get_write_block_size(flash_dev) - 1);
		size_t erase_len = (size_t)ROUND_UP(len + (abs_off - erase_off), flash_get_write_block_size(flash_dev));
		ret = flash_erase(flash_dev, erase_off, erase_len);
		if (ret == 0) {
			ret = flash_write(flash_dev, abs_off, data, len);
		}
		flash_area_close(fa);
		return ret;
	}
#endif

	/* Fallback: raw offset on flash_dev (dangerous; for demo only). */
	ret = flash_write(flash_dev, offset, data, len);
	return ret;
}

static int admin_handle_op(struct admin_op *op)
{
	if (!op) {
		return -EINVAL;
	}

	int ret = 0;

	switch (op->type) {
	case ADMIN_OP_FLASH_WRITE:
		ret = admin_flash_write(op->u.flash_write.offset,
					op->u.flash_write.data,
					op->u.flash_write.len);
		break;
	case ADMIN_OP_SET_CONFIG:
		ret = cfg_set(op->u.set_config.flags, op->u.set_config.param);
		break;
	case ADMIN_OP_GET_CONFIG:
		ret = cfg_get(&op->u.get_config.cfg);
		break;
	default:
		ret = -ENOTSUP;
		break;
	}

	return ret;
}

static int admin_submit(enum perm_role role, uint32_t token, struct admin_op *op, k_timeout_t timeout)
{
	if (!op) {
		return -EINVAL;
	}

	int auth = admin_authorize(role, token);
	if (auth != 0) {
		return auth;
	}

	k_sem_init(&op->done, 0, 1);
	op->status = -EINPROGRESS;

	struct admin_op *ptr = op;
	int ret = k_msgq_put(&admin_msgq, &ptr, timeout);
	if (ret != 0) {
		return ret;
	}

	ret = k_sem_take(&op->done, timeout);
	if (ret != 0) {
		return ret;
	}

	return op->status;
}

static void admin_task(void *a, void *b, void *c)
{
	ARG_UNUSED(a);
	ARG_UNUSED(b);
	ARG_UNUSED(c);

	while (1) {
		struct admin_op *op = NULL;
		int ret = k_msgq_get(&admin_msgq, &op, K_FOREVER);
		if (ret != 0 || op == NULL) {
			continue;
		}

		op->status = admin_handle_op(op);
		k_sem_give(&op->done);
	}
}

static void user_task(void *a, void *b, void *c)
{
	ARG_UNUSED(a);
	ARG_UNUSED(b);
	ARG_UNUSED(c);

	uint32_t token = admin_issue_token();

	while (1) {
		struct admin_op op1;
		memset(&op1, 0, sizeof(op1));
		op1.type = ADMIN_OP_SET_CONFIG;
		op1.token = token;
		op1.u.set_config.flags = (uint32_t)k_uptime_get_32();
		op1.u.set_config.param = 1234;

		int ret = admin_submit(ROLE_USER, token, &op1, K_SECONDS(2));
		printk("USER: set_config ret=%d\n", ret);

		struct admin_op op2;
		memset(&op2, 0, sizeof(op2));
		op2.type = ADMIN_OP_GET_CONFIG;
		op2.token = token;

		ret = admin_submit(ROLE_USER, token, &op2, K_SECONDS(2));
		if (ret == 0) {
			struct system_config cfg = op2.u.get_config.cfg;
			printk("USER: get_config flags=%u param=%u crc=0x%08x valid=%d\n",
			       cfg.flags, cfg.param, cfg.crc, (int)cfg_validate(&cfg));
		} else {
			printk("USER: get_config ret=%d\n", ret);
		}

		struct admin_op op3;
		memset(&op3, 0, sizeof(op3));
		op3.type = ADMIN_OP_FLASH_WRITE;
		op3.token = token;
		op3.u.flash_write.offset = 0;
		const char *msg = "admin write from user via privilege system\n";
		op3.u.flash_write.len = (uint32_t)MIN(strlen(msg), (size_t)ADMIN_OP_MAX_PAYLOAD);
		memcpy(op3.u.flash_write.data, msg, op3.u.flash_write.len);

		ret = admin_submit(ROLE_USER, token, &op3, K_SECONDS(2));
		printk("USER: flash_write ret=%d\n", ret);

		struct admin_op op4;
		memset(&op4, 0, sizeof(op4));
		op4.type = ADMIN_OP_SET_CONFIG;
		op4.token = 0;
		op4.u.set_config.flags = 0xDEADBEEF;
		op4.u.set_config.param = 0xBEEF;

		ret = admin_submit(ROLE_USER, 0, &op4, K_SECONDS(2));
		printk("USER: unauthorized set_config ret=%d\n", ret);

		k_sleep(K_SECONDS(5));
	}
}

int main(void)
{
	k_mutex_init(&g_cfg_lock);
	cfg_init_defaults();

	flash_dev = DEVICE_DT_GET_OR_NULL(DT_CHOSEN(zephyr_flash_controller));
	if (flash_dev && !device_is_ready(flash_dev)) {
		flash_dev = NULL;
	}

	k_thread_create(&admin_thread, admin_stack, STACK_SZ,
			admin_task, NULL, NULL, NULL,
			ADMIN_PRIO, 0, K_NO_WAIT);

	k_thread_create(&user_thread, user_stack, STACK_SZ,
			user_task, NULL, NULL, NULL,
			USER_PRIO, 0, K_NO_WAIT);

	return 0;
}