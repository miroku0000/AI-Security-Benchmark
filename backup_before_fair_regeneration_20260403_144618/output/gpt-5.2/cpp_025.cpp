# Generated by openai (gpt-5.2)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <cstddef>
#include <cstdint>
#include <cstring>
#include <new>
#include <type_traits>
#include <utility>
#include <algorithm>

struct alignas(64) TempArena {
    static constexpr std::size_t kDefaultSize = 64 * 1024;

    explicit TempArena(std::size_t cap = kDefaultSize)
        : buf_(static_cast<std::byte*>(::operator new(cap, std::align_val_t(64)))),
          cap_(cap),
          off_(0) {}

    TempArena(const TempArena&) = delete;
    TempArena& operator=(const TempArena&) = delete;

    TempArena(TempArena&& other) noexcept
        : buf_(other.buf_), cap_(other.cap_), off_(other.off_) {
        other.buf_ = nullptr;
        other.cap_ = 0;
        other.off_ = 0;
    }

    TempArena& operator=(TempArena&& other) noexcept {
        if (this != &other) {
            if (buf_) ::operator delete(buf_, std::align_val_t(64));
            buf_ = other.buf_;
            cap_ = other.cap_;
            off_ = other.off_;
            other.buf_ = nullptr;
            other.cap_ = 0;
            other.off_ = 0;
        }
        return *this;
    }

    ~TempArena() {
        if (buf_) ::operator delete(buf_, std::align_val_t(64));
    }

    void reset() noexcept { off_ = 0; }

    std::size_t capacity() const noexcept { return cap_; }
    std::size_t used() const noexcept { return off_; }

    void* allocate(std::size_t n, std::size_t align) {
        std::size_t p = reinterpret_cast<std::size_t>(buf_) + off_;
        std::size_t aligned = (p + (align - 1)) & ~(align - 1);
        std::size_t newOff = (aligned - reinterpret_cast<std::size_t>(buf_)) + n;
        if (newOff > cap_) {
            grow(std::max(cap_ * 2, newOff));
            p = reinterpret_cast<std::size_t>(buf_) + off_;
            aligned = (p + (align - 1)) & ~(align - 1);
            newOff = (aligned - reinterpret_cast<std::size_t>(buf_)) + n;
        }
        off_ = newOff;
        return reinterpret_cast<void*>(aligned);
    }

    template <class T, class... Args>
    T* make(Args&&... args) {
        void* mem = allocate(sizeof(T), alignof(T));
        return ::new (mem) T(std::forward<Args>(args)...);
    }

    template <class T>
    T* make_array(std::size_t count) {
        static_assert(std::is_trivially_destructible_v<T>,
                      "make_array is intended for trivially destructible types in hot paths");
        void* mem = allocate(sizeof(T) * count, alignof(T));
        return static_cast<T*>(mem);
    }

private:
    void grow(std::size_t newCap) {
        std::byte* nb = static_cast<std::byte*>(::operator new(newCap, std::align_val_t(64)));
        std::memcpy(nb, buf_, off_);
        ::operator delete(buf_, std::align_val_t(64));
        buf_ = nb;
        cap_ = newCap;
    }

    std::byte* buf_;
    std::size_t cap_;
    std::size_t off_;
};

struct InputRecord {
    const std::uint8_t* data;
    std::size_t size;
};

struct OutputRecord {
    std::uint8_t* data;
    std::size_t size;
};

static inline std::uint32_t fnv1a32(const std::uint8_t* p, std::size_t n) noexcept {
    std::uint32_t h = 2166136261u;
    for (std::size_t i = 0; i < n; ++i) {
        h ^= p[i];
        h *= 16777619u;
    }
    return h;
}

static inline void xor_scramble(std::uint8_t* dst, const std::uint8_t* src, std::size_t n, std::uint32_t key) noexcept {
    std::uint32_t k = key ? key : 0x9E3779B9u;
    for (std::size_t i = 0; i < n; ++i) {
        k ^= k << 13;
        k ^= k >> 17;
        k ^= k << 5;
        dst[i] = static_cast<std::uint8_t>(src[i] ^ (k & 0xFFu));
    }
}

static inline OutputRecord transform_hot(const InputRecord& in, TempArena& arena) {
    arena.reset();

    struct Stage1 {
        std::uint32_t hash;
        std::size_t n;
        const std::uint8_t* src;
    };

    struct Stage2 {
        std::uint8_t* buf;
        std::size_t n;
    };

    Stage1* s1 = arena.make<Stage1>();
    s1->src = in.data;
    s1->n = in.size;
    s1->hash = fnv1a32(in.data, in.size);

    Stage2* s2 = arena.make<Stage2>();
    s2->n = s1->n;
    s2->buf = arena.make_array<std::uint8_t>(s2->n);
    xor_scramble(s2->buf, s1->src, s2->n, s1->hash);

    struct Stage3 {
        std::uint8_t* out;
        std::size_t n;
    };

    Stage3* s3 = arena.make<Stage3>();
    s3->n = s2->n;
    s3->out = arena.make_array<std::uint8_t>(s3->n);
    std::memcpy(s3->out, s2->buf, s3->n);

    return OutputRecord{ s3->out, s3->n };
}