# Generated by openai (gpt-5.2)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"
#include <stdint.h>
#include <string.h>

typedef struct
{
    uint32_t seq;
    uint32_t timestamp_us;
    int32_t  temperature_mC;
    int32_t  pressure_Pa;
    int32_t  flow_mLmin;
    uint32_t status_flags;
} sensor_data_t;

volatile sensor_data_t sensor_data;

static TaskHandle_t gTaskSensorHandle = NULL;
static TaskHandle_t gTaskControlHandle = NULL;

static uint32_t platform_time_us(void)
{
    static uint32_t t = 0;
    t += 1000;
    return t;
}

static void sensor_hw_read(int32_t *temp_mC, int32_t *press_Pa, int32_t *flow_mLmin, uint32_t *status)
{
    static int32_t temp = 25000;
    static int32_t press = 101325;
    static int32_t flow = 1000;

    temp += 1;
    press += 2;
    flow += 3;

    *temp_mC = temp;
    *press_Pa = press;
    *flow_mLmin = flow;
    *status = 0u;
}

static void control_apply(int32_t control_output)
{
    (void)control_output;
}

static int32_t control_compute(const sensor_data_t *d)
{
    int32_t out = 0;
    out += (d->temperature_mC - 25000) / 10;
    out += (d->pressure_Pa - 101325) / 100;
    out += (d->flow_mLmin - 1000) / 10;
    return out;
}

static void task_sensor(void *arg)
{
    (void)arg;

    TickType_t last = xTaskGetTickCount();
    const TickType_t period = pdMS_TO_TICKS(1);

    uint32_t seq = 0;

    for (;;)
    {
        int32_t t_mC, p_Pa, f_mLmin;
        uint32_t st;
        uint32_t ts = platform_time_us();

        sensor_hw_read(&t_mC, &p_Pa, &f_mLmin, &st);

        taskENTER_CRITICAL();
        sensor_data.timestamp_us = ts;
        sensor_data.temperature_mC = t_mC;
        sensor_data.pressure_Pa = p_Pa;
        sensor_data.flow_mLmin = f_mLmin;
        sensor_data.status_flags = st;
        sensor_data.seq = ++seq;
        taskEXIT_CRITICAL();

        vTaskDelayUntil(&last, period);
    }
}

static void task_control(void *arg)
{
    (void)arg;

    TickType_t last = xTaskGetTickCount();
    const TickType_t period = pdMS_TO_TICKS(1);

    sensor_data_t local;
    uint32_t last_seq = 0;

    for (;;)
    {
        uint32_t s1, s2;

        do
        {
            taskENTER_CRITICAL();
            s1 = sensor_data.seq;
            local.timestamp_us = sensor_data.timestamp_us;
            local.temperature_mC = sensor_data.temperature_mC;
            local.pressure_Pa = sensor_data.pressure_Pa;
            local.flow_mLmin = sensor_data.flow_mLmin;
            local.status_flags = sensor_data.status_flags;
            s2 = sensor_data.seq;
            taskEXIT_CRITICAL();
        } while (s1 != s2);

        local.seq = s2;

        if (local.seq != last_seq)
        {
            int32_t u = control_compute(&local);
            control_apply(u);
            last_seq = local.seq;
        }

        vTaskDelayUntil(&last, period);
    }
}

void app_start(void)
{
    memset((void *)&sensor_data, 0, sizeof(sensor_data));

    (void)xTaskCreate(task_sensor, "SENS", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 3, &gTaskSensorHandle);
    (void)xTaskCreate(task_control, "CTRL", configMINIMAL_STACK_SIZE + 128, NULL, tskIDLE_PRIORITY + 2, &gTaskControlHandle);

    vTaskStartScheduler();
    for (;;)
    {
    }
}