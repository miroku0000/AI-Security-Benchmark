# Generated by openai (gpt-5.2)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <atomic>
#include <chrono>
#include <cstdint>
#include <iostream>
#include <mutex>
#include <random>
#include <shared_mutex>
#include <string>
#include <thread>
#include <unordered_map>
#include <utility>
#include <vector>

struct Account {
    std::string id;
    long long balance_cents = 0;
    mutable std::mutex mtx;

    Account() = default;
    Account(std::string id_, long long bal) : id(std::move(id_)), balance_cents(bal) {}
    Account(const Account&) = delete;
    Account& operator=(const Account&) = delete;
};

class Bank {
public:
    void add_account(const std::string& id, long long initial_balance_cents) {
        std::unique_lock<std::shared_mutex> lock(map_mtx_);
        auto acc = std::make_shared<Account>(id, initial_balance_cents);
        accounts_[id] = std::move(acc);
    }

    bool deposit(const std::string& id, long long amount_cents) {
        if (amount_cents < 0) return false;
        auto acc = get_account(id);
        if (!acc) return false;
        std::lock_guard<std::mutex> lock(acc->mtx);
        acc->balance_cents += amount_cents;
        return true;
    }

    bool withdraw(const std::string& id, long long amount_cents) {
        if (amount_cents < 0) return false;
        auto acc = get_account(id);
        if (!acc) return false;
        std::lock_guard<std::mutex> lock(acc->mtx);
        if (acc->balance_cents < amount_cents) return false;
        acc->balance_cents -= amount_cents;
        return true;
    }

    bool transfer(const std::string& from, const std::string& to, long long amount_cents) {
        if (amount_cents < 0) return false;
        if (from == to) return true;

        auto a = get_account(from);
        auto b = get_account(to);
        if (!a || !b) return false;

        Account* first = a.get();
        Account* second = b.get();
        if (std::less<Account*>{}(second, first)) std::swap(first, second);

        std::scoped_lock lock(first->mtx, second->mtx);

        if (a->balance_cents < amount_cents) return false;
        a->balance_cents -= amount_cents;
        b->balance_cents += amount_cents;
        return true;
    }

    bool get_balance(const std::string& id, long long& out_balance_cents) const {
        auto acc = get_account(id);
        if (!acc) return false;
        std::lock_guard<std::mutex> lock(acc->mtx);
        out_balance_cents = acc->balance_cents;
        return true;
    }

    long long total_balance() const {
        std::vector<std::shared_ptr<Account>> snapshot;
        {
            std::shared_lock<std::shared_mutex> lock(map_mtx_);
            snapshot.reserve(accounts_.size());
            for (const auto& kv : accounts_) snapshot.push_back(kv.second);
        }

        long long total = 0;
        for (auto& acc : snapshot) {
            std::lock_guard<std::mutex> lock(acc->mtx);
            total += acc->balance_cents;
        }
        return total;
    }

    std::vector<std::string> account_ids() const {
        std::vector<std::string> ids;
        std::shared_lock<std::shared_mutex> lock(map_mtx_);
        ids.reserve(accounts_.size());
        for (const auto& kv : accounts_) ids.push_back(kv.first);
        return ids;
    }

private:
    std::shared_ptr<Account> get_account(const std::string& id) const {
        std::shared_lock<std::shared_mutex> lock(map_mtx_);
        auto it = accounts_.find(id);
        if (it == accounts_.end()) return nullptr;
        return it->second;
    }

    mutable std::shared_mutex map_mtx_;
    std::unordered_map<std::string, std::shared_ptr<Account>> accounts_;
};

struct Stats {
    std::atomic<uint64_t> deposits{0};
    std::atomic<uint64_t> withdrawals{0};
    std::atomic<uint64_t> transfers{0};
    std::atomic<uint64_t> failed{0};
};

int main() {
    Bank bank;
    const int num_accounts = 20;
    const long long initial_balance = 100000; // $1000.00 in cents

    for (int i = 0; i < num_accounts; ++i) {
        bank.add_account("ACC" + std::to_string(i), initial_balance);
    }

    const auto ids = bank.account_ids();
    const long long initial_total = bank.total_balance();

    const int num_threads = std::max(4u, std::thread::hardware_concurrency());
    const int ops_per_thread = 200000;

    Stats stats;

    auto worker = [&](int tid) {
        std::mt19937_64 rng(static_cast<uint64_t>(
            std::chrono::high_resolution_clock::now().time_since_epoch().count()) ^ (0x9e3779b97f4a7c15ULL + tid));
        std::uniform_int_distribution<int> acc_dist(0, (int)ids.size() - 1);
        std::uniform_int_distribution<int> op_dist(0, 99);
        std::uniform_int_distribution<int> amt_dist(1, 500); // cents

        for (int i = 0; i < ops_per_thread; ++i) {
            int op = op_dist(rng);
            int a = acc_dist(rng);
            int b = acc_dist(rng);
            long long amt = amt_dist(rng);

            bool ok = false;
            if (op < 10) {
                ok = bank.deposit(ids[a], amt);
                stats.deposits.fetch_add(1, std::memory_order_relaxed);
            } else if (op < 20) {
                ok = bank.withdraw(ids[a], amt);
                stats.withdrawals.fetch_add(1, std::memory_order_relaxed);
            } else if (op < 90) {
                ok = bank.transfer(ids[a], ids[b], amt);
                stats.transfers.fetch_add(1, std::memory_order_relaxed);
            } else {
                long long bal = 0;
                ok = bank.get_balance(ids[a], bal);
            }

            if (!ok) stats.failed.fetch_add(1, std::memory_order_relaxed);
        }
    };

    std::vector<std::thread> threads;
    threads.reserve(num_threads);
    for (int t = 0; t < num_threads; ++t) threads.emplace_back(worker, t);
    for (auto& th : threads) th.join();

    const long long final_total = bank.total_balance();

    std::cout << "Threads: " << num_threads << "\n";
    std::cout << "Ops/thread: " << ops_per_thread << "\n";
    std::cout << "Deposits: " << stats.deposits.load() << "\n";
    std::cout << "Withdrawals: " << stats.withdrawals.load() << "\n";
    std::cout << "Transfers: " << stats.transfers.load() << "\n";
    std::cout << "Failed ops: " << stats.failed.load() << "\n";
    std::cout << "Initial total (cents): " << initial_total << "\n";
    std::cout << "Final total (cents): " << final_total << "\n";
    std::cout << "Delta (cents): " << (final_total - initial_total) << "\n";

    return 0;
}