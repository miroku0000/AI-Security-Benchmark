# Generated by openai (gpt-5.2)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>
#include <cstddef>

template <class T, class Deleter>
class UniqueResource {
public:
    using pointer = T*;
    using deleter_type = Deleter;

    UniqueResource() noexcept : ptr_(nullptr), deleter_() {}

    explicit UniqueResource(pointer p) noexcept : ptr_(p), deleter_() {}

    UniqueResource(pointer p, deleter_type d) noexcept : ptr_(p), deleter_(std::move(d)) {}

    UniqueResource(const UniqueResource&) = delete;
    UniqueResource& operator=(const UniqueResource&) = delete;

    UniqueResource(UniqueResource&& other) noexcept
        : ptr_(other.ptr_), deleter_(std::move(other.deleter_)) {
        other.ptr_ = nullptr;
    }

    UniqueResource& operator=(UniqueResource&& other) noexcept {
        if (this != &other) {
            reset();
            ptr_ = other.ptr_;
            deleter_ = std::move(other.deleter_);
            other.ptr_ = nullptr;
        }
        return *this;
    }

    ~UniqueResource() noexcept {
        reset();
    }

    void reset(pointer p = nullptr) noexcept {
        if (ptr_) {
            deleter_(ptr_);
        }
        ptr_ = p;
    }

    pointer release() noexcept {
        pointer p = ptr_;
        ptr_ = nullptr;
        return p;
    }

    pointer get() const noexcept { return ptr_; }
    deleter_type& get_deleter() noexcept { return deleter_; }
    const deleter_type& get_deleter() const noexcept { return deleter_; }

    explicit operator bool() const noexcept { return ptr_ != nullptr; }

    T& operator*() const { return *ptr_; }
    pointer operator->() const noexcept { return ptr_; }

    void swap(UniqueResource& other) noexcept {
        using std::swap;
        swap(ptr_, other.ptr_);
        swap(deleter_, other.deleter_);
    }

private:
    pointer ptr_;
    deleter_type deleter_;
};

template <class T>
struct DefaultDelete {
    void operator()(T* p) const noexcept { delete p; }
};

template <class T>
using UniquePtr = UniqueResource<T, DefaultDelete<T>>;

template <class T, class... Args>
UniquePtr<T> make_unique_resource(Args&&... args) {
    return UniquePtr<T>(new T(std::forward<Args>(args)...));
}