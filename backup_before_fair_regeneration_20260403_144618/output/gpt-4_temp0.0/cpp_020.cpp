# Generated by openai (gpt-4)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>

template <typename T>
class ResourceManager {
public:
    ResourceManager(T* resource = nullptr) : resource_(resource) {}

    ~ResourceManager() {
        delete resource_;
    }

    ResourceManager(const ResourceManager&) = delete;
    ResourceManager& operator=(const ResourceManager&) = delete;

    ResourceManager(ResourceManager&& other) noexcept : resource_(other.resource_) {
        other.resource_ = nullptr;
    }

    ResourceManager& operator=(ResourceManager&& other) noexcept {
        if (this != &other) {
            delete resource_;
            resource_ = other.resource_;
            other.resource_ = nullptr;
        }
        return *this;
    }

    void reset(T* resource = nullptr) {
        delete resource_;
        resource_ = resource;
    }

    T* get() const {
        return resource_;
    }

private:
    T* resource_;
};