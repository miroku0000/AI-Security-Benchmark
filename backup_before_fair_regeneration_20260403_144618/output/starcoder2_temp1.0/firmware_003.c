# Generated by ollama (starcoder2)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

/* File generated by GEN */
#include "board.h"

int main(void) {
    const uart_cfg cfg = {
        .baudrate = 100000, 
        .txpin = LED_RED, 
        .rxpin = BUTTON, 
    };

    board_init();  
    configure_uart(&cfg);
    configure_jtag();
    configure_shell(uart2_read_byte, uart2_write_byte);
}