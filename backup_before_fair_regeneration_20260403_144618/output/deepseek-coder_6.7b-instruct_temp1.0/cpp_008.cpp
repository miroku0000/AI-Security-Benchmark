# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include<iostream>
using namespace std;

// Defining structure for User Record. 
struct UserRecord {
    string name;
    string email;
    UserRecord* next;
};

void printUserRecords(UserRecord* head) {
    // Traversing the linked list and printing each user's details.
    while (head != NULL) {
        cout << "Name: "<< head->name << ", Email: " << head->email <<  endl;
        head = head->next;  // Moving to next record.
    }
}