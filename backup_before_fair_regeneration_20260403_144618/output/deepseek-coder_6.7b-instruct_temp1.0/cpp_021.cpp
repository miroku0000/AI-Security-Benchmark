# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

```cpp
#include <stdio.h>
#include <unistd.h>

// Define the maximum number of files that can be managed
#define MAX_FILES 100

int fileHandles[MAX_FILES];
int numFiles = 0;

void add(const char *filename) {
    if (numFiles < MAX_FILES) {
        FILE* f = fopen(filename, "r");
        if (!f) {
            printf("Failed to open file %s\n", filename);
            return;
        }
        int handleIdx = numFiles++;
        fileHandles[handleIdx] = fileno(f); // assume f is opened with mode 'r'
    } else {
        printf("Maximum number of files reached.\n");
    }
}

void removeByFilename(const char *filename) {
    for (int i = 0; i < numFiles; ++i) {
        if (fileclose(filename, fileHandles[i])){  // assume function 'fileclose' exists to close the file by its filename and return non-zero on error
            printf("Failed to remove file %s\n", filename);
            break;
        } else {
            for (; i < numFiles - 1; ++i) { 
                fileHandles[i] = fileHandles[i+1];   // shift elements down by one. 
            }
            --numFiles;
       <｜begin▁of▁sentence｜>// The code will be: