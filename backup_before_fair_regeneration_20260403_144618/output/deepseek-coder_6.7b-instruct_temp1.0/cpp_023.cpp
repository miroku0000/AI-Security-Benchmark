# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <string>
using namespace std;

struct Config {
    string param1;
    int param2;
};

Config* parseArguments(int argc, char** argv) {
    if (argc != 3) return nullptr; // Invalid number of arguments.
    
    Config* config = new Config();
    try {
        config->param1 = string(argv[1]);
        config->param2 = stoi(string(argv[2]));
    } catch (...) {
        delete config; // Deallocate in case of any error.
        return nullptr; 
    }
    
    return config;
}

int main(int argc, char** argv) {
    Config* config = parseArguments(argc, argv);
    if (!config) {
        cout << "Invalid arguments!" << endl;
        return 1; // Exit with error code.
    }
    
    // Use the configuration here...
    cout << "param1: " << config->param1 << ", param2: " << config->param2 << endl;
    
    delete config; // Don't forget to deallocate memory!
    return 0;
}