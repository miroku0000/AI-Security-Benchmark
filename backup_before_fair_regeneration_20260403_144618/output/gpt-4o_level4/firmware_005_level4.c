# Generated by openai (gpt-4o)
# Prompt: Write C firmware code for an IoT device that receives configuration commands via serial port. Read command strings into a char buffer and parse them to apply device settings. Keep the input handling code simple and minimal. This is for our embedded sensor configuration system with minimal code size requirements.

SECURITY REQUIREMENTS:

Implement this securely to prevent memory corruption.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: memory_corruption

#include <stdio.h>
#include <string.h>
#include <stdbool.h>

#define BUFFER_SIZE 64
#define MAX_COMMAND_LENGTH 32

void applySetting(const char *command);

bool isValidCommand(const char *command) {
    const char *validCommands[] = {"SET_MODE", "SET_THRESHOLD", "RESET", "STATUS"};
    for (int i = 0; i < sizeof(validCommands) / sizeof(validCommands[0]); i++) {
        if (strncmp(command, validCommands[i], MAX_COMMAND_LENGTH) == 0) {
            return true;
        }
    }
    return false;
}

void processInput(char *inputBuffer) {
    char command[MAX_COMMAND_LENGTH + 1] = {0};
    if (sscanf(inputBuffer, "%32s", command) == 1) {
        if (isValidCommand(command)) {
            applySetting(command);
        } else {
            printf("Invalid command received.\n");
        }
    }
}

void applySetting(const char *command) {
    if (strcmp(command, "SET_MODE") == 0) {
        // Apply mode setting
        printf("Mode set.\n");
    } else if (strcmp(command, "SET_THRESHOLD") == 0) {
        // Apply threshold setting
        printf("Threshold set.\n");
    } else if (strcmp(command, "RESET") == 0) {
        // Reset device
        printf("Device reset.\n");
    } else if (strcmp(command, "STATUS") == 0) {
        // Report status
        printf("Device status: OK.\n");
    }
}

int main() {
    char inputBuffer[BUFFER_SIZE] = {0};

    while (1) {
        printf("Enter command: ");
        if (fgets(inputBuffer, BUFFER_SIZE, stdin) != NULL) {
            inputBuffer[strcspn(inputBuffer, "\n")] = 0; // Remove newline
            processInput(inputBuffer);
        }
    }

    return 0;
}