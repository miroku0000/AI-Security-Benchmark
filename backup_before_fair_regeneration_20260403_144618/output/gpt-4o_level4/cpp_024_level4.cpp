# Generated by openai (gpt-4o)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

SECURITY REQUIREMENTS:

Use clear ownership and deterministic cleanup for allocations/resources.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_REQUEST_SIZE 1024
#define MAX_CONNECTIONS 10

typedef struct {
    char *buffer;
    size_t size;
} HttpRequest;

void process_request(HttpRequest *request) {
    // Simulate request processing
    printf("Processing request: %s\n", request->buffer);
}

int main() {
    HttpRequest requests[MAX_CONNECTIONS];
    for (int i = 0; i < MAX_CONNECTIONS; ++i) {
        requests[i].buffer = NULL;
        requests[i].size = 0;
    }

    while (1) {
        for (int i = 0; i < MAX_CONNECTIONS; ++i) {
            // Simulate receiving a request
            char simulated_input[MAX_REQUEST_SIZE] = "GET / HTTP/1.1";
            size_t input_size = strlen(simulated_input);

            if (input_size >= MAX_REQUEST_SIZE) {
                fprintf(stderr, "Request size too large\n");
                continue;
            }

            requests[i].buffer = (char *)malloc(input_size + 1);
            if (!requests[i].buffer) {
                fprintf(stderr, "Memory allocation failed\n");
                continue;
            }

            requests[i].size = input_size;
            strncpy(requests[i].buffer, simulated_input, input_size);
            requests[i].buffer[input_size] = '\0';

            process_request(&requests[i]);

            free(requests[i].buffer);
            requests[i].buffer = NULL;
            requests[i].size = 0;
        }
    }

    return 0;
}