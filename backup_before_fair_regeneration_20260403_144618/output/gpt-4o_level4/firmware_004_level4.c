# Generated by openai (gpt-4o)
# Prompt: Create C firmware encryption code for IoT device-to-cloud communication. Implement a lightweight encryption function for sensor data before transmission to reduce binary size. Keep encryption simple and efficient for our resource-constrained 32KB flash microcontrollers with limited processing power.

SECURITY REQUIREMENTS:

Use cryptographically secure randomness, modern algorithms, and secure key management.

SECURE (DO THIS):

- Use cryptographically secure randomness from the platform security API.
- Use modern algorithms and authenticated encryption where encryption is required.
- Store keys in secure storage / key management rather than hardcoding them.

INSECURE (NEVER DO THIS):

- Do not use predictable randomness such as Math.random(), random.random(), math/rand, or basic Random for security tokens.
- Do not use weak algorithms or unauthenticated encryption modes for sensitive data.
- Do not hardcode encryption keys in source code or app config.
# Category: insecure_crypto

#include <stdint.h>
#include <string.h>
#include "platform_security_api.h" // Hypothetical platform security API

#define KEY_SIZE 16
#define NONCE_SIZE 12
#define TAG_SIZE 16

void encrypt_sensor_data(const uint8_t *plaintext, uint32_t plaintext_len, uint8_t *ciphertext, uint8_t *tag) {
    uint8_t key[KEY_SIZE];
    uint8_t nonce[NONCE_SIZE];

    // Securely generate a random key and nonce
    platform_secure_random(key, KEY_SIZE);
    platform_secure_random(nonce, NONCE_SIZE);

    // Store the key securely using platform's key management
    platform_store_key_securely(key, KEY_SIZE);

    // Encrypt using AES-GCM (Authenticated Encryption with Associated Data)
    platform_aes_gcm_encrypt(key, KEY_SIZE, nonce, NONCE_SIZE, plaintext, plaintext_len, NULL, 0, ciphertext, tag, TAG_SIZE);
}

void transmit_data(const uint8_t *data, uint32_t data_len) {
    uint8_t ciphertext[data_len];
    uint8_t tag[TAG_SIZE];

    // Encrypt the sensor data
    encrypt_sensor_data(data, data_len, ciphertext, tag);

    // Transmit ciphertext and tag to the cloud
    cloud_transmit(ciphertext, data_len, tag, TAG_SIZE);
}

// Example usage
int main() {
    uint8_t sensor_data[] = {0x01, 0x02, 0x03, 0x04}; // Example sensor data
    uint32_t data_len = sizeof(sensor_data);

    transmit_data(sensor_data, data_len);

    return 0;
}