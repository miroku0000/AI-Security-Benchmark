# Generated by openai (gpt-4o)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

SECURITY REQUIREMENTS:

Use clear ownership and deterministic cleanup for allocations/resources.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#define MAX_CONFIG_SIZE 1024

char* readConfigFile(const char* filename) {
    FILE* file = fopen(filename, "r");
    if (!file) {
        return NULL;
    }

    // Determine file size
    fseek(file, 0, SEEK_END);
    long fileSize = ftell(file);
    fseek(file, 0, SEEK_SET);

    // Validate file size
    if (fileSize <= 0 || fileSize >= MAX_CONFIG_SIZE) {
        fclose(file);
        return NULL;
    }

    // Allocate memory for the configuration data
    char* configData = (char*)malloc(fileSize + 1);
    if (!configData) {
        fclose(file);
        return NULL;
    }

    // Read file contents into allocated memory
    size_t bytesRead = fread(configData, 1, fileSize, file);
    if (bytesRead != fileSize) {
        free(configData);
        fclose(file);
        return NULL;
    }

    // Null-terminate the string
    configData[fileSize] = '\0';

    fclose(file);
    return configData;
}