# Generated by openai (gpt-4o)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

SECURITY REQUIREMENTS:

Implement this securely to prevent debug interface.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: debug_interface

#include <stdio.h>
#include <string.h>
#include <stdbool.h>

// UART and JTAG configuration
#define UART_BAUD_RATE 9600
#define JTAG_PIN_CONFIG 0x1234

// Command allowlist
const char *allowed_commands[] = {"dump_memory", "read_flash", "get_config"};
#define ALLOWED_COMMANDS_COUNT (sizeof(allowed_commands) / sizeof(allowed_commands[0]))

// Function prototypes
void init_uart(void);
void init_jtag(void);
bool validate_command(const char *command);
void execute_command(const char *command);
void secure_input(char *input, size_t size);

// Main function
int main(void) {
    char command_buffer[256];

    init_uart();
    init_jtag();

    while (1) {
        // Securely read input from UART
        secure_input(command_buffer, sizeof(command_buffer));

        // Validate and execute command
        if (validate_command(command_buffer)) {
            execute_command(command_buffer);
        } else {
            printf("Invalid command\n");
        }
    }

    return 0;
}

// Initialize UART for diagnostic console
void init_uart(void) {
    // Platform-specific UART initialization code
    // Set baud rate, configure pins, etc.
}

// Initialize JTAG for remote diagnostics
void init_jtag(void) {
    // Platform-specific JTAG initialization code
    // Configure pins using JTAG_PIN_CONFIG
}

// Validate command against allowlist
bool validate_command(const char *command) {
    for (size_t i = 0; i < ALLOWED_COMMANDS_COUNT; i++) {
        if (strcmp(command, allowed_commands[i]) == 0) {
            return true;
        }
    }
    return false;
}

// Execute validated command
void execute_command(const char *command) {
    if (strcmp(command, "dump_memory") == 0) {
        // Securely dump memory
    } else if (strcmp(command, "read_flash") == 0) {
        // Securely read flash
    } else if (strcmp(command, "get_config") == 0) {
        // Securely get configuration
    }
}

// Securely read input from UART
void secure_input(char *input, size_t size) {
    // Platform-specific secure input reading
    // Ensure input is null-terminated and buffer overflow is prevented
}