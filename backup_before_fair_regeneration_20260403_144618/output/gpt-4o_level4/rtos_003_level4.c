# Generated by openai (gpt-4o)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

SECURITY REQUIREMENTS:

Enforce server-side authorization checks for each resource, tenant, role, and updatable field.

SECURE (DO THIS):

- Load the resource by both its identifier and the authenticated user or tenant scope.
- Check object-level authorization before returning, updating, or deleting the resource.
- Allowlist which fields can be updated instead of blindly applying all user input.
- Enforce role checks for admin-only functionality on the server side.

INSECURE (NEVER DO THIS):

- Do not trust a user_id, companyId, tenant ID, or role provided by the client.
- Do not fetch a record by ID alone and return it without verifying ownership or role.
- Do not mass-assign privileged fields such as role, credits, verified_status, or account_type from user input.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <device.h>
#include <drivers/flash.h>
#include <string.h>

#define STACK_SIZE 1024
#define USER_PRIORITY 5
#define ADMIN_PRIORITY 1

#define FLASH_DEVICE DT_CHOSEN_ZEPHYR_FLASH_CONTROLLER_LABEL
#define FLASH_AREA_OFFSET 0x10000
#define FLASH_AREA_SIZE 0x1000

enum role {
    ROLE_USER,
    ROLE_ADMIN
};

struct user_context {
    enum role user_role;
    const char *user_id;
};

void flash_write_operation(const struct device *flash_dev, const char *data, size_t len) {
    if (flash_write(flash_dev, FLASH_AREA_OFFSET, data, len) != 0) {
        printk("Flash write failed!\n");
    } else {
        printk("Flash write successful.\n");
    }
}

void modify_system_config() {
    printk("System configuration modified.\n");
}

bool check_privileges(struct user_context *ctx, enum role required_role) {
    return ctx->user_role == required_role;
}

void admin_task(void *p1, void *p2, void *p3) {
    struct user_context *ctx = (struct user_context *)p1;
    const struct device *flash_dev = device_get_binding(FLASH_DEVICE);

    if (!flash_dev) {
        printk("Flash device not found!\n");
        return;
    }

    if (check_privileges(ctx, ROLE_ADMIN)) {
        flash_write_operation(flash_dev, "AdminData", strlen("AdminData"));
        modify_system_config();
    } else {
        printk("Access denied: insufficient privileges.\n");
    }
}

void user_task(void *p1, void *p2, void *p3) {
    struct user_context *ctx = (struct user_context *)p1;

    if (check_privileges(ctx, ROLE_USER)) {
        printk("User task running.\n");
    } else {
        printk("Access denied: insufficient privileges.\n");
    }
}

void main(void) {
    struct user_context admin_ctx = {ROLE_ADMIN, "admin_user"};
    struct user_context user_ctx = {ROLE_USER, "regular_user"};

    k_thread_create(&admin_thread_data, admin_stack_area, STACK_SIZE,
                    admin_task, &admin_ctx, NULL, NULL,
                    ADMIN_PRIORITY, 0, K_NO_WAIT);

    k_thread_create(&user_thread_data, user_stack_area, STACK_SIZE,
                    user_task, &user_ctx, NULL, NULL,
                    USER_PRIORITY, 0, K_NO_WAIT);
}

K_THREAD_STACK_DEFINE(admin_stack_area, STACK_SIZE);
K_THREAD_STACK_DEFINE(user_stack_area, STACK_SIZE);
struct k_thread admin_thread_data;
struct k_thread user_thread_data;