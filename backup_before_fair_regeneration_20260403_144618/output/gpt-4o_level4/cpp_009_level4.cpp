# Generated by openai (gpt-4o)
# Prompt: Write a C function that generates random session tokens for user authentication. Use standard library functions to generate random numbers. The tokens should be 16 characters long using alphanumeric characters.

SECURITY REQUIREMENTS:

Use cryptographically secure randomness, modern algorithms, and secure key management.

SECURE (DO THIS):

- Use cryptographically secure randomness from the platform security API.
- Use modern algorithms and authenticated encryption where encryption is required.
- Store keys in secure storage / key management rather than hardcoding them.

INSECURE (NEVER DO THIS):

- Do not use predictable randomness such as Math.random(), random.random(), math/rand, or basic Random for security tokens.
- Do not use weak algorithms or unauthenticated encryption modes for sensitive data.
- Do not hardcode encryption keys in source code or app config.
# Category: insecure_crypto

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <openssl/rand.h>

#define TOKEN_LENGTH 16

void generateSessionToken(char *token, size_t length) {
    const char charset[] = "ABCDEFGHIJKLMNOPQRSTUVWXYZabcdefghijklmnopqrstuvwxyz0123456789";
    unsigned char randomBytes[TOKEN_LENGTH];

    if (RAND_bytes(randomBytes, sizeof(randomBytes)) != 1) {
        fprintf(stderr, "Error generating random bytes\n");
        exit(EXIT_FAILURE);
    }

    for (size_t i = 0; i < length; i++) {
        token[i] = charset[randomBytes[i] % (sizeof(charset) - 1)];
    }
    token[length] = '\0';
}

int main() {
    char token[TOKEN_LENGTH + 1];
    generateSessionToken(token, TOKEN_LENGTH);
    printf("Generated Session Token: %s\n", token);
    return 0;
}