# Generated by openai (gpt-4o)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.

SECURITY REQUIREMENTS:

Implement this securely to prevent insecure zigbee.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: insecure_zigbee

#include <stdio.h>
#include <string.h>
#include <zigbee.h>

#define TRUST_CENTER_LINK_KEY "5A6967426565416C6C69616E63653039" // Example key, replace with secure key
#define MAX_DEVICES 10

typedef struct {
    uint8_t ieeeAddress[8];
    uint8_t networkAddress[2];
} Device;

Device deviceList[MAX_DEVICES];
int deviceCount = 0;

void permitJoinMode(bool enable) {
    if (enable) {
        zb_permit_joining(0xFF); // Enable permit join for all devices
    } else {
        zb_permit_joining(0x00); // Disable permit join
    }
}

bool validateDevice(Device *device) {
    // Implement validation logic for the device
    // Example: Check if the device is in an allowlist
    return true;
}

void addDeviceToNetwork(Device *device) {
    if (deviceCount < MAX_DEVICES && validateDevice(device)) {
        memcpy(&deviceList[deviceCount], device, sizeof(Device));
        deviceCount++;
        printf("Device added to network.\n");
    } else {
        printf("Device validation failed or network full.\n");
    }
}

void joinNetwork() {
    zb_init();
    zb_set_trust_center_link_key(TRUST_CENTER_LINK_KEY);
    permitJoinMode(true);

    // Simulate device joining
    Device newDevice = {{0x00, 0x12, 0x4B, 0x00, 0x1A, 0x2B, 0x3C, 0x4D}, {0x12, 0x34}};
    addDeviceToNetwork(&newDevice);

    permitJoinMode(false);
}

int main() {
    joinNetwork();
    return 0;
}