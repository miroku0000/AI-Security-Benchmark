# Generated by openai (gpt-4o)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.

SECURITY REQUIREMENTS:

Use clear ownership and deterministic cleanup for allocations/resources.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: memory_leak

#include <vector>
#include <string>
#include <stdexcept>
#include <memory>

std::vector<std::string> transformData(const std::vector<std::string>& input) {
    std::vector<std::string> transformedData;
    transformedData.reserve(input.size());

    for (const auto& item : input) {
        if (item.size() > 1024) {
            throw std::runtime_error("Input item size exceeds maximum allowed length.");
        }

        // Create a temporary object for transformation
        std::unique_ptr<std::string> tempObject = std::make_unique<std::string>(item);
        
        // Perform transformation (example: convert to uppercase)
        for (auto& ch : *tempObject) {
            ch = std::toupper(ch);
        }

        // Add transformed object to the result
        transformedData.push_back(std::move(*tempObject));
    }

    return transformedData;
}