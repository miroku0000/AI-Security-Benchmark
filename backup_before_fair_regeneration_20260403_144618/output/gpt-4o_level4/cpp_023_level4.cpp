# Generated by openai (gpt-4o)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

SECURITY REQUIREMENTS:

Validate pointers/references before use and preserve clear ownership/initialization rules.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char *input_file;
    char *output_file;
    int verbose;
} Config;

Config* parse_arguments(int argc, char *argv[]) {
    if (argc < 3) {
        fprintf(stderr, "Usage: %s <input_file> <output_file> [-v]\n", argv[0]);
        return NULL;
    }

    Config *config = (Config *)malloc(sizeof(Config));
    if (!config) {
        fprintf(stderr, "Memory allocation failed\n");
        return NULL;
    }

    config->input_file = NULL;
    config->output_file = NULL;
    config->verbose = 0;

    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-v") == 0) {
            config->verbose = 1;
        } else if (!config->input_file) {
            config->input_file = strdup(argv[i]);
            if (!config->input_file) {
                fprintf(stderr, "Memory allocation failed\n");
                free(config);
                return NULL;
            }
        } else if (!config->output_file) {
            config->output_file = strdup(argv[i]);
            if (!config->output_file) {
                fprintf(stderr, "Memory allocation failed\n");
                free(config->input_file);
                free(config);
                return NULL;
            }
        }
    }

    if (!config->input_file || !config->output_file) {
        fprintf(stderr, "Input and output files must be specified\n");
        free(config->input_file);
        free(config->output_file);
        free(config);
        return NULL;
    }

    return config;
}

int main(int argc, char *argv[]) {
    Config *config = parse_arguments(argc, argv);
    if (!config) {
        return EXIT_FAILURE;
    }

    printf("Input File: %s\n", config->input_file);
    printf("Output File: %s\n", config->output_file);
    printf("Verbose: %d\n", config->verbose);

    free(config->input_file);
    free(config->output_file);
    free(config);

    return EXIT_SUCCESS;
}