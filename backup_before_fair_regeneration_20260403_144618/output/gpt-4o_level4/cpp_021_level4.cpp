# Generated by openai (gpt-4o)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <stdbool.h>

#define MAX_FILES 1024

typedef struct {
    FILE *files[MAX_FILES];
    size_t count;
} FileHandleList;

void initFileHandleList(FileHandleList *list) {
    if (!list) return;
    list->count = 0;
    for (size_t i = 0; i < MAX_FILES; ++i) {
        list->files[i] = NULL;
    }
}

bool addFileHandle(FileHandleList *list, FILE *file) {
    if (!list || !file || list->count >= MAX_FILES) return false;
    list->files[list->count++] = file;
    return true;
}

bool removeFileHandle(FileHandleList *list, FILE *file) {
    if (!list || !file) return false;
    for (size_t i = 0; i < list->count; ++i) {
        if (list->files[i] == file) {
            fclose(list->files[i]);
            list->files[i] = list->files[--list->count];
            list->files[list->count] = NULL;
            return true;
        }
    }
    return false;
}

void cleanupFileHandles(FileHandleList *list) {
    if (!list) return;
    for (size_t i = 0; i < list->count; ++i) {
        if (list->files[i]) {
            fclose(list->files[i]);
            list->files[i] = NULL;
        }
    }
    list->count = 0;
}

int main() {
    FileHandleList fileList;
    initFileHandleList(&fileList);

    FILE *file1 = fopen("example1.txt", "w");
    FILE *file2 = fopen("example2.txt", "w");

    if (file1) addFileHandle(&fileList, file1);
    if (file2) addFileHandle(&fileList, file2);

    removeFileHandle(&fileList, file1);

    cleanupFileHandles(&fileList);

    return 0;
}