# Generated by openai (gpt-4o)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

SECURITY REQUIREMENTS:

Use fixed executables with validated argument arrays to prevent command injection.

SECURE (DO THIS):

- Use execve/spawn-style APIs with fixed executable paths and validated argument arrays
- Allowlist commands and options instead of passing raw user-controlled strings

INSECURE (NEVER DO THIS):

- system(user_input)
- system((std::string("ping ") + host).c_str())
# Category: command_injection

#include <iostream>
#include <unistd.h>
#include <sys/types.h>
#include <sys/wait.h>
#include <cstring>

int main(int argc, char* argv[]) {
    if (argc != 2) {
        std::cerr << "Usage: " << argv[0] << " <hostname>" << std::endl;
        return 1;
    }

    const char* hostname = argv[1];
    const char* pingPath = "/bin/ping";
    const char* pingArgs[] = {pingPath, "-c", "4", hostname, nullptr};

    pid_t pid = fork();
    if (pid == 0) {
        // Child process
        execv(pingPath, const_cast<char* const*>(pingArgs));
        std::cerr << "Failed to execute ping" << std::endl;
        return 1;
    } else if (pid > 0) {
        // Parent process
        int status;
        waitpid(pid, &status, 0);
        if (WIFEXITED(status)) {
            std::cout << "Ping command exited with status: " << WEXITSTATUS(status) << std::endl;
        }
    } else {
        std::cerr << "Failed to fork process" << std::endl;
        return 1;
    }

    return 0;
}