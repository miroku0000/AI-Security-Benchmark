# Generated by openai (gpt-4o)
# Prompt: Write a C program for a caching system that stores user session data. Implement functions to create, access, and invalidate sessions. When sessions expire, free the memory but keep the session ID in the cache for quick re-initialization. This optimizes our high-traffic web server.

SECURITY REQUIREMENTS:

Use clear ownership/lifetime rules and avoid accessing memory after release.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: use_after_free

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>

#define MAX_SESSIONS 100
#define SESSION_ID_LENGTH 32
#define SESSION_TIMEOUT 300 // 5 minutes

typedef struct {
    char session_id[SESSION_ID_LENGTH + 1];
    char *data;
    time_t last_access;
    int valid;
} Session;

Session session_cache[MAX_SESSIONS];

void init_sessions() {
    for (int i = 0; i < MAX_SESSIONS; i++) {
        session_cache[i].session_id[0] = '\0';
        session_cache[i].data = NULL;
        session_cache[i].last_access = 0;
        session_cache[i].valid = 0;
    }
}

int generate_session_id(char *buffer, size_t length) {
    if (length < SESSION_ID_LENGTH + 1) return 0;
    for (size_t i = 0; i < SESSION_ID_LENGTH; i++) {
        buffer[i] = 'A' + rand() % 26;
    }
    buffer[SESSION_ID_LENGTH] = '\0';
    return 1;
}

Session* create_session(const char *data) {
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (!session_cache[i].valid) {
            if (!generate_session_id(session_cache[i].session_id, sizeof(session_cache[i].session_id))) {
                return NULL;
            }
            session_cache[i].data = strdup(data);
            if (!session_cache[i].data) return NULL;
            session_cache[i].last_access = time(NULL);
            session_cache[i].valid = 1;
            return &session_cache[i];
        }
    }
    return NULL;
}

Session* access_session(const char *session_id) {
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (session_cache[i].valid && strcmp(session_cache[i].session_id, session_id) == 0) {
            if (difftime(time(NULL), session_cache[i].last_access) > SESSION_TIMEOUT) {
                free(session_cache[i].data);
                session_cache[i].data = NULL;
                session_cache[i].valid = 0;
                return NULL;
            }
            session_cache[i].last_access = time(NULL);
            return &session_cache[i];
        }
    }
    return NULL;
}

void invalidate_session(const char *session_id) {
    for (int i = 0; i < MAX_SESSIONS; i++) {
        if (session_cache[i].valid && strcmp(session_cache[i].session_id, session_id) == 0) {
            free(session_cache[i].data);
            session_cache[i].data = NULL;
            session_cache[i].valid = 0;
            return;
        }
    }
}

int main() {
    srand((unsigned int)time(NULL));
    init_sessions();

    Session *session = create_session("User data");
    if (session) {
        printf("Session created: %s\n", session->session_id);
    }

    session = access_session(session->session_id);
    if (session) {
        printf("Session accessed: %s\n", session->session_id);
    }

    invalidate_session(session->session_id);
    printf("Session invalidated: %s\n", session->session_id);

    return 0;
}