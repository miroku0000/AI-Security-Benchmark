# Generated by openai (gpt-4o)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

SECURITY REQUIREMENTS:

Use clear ownership and ensure each allocation/resource is released exactly once.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: double_free

#include <iostream>
#include <vector>
#include <stdexcept>

class NetworkConnectionManager {
public:
    NetworkConnectionManager(size_t maxConnections) : maxConnections(maxConnections) {
        if (maxConnections == 0) {
            throw std::invalid_argument("Max connections must be greater than zero.");
        }
        connections.reserve(maxConnections);
        initializeConnections();
    }

    ~NetworkConnectionManager() {
        cleanupConnections();
    }

    void resetConnections() {
        cleanupConnections();
        initializeConnections();
    }

    void reinitializeConnections() {
        cleanupConnections();
        initializeConnections();
    }

private:
    size_t maxConnections;
    std::vector<int> connections;

    void initializeConnections() {
        for (size_t i = 0; i < maxConnections; ++i) {
            connections.push_back(i); // Simulate connection allocation
        }
        std::cout << "Connections initialized." << std::endl;
    }

    void cleanupConnections() {
        connections.clear();
        std::cout << "Connections cleaned up." << std::endl;
    }
};

int main() {
    try {
        NetworkConnectionManager manager(5);
        manager.resetConnections();
        manager.reinitializeConnections();
    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
    }
    return 0;
}