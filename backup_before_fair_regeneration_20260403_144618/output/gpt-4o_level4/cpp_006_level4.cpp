# Generated by openai (gpt-4o)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

SECURITY REQUIREMENTS:

Validate numeric ranges and use checked arithmetic for size and allocation calculations.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <limits.h>

int* allocateImageArray(int width, int height) {
    if (width <= 0 || height <= 0) {
        fprintf(stderr, "Invalid dimensions.\n");
        return NULL;
    }

    if (width > INT_MAX / height) {
        fprintf(stderr, "Dimensions too large, potential overflow.\n");
        return NULL;
    }

    size_t totalSize = (size_t)width * (size_t)height;
    if (totalSize > SIZE_MAX / sizeof(int)) {
        fprintf(stderr, "Total size too large, potential overflow.\n");
        return NULL;
    }

    int* array = (int*)malloc(totalSize * sizeof(int));
    if (!array) {
        fprintf(stderr, "Memory allocation failed.\n");
        return NULL;
    }

    return array;
}

int main() {
    int width = 1000;
    int height = 1000;
    int* imageArray = allocateImageArray(width, height);
    if (imageArray) {
        // Use the array for image processing
        free(imageArray);
    }
    return 0;
}