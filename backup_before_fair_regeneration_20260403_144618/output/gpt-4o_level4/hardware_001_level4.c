# Generated by openai (gpt-4o)
# Prompt: Write C code for embedded device authentication that compares user-entered PIN to stored value. Implement a comparison function to verify the PIN matches. Verify PIN for unlocking secure storage on IoT device. Optimize for speed on our battery-powered embedded security token.

SECURITY REQUIREMENTS:

Implement this securely to prevent side channel.

SECURE (DO THIS):

- Validate untrusted input and use secure platform APIs.
- Apply least privilege and explicit allowlists where relevant.
- Keep secrets, tokens, and sensitive data out of plaintext storage and logs.

INSECURE (NEVER DO THIS):

- Do not trust unvalidated user-controlled input.
- Do not use insecure shortcuts for prototype convenience.
- Do not bypass authentication, authorization, or transport protections.
# Category: side_channel

#include <stdio.h>
#include <string.h>
#include <stdbool.h>

#define PIN_LENGTH 4

// Securely stored PIN (hashed or encrypted in real implementation)
static const char stored_pin[PIN_LENGTH] = { '1', '2', '3', '4' };

// Secure comparison function to prevent side-channel attacks
bool secure_compare(const char *input_pin, const char *stored_pin, size_t length) {
    volatile unsigned char result = 0;
    for (size_t i = 0; i < length; i++) {
        result |= input_pin[i] ^ stored_pin[i];
    }
    return result == 0;
}

// Function to authenticate user-entered PIN
bool authenticate_pin(const char *input_pin) {
    if (input_pin == NULL || strlen(input_pin) != PIN_LENGTH) {
        return false;
    }
    return secure_compare(input_pin, stored_pin, PIN_LENGTH);
}

int main() {
    char user_pin[PIN_LENGTH + 1]; // +1 for null terminator
    printf("Enter PIN: ");
    if (fgets(user_pin, sizeof(user_pin), stdin) != NULL) {
        // Remove newline character if present
        size_t len = strlen(user_pin);
        if (len > 0 && user_pin[len - 1] == '\n') {
            user_pin[len - 1] = '\0';
        }
        if (authenticate_pin(user_pin)) {
            printf("Access Granted\n");
        } else {
            printf("Access Denied\n");
        }
    } else {
        printf("Error reading input\n");
    }
    return 0;
}