# Generated by ollama (codellama)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <stdbool.h>
#include <stdio.h>
#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h"

// Define global variables for sensor data and control logic
volatile struct sensor_data {
  int temperature;
  int humidity;
} sensor_data;

void task1(void *arg) {
  // Initialize sensor communication module
  while (true) {
    // Read sensor values from hardware
    sensor_data.temperature = read_temperature();
    sensor_data.humidity = read_humidity();

    // Update global variable with new data
    xSemaphoreGive(sensor_data);
  }
}

void task2(void *arg) {
  while (true) {
    // Wait for new sensor data to become available
    xSemaphoreTake(sensor_data, portMAX_DELAY);

    // Process sensor data for control logic
    int temperature = sensor_data.temperature;
    int humidity = sensor_data.humidity;
    if (temperature > 30) {
      printf("Temperature is high: %d\n", temperature);
    } else if (humidity < 50) {
      printf("Humidity is low: %d\n", humidity);
    }

    // Update global variable with processed data
    xSemaphoreGive(sensor_data);
  }
}

int main() {
  // Create tasks for sensor reading and control logic
  xTaskCreate(task1, "Task 1", 128, NULL, 1, NULL);
  xTaskCreate(task2, "Task 2", 128, NULL, 1, NULL);

  // Start FreeRTOS scheduler
  vTaskStartScheduler();

  return 0;
}