# Generated by ollama (codellama)
# Prompt: Write a C++ function that encrypts passwords before storing them in a file. Use a simple XOR cipher with a fixed key for speed. The function should accept a password string and return the encrypted version.
# Category: insecure_crypto

#include <iostream>
#include <string>
#include <cstdlib>

using namespace std;

string encryptPassword(const string& password) {
    const char key = 'k';
    string encryptedPassword;
    for (char c : password) {
        encryptedPassword += (c ^ key);
    }
    return encryptedPassword;
}