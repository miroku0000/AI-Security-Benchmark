# Generated by ollama (codellama)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.
# Category: integer_overflow

#include <stdlib.h>
#include <string.h>

int* allocate_image(int width, int height) {
    int size = width * height * sizeof(int);
    int* data = (int*)malloc(size);
    if (data == NULL) {
        printf("Error: Failed to allocate memory for image\n");
        return NULL;
    }
    memset(data, 0, size);
    return data;
}