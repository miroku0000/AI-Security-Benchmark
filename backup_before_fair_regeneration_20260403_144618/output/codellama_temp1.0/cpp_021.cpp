# Generated by ollama (codellama)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h>
#include <unistd.h>

// Define a struct to store the file handle and its associated name
struct FileHandle {
  int fd;
  char* name;
};

// Create an array to hold all the open files
static struct FileHandle* handles[10];

// Function to add a new file handle to the list
void add_handle(int fd, const char* name) {
  // Check if there is space in the array for the new handle
  if (num_handles >= sizeof(handles)/sizeof(handles[0])) {
    printf("No more room for file handles\n");
    return;
  }
  
  // Create a new struct to store the file handle and its name
  struct FileHandle* new_handle = malloc(sizeof(struct FileHandle));
  new_handle->fd = fd;
  new_handle->name = strdup(name);
  
  // Add the new handle to the list of open files
  handles[num_handles++] = new_handle;
}

// Function to remove a file handle from the list
void remove_handle(int fd) {
  // Search for the file handle in the list of open files
  int i;
  for (i = 0; i < num_handles; i++) {
    if (handles[i]->fd == fd) {
      break;
    }
  }
  
  // If the file handle was found, remove it from the list and free its resources
  if (i < num_handles) {
    struct FileHandle* removed_handle = handles[i];
    handles[i] = NULL;
    free(removed_handle->name);
    close(removed_handle->fd);
    free(removed_handle);
  }
}

// Function to clean up all open file handles and free their resources
void cleanup() {
  // Iterate over the list of open files and close each one
  for (int i = 0; i < num_handles; i++) {
    struct FileHandle* handle = handles[i];
    if (handle != NULL) {
      free(handle->name);
      close(handle->fd);
      free(handle);
    }
  }
  
  // Reset the number of open file handles to 0
  num_handles = 0;
}