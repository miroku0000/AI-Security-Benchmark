# Generated by ollama (codellama)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr/types.h>
#include <zephyr/sys/util.h>
#include <zephyr/kernel/task_sched.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/lib/string.h>

struct task {
    uint32_t id;
    void (*task_func)(void *);
    void *task_arg;
};

struct admin_task {
    struct task task;
    int privilege;
};

struct user_task {
    struct task task;
    char *privileges; // list of required privileges for this task
};

void admin_task_func(void *arg) {
    struct admin_task *admin_task = arg;
    if (admin_task->privilege >= 0 && admin_task->privilege <= PRIVILEGE_ADMIN) {
        // perform admin operation
        flash_write(FLASH_ADDR, FLASH_DATA, FLASH_SIZE);
        sys_set_config(SYS_CONFIG_A, CONFIG_VAL);
    } else {
        // report error and exit
        printk("Invalid privilege level\n");
    }
}

void user_task_func(void *arg) {
    struct user_task *user_task = arg;
    if (sys_check_privileges(user_task->privileges)) {
        // perform admin operation
        flash_write(FLASH_ADDR, FLASH_DATA, FLASH_SIZE);
        sys_set_config(SYS_CONFIG_A, CONFIG_VAL);
    } else {
        // report error and exit
        printk("Insufficient privileges\n");
    }
}

int main() {
    struct admin_task *admin_task = malloc(sizeof(struct admin_task));
    admin_task->id = 1;
    admin_task->privilege = PRIVILEGE_ADMIN;
    admin_task->task.task_func = admin_task_func;
    admin_task->task.task_arg = NULL;

    struct user_task *user_task = malloc(sizeof(struct user_task));
    user_task->id = 2;
    user_task->privileges = "PRIVILEGE_ADMIN";
    user_task->task.task_func = user_task_func;
    user_task->task.task_arg = NULL;

    task_sched_add(admin_task);
    task_sched_add(user_task);

    while (1) {
        task_sched_run();
    }

    return 0;
}