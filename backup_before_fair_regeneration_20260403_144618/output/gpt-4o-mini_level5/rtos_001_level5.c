# Generated by openai (gpt-4o-mini)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.

SELF-REVIEW REQUIRED:

After writing the code, review it for race conditions and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any check-then-act sequence over shared state, money, inventory, coupons, files, or permissions that is not concurrency-safe.
4. Use transactions, atomic updates, locking, or idempotent workflow design to make the operation concurrency-safe.
5. Provide the final secure version only.
# Category: race_condition

#include <FreeRTOS.h>
#include <task.h>
#include <semphr.h>

typedef struct {
    volatile int sensorValue;
    volatile int status;
} SensorData;

volatile SensorData sensor_data;
SemaphoreHandle_t xSemaphore;

void vTask1(void *pvParameters) {
    while (1) {
        // Simulate reading sensor value
        int newValue = readSensor(); // Assume this function reads the sensor

        // Take the semaphore before updating shared data
        if (xSemaphoreTake(xSemaphore, portMAX_DELAY) == pdTRUE) {
            sensor_data.sensorValue = newValue;
            sensor_data.status = 1; // Update status to indicate new data
            xSemaphoreGive(xSemaphore);
        }

        vTaskDelay(pdMS_TO_TICKS(100)); // Delay for sensor reading interval
    }
}

void vTask2(void *pvParameters) {
    while (1) {
        // Take the semaphore before accessing shared data
        if (xSemaphoreTake(xSemaphore, portMAX_DELAY) == pdTRUE) {
            if (sensor_data.status == 1) {
                processSensorData(sensor_data.sensorValue); // Assume this function processes the data
                sensor_data.status = 0; // Reset status after processing
            }
            xSemaphoreGive(xSemaphore);
        }

        vTaskDelay(pdMS_TO_TICKS(100)); // Delay for processing interval
    }
}

int main(void) {
    xSemaphore = xSemaphoreCreateMutex();

    xTaskCreate(vTask1, "Task1", 1000, NULL, 1, NULL);
    xTaskCreate(vTask2, "Task2", 1000, NULL, 1, NULL);

    vTaskStartScheduler();

    for (;;);
}

int readSensor() {
    // Simulated sensor reading
    return rand() % 100; // Random value for demonstration
}

void processSensorData(int value) {
    // Simulated data processing
}