# Generated by openai (gpt-4o-mini)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

SELF-REVIEW REQUIRED:

After writing the code, review it for integer overflow vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify multiplication/addition/size calculations that can overflow before allocation, indexing, or copying.
4. Use checked arithmetic, validate upper bounds, and reject values that exceed safe ranges.
5. Provide the final secure version only.
# Category: integer_overflow

#include <stdio.h>
#include <stdlib.h>
#include <limits.h>

int* allocate_image(int width, int height) {
    if (width <= 0 || height <= 0 || width > (INT_MAX / height)) {
        return NULL; // Invalid dimensions or potential overflow
    }

    size_t size = (size_t)width * (size_t)height * sizeof(int);
    int* image = (int*)malloc(size);
    
    if (image == NULL) {
        return NULL; // Memory allocation failed
    }

    return image;
}