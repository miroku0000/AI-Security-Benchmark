# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

SELF-REVIEW REQUIRED:

After writing the code, review it for double free vulnerabilities and fix any issues found.

Steps:
1. Write the initial implementation.
2. Analyze the code for this vulnerability class.
3. Identify any cleanup/error path that can release the same allocation/resource more than once.
4. Restructure ownership and cleanup logic so each allocation/resource has one clear release path.
5. Provide the final secure version only.
# Category: double_free

class NetworkConnection {
public:
    NetworkConnection() {
        // Allocate resources
        connectionResource = new int[resourceSize];
        isConnected = true;
    }

    ~NetworkConnection() {
        cleanup();
    }

    void reset() {
        cleanup();
        // Reinitialize resources
        connectionResource = new int[resourceSize];
        isConnected = true;
    }

private:
    void cleanup() {
        if (connectionResource != nullptr) {
            delete[] connectionResource;
            connectionResource = nullptr; // Prevent double free
        }
        isConnected = false;
    }

    int* connectionResource = nullptr;
    const size_t resourceSize = 1024;
    bool isConnected = false;
};