# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE_ADDR 0x40004000
#define UART_DR   (*(volatile uint32_t *)(UART_BASE_ADDR + 0x00))
#define UART_FR   (*(volatile uint32_t *)(UART_BASE_ADDR + 0x18))
#define UART_IBRD (*(volatile uint32_t *)(UART_BASE_ADDR + 0x24))
#define UART_FBRD (*(volatile uint32_t *)(UART_BASE_ADDR + 0x28))
#define UART_LCRH (*(volatile uint32_t *)(UART_BASE_ADDR + 0x2C))
#define UART_CR   (*(volatile uint32_t *)(UART_BASE_ADDR + 0x30))

#define GPIO_BASE_ADDR 0x40020000
#define GPIOA_MODER (*(volatile uint32_t *)(GPIO_BASE_ADDR + 0x00))
#define GPIOA_AFRL  (*(volatile uint32_t *)(GPIO_BASE_ADDR + 0x20))
#define GPIOA_PUPDR (*(volatile uint32_t *)(GPIO_BASE_ADDR + 0x0C))

#define FLASH_BASE_ADDR 0x08000000
#define CONFIG_BASE_ADDR 0x0801F000

#define CMD_BUFFER_SIZE 128
#define MAX_ARGS 8

typedef struct {
    char buffer[CMD_BUFFER_SIZE];
    uint8_t index;
} CommandBuffer;

typedef struct {
    uint32_t device_id;
    uint32_t firmware_version;
    uint32_t sensor_type;
    uint32_t calibration_data[16];
    uint32_t network_config[8];
} DeviceConfig;

static CommandBuffer cmd_buf = {0};
static DeviceConfig device_config;

void uart_init(uint32_t baudrate) {
    UART_CR = 0;
    
    uint32_t clock = 16000000;
    uint32_t div = (clock * 4) / baudrate;
    UART_IBRD = div >> 6;
    UART_FBRD = div & 0x3F;
    
    UART_LCRH = (3 << 5);
    UART_CR = (1 << 0) | (1 << 8) | (1 << 9);
}

void uart_putc(char c) {
    while (UART_FR & (1 << 5));
    UART_DR = c;
}

void uart_puts(const char *str) {
    while (*str) {
        if (*str == '\n') {
            uart_putc('\r');
        }
        uart_putc(*str++);
    }
}

char uart_getc(void) {
    while (UART_FR & (1 << 4));
    return (char)(UART_DR & 0xFF);
}

void uart_printf(const char *format, ...) {
    char buffer[256];
    va_list args;
    va_start(args, format);
    vsnprintf(buffer, sizeof(buffer), format, args);
    va_end(args);
    uart_puts(buffer);
}

void jtag_init(void) {
    GPIOA_MODER &= ~((3 << (13*2)) | (3 << (14*2)) | (3 << (15*2)));
    GPIOA_MODER |= (2 << (13*2)) | (2 << (14*2)) | (2 << (15*2));
    
    GPIOA_AFRL &= ~((0xF << (13*4)) | (0xF << (14*4)) | (0xF << (15*4)));
    GPIOA_AFRL |= (0 << (13*4)) | (0 << (14*4)) | (0 << (15*4));
    
    GPIOA_PUPDR &= ~((3 << (13*2)) | (3 << (14*2)) | (3 << (15*2)));
    GPIOA_PUPDR |= (1 << (13*2)) | (1 << (14*2)) | (1 << (15*2));
}

void load_device_config(void) {
    volatile DeviceConfig *flash_config = (DeviceConfig *)CONFIG_BASE_ADDR;
    memcpy(&device_config, (void *)flash_config, sizeof(DeviceConfig));
}

void cmd_dump_memory(char *args[], int argc) {
    uint32_t start_addr = 0x20000000;
    uint32_t length = 256;
    
    if (argc >= 1) {
        sscanf(args[0], "%lx", &start_addr);
    }
    if (argc >= 2) {
        sscanf(args[1], "%lu", &length);
    }
    
    uart_printf("\nMemory Dump - Address: 0x%08lX, Length: %lu bytes\n", start_addr, length);
    uart_puts("------------------------------------------------------------\n");
    
    volatile uint8_t *ptr = (volatile uint8_t *)start_addr;
    for (uint32_t i = 0; i < length; i += 16) {
        uart_printf("%08lX: ", start_addr + i);
        
        for (uint32_t j = 0; j < 16 && (i + j) < length; j++) {
            uart_printf("%02X ", ptr[i + j]);
        }
        
        uart_puts(" | ");
        for (uint32_t j = 0; j < 16 && (i + j) < length; j++) {
            char c = ptr[i + j];
            uart_putc((c >= 32 && c <= 126) ? c : '.');
        }
        uart_puts("\n");
    }
    uart_puts("------------------------------------------------------------\n");
}

void cmd_read_flash(char *args[], int argc) {
    uint32_t start_addr = FLASH_BASE_ADDR;
    uint32_t length = 256;
    
    if (argc >= 1) {
        sscanf(args[0], "%lx", &start_addr);
    }
    if (argc >= 2) {
        sscanf(args[1], "%lu", &length);
    }
    
    uart_printf("\nFlash Read - Address: 0x%08lX, Length: %lu bytes\n", start_addr, length);
    uart_puts("------------------------------------------------------------\n");
    
    volatile uint32_t *ptr = (volatile uint32_t *)start_addr;
    for (uint32_t i = 0; i < length / 4; i += 4) {
        uart_printf("%08lX: %08lX %08lX %08lX %08lX\n", 
                   start_addr + (i * 4),
                   ptr[i], ptr[i+1], ptr[i+2], ptr[i+3]);
    }
    uart_puts("------------------------------------------------------------\n");
}

void cmd_get_config(char *args[], int argc) {
    uart_puts("\n=== Device Configuration ===\n");
    uart_printf("Device ID:         0x%08lX\n", device_config.device_id);
    uart_printf("Firmware Version:  %lu.%lu.%lu\n", 
               (device_config.firmware_version >> 16) & 0xFF,
               (device_config.firmware_version >> 8) & 0xFF,
               device_config.firmware_version & 0xFF);
    uart_printf("Sensor Type:       0x%08lX\n", device_config.sensor_type);
    
    uart_puts("\nCalibration Data:\n");
    for (int i = 0; i < 16; i += 4) {
        uart_printf("  [%02d-%02d]: %08lX %08lX %08lX %08lX\n", 
                   i, i+3,
                   device_config.calibration_data[i],
                   device_config.calibration_data[i+1],
                   device_config.calibration_data[i+2],
                   device_config.calibration_data[i+3]);
    }
    
    uart_puts("\nNetwork Configuration:\n");
    for (int i = 0; i < 8; i += 2) {
        uart_printf("  [%d-%d]: %08lX %08lX\n", 
                   i, i+1,
                   device_config.network_config[i],
                   device_config.network_config[i+1]);
    }
    uart_puts("============================\n");
}

void cmd_help(char *args[], int argc) {
    uart_puts("\n=== Diagnostic Console Commands ===\n");
    uart_puts("dump_memory [addr] [length] - Dump memory contents\n");
    uart_puts("  addr:   Start address (hex, default: 0x20000000)\n");
    uart_puts("  length: Number of bytes (dec, default: 256)\n");
    uart_puts("\nread_flash [addr] [length]  - Read flash memory\n");
    uart_puts("  addr:   Start address (hex, default: 0x08000000)\n");
    uart_puts("  length: Number of bytes (dec, default: 256)\n");
    uart_puts("\nget_config                  - Display device configuration\n");
    uart_puts("\nreset                       - Reset device\n");
    uart_puts("version                     - Show firmware version\n");
    uart_puts("help                        - Show this help\n");
    uart_puts("===================================\n");
}

void cmd_version(char *args[], int argc) {
    uart_puts("\n=== Firmware Information ===\n");
    uart_printf("Version:    %lu.%lu.%lu\n", 
               (device_config.firmware_version >> 16) & 0xFF,
               (device_config.firmware_version >> 8) & 0xFF,
               device_config.firmware_version & 0xFF);
    uart_puts("Build Date: " __DATE__ " " __TIME__ "\n");
    uart_puts("Device:     Industrial IoT Sensor\n");
    uart_puts("============================\n");
}

void cmd_reset(char *args[], int argc) {
    uart_puts("\nResetting device...\n");
    for (volatile int i = 0; i < 1000000; i++);
    
    void (*reset_handler)(void) = (void (*)(void))(*(volatile uint32_t *)0x00000004);
    reset_handler();
}

void parse_and_execute_command(char *cmd_line) {
    char *args[MAX_ARGS];
    int argc = 0;
    
    char *token = strtok(cmd_line, " \t");
    char *command = token;
    
    while ((token = strtok(NULL, " \t")) != NULL && argc < MAX_ARGS) {
        args[argc++] = token;
    }
    
    if (command == NULL || strlen(command) == 0) {
        return;
    }
    
    if (strcmp(command, "dump_memory") == 0) {
        cmd_dump_memory(args, argc);
    } else if (strcmp(command, "read_flash") == 0) {
        cmd_read_flash(args, argc);
    } else if (strcmp(command, "get_config") == 0) {
        cmd_get_config(args, argc);
    } else if (strcmp(command, "help") == 0) {
        cmd_help(args, argc);
    } else if (strcmp(command, "version") == 0) {
        cmd_version(args, argc);
    } else if (strcmp(command, "reset") == 0) {
        cmd_reset(args, argc);
    } else {
        uart_printf("Unknown command: %s\n", command);
        uart_puts("Type 'help' for available commands\n");
    }
}

void process_uart_input(void) {
    if (!(UART_FR & (1 << 4))) {
        char c = uart_getc();
        
        if (c == '\r' || c == '\n') {
            uart_puts("\n");
            cmd_buf.buffer[cmd_buf.index] = '\0';
            
            if (cmd_buf.index > 0) {
                parse_and_execute_command(cmd_buf.buffer);
            }
            
            cmd_buf.index = 0;
            memset(cmd_buf.buffer, 0, CMD_BUFFER_SIZE);
            uart_puts("\n> ");
        } else if (c == 127 || c == 8) {
            if (cmd_buf.index > 0) {
                cmd_buf.index--;
                uart_puts("\b \b");
            }
        } else if (c >= 32 && c < 127) {
            if (cmd_buf.index < CMD_BUFFER_SIZE - 1) {
                cmd_buf.buffer[cmd_buf.index++] = c;
                uart_putc(c);
            }
        }
    }
}

void diagnostic_console_init(void) {
    uart_init(115200);
    jtag_init();
    load_device_config();
    
    uart_puts("\n\n");
    uart_puts("========================================\n");
    uart_puts("  Industrial IoT Sensor Diagnostics\n");
    uart_puts("  Firmware v");
    uart_printf("%lu.%lu.%lu\n", 
               (device_config.firmware_version >> 16) & 0xFF,
               (device_config.firmware_version >> 8) & 0xFF,
               device_config.firmware_version & 0xFF);
    uart_puts("========================================\n");
    uart_printf("Device ID: 0x%08lX\n", device_config.device_id);
    uart_puts("JTAG: Enabled\n");
    uart_puts("Type 'help' for available commands\n");
    uart_puts("========================================\n\n");
    uart_puts("> ");
}

void diagnostic_console_task(void) {
    process_uart_input();
}

int main(void) {
    device_config.device_id = 0x12345678;
    device_config.firmware_version = 0x010203;
    device_config.sensor_type = 0xABCD;
    
    diagnostic_console_init();
    
    while (1) {
        diagnostic_console_task();
    }
    
    return 0;
}