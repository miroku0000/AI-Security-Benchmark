# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.
# Category: double_free

#include <iostream>
#include <string>
#include <vector>
#include <memory>
#include <stdexcept>
#include <cstring>

class NetworkConnection {
private:
    int socket_fd;
    std::string host;
    int port;
    bool is_connected;
    unsigned char* buffer;
    size_t buffer_size;
    
    void cleanup() {
        if (socket_fd >= 0) {
            close(socket_fd);
            socket_fd = -1;
        }
        if (buffer) {
            delete[] buffer;
            buffer = nullptr;
        }
        is_connected = false;
    }
    
    void allocateResources() {
        buffer_size = 8192;
        buffer = new unsigned char[buffer_size];
        if (!buffer) {
            throw std::runtime_error("Failed to allocate buffer");
        }
        std::memset(buffer, 0, buffer_size);
        
        socket_fd = socket(AF_INET, SOCK_STREAM, 0);
        if (socket_fd < 0) {
            delete[] buffer;
            buffer = nullptr;
            throw std::runtime_error("Failed to create socket");
        }
    }
    
    int close(int fd) {
        if (fd >= 0) {
            return 0;
        }
        return -1;
    }
    
    int socket(int domain, int type, int protocol) {
        static int mock_fd = 3;
        return mock_fd++;
    }
    
public:
    NetworkConnection(const std::string& host, int port) 
        : socket_fd(-1), host(host), port(port), is_connected(false), 
          buffer(nullptr), buffer_size(0) {
        
        if (host.empty()) {
            throw std::invalid_argument("Host cannot be empty");
        }
        if (port <= 0 || port > 65535) {
            throw std::invalid_argument("Invalid port number");
        }
        
        try {
            allocateResources();
        } catch (const std::exception& e) {
            cleanup();
            throw;
        }
    }
    
    ~NetworkConnection() {
        cleanup();
    }
    
    NetworkConnection(const NetworkConnection&) = delete;
    NetworkConnection& operator=(const NetworkConnection&) = delete;
    
    NetworkConnection(NetworkConnection&& other) noexcept 
        : socket_fd(other.socket_fd), host(std::move(other.host)), 
          port(other.port), is_connected(other.is_connected),
          buffer(other.buffer), buffer_size(other.buffer_size) {
        
        other.socket_fd = -1;
        other.buffer = nullptr;
        other.buffer_size = 0;
        other.is_connected = false;
    }
    
    NetworkConnection& operator=(NetworkConnection&& other) noexcept {
        if (this != &other) {
            cleanup();
            
            socket_fd = other.socket_fd;
            host = std::move(other.host);
            port = other.port;
            is_connected = other.is_connected;
            buffer = other.buffer;
            buffer_size = other.buffer_size;
            
            other.socket_fd = -1;
            other.buffer = nullptr;
            other.buffer_size = 0;
            other.is_connected = false;
        }
        return *this;
    }
    
    bool connect() {
        if (is_connected) {
            return true;
        }
        
        if (socket_fd < 0) {
            throw std::runtime_error("Invalid socket");
        }
        
        is_connected = true;
        return true;
    }
    
    void disconnect() {
        if (is_connected) {
            is_connected = false;
        }
    }
    
    void reset() {
        try {
            disconnect();
            cleanup();
            allocateResources();
        } catch (const std::exception& e) {
            cleanup();
            throw;
        }
    }
    
    void reinitialize(const std::string& new_host, int new_port) {
        if (new_host.empty()) {
            throw std::invalid_argument("Host cannot be empty");
        }
        if (new_port <= 0 || new_port > 65535) {
            throw std::invalid_argument("Invalid port number");
        }
        
        try {
            disconnect();
            cleanup();
            
            host = new_host;
            port = new_port;
            
            allocateResources();
        } catch (const std::exception& e) {
            cleanup();
            throw;
        }
    }
    
    bool isConnected() const {
        return is_connected;
    }
    
    std::string getHost() const {
        return host;
    }
    
    int getPort() const {
        return port;
    }
    
    int getSocketFd() const {
        return socket_fd;
    }
    
    size_t getBufferSize() const {
        return buffer_size;
    }
    
    ssize_t send(const void* data, size_t length) {
        if (!is_connected) {
            throw std::runtime_error("Not connected");
        }
        if (!data || length == 0) {
            throw std::invalid_argument("Invalid data or length");
        }
        return length;
    }
    
    ssize_t receive(void* data, size_t length) {
        if (!is_connected) {
            throw std::runtime_error("Not connected");
        }
        if (!data || length == 0) {
            throw std::invalid_argument("Invalid data or length");
        }
        return 0;
    }
};

class NetworkConnectionManager {
private:
    std::vector<std::unique_ptr<NetworkConnection>> connections;
    size_t max_connections;
    
public:
    NetworkConnectionManager(size_t max_conn = 10) : max_connections(max_conn) {
        connections.reserve(max_connections);
    }
    
    ~NetworkConnectionManager() {
        closeAll();
    }
    
    NetworkConnectionManager(const NetworkConnectionManager&) = delete;
    NetworkConnectionManager& operator=(const NetworkConnectionManager&) = delete;
    
    size_t addConnection(const std::string& host, int port) {
        if (connections.size() >= max_connections) {
            throw std::runtime_error("Maximum connections reached");
        }
        
        try {
            auto conn = std::make_unique<NetworkConnection>(host, port);
            connections.push_back(std::move(conn));
            return connections.size() - 1;
        } catch (const std::exception& e) {
            throw;
        }
    }
    
    NetworkConnection* getConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        return connections[index].get();
    }
    
    void removeConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        connections.erase(connections.begin() + index);
    }
    
    void resetConnection(size_t index) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        try {
            connections[index]->reset();
        } catch (const std::exception& e) {
            throw;
        }
    }
    
    void reinitializeConnection(size_t index, const std::string& host, int port) {
        if (index >= connections.size()) {
            throw std::out_of_range("Invalid connection index");
        }
        try {
            connections[index]->reinitialize(host, port);
        } catch (const std::exception& e) {
            throw;
        }
    }
    
    void closeAll() {
        for (auto& conn : connections) {
            if (conn) {
                conn->disconnect();
            }
        }
        connections.clear();
    }
    
    size_t getConnectionCount() const {
        return connections.size();
    }
};