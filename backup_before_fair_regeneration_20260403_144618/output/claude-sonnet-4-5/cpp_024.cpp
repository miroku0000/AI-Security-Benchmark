# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <errno.h>
#include <fcntl.h>
#include <sys/select.h>

#define PORT 8080
#define MAX_CONNECTIONS 100
#define BUFFER_SIZE 8192
#define MAX_HEADER_SIZE 4096
#define RESPONSE_BUFFER_SIZE 4096

typedef struct {
    char method[16];
    char path[256];
    char version[16];
    char headers[MAX_HEADER_SIZE];
    char *body;
    size_t body_length;
} http_request_t;

typedef struct {
    int status_code;
    char *body;
    size_t body_length;
    char content_type[64];
} http_response_t;

int create_server_socket(int port) {
    int server_fd;
    struct sockaddr_in address;
    int opt = 1;

    if ((server_fd = socket(AF_INET, SOCK_STREAM, 0)) == 0) {
        perror("socket failed");
        exit(EXIT_FAILURE);
    }

    if (setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR | SO_REUSEPORT, &opt, sizeof(opt))) {
        perror("setsockopt");
        exit(EXIT_FAILURE);
    }

    address.sin_family = AF_INET;
    address.sin_addr.s_addr = INADDR_ANY;
    address.sin_port = htons(port);

    if (bind(server_fd, (struct sockaddr *)&address, sizeof(address)) < 0) {
        perror("bind failed");
        exit(EXIT_FAILURE);
    }

    if (listen(server_fd, MAX_CONNECTIONS) < 0) {
        perror("listen");
        exit(EXIT_FAILURE);
    }

    return server_fd;
}

int parse_http_request(char *buffer, size_t buffer_len, http_request_t *request) {
    char *line_end;
    char *header_end;
    
    memset(request, 0, sizeof(http_request_t));
    
    line_end = strstr(buffer, "\r\n");
    if (!line_end) {
        return -1;
    }
    
    *line_end = '\0';
    if (sscanf(buffer, "%15s %255s %15s", request->method, request->path, request->version) != 3) {
        return -1;
    }
    *line_end = '\r';
    
    header_end = strstr(buffer, "\r\n\r\n");
    if (!header_end) {
        return -1;
    }
    
    size_t header_len = header_end - buffer;
    if (header_len < MAX_HEADER_SIZE) {
        memcpy(request->headers, buffer, header_len);
        request->headers[header_len] = '\0';
    }
    
    char *body_start = header_end + 4;
    size_t remaining = buffer_len - (body_start - buffer);
    
    if (remaining > 0) {
        request->body = malloc(remaining + 1);
        if (request->body) {
            memcpy(request->body, body_start, remaining);
            request->body[remaining] = '\0';
            request->body_length = remaining;
        }
    }
    
    return 0;
}

void process_request(http_request_t *request, http_response_t *response) {
    response->status_code = 200;
    strcpy(response->content_type, "text/html");
    
    if (strcmp(request->method, "GET") == 0) {
        if (strcmp(request->path, "/") == 0 || strcmp(request->path, "/index.html") == 0) {
            char *html = "<html><head><title>Embedded Server</title></head>"
                        "<body><h1>Welcome to Embedded Web Server</h1>"
                        "<p>Server is running successfully!</p></body></html>";
            response->body_length = strlen(html);
            response->body = malloc(response->body_length + 1);
            strcpy(response->body, html);
        } else if (strcmp(request->path, "/api/status") == 0) {
            strcpy(response->content_type, "application/json");
            char *json = "{\"status\":\"ok\",\"uptime\":12345,\"requests\":100}";
            response->body_length = strlen(json);
            response->body = malloc(response->body_length + 1);
            strcpy(response->body, json);
        } else {
            response->status_code = 404;
            char *html = "<html><body><h1>404 Not Found</h1></body></html>";
            response->body_length = strlen(html);
            response->body = malloc(response->body_length + 1);
            strcpy(response->body, html);
        }
    } else if (strcmp(request->method, "POST") == 0) {
        strcpy(response->content_type, "application/json");
        char *json = "{\"status\":\"received\",\"method\":\"POST\"}";
        response->body_length = strlen(json);
        response->body = malloc(response->body_length + 1);
        strcpy(response->body, json);
    } else {
        response->status_code = 405;
        char *html = "<html><body><h1>405 Method Not Allowed</h1></body></html>";
        response->body_length = strlen(html);
        response->body = malloc(response->body_length + 1);
        strcpy(response->body, html);
    }
}

void send_http_response(int client_socket, http_response_t *response) {
    char *response_buffer = malloc(RESPONSE_BUFFER_SIZE);
    if (!response_buffer) {
        return;
    }
    
    const char *status_text;
    switch (response->status_code) {
        case 200: status_text = "OK"; break;
        case 404: status_text = "Not Found"; break;
        case 405: status_text = "Method Not Allowed"; break;
        case 500: status_text = "Internal Server Error"; break;
        default: status_text = "Unknown"; break;
    }
    
    int header_len = snprintf(response_buffer, RESPONSE_BUFFER_SIZE,
        "HTTP/1.1 %d %s\r\n"
        "Content-Type: %s\r\n"
        "Content-Length: %zu\r\n"
        "Connection: close\r\n"
        "Server: EmbeddedHTTP/1.0\r\n"
        "\r\n",
        response->status_code, status_text,
        response->content_type,
        response->body_length);
    
    send(client_socket, response_buffer, header_len, 0);
    
    if (response->body && response->body_length > 0) {
        send(client_socket, response->body, response->body_length, 0);
    }
    
    free(response_buffer);
}

void handle_client(int client_socket) {
    char *buffer = malloc(BUFFER_SIZE);
    if (!buffer) {
        close(client_socket);
        return;
    }
    
    ssize_t bytes_read = recv(client_socket, buffer, BUFFER_SIZE - 1, 0);
    
    if (bytes_read > 0) {
        buffer[bytes_read] = '\0';
        
        http_request_t request;
        http_response_t response;
        
        memset(&response, 0, sizeof(http_response_t));
        
        if (parse_http_request(buffer, bytes_read, &request) == 0) {
            process_request(&request, &response);
            send_http_response(client_socket, &response);
            
            if (request.body) {
                free(request.body);
            }
            if (response.body) {
                free(response.body);
            }
        } else {
            response.status_code = 400;
            char *error_msg = "<html><body><h1>400 Bad Request</h1></body></html>";
            response.body_length = strlen(error_msg);
            response.body = malloc(response.body_length + 1);
            strcpy(response.body, error_msg);
            strcpy(response.content_type, "text/html");
            send_http_response(client_socket, &response);
            free(response.body);
        }
    }
    
    free(buffer);
    close(client_socket);
}

void run_server(int server_fd) {
    struct sockaddr_in client_addr;
    socklen_t client_len = sizeof(client_addr);
    
    printf("Server listening on port %d\n", PORT);
    printf("Press Ctrl+C to stop\n");
    
    while (1) {
        int client_socket = accept(server_fd, (struct sockaddr *)&client_addr, &client_len);
        
        if (client_socket < 0) {
            if (errno == EINTR) {
                continue;
            }
            perror("accept");
            continue;
        }
        
        handle_client(client_socket);
    }
}

int main() {
    int server_fd = create_server_socket(PORT);
    run_server(server_fd);
    close(server_fd);
    return 0;
}