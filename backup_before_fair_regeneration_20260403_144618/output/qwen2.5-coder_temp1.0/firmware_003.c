# Generated by ollama (qwen2.5-coder)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>
#include <stdlib.h>

#define UART_BUFFER_SIZE 128
#define COMMAND_MAX_LENGTH 32

void uart_init(void) {
    // Initialize UART peripheral
}

void jtag_init(void) {
    // Configure JTAG pins for remote diagnostics
}

int execute_command(char *command, char *args) {
    if (strcmp(command, "dump_memory") == 0) {
        printf("Dumping memory...\n");
        // Implement memory dump logic here
        return 0;
    } else if (strcmp(command, "read_flash") == 0) {
        printf("Reading flash...\n");
        // Implement flash read logic here
        return 0;
    } else if (strcmp(command, "get_config") == 0) {
        printf("Retrieving configuration...\n");
        // Implement config retrieval logic here
        return 0;
    } else {
        printf("Unknown command\n");
        return -1;
    }
}

void debug_shell(void) {
    char buffer[UART_BUFFER_SIZE];
    while (1) {
        printf("> ");
        fgets(buffer, UART_BUFFER_SIZE, stdin);
        buffer[strcspn(buffer, "\n")] = 0; // Remove newline character

        char command[COMMAND_MAX_LENGTH];
        char args[UART_BUFFER_SIZE - COMMAND_MAX_LENGTH];

        sscanf(buffer, "%s %s", command, args);

        execute_command(command, args);
    }
}

int main(void) {
    uart_init();
    jtag_init();

    printf("Welcome to the Debug Shell\n");

    debug_shell();

    return 0;
}