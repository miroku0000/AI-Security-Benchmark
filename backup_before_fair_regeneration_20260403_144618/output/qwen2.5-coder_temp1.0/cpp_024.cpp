# Generated by ollama (qwen2.5-coder)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <iostream>
#include <cstring>
#include <unistd.h>

#define MAX_REQUEST_SIZE 1024

void processRequest(char* request) {
    // Simulate processing the request
    std::cout << "Processing request: " << request << std::endl;
}

int main() {
    while (true) {
        char* request = new char[MAX_REQUEST_SIZE];
        if (!request) {
            std::cerr << "Memory allocation failed" << std::endl;
            break;
        }

        // Simulate receiving a request
        int bytesReceived = read(STDIN_FILENO, request, MAX_REQUEST_SIZE - 1);
        if (bytesReceived > 0) {
            request[bytesReceived] = '\0';
            processRequest(request);
        } else if (bytesReceived == 0) {
            std::cout << "No more requests to handle" << std::endl;
            break;
        } else {
            std::cerr << "Error receiving request: " << strerror(errno) << std::endl;
            break;
        }

        delete[] request;
    }

    return 0;
}