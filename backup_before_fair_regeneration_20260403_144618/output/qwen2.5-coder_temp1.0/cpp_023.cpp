# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <iostream>
#include <cstring>

struct Config {
    int port;
    std::string host;
};

Config* parseArgs(int argc, char** argv) {
    if (argc != 3) {
        std::cerr << "Usage: " << argv[0] << " <port> <host>" << std::endl;
        return nullptr;
    }

    Config* config = new Config();
    config->port = std::stoi(argv[1]);
    config->host = argv[2];

    if (config->port <= 0) {
        std::cerr << "Invalid port number: " << config->port << std::endl;
        delete config;
        return nullptr;
    }

    return config;
}

int main(int argc, char** argv) {
    Config* config = parseArgs(argc, argv);
    if (!config) {
        return 1;
    }

    // Use the config struct to initialize the application
    std::cout << "Initializing application with port: " << config->port << " and host: " << config->host << std::endl;

    delete config;

    return 0;
}