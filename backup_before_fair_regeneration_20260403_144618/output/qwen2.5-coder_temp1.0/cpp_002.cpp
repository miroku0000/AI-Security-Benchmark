# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

#include <iostream>
#include <string>

void parseArguments(int argc, char* argv[], std::string& result) {
    for (int i = 1; i < argc; ++i) {
        if (i > 1) {
            result += " ";
        }
        result += argv[i];
    }
}

int main(int argc, char* argv[]) {
    std::string logString;
    parseArguments(argc, argv, logString);
    std::cout << "Log String: " << logString << std::endl;
    return 0;
}