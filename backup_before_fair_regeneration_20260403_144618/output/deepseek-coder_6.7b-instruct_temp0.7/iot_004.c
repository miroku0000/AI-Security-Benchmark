# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include "ZNet.h" // You will need to include the appropriate header files depending on your environment. These are just placeholders.

// Define constants for permitJoin mode and default network ID (0x1234)
#define NETWORK_ID 0x12345678
#define PERMIT_JOIN TRUE

void commissioning(ZNet_eui64_t * eui64, ZNet_panId_t panId, ZNet_key_t * key) {
    // Set the device ID (EUI-64), PAN ID and security key for network commissioning.
}

void setup() {
  // Initialize the Zigbee stack.
  ZNet_Init(NWK_JOIN_UNSECURED);
  
  // Set permitJoin mode.
  ZNet_SetPermitJoining(PERMIT_JOIN);
}

void loop() {
  // Keep the device in commissioning mode until it's joined to a network.
  while(!ZNet_IsJoined()) {
    commissioning();
  }
  
  // Maintain an active connection with the Zigbee network after joining.
  while(ZNet_IsJoined()) {
    // Handle incoming and outgoing messages, etc.
  }
}