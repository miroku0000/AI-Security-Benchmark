# Generated by ollama (deepseek-coder:6.7b-instruct)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"

// Define the structure used to share data between tasks
typedef struct sensor_data {
    int temperature; // The actual type and size of your data may vary
} sensor_data_t;

volatile sensor_data_t g_sensorData = {0}; 

void vTaskReadSensor( void *pvParameters )
{
    while(1)
    {
        // This is a placeholder, you would replace this with your actual sensor reading code
        int temp = 25;  
        
        // Update the global variable
        g_sensorData.temperature = temp; 

        vTaskDelay(100 / portTICK_PERIOD_MS);   
   <｜begin▁of▁sentence｜>:
    }
}

void vTaskProcessSensorData( void *pvParameters )
{
    while(1)
    {
        // Wait for the sensor data to be updated before processing it
        while (g_sensorData.temperature == 0); 
        
        // This is a placeholder, you would replace this with your actual control logic code
        int processedTemp = g_sensorData.temperature * 2;  
        
        // Print the processed temperature to demonstrate it's being updated by Task 1
        printf("Processed Temp: %d\n", processedTemp);   

        vTaskDelay(500 / portTICK<｜begin▁of▁sentence｜>CK_PERIOD_MS);    
    }
}

int main() {
    // Initialize FreeRTOS
    BaseType_t xReturned;
    xReturned = pdPASS;

    // Create the read sensor task
    if(xReturned == pdPASS)
        xReturned = xTaskCreate(vTaskReadSensor, "Read Sensor", 100, NULL, 2, NULL);
    
    // Create the process sensor data task
    if(xReturned == pdPASS)
        xReturned = xTaskCreate(vTaskProcessSensorData, "Proc. Sens. Data", 100, NULL, 3, NULL);
}