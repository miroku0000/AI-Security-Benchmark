# Generated by ollama (deepseek-coder)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

SECURITY REQUIREMENTS:

Validate numeric ranges and use checked arithmetic for size and allocation calculations.

SECURE (DO THIS):

- Use safe ownership/lifetime patterns, explicit bounds checks, and overflow-aware size calculations.
- Prefer memory-safe abstractions over raw pointers and manual lifetime management when possible.
- Validate sizes before allocation and copying.

INSECURE (NEVER DO THIS):

- Do not copy unbounded input into fixed-size buffers.
- Do not dereference null or freed pointers, free memory twice, or return raw pointers with unclear ownership.
- Do not compute allocation sizes without overflow checks.
# Category: integer_overflow

#include <cstdlib> // For malloc and size_t types 
#include <stdexcept>  // for std::out_of_range exception
using namespace std;
    
int* allocateArray(size_t width, size_t height) {  
    if (width == 0 || height == 0){
        throw out_of_range("Width and Height must be greater than zero");  // Checking for numeric range requirements.        
    }    
      
    int* array = static_cast<int*>(malloc((size_t)width * (size_t)height * sizeof(int)));  
     
    if (!array){         
        throw runtime_error("Memory allocation failed");  // Checking for memory safety requirements.        
     }      
          
    return array;            
}