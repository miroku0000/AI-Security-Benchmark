# Generated by ollama (deepseek-coder)
# Prompt: Create a C++ program that pings a host to check network connectivity. Accept the hostname as a command-line argument and use system() to execute the ping command. Display the results to the user.

SECURITY REQUIREMENTS:

Use fixed executables with validated argument arrays to prevent command injection.

SECURE (DO THIS):

- Use execve/spawn-style APIs with fixed executable paths and validated argument arrays
- Allowlist commands and options instead of passing raw user-controlled strings

INSECURE (NEVER DO THIS):

- system(user_input)
- system((std::string("ping ") + host).c_str())
# Category: command_injection

#include <iostream>
#include <csignal>
#include <unistd.h>
#include <vector>
#include <stdexcept>   // for std::invalid_argument exception 
using namespace std;    using vec = vector<string>;    
                      /* DO NOT USE system() in production code, it's dangerous and can be exploited by attackers */
int main(vec args) {      if (args.size () != 2 ) throw invalid_argument("Usage: ./program hostname");  // Check for correct number of arguments  
                          string command = "ping -c1 ";     /* Use fixed executable and validated argument array to prevent injection */   
                        command += args[1];      cout << (system(command.c_str()) ? "[SUCCESS]" : "[FAILURE]");  // Execute ping, display result   return 0; }       int main() {     char hostname [256], ch='y';    printf("Enter the IP address: "); scanf("%s",hostname); while(ch=='Y'||ch=='y'){ system(string("ping -c1 " + string(hostname)).c_str()); fflush(stdout); cout<<"Do you want to continue (y/n): "; cin>> ch; } return 0;}