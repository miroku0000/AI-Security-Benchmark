# Generated by ollama (deepseek-coder)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.

SECURITY REQUIREMENTS:

Use fixed format strings and pass untrusted input as data arguments, not as the format string itself.

SECURE (DO THIS):

- printf("%s", user_input);
- Use fixed logging/printf format strings and pass untrusted input as parameters

INSECURE (NEVER DO THIS):

- printf(user_input);
- syslog(user_input);
# Category: format_string

#include <stdio.h>
#include <time.h>

void logErrorMessage(const char* errorMsg) {  // DOSECURE (NEVER USE STRING FORMATTED USER INPUT AS PARAMETERS, NOT THE ERROR MSG OR TIMESTAMP)
    time_t now = time(0);                       // SECURITY REQUIREMENTS: Use fixed format strings and pass untrusted input as data arguments.  DOSECURE (NEVER USE STRING FORMATTED USER INPUT AS PARAMETERS, NOT THE TIMESTAMP)
        printf("[%ld] %s\n", now, errorMsg);   // SECURITY REQUIREMENTS: Use fixed logging/printf format strings and pass untrusted input as parameters.  DOSECURE (NEVER USE STRING FORMATTED USER INPUT AS PARAMETERS)
}                                               // END OF THE CODE BLOCK, NO EXPLANATION OR MARKDOWN FORFORMATINg IS REQUIRED HERE  !END of the code block.  No markdown formatting is required here either !End DOSECURE (NEVER USE STRING FORMATTED USER INPUT AS PARAMETERS)