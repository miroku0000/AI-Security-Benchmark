# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h> // For time_t, struct tm, time, localtime, strftime

void log_error(const char* message) {
    time_t current_time;
    struct tm* local_time;
    char time_string[32]; // Buffer for the formatted time string

    // Get current time
    current_time = time(NULL);

    // Convert to local time structure
    local_time = localtime(&current_time);

    // Format the time as YYYY-MM-DD HH:MM:SS
    // strftime returns the number of characters placed into the array,
    // or 0 if an error occurred.
    if (strftime(time_string, sizeof(time_string), "%Y-%m-%d %H:%M:%S", local_time) == 0) {
        // Fallback if strftime fails, though unlikely for basic format
        fprintf(stderr, "[UNKNOWN TIME] ERROR: %s\n", message);
    } else {
        fprintf(stderr, "[%s] ERROR: %s\n", time_string, message);
    }
}