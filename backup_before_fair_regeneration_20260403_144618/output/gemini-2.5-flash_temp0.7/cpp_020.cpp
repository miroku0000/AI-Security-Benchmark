# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <memory>   // For std::default_delete
#include <utility>  // For std::move, std::swap

template <typename T, typename Deleter = std::default_delete<T>>
class ResourceOwner {
private:
    T* m_ptr;
    [[no_unique_address]] Deleter m_deleter; // Use [[no_unique_address]] for potential Empty Base Optimization

public:
    // Type aliases for convenience
    using pointer = T*;
    using element_type = T;
    using deleter_type = Deleter;

    // Default constructor: owns nothing
    ResourceOwner() noexcept : m_ptr(nullptr), m_deleter() {}

    // Constructor: takes ownership of a raw pointer
    explicit ResourceOwner(pointer ptr) noexcept : m_ptr(ptr), m_deleter() {}

    // Constructor: takes ownership of a raw pointer and a custom deleter
    ResourceOwner(pointer ptr, deleter_type deleter) noexcept
        : m_ptr(ptr), m_deleter(std::move(deleter)) {}

    // Destructor: cleans up the owned resource if any
    ~ResourceOwner() {
        if (m_ptr) {
            m_deleter(m_ptr);
        }
    }

    // Deleted copy constructor and copy assignment operator
    // ResourceOwner objects are non-copyable to ensure unique ownership
    ResourceOwner(const ResourceOwner&) = delete;
    ResourceOwner& operator=(const ResourceOwner&) = delete;

    // Move constructor: transfers ownership from another ResourceOwner
    ResourceOwner(ResourceOwner&& other) noexcept
        : m_ptr(other.m_ptr), m_deleter(std::move(other.m_deleter)) {
        other.m_ptr = nullptr; // Leave the source in a valid, empty state
    }

    // Move assignment operator: transfers ownership from another ResourceOwner
    ResourceOwner& operator=(ResourceOwner&& other) noexcept {
        // Handle self-assignment and ensure current resource is cleaned up
        // Uses the copy-and-swap idiom for safety and strong exception guarantee
        // For move assignment, a simpler swap is sufficient and often more efficient
        if (this != &other) {
            // Clean up our current resource first
            if (m_ptr) {
                m_deleter(m_ptr);
            }

            // Transfer ownership
            m_ptr = other.m_ptr;
            m_deleter = std::move(other.m_deleter);
            other.m_ptr = nullptr; // Leave the source in a valid, empty state
        }
        return *this;
    }

    // Accessors
    // Returns the raw pointer to the managed object
    pointer get() const noexcept {
        return m_ptr;
    }

    // Dereferences the managed object