# Generated by google (gemini-2.5-flash)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h> // For close, read, write in a real scenario
#include <sys/socket.h> // For socket, bind, listen, accept in a real scenario
#include <netinet/in.h> // For sockaddr_in in a real scenario

// Define a reasonable buffer size for HTTP requests
// This should be tuned based on expected request header sizes
#define REQUEST_BUFFER_SIZE 4096
#define PORT 8080 // Example port for a real server

// Simulate a socket file descriptor
// In a real server, this would be an actual connected client socket
typedef int SocketFd;

// Function to simulate reading data from a socket
// In a real server, this would use `recv` or `read`
ssize_t simulate_recv(SocketFd client_fd, char *buffer, size_t len, int flags) {
    // For demonstration, we'll return a fixed request after a few calls
    static int request_count = 0;
    const char *requests[] = {
        "GET /index.html HTTP/1.1\r\nHost: example.com\r\nUser-Agent: SimulatedClient\r\n\r\n",
        "POST /api/data HTTP/1.1\r\nHost: example.com\r\nContent-Type: application/json\r\nContent-Length: 17\r\n\r\n{\"key\":\"value\"}",
        "GET /styles.css HTTP/1.1\r\nHost: example.com\r\n\r\n",
        "GET /nonexistent HTTP/1.1\r\nHost: example.com\r\n\r\n",
        // Simulate a longer request to test buffer capacity
        "GET /long/path/to/resource/with/many/segments/and/query/parameters?param1=value1&param2=value2&param3=value3&param4=value4&param5=value5&param6=value6&param7=value7&param8=value8&param9=value9&param10=value10 HTTP/1.1\r\nHost: example.com\r\nUser-Agent: LongRequestClient\r\nAccept: */*\r\nReferer: http://example.com/\r\nConnection: keep-alive\r\n\r\n",
        NULL // Sentinel to indicate no more simulated requests
    };

    if (requests[request_count] != NULL) {
        size_t request_len = strlen(requests[request_count]);
        if (request_len > len) {
            // Request too long for buffer, simulate truncation or error
            fprintf(stderr, "Warning: Simulated request too long for buffer, truncating.\n");
            strncpy(buffer, requests[request_count], len - 1);
            buffer[len - 1] = '\0';
            request_count++;
            return len - 1;
        } else {
            strcpy(buffer, requests[request_count]);
            request_count++;
            return request_len;
        }
    } else {
        // No more simulated requests, simulate connection close
        return 0; // recv returning 0 indicates connection closed
    }
}

// Function to simulate sending data to a socket
// In a real server, this would use `send` or `write`
ssize_t simulate_send(SocketFd client_fd, const char *buffer, size_t len, int flags) {
    printf("--- Simulated Response (FD: %d, Length: %zu) ---\n", client_fd, len);
    printf("%.*s\n", (int)len, buffer); // Print response up to 'len' characters
    printf("---------------------------------------------------\n\n");
    return len;
}


// A very basic HTTP request parser (for demonstration purposes)
// In a real server, this would be much more robust.
void parse_request(const char *request_buffer, size_t request_len) {
    // Find the first line (request line)
    const char *end_of_line = strstr(request_buffer, "\r\n");
    if (!end_of_line) {
        printf("Malformed request: No CRLF found.\n");
        return;
    }

    size_t line_len = end_of_line - request_buffer;
    char request_line[line_len + 1];
    strncpy(request_line, request_buffer, line_len);
    request_line[line_len] = '\0';

    char method[16], path[256], http_version[16];
    if (sscanf(request_line, "%15s %255s %15s", method, path, http_version) == 3) {
        printf("Parsed Request: Method='%s', Path='%s', Version='%s'\n", method, path, http_version);
    } else {
        printf("Failed to parse request line: '%s'\n", request_line);
    }

    // In a real server, you'd parse headers, body, etc. here.
}


// Function to handle a single HTTP request
// This is the core logic for processing a client's request
void handle_http_request(SocketFd client_fd, char *request_buffer) {
    ssize_t bytes_received;

    // 1. Read the HTTP request from the client socket
    // We assume a single read is sufficient for the header for simplicity.
    // In a real server, you might need to loop `recv` until CRLF CRLF is found,
    // or until content-length bytes are received for POST requests.
    bytes_received = simulate_recv(client_fd, request_buffer, REQUEST_BUFFER_SIZE - 1, 0);

    if (bytes_received > 0) {
        request_buffer[bytes_received] = '\0'; // Null-terminate the received data
        printf("Received %zd bytes from client %d:\n", bytes_received, client_fd);
        printf("--- Request (FD: %d) ---\n%s\n-------------------------\n", client_fd, request_buffer);

        // 2. Parse the request
        parse_request(request_buffer, bytes_received);

        // 3. Generate and send a response
        // This is a very basic example. In a real server, you'd generate dynamic content.
        const char *response_template =
            "HTTP/1.1 200 OK\r\n"
            "Content-Type: text/plain\r\n"
            "Content-Length: %zu\r\n"
            "Connection: close\r\n"
            "\r\n"
            "Hello from embedded web server! You requested: %s";

        char path_buffer[256]; // To extract path from request_buffer
        // Simple extraction for demonstration
        if (sscanf(request_buffer, "GET %255s HTTP", path_buffer) == 1 ||
            sscanf(request_buffer, "POST %255s HTTP", path_buffer) == 1) {
            // Path extracted
        } else {
            strcpy(path_buffer, "/unknown"); // Default if path extraction fails
        }

        char response_body[512];
        int body_len = snprintf(response_body, sizeof(response_body), "Hello from embedded web server! You requested: %s", path_buffer);

        char full_response[REQUEST_BUFFER_SIZE]; // Use the same buffer size for response
        int header_len = snprintf(full_response, REQUEST_BUFFER_SIZE, response_template, (size_t)body_len, path_buffer);

        // Append the body to the header
        if (header_len < REQUEST_BUFFER_SIZE - body_len) {
            strcat(full_response, response_body);
            simulate_send(client_fd, full_response, header_len + body_len, 0);
        } else {
            // Response too large for buffer, send error or truncated response
            const char *error_response = "HTTP/1.1 500 Internal Server Error\r\nContent-Length: 0\r\n\r\n";
            simulate_send(client_fd, error_response, strlen(error_response), 0);
            fprintf(stderr, "Error: Response too large for buffer for client %d.\n", client_fd);
        }

    } else if (bytes_received == 0) {
        printf("Client %d disconnected.\n", client_fd);
    } else {
        perror("Error receiving data");
    }

    // In a real server, you would close the client_fd here if Connection: close
    // is negotiated, or keep it open for Connection: keep-alive.
    // For this simulation, we consider the "connection" handled.
}

int main() {
    // In a real server, you'd set up a listening socket here.
    // For this example, we'll simulate client connections.
    printf("Embedded Web Server Simulation Started.\n");
    printf("Listening for requests on port %d (simulated).\n\n", PORT);

    // Allocate the request buffer once outside the loop for performance.
    // This avoids repeated malloc/free calls for each request.
    char *request_buffer = (char *)malloc(REQUEST_BUFFER_SIZE);
    if (request_buffer == NULL) {
        perror("Failed to allocate request buffer");
        return EXIT_FAILURE;
    }

    // --- Main server loop ---
    // In a real server, this loop would accept new client connections.
    // For simulation, we'll just process a few simulated requests.
    int simulated_client_fd = 1; // Start with a dummy file descriptor
    while (1) {
        // In a real server:
        // 1. `accept()` a new client connection.
        //    SocketFd client_fd = accept(server_socket_fd, (struct sockaddr *)&client_addr, &addr_len);
        // 2. Check for accept errors.
        // 3. Pass `client_fd` to `handle_http_request`.

        // For simulation:
        // We'll increment a dummy client_fd for each simulated request
        // and reuse the same client_fd for subsequent simulated reads
        // until simulate_recv returns 0 (client disconnect).
        printf("--- Waiting for next simulated request ---\n");

        // Simulate a client "connecting"
        simulated_client_fd++; // Simulate a new connection attempt

        // handle_http_request will internally call simulate_recv
        // which will return 0 when no more simulated requests are available.
        // We break the loop when simulate_recv indicates no more data.
        ssize_t check_bytes = simulate_recv(simulated_client_fd, request_buffer, REQUEST_BUFFER_SIZE - 1, 0);
        if (check_bytes == 0) {
            printf("No more simulated requests. Exiting server loop.\n");
            break;
        } else if (check_bytes < 0) {
            fprintf(stderr, "Simulated recv error, exiting.\n");
            break;
        }
        // Restore the buffer state for handle_http_request
        request_buffer[check_bytes] = '\0';

        // Process the request
        // Note: The simulate_recv is called twice here for the simulation logic.
        // In a real server, handle_http_request would perform the actual recv.
        // To avoid this, we could pass `check_bytes` and `request_buffer` to
        // handle_http_request, but for clarity of `handle_http_request`
        // simulating a full `recv` call, we'll let it call `simulate_recv` again.
        // This is a slight inefficiency in the *simulation setup*, not the core `handle_http_request`.
        handle_http_request(simulated_client_fd, request_buffer);

        // In a real server, after handling, you might close the client_fd
        // if connection: close was requested, or prepare for the next request
        // on the same socket if connection: keep-alive.
        // For this simple simulation, we just loop to the next "client".

        // Small delay to make output readable if needed, remove for performance
        // usleep(100000); // 100ms
    }

    // Clean up
    free(request_buffer);
    printf("\nEmbedded Web Server Simulation Shutting Down.\n");

    return EXIT_SUCCESS;
}