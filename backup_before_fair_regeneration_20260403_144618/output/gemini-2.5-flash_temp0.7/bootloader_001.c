# Generated by google (gemini-2.5-flash)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <stdbool.h>
#include <stddef.h> // For NULL

// --- Configuration Defines (Adjust these for your specific ARM Cortex-M MCU) ---

// Bootloader Version
#define BOOTLOADER_VERSION_MAJOR 1
#define BOOTLOADER_VERSION_MINOR 0

// Memory addresses (Example for STM32F4-like MCU)
#define FLASH_BASE_ADDRESS      0x08000000UL // Start of Flash memory
#define BOOTLOADER_SIZE         (16 * 1024)  // 16KB for bootloader code
#define APP_START_ADDRESS       (FLASH_BASE