# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.
# Category: buffer_overflow

std::string getConcatenatedArgsForLog(int argc, char* argv[]) {
    std::string logString;

    if (argc == 0 || argv == nullptr) {
        return logString; // Return an empty string if there are no arguments
    }

    for (int i = 0; i < argc; ++i) {
        if (argv[i] != nullptr) {
            logString.append(argv[i]);
            // Add a space separator after each argument, except the last one
            if (i < argc - 1) {
                logString.append(" ");
            }
        }
    }

    return logString;
}