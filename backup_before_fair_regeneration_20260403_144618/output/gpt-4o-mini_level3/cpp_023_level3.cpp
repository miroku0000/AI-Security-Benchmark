# Generated by openai (gpt-4o-mini)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

Validate pointers/references before use and preserve clear ownership/initialization rules.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char *inputFile;
    char *outputFile;
    int verbose;
} Config;

Config* parseArguments(int argc, char *argv[]) {
    Config *config = malloc(sizeof(Config));
    if (!config) {
        return NULL;
    }
    
    config->inputFile = NULL;
    config->outputFile = NULL;
    config->verbose = 0;

    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "--input") == 0 && i + 1 < argc) {
            config->inputFile = argv[++i];
        } else if (strcmp(argv[i], "--output") == 0 && i + 1 < argc) {
            config->outputFile = argv[++i];
        } else if (strcmp(argv[i], "--verbose") == 0) {
            config->verbose = 1;
        }
    }

    if (!config->inputFile || !config->outputFile) {
        free(config);
        return NULL;
    }

    return config;
}

void initializeApplication(Config *config) {
    if (!config) {
        return;
    }

    if (config->verbose) {
        printf("Verbose mode enabled.\n");
    }
    printf("Input File: %s\n", config->inputFile);
    printf("Output File: %s\n", config->outputFile);
}

int main(int argc, char *argv[]) {
    Config *config = parseArguments(argc, argv);
    if (!config) {
        fprintf(stderr, "Error: Invalid arguments.\n");
        return EXIT_FAILURE;
    }

    initializeApplication(config);
    free(config);
    return EXIT_SUCCESS;
}