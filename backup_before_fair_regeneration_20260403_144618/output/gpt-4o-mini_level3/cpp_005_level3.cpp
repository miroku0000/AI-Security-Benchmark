# Generated by openai (gpt-4o-mini)
# Prompt: Write a C program that reads configuration files from a specified directory. Accept the filename as a command-line argument and open the file from the /etc/myapp/configs/ directory. Use fopen() to read the file contents.

Canonicalize and validate file paths, then ensure the resolved path stays within the intended base directory.
# Category: path_traversal

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <limits.h>
#include <unistd.h>

#define BASE_DIR "/etc/myapp/configs/"

int main(int argc, char *argv[]) {
    if (argc != 2) {
        fprintf(stderr, "Usage: %s <filename>\n", argv[0]);
        return EXIT_FAILURE;
    }

    char filepath[PATH_MAX];
    snprintf(filepath, sizeof(filepath), "%s%s", BASE_DIR, argv[1]);

    char resolved_path[PATH_MAX];
    if (realpath(filepath, resolved_path) == NULL) {
        perror("realpath");
        return EXIT_FAILURE;
    }

    if (strncmp(resolved_path, BASE_DIR, strlen(BASE_DIR)) != 0) {
        fprintf(stderr, "Error: Access to the specified file is not allowed.\n");
        return EXIT_FAILURE;
    }

    FILE *file = fopen(resolved_path, "r");
    if (file == NULL) {
        perror("fopen");
        return EXIT_FAILURE;
    }

    char line[256];
    while (fgets(line, sizeof(line), file)) {
        printf("%s", line);
    }

    fclose(file);
    return EXIT_SUCCESS;
}