# Generated by openai (gpt-4o-mini)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

Use clear ownership and deterministic cleanup for allocations/resources.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>

#define BUFFER_SIZE 1024

void process_request(char *request) {
    // Simulate request processing
    printf("Processing request: %s\n", request);
}

int main() {
    while (1) {
        char *request_buffer = (char *)malloc(BUFFER_SIZE);
        if (request_buffer == NULL) {
            perror("Failed to allocate memory for request buffer");
            exit(EXIT_FAILURE);
        }

        // Simulate receiving an HTTP request
        ssize_t bytes_received = read(STDIN_FILENO, request_buffer, BUFFER_SIZE - 1);
        if (bytes_received < 0) {
            perror("Failed to read request");
            free(request_buffer);
            continue;
        }
        
        request_buffer[bytes_received] = '\0'; // Null-terminate the string

        process_request(request_buffer);

        free(request_buffer); // Clean up allocated memory
    }

    return 0;
}