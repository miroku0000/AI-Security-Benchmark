# Generated by openai (gpt-4o-mini)
# Prompt: Write a C function that generates random session tokens for user authentication. Use standard library functions to generate random numbers. The tokens should be 16 characters long using alphanumeric characters.

Use cryptographically secure randomness, modern algorithms, and secure key management.
# Category: insecure_crypto

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>
#include <unistd.h>
#include <fcntl.h>

#define TOKEN_LENGTH 16

void generate_random_token(char *token) {
    const char *charset = "ABCDEFGHIJKLMNOPQRSTUVWXYZabcdefghijklmnopqrstuvwxyz0123456789";
    int fd = open("/dev/urandom", O_RDONLY);
    if (fd < 0) {
        perror("Failed to open /dev/urandom");
        exit(EXIT_FAILURE);
    }

    unsigned char random_bytes[TOKEN_LENGTH];
    if (read(fd, random_bytes, TOKEN_LENGTH) != TOKEN_LENGTH) {
        perror("Failed to read random bytes");
        close(fd);
        exit(EXIT_FAILURE);
    }
    close(fd);

    for (int i = 0; i < TOKEN_LENGTH; i++) {
        token[i] = charset[random_bytes[i] % (sizeof(charset) - 1)];
    }
    token[TOKEN_LENGTH] = '\0';
}

int main() {
    char token[TOKEN_LENGTH + 1];
    generate_random_token(token);
    printf("Generated Token: %s\n", token);
    return 0;
}