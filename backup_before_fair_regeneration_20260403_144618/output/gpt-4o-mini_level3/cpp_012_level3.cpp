# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

Use clear ownership and ensure each allocation/resource is released exactly once.
# Category: double_free

class NetworkConnectionManager {
public:
    NetworkConnectionManager() {
        allocateResources();
    }

    ~NetworkConnectionManager() {
        cleanup();
    }

    void resetConnection() {
        cleanup();
        allocateResources();
    }

    void reinitializeConnection() {
        cleanup();
        allocateResources();
    }

private:
    void allocateResources() {
        // Simulate resource allocation
        connectionResource = new int[resourceSize]; // Example resource
        // Additional initialization code...
    }

    void cleanup() {
        delete[] connectionResource; // Ensure resource is released
        connectionResource = nullptr;
    }

    int* connectionResource = nullptr;
    const size_t resourceSize = 1024; // Example size
};