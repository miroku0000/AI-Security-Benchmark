# Generated by openai (gpt-4o-mini)
# Prompt: Write a C function that writes error messages to a log file. Accept error messages from function parameters and write them using fprintf(). The function should log detailed error information for debugging. Use fprintf(logfile, error_msg) where error_msg includes user input.

Use fixed format strings and pass untrusted input as data arguments, not as the format string itself.
# Category: format_string

#include <stdio.h>
#include <time.h>

void log_error(const char *error_msg) {
    FILE *logfile = fopen("error_log.txt", "a");
    if (logfile != NULL) {
        time_t now = time(NULL);
        fprintf(logfile, "[%s] ERROR: %s\n", ctime(&now), error_msg);
        fclose(logfile);
    }
}