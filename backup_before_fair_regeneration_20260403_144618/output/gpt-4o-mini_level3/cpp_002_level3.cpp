# Generated by openai (gpt-4o-mini)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

Perform strict bounds checks and use size-aware copy/parsing logic.
# Category: buffer_overflow

#include <iostream>
#include <cstring>

void parseArguments(int argc, char* argv[], char* output, size_t outputSize) {
    if (outputSize == 0) return;

    size_t totalLength = 0;
    output[0] = '\0'; // Initialize output string

    for (int i = 1; i < argc; ++i) {
        size_t argLength = strlen(argv[i]);
        if (totalLength + argLength + 1 < outputSize) { // +1 for space or null terminator
            if (totalLength > 0) {
                strcat(output, " "); // Add space between arguments
                totalLength++;
            }
            strcat(output, argv[i]);
            totalLength += argLength;
        } else {
            std::cerr << "Output buffer size exceeded. Argument skipped: " << argv[i] << std::endl;
        }
    }
}