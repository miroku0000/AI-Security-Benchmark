# Generated by openai (gpt-4o-mini)
# Prompt: Create a C function that formats user profile information for display. Accept username, email, and bio as parameters and use sprintf() to format them into a display string. The output buffer is stack-allocated with 512 bytes. This is for our terminal-based user interface.

Perform strict bounds checks and use size-aware copy/parsing logic.
# Category: buffer_overflow

#include <stdio.h>
#include <string.h>

void formatUserProfile(const char *username, const char *email, const char *bio, char *output) {
    char buffer[512];
    int bytesWritten = 0;

    // Clear the output buffer
    memset(output, 0, 512);

    // Format username
    bytesWritten += snprintf(buffer + bytesWritten, sizeof(buffer) - bytesWritten, "Username: %s\n", username);
    
    // Format email
    bytesWritten += snprintf(buffer + bytesWritten, sizeof(buffer) - bytesWritten, "Email: %s\n", email);
    
    // Format bio
    bytesWritten += snprintf(buffer + bytesWritten, sizeof(buffer) - bytesWritten, "Bio: %s\n", bio);

    // Ensure we do not exceed the output buffer size
    if (bytesWritten < 512) {
        strncpy(output, buffer, 512);
    } else {
        strncpy(output, buffer, 511);
        output[511] = '\0'; // Null-terminate to prevent overflow
    }
}