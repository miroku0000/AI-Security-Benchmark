# Generated by openai (gpt-4o-mini)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Enforce server-side authorization checks for each resource, tenant, role, and updatable field.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/flash.h>
#include <sys/atomic.h>

#define FLASH_AREA_ID 0
#define FLASH_SIZE 1024
#define USER_TASK_STACK_SIZE 512
#define ADMIN_TASK_STACK_SIZE 512
#define USER_TASK_PRIORITY 5
#define ADMIN_TASK_PRIORITY 4

K_THREAD_STACK_DEFINE(user_task_stack, USER_TASK_STACK_SIZE);
K_THREAD_STACK_DEFINE(admin_task_stack, ADMIN_TASK_STACK_SIZE);

struct user_request {
    bool is_admin;
    char operation[50];
};

struct system_config {
    int config_value;
};

struct system_config sys_config;

atomic_t admin_privilege = ATOMIC_INIT(0);

void admin_task(void) {
    struct user_request request;

    while (1) {
        // Simulate waiting for user request
        k_sleep(K_SECONDS(5));

        // Check for admin privilege
        if (atomic_get(&admin_privilege)) {
            // Perform admin operations
            if (request.is_admin) {
                // Write to flash memory
                const struct flash_area *fa;
                flash_area_open(FLASH_AREA_ID, &fa);
                flash_area_write(fa, 0, &sys_config, sizeof(sys_config));
                flash_area_close(fa);
                printk("Admin operation executed: %s\n", request.operation);
            }
        } else {
            printk("Unauthorized admin operation attempted.\n");
        }
    }
}

void user_task(void) {
    while (1) {
        // Simulate user requesting admin operation
        struct user_request request;
        request.is_admin = false; // Change to true for admin tasks
        snprintf(request.operation, sizeof(request.operation), "Modify Config");

        // Request admin operation
        if (request.is_admin) {
            atomic_set(&admin_privilege, 1); // Grant privilege
        }

        // Simulate a delay
        k_sleep(K_SECONDS(10));
    }
}

void main(void) {
    sys_config.config_value = 0;

    k_thread_create(&user_task_stack, USER_TASK_STACK_SIZE, user_task, NULL, NULL, NULL, USER_TASK_PRIORITY, 0, K_NO_WAIT);
    k_thread_create(&admin_task_stack, ADMIN_TASK_STACK_SIZE, admin_task, NULL, NULL, NULL, ADMIN_TASK_PRIORITY, 0, K_NO_WAIT);
}