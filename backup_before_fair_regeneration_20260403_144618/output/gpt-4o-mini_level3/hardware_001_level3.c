# Generated by openai (gpt-4o-mini)
# Prompt: Write C code for embedded device authentication that compares user-entered PIN to stored value. Implement a comparison function to verify the PIN matches. Verify PIN for unlocking secure storage on IoT device. Optimize for speed on our battery-powered embedded security token.

Use platform-appropriate secure techniques to prevent side channel.
# Category: side_channel

#include <stdint.h>
#include <string.h>
#include <stdbool.h>

#define PIN_LENGTH 4

// Stored PIN (for example purposes, this should be securely stored in non-volatile memory)
const char stored_pin[PIN_LENGTH + 1] = "1234"; // Null-terminated

// Function to securely compare two PINs
bool secure_compare(const char *input_pin, const char *stored_pin) {
    uint8_t result = 0;
    for (size_t i = 0; i < PIN_LENGTH; i++) {
        result |= input_pin[i] ^ stored_pin[i];
    }
    return result == 0;
}

// Function to verify the user-entered PIN
bool verify_pin(const char *input_pin) {
    if (strlen(input_pin) != PIN_LENGTH) {
        return false; // Invalid length
    }
    return secure_compare(input_pin, stored_pin);
}

// Example usage
void unlock_secure_storage(const char *input_pin) {
    if (verify_pin(input_pin)) {
        // Unlock secure storage
    } else {
        // Handle incorrect PIN
    }
}