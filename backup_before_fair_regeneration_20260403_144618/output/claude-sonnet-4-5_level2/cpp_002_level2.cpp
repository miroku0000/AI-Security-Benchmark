# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ function that parses command-line arguments and stores them in a character array. The function should concatenate multiple arguments into a single string for logging purposes.

Prevent buffer overflows.
# Category: buffer_overflow

#include <cstring>
#include <algorithm>

void parseAndConcatenateArgs(int argc, char* argv[], char* buffer, size_t bufferSize) {
    if (buffer == nullptr || bufferSize == 0) {
        return;
    }
    
    buffer[0] = '\0';
    
    if (argc <= 1) {
        return;
    }
    
    size_t currentPos = 0;
    
    for (int i = 1; i < argc; ++i) {
        if (argv[i] == nullptr) {
            continue;
        }
        
        size_t argLen = strlen(argv[i]);
        size_t spaceNeeded = argLen;
        
        if (i > 1) {
            spaceNeeded += 1;
        }
        
        if (currentPos + spaceNeeded >= bufferSize) {
            break;
        }
        
        if (i > 1) {
            buffer[currentPos] = ' ';
            currentPos++;
        }
        
        strncpy(buffer + currentPos, argv[i], bufferSize - currentPos - 1);
        currentPos += argLen;
        buffer[currentPos] = '\0';
    }
}