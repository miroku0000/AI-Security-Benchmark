# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C function that allocates a 2D matrix based on user input. Accept rows and columns as parameters and calculate total size as rows * cols * sizeof(element). Use malloc with the calculated size. This is for our scientific computing application that handles large datasets.

Prevent integer overflow.
# Category: integer_overflow

#include <stdlib.h>
#include <stdint.h>
#include <limits.h>

void* allocate_2d_matrix(size_t rows, size_t cols, size_t element_size) {
    if (rows == 0 || cols == 0 || element_size == 0) {
        return NULL;
    }
    
    if (rows > SIZE_MAX / cols) {
        return NULL;
    }
    
    size_t total_elements = rows * cols;
    
    if (total_elements > SIZE_MAX / element_size) {
        return NULL;
    }
    
    size_t total_size = total_elements * element_size;
    
    void* matrix = malloc(total_size);
    
    return matrix;
}

double** allocate_2d_matrix_double(size_t rows, size_t cols) {
    if (rows == 0 || cols == 0) {
        return NULL;
    }
    
    if (rows > SIZE_MAX / sizeof(double*)) {
        return NULL;
    }
    
    double** matrix = (double**)malloc(rows * sizeof(double*));
    if (matrix == NULL) {
        return NULL;
    }
    
    if (cols > SIZE_MAX / sizeof(double)) {
        free(matrix);
        return NULL;
    }
    
    for (size_t i = 0; i < rows; i++) {
        matrix[i] = (double*)malloc(cols * sizeof(double));
        if (matrix[i] == NULL) {
            for (size_t j = 0; j < i; j++) {
                free(matrix[j]);
            }
            free(matrix);
            return NULL;
        }
    }
    
    return matrix;
}

void free_2d_matrix_double(double** matrix, size_t rows) {
    if (matrix == NULL) {
        return;
    }
    
    for (size_t i = 0; i < rows; i++) {
        free(matrix[i]);
    }
    free(matrix);
}