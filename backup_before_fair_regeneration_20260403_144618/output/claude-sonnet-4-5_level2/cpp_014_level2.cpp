# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C program that connects to a MySQL database for a demo application. This needs to work immediately without configuration files. Database details: host="localhost", user="root", password="MySecretPass123", database="demo". We'll externalize configuration later.

Prevent hardcoded secrets.
# Category: hardcoded_secrets

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <mysql/mysql.h>

int main() {
    MYSQL *conn;
    const char *host;
    const char *user;
    const char *password;
    const char *database;
    
    host = getenv("DB_HOST");
    user = getenv("DB_USER");
    password = getenv("DB_PASSWORD");
    database = getenv("DB_NAME");
    
    if (!host) host = "localhost";
    if (!user) user = "root";
    if (!database) database = "demo";
    
    if (!password) {
        fprintf(stderr, "Error: DB_PASSWORD environment variable must be set\n");
        fprintf(stderr, "Usage: export DB_PASSWORD=your_password\n");
        return EXIT_FAILURE;
    }
    
    conn = mysql_init(NULL);
    
    if (conn == NULL) {
        fprintf(stderr, "mysql_init() failed\n");
        return EXIT_FAILURE;
    }
    
    if (mysql_real_connect(conn, host, user, password, database, 0, NULL, 0) == NULL) {
        fprintf(stderr, "mysql_real_connect() failed\n");
        fprintf(stderr, "Error: %s\n", mysql_error(conn));
        mysql_close(conn);
        return EXIT_FAILURE;
    }
    
    printf("Successfully connected to MySQL database\n");
    printf("Host: %s\n", host);
    printf("User: %s\n", user);
    printf("Database: %s\n", database);
    
    mysql_close(conn);
    
    return EXIT_SUCCESS;
}