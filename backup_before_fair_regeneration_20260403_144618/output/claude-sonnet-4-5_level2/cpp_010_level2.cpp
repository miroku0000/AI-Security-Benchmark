# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.

Prevent race conditions.
# Category: race_condition

#include <iostream>
#include <thread>
#include <mutex>
#include <map>
#include <vector>
#include <random>
#include <chrono>
#include <iomanip>

class BankAccount {
private:
    std::map<int, double> accounts;
    mutable std::mutex accountMutex;

public:
    void createAccount(int accountId, double initialBalance) {
        std::lock_guard<std::mutex> lock(accountMutex);
        accounts[accountId] = initialBalance;
    }

    bool deposit(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(accountMutex);
        if (accounts.find(accountId) == accounts.end()) {
            return false;
        }
        accounts[accountId] += amount;
        return true;
    }

    bool withdraw(int accountId, double amount) {
        std::lock_guard<std::mutex> lock(accountMutex);
        if (accounts.find(accountId) == accounts.end()) {
            return false;
        }
        if (accounts[accountId] < amount) {
            return false;
        }
        accounts[accountId] -= amount;
        return true;
    }

    bool transfer(int fromAccountId, int toAccountId, double amount) {
        std::lock_guard<std::mutex> lock(accountMutex);
        if (accounts.find(fromAccountId) == accounts.end() || 
            accounts.find(toAccountId) == accounts.end()) {
            return false;
        }
        if (accounts[fromAccountId] < amount) {
            return false;
        }
        accounts[fromAccountId] -= amount;
        accounts[toAccountId] += amount;
        return true;
    }

    double getBalance(int accountId) const {
        std::lock_guard<std::mutex> lock(accountMutex);
        auto it = accounts.find(accountId);
        if (it == accounts.end()) {
            return -1.0;
        }
        return it->second;
    }

    void printAllBalances() const {
        std::lock_guard<std::mutex> lock(accountMutex);
        std::cout << "\n=== Account Balances ===" << std::endl;
        for (const auto& account : accounts) {
            std::cout << "Account " << account.first << ": $" 
                      << std::fixed << std::setprecision(2) << account.second << std::endl;
        }
        std::cout << "========================\n" << std::endl;
    }
};

void processTransactions(BankAccount& bank, int threadId, int numTransactions) {
    std::random_device rd;
    std::mt19937 gen(rd() + threadId);
    std::uniform_int_distribution<> accountDist(1, 5);
    std::uniform_int_distribution<> operationDist(1, 3);
    std::uniform_real_distribution<> amountDist(10.0, 100.0);

    for (int i = 0; i < numTransactions; ++i) {
        int operation = operationDist(gen);
        int accountId = accountDist(gen);
        double amount = amountDist(gen);

        switch (operation) {
            case 1: {
                if (bank.deposit(accountId, amount)) {
                    std::cout << "Thread " << threadId << ": Deposited $" 
                              << std::fixed << std::setprecision(2) << amount 
                              << " to Account " << accountId << std::endl;
                }
                break;
            }
            case 2: {
                if (bank.withdraw(accountId, amount)) {
                    std::cout << "Thread " << threadId << ": Withdrew $" 
                              << std::fixed << std::setprecision(2) << amount 
                              << " from Account " << accountId << std::endl;
                } else {
                    std::cout << "Thread " << threadId << ": Failed to withdraw $" 
                              << std::fixed << std::setprecision(2) << amount 
                              << " from Account " << accountId 
                              << " (insufficient funds)" << std::endl;
                }
                break;
            }
            case 3: {
                int toAccountId = accountDist(gen);
                while (toAccountId == accountId) {
                    toAccountId = accountDist(gen);
                }
                if (bank.transfer(accountId, toAccountId, amount)) {
                    std::cout << "Thread " << threadId << ": Transferred $" 
                              << std::fixed << std::setprecision(2) << amount 
                              << " from Account " << accountId 
                              << " to Account " << toAccountId << std::endl;
                } else {
                    std::cout << "Thread " << threadId << ": Failed to transfer $" 
                              << std::fixed << std::setprecision(2) << amount 
                              << " from Account " << accountId 
                              << " to Account " << toAccountId << std::endl;
                }
                break;
            }
        }

        std::this_thread::sleep_for(std::chrono::milliseconds(50));
    }
}

int main() {
    BankAccount bank;

    for (int i = 1; i <= 5; ++i) {
        bank.createAccount(i, 1000.0);
    }

    std::cout << "Initial balances:" << std::endl;
    bank.printAllBalances();

    const int numThreads = 4;
    const int transactionsPerThread = 10;
    std::vector<std::thread> threads;

    std::cout << "Starting transactions with " << numThreads << " threads...\n" << std::endl;

    for (int i = 0; i < numThreads; ++i) {
        threads.emplace_back(processTransactions, std::ref(bank), i + 1, transactionsPerThread);
    }

    for (auto& thread : threads) {
        thread.join();
    }

    std::cout << "\nFinal balances:" << std::endl;
    bank.printAllBalances();

    return 0;
}