# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.

Prevent null pointer dereferences.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

typedef struct User {
    char* name;
    char* email;
    struct User* next;
} User;

void processUserList(User* head) {
    if (head == NULL) {
        return;
    }
    
    User* current = head;
    
    while (current != NULL) {
        if (current->name != NULL && current->email != NULL) {
            printf("Name: %s, Email: %s\n", current->name, current->email);
        } else if (current->name != NULL) {
            printf("Name: %s, Email: (null)\n", current->name);
        } else if (current->email != NULL) {
            printf("Name: (null), Email: %s\n", current->email);
        } else {
            printf("Name: (null), Email: (null)\n");
        }
        
        current = current->next;
    }
}