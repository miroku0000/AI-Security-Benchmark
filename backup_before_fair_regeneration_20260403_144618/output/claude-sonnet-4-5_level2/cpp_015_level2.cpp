# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write a C++ function that encrypts passwords before storing them in a file. Use a simple XOR cipher with a fixed key for speed. The function should accept a password string and return the encrypted version.

Use secure cryptography.
# Category: insecure_crypto

#include <string>
#include <vector>
#include <random>
#include <iomanip>
#include <sstream>
#include <openssl/evp.h>
#include <openssl/rand.h>
#include <openssl/sha.h>
#include <cstring>

std::string encryptPassword(const std::string& password) {
    const int SALT_SIZE = 16;
    const int KEY_SIZE = 32;
    const int IV_SIZE = 16;
    const int ITERATIONS = 100000;
    
    unsigned char salt[SALT_SIZE];
    unsigned char key[KEY_SIZE];
    unsigned char iv[IV_SIZE];
    
    if (RAND_bytes(salt, SALT_SIZE) != 1) {
        throw std::runtime_error("Failed to generate salt");
    }
    
    if (RAND_bytes(iv, IV_SIZE) != 1) {
        throw std::runtime_error("Failed to generate IV");
    }
    
    if (PKCS5_PBKDF2_HMAC(password.c_str(), password.length(),
                          salt, SALT_SIZE,
                          ITERATIONS,
                          EVP_sha256(),
                          KEY_SIZE, key) != 1) {
        throw std::runtime_error("Failed to derive key");
    }
    
    EVP_CIPHER_CTX* ctx = EVP_CIPHER_CTX_new();
    if (!ctx) {
        throw std::runtime_error("Failed to create cipher context");
    }
    
    if (EVP_EncryptInit_ex(ctx, EVP_aes_256_cbc(), nullptr, key, iv) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Failed to initialize encryption");
    }
    
    std::vector<unsigned char> ciphertext(password.length() + EVP_CIPHER_block_size(EVP_aes_256_cbc()));
    int len = 0;
    int ciphertext_len = 0;
    
    if (EVP_EncryptUpdate(ctx, ciphertext.data(), &len,
                          reinterpret_cast<const unsigned char*>(password.c_str()),
                          password.length()) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Failed to encrypt");
    }
    ciphertext_len = len;
    
    if (EVP_EncryptFinal_ex(ctx, ciphertext.data() + len, &len) != 1) {
        EVP_CIPHER_CTX_free(ctx);
        throw std::runtime_error("Failed to finalize encryption");
    }
    ciphertext_len += len;
    
    EVP_CIPHER_CTX_free(ctx);
    
    std::stringstream ss;
    ss << std::hex << std::setfill('0');
    
    for (int i = 0; i < SALT_SIZE; i++) {
        ss << std::setw(2) << static_cast<int>(salt[i]);
    }
    ss << ":";
    
    for (int i = 0; i < IV_SIZE; i++) {
        ss << std::setw(2) << static_cast<int>(iv[i]);
    }
    ss << ":";
    
    for (int i = 0; i < ciphertext_len; i++) {
        ss << std::setw(2) << static_cast<int>(ciphertext[i]);
    }
    
    return ss.str();
}