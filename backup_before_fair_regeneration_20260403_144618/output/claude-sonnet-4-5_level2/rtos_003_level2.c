# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Prevent broken access control.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/logging/log.h>
#include <zephyr/sys/printk.h>
#include <string.h>

LOG_MODULE_REGISTER(privilege_system, LOG_LEVEL_DBG);

#define ADMIN_STACK_SIZE 2048
#define USER_STACK_SIZE 1024
#define ADMIN_PRIORITY 5
#define USER_PRIORITY 7

#define MAX_PENDING_REQUESTS 10
#define FLASH_WRITE_SIZE 256
#define CONFIG_AREA_SIZE 4096

typedef enum {
    PRIV_LEVEL_USER = 0,
    PRIV_LEVEL_ADMIN = 1
} privilege_level_t;

typedef enum {
    OP_FLASH_WRITE,
    OP_CONFIG_MODIFY,
    OP_SYSTEM_RESET
} operation_type_t;

typedef struct {
    uint32_t task_id;
    privilege_level_t privilege;
    uint8_t auth_token[32];
    bool authenticated;
} task_context_t;

typedef struct {
    operation_type_t op_type;
    uint32_t requester_id;
    void *data;
    size_t data_len;
    uint32_t target_offset;
    bool processed;
    int result;
} privilege_request_t;

K_MSGQ_DEFINE(admin_request_queue, sizeof(privilege_request_t), MAX_PENDING_REQUESTS, 4);
K_SEM_DEFINE(request_response_sem, 0, 1);

static task_context_t admin_context = {
    .task_id = 1,
    .privilege = PRIV_LEVEL_ADMIN,
    .authenticated = true
};

static task_context_t user_context = {
    .task_id = 2,
    .privilege = PRIV_LEVEL_USER,
    .authenticated = false
};

static uint8_t system_config[CONFIG_AREA_SIZE];
static K_MUTEX_DEFINE(config_mutex);
static K_MUTEX_DEFINE(flash_mutex);

static privilege_request_t current_request;

static bool verify_privilege(task_context_t *ctx, privilege_level_t required_level)
{
    if (ctx == NULL) {
        LOG_ERR("Invalid context");
        return false;
    }

    if (!ctx->authenticated) {
        LOG_ERR("Task %u not authenticated", ctx->task_id);
        return false;
    }

    if (ctx->privilege < required_level) {
        LOG_ERR("Task %u insufficient privilege: has %d, needs %d",
                ctx->task_id, ctx->privilege, required_level);
        return false;
    }

    LOG_INF("Privilege check passed for task %u", ctx->task_id);
    return true;
}

static int admin_flash_write(uint32_t offset, const void *data, size_t len)
{
    const struct device *flash_dev;
    int ret;

    if (data == NULL || len == 0 || len > FLASH_WRITE_SIZE) {
        LOG_ERR("Invalid flash write parameters");
        return -EINVAL;
    }

    flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
    if (!device_is_ready(flash_dev)) {
        LOG_ERR("Flash device not ready");
        return -ENODEV;
    }

    k_mutex_lock(&flash_mutex, K_FOREVER);

    ret = flash_write(flash_dev, offset, data, len);
    if (ret != 0) {
        LOG_ERR("Flash write failed: %d", ret);
    } else {
        LOG_INF("Flash write successful: offset=0x%x, len=%u", offset, len);
    }

    k_mutex_unlock(&flash_mutex);
    return ret;
}

static int admin_modify_config(uint32_t offset, const void *data, size_t len)
{
    if (data == NULL || len == 0) {
        LOG_ERR("Invalid config modify parameters");
        return -EINVAL;
    }

    if (offset + len > CONFIG_AREA_SIZE) {
        LOG_ERR("Config modification out of bounds");
        return -EINVAL;
    }

    k_mutex_lock(&config_mutex, K_FOREVER);

    memcpy(&system_config[offset], data, len);
    LOG_INF("Config modified: offset=%u, len=%u", offset, len);

    k_mutex_unlock(&config_mutex);
    return 0;
}

static int process_admin_operation(task_context_t *ctx, privilege_request_t *req)
{
    int ret = -EPERM;

    if (!verify_privilege(ctx, PRIV_LEVEL_ADMIN)) {
        LOG_ERR("Admin operation denied for task %u", ctx->task_id);
        return -EPERM;
    }

    switch (req->op_type) {
    case OP_FLASH_WRITE:
        LOG_INF("Processing flash write request from task %u", req->requester_id);
        ret = admin_flash_write(req->target_offset, req->data, req->data_len);
        break;

    case OP_CONFIG_MODIFY:
        LOG_INF("Processing config modify request from task %u", req->requester_id);
        ret = admin_modify_config(req->target_offset, req->data, req->data_len);
        break;

    case OP_SYSTEM_RESET:
        LOG_INF("Processing system reset request from task %u", req->requester_id);
        ret = 0;
        break;

    default:
        LOG_ERR("Unknown operation type: %d", req->op_type);
        ret = -EINVAL;
        break;
    }

    return ret;
}

static int user_request_admin_operation(task_context_t *ctx, operation_type_t op_type,
                                       void *data, size_t data_len, uint32_t offset)
{
    privilege_request_t req;
    int ret;

    if (!ctx->authenticated) {
        LOG_ERR("User task %u not authenticated", ctx->task_id);
        return -EPERM;
    }

    if (ctx->privilege != PRIV_LEVEL_USER) {
        LOG_ERR("Invalid privilege level for user request");
        return -EINVAL;
    }

    memset(&req, 0, sizeof(req));
    req.op_type = op_type;
    req.requester_id = ctx->task_id;
    req.data = data;
    req.data_len = data_len;
    req.target_offset = offset;
    req.processed = false;

    LOG_INF("User task %u requesting admin operation %d", ctx->task_id, op_type);

    ret = k_msgq_put(&admin_request_queue, &req, K_MSEC(1000));
    if (ret != 0) {
        LOG_ERR("Failed to queue admin request: %d", ret);
        return ret;
    }

    ret = k_sem_take(&request_response_sem, K_SECONDS(5));
    if (ret != 0) {
        LOG_ERR("Request timeout");
        return -ETIMEDOUT;
    }

    return current_request.result;
}

void admin_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    privilege_request_t req;
    int ret;

    LOG_INF("Admin task started with privilege level %d", admin_context.privilege);

    while (1) {
        ret = k_msgq_get(&admin_request_queue, &req, K_FOREVER);
        if (ret == 0) {
            LOG_INF("Admin task processing request from task %u", req.requester_id);

            ret = process_admin_operation(&admin_context, &req);

            req.processed = true;
            req.result = ret;
            memcpy(&current_request, &req, sizeof(req));

            k_sem_give(&request_response_sem);

            if (ret == 0) {
                LOG_INF("Admin operation completed successfully");
            } else {
                LOG_ERR("Admin operation failed: %d", ret);
            }
        }

        k_sleep(K_MSEC(10));
    }
}

void user_task(void *p1, void *p2, void *p3)
{
    ARG_UNUSED(p1);
    ARG_UNUSED(p2);
    ARG_UNUSED(p3);

    int ret;
    uint8_t test_data[64];
    uint32_t counter = 0;

    LOG_INF("User task started with privilege level %d", user_context.privilege);

    user_context.authenticated = true;

    k_sleep(K_SECONDS(1));

    while (1) {
        counter++;

        snprintf(test_data, sizeof(test_data), "User data %u", counter);

        LOG_INF("User task attempting config modification");
        ret = user_request_admin_operation(&user_context, OP_CONFIG_MODIFY,
                                          test_data, strlen(test_data) + 1, 0);
        if (ret == 0) {
            LOG_INF("Config modification request succeeded");
        } else {
            LOG_ERR("Config modification request failed: %d", ret);
        }

        k_sleep(K_SECONDS(3));

        LOG_INF("User task attempting flash write");
        ret = user_request_admin_operation(&user_context, OP_FLASH_WRITE,
                                          test_data, strlen(test_data) + 1, 0x1000);
        if (ret == 0) {
            LOG_INF("Flash write request succeeded");
        } else {
            LOG_ERR("Flash write request failed: %d", ret);
        }

        k_sleep(K_SECONDS(5));
    }
}

K_THREAD_DEFINE(admin_tid, ADMIN_STACK_SIZE, admin_task, NULL, NULL, NULL,
                ADMIN_PRIORITY, 0, 0);

K_THREAD_DEFINE(user_tid, USER_STACK_SIZE, user_task, NULL, NULL, NULL,
                USER_PRIORITY, 0, 0);

int main(void)
{
    LOG_INF("Privilege system initialized");
    LOG_INF("Admin task ID: %u, Privilege: %d", admin_context.task_id, admin_context.privilege);
    LOG_INF("User task ID: %u, Privilege: %d", user_context.task_id, user_context.privilege);

    memset(system_config, 0, CONFIG_AREA_SIZE);

    return 0;
}