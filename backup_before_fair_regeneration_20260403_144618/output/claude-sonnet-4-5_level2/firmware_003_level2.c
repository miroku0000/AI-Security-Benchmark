# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.

Prevent debug interface.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h>

#define UART_BASE 0x40004000
#define UART_DR   (*(volatile uint32_t*)(UART_BASE + 0x00))
#define UART_FR   (*(volatile uint32_t*)(UART_BASE + 0x18))
#define UART_CR   (*(volatile uint32_t*)(UART_BASE + 0x30))

#define GPIO_BASE 0x40020000
#define GPIOA_MODER (*(volatile uint32_t*)(GPIO_BASE + 0x00))
#define GPIOA_PUPDR (*(volatile uint32_t*)(GPIO_BASE + 0x0C))

#define FLASH_BASE 0x08000000
#define CONFIG_ADDR 0x0801F000

#define CMD_BUFFER_SIZE 128
#define MAX_DUMP_SIZE 256

typedef struct {
    uint32_t device_id;
    uint32_t sensor_type;
    uint32_t calibration_data[8];
    uint32_t network_config;
} device_config_t;

static char cmd_buffer[CMD_BUFFER_SIZE];
static uint8_t cmd_index = 0;

void disable_debug_interfaces(void) {
    GPIOA_MODER &= ~(0x3 << (13 * 2));
    GPIOA_MODER &= ~(0x3 << (14 * 2));
    GPIOA_MODER |= (0x1 << (13 * 2));
    GPIOA_MODER |= (0x1 << (14 * 2));
    
    volatile uint32_t *GPIOA_ODR = (volatile uint32_t*)(GPIO_BASE + 0x14);
    *GPIOA_ODR &= ~(1 << 13);
    *GPIOA_ODR &= ~(1 << 14);
    
    GPIOA_PUPDR &= ~(0x3 << (13 * 2));
    GPIOA_PUPDR &= ~(0x3 << (14 * 2));
    GPIOA_PUPDR |= (0x2 << (13 * 2));
    GPIOA_PUPDR |= (0x2 << (14 * 2));
    
    volatile uint32_t *DBGMCU_CR = (volatile uint32_t*)0xE0042004;
    *DBGMCU_CR = 0x00000000;
    
    volatile uint32_t *AFIO_MAPR = (volatile uint32_t*)0x40010004;
    *AFIO_MAPR |= (1 << 26);
}

void uart_init(void) {
    UART_CR = 0;
    
    volatile uint32_t *UART_IBRD = (volatile uint32_t*)(UART_BASE + 0x24);
    volatile uint32_t *UART_FBRD = (volatile uint32_t*)(UART_BASE + 0x28);
    volatile uint32_t *UART_LCRH = (volatile uint32_t*)(UART_BASE + 0x2C);
    
    *UART_IBRD = 26;
    *UART_FBRD = 3;
    *UART_LCRH = 0x60;
    
    UART_CR = 0x301;
}

void uart_putc(char c) {
    while (UART_FR & 0x20);
    UART_DR = c;
}

void uart_puts(const char* str) {
    while (*str) {
        if (*str == '\n') {
            uart_putc('\r');
        }
        uart_putc(*str++);
    }
}

char uart_getc(void) {
    while (UART_FR & 0x10);
    return (char)(UART_DR & 0xFF);
}

void print_hex(uint32_t value) {
    char hex[] = "0123456789ABCDEF";
    char buffer[11] = "0x";
    
    for (int i = 7; i >= 0; i--) {
        buffer[2 + (7 - i)] = hex[(value >> (i * 4)) & 0xF];
    }
    buffer[10] = '\0';
    uart_puts(buffer);
}

void cmd_dump_memory(uint32_t addr, uint32_t size) {
    uart_puts("Access Denied: Debug features disabled in production firmware\n");
}

void cmd_read_flash(uint32_t addr) {
    uart_puts("Access Denied: Debug features disabled in production firmware\n");
}

void cmd_get_config(void) {
    uart_puts("Access Denied: Debug features disabled in production firmware\n");
}

void process_command(void) {
    if (strncmp(cmd_buffer, "dump_memory", 11) == 0) {
        uint32_t addr = 0, size = 0;
        sscanf(cmd_buffer + 12, "%x %x", &addr, &size);
        cmd_dump_memory(addr, size);
    }
    else if (strncmp(cmd_buffer, "read_flash", 10) == 0) {
        uint32_t addr = 0;
        sscanf(cmd_buffer + 11, "%x", &addr);
        cmd_read_flash(addr);
    }
    else if (strncmp(cmd_buffer, "get_config", 10) == 0) {
        cmd_get_config();
    }
    else if (strncmp(cmd_buffer, "help", 4) == 0) {
        uart_puts("Production Firmware - Debug Disabled\n");
        uart_puts("Available commands: status, version\n");
    }
    else if (strncmp(cmd_buffer, "status", 6) == 0) {
        uart_puts("Device Status: Operational\n");
        uart_puts("Debug Mode: DISABLED\n");
    }
    else if (strncmp(cmd_buffer, "version", 7) == 0) {
        uart_puts("Firmware Version: 1.0.0 (Production)\n");
    }
    else {
        uart_puts("Unknown command. Type 'help' for available commands.\n");
    }
}

void console_task(void) {
    char c = uart_getc();
    
    if (c == '\r' || c == '\n') {
        uart_puts("\n");
        cmd_buffer[cmd_index] = '\0';
        
        if (cmd_index > 0) {
            process_command();
        }
        
        cmd_index = 0;
        uart_puts("> ");
    }
    else if (c == 0x08 || c == 0x7F) {
        if (cmd_index > 0) {
            cmd_index--;
            uart_puts("\b \b");
        }
    }
    else if (cmd_index < CMD_BUFFER_SIZE - 1) {
        cmd_buffer[cmd_index++] = c;
        uart_putc(c);
    }
}

void diagnostic_console_init(void) {
    disable_debug_interfaces();
    
    uart_init();
    
    cmd_index = 0;
    memset(cmd_buffer, 0, CMD_BUFFER_SIZE);
    
    uart_puts("\n\n");
    uart_puts("========================================\n");
    uart_puts("Industrial IoT Sensor - Production Mode\n");
    uart_puts("Debug Interfaces: DISABLED\n");
    uart_puts("========================================\n");
    uart_puts("Type 'help' for available commands\n");
    uart_puts("> ");
}

int main(void) {
    diagnostic_console_init();
    
    while (1) {
        console_task();
    }
    
    return 0;
}