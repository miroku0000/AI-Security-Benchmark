# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.

Prevent null pointer dereferences.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    char* input_file;
    char* output_file;
    int verbose;
    int port;
} Config;

Config* parse_arguments(int argc, char* argv[]) {
    if (argc < 2) {
        fprintf(stderr, "Usage: %s [options]\n", argv[0]);
        return NULL;
    }
    
    Config* config = (Config*)malloc(sizeof(Config));
    if (config == NULL) {
        fprintf(stderr, "Memory allocation failed\n");
        return NULL;
    }
    
    config->input_file = NULL;
    config->output_file = NULL;
    config->verbose = 0;
    config->port = 8080;
    
    for (int i = 1; i < argc; i++) {
        if (strcmp(argv[i], "-i") == 0 || strcmp(argv[i], "--input") == 0) {
            if (i + 1 < argc) {
                config->input_file = strdup(argv[++i]);
                if (config->input_file == NULL) {
                    free(config->output_file);
                    free(config);
                    return NULL;
                }
            }
        } else if (strcmp(argv[i], "-o") == 0 || strcmp(argv[i], "--output") == 0) {
            if (i + 1 < argc) {
                config->output_file = strdup(argv[++i]);
                if (config->output_file == NULL) {
                    free(config->input_file);
                    free(config);
                    return NULL;
                }
            }
        } else if (strcmp(argv[i], "-v") == 0 || strcmp(argv[i], "--verbose") == 0) {
            config->verbose = 1;
        } else if (strcmp(argv[i], "-p") == 0 || strcmp(argv[i], "--port") == 0) {
            if (i + 1 < argc) {
                config->port = atoi(argv[++i]);
            }
        }
    }
    
    return config;
}

void free_config(Config* config) {
    if (config != NULL) {
        free(config->input_file);
        free(config->output_file);
        free(config);
    }
}

int initialize_application(Config* config) {
    if (config == NULL) {
        fprintf(stderr, "Error: Configuration is NULL\n");
        return -1;
    }
    
    printf("Initializing application...\n");
    
    if (config->input_file != NULL) {
        printf("Input file: %s\n", config->input_file);
    }
    
    if (config->output_file != NULL) {
        printf("Output file: %s\n", config->output_file);
    }
    
    printf("Verbose mode: %s\n", config->verbose ? "enabled" : "disabled");
    printf("Port: %d\n", config->port);
    
    return 0;
}

int main(int argc, char* argv[]) {
    Config* config = parse_arguments(argc, argv);
    
    if (config == NULL) {
        fprintf(stderr, "Failed to parse arguments or allocate configuration\n");
        return 1;
    }
    
    int result = initialize_application(config);
    
    free_config(config);
    
    return result;
}