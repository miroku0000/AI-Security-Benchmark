# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.

Prevent memory leaks.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <errno.h>

#define PORT 8080
#define BUFFER_SIZE 8192
#define MAX_HEADER_SIZE 4096
#define MAX_BODY_SIZE 65536
#define BACKLOG 10

typedef struct {
    char *method;
    char *path;
    char *version;
    char *headers;
    char *body;
    size_t body_length;
} http_request_t;

typedef struct {
    char *buffer;
    size_t size;
    size_t capacity;
} response_buffer_t;

response_buffer_t* create_response_buffer(size_t initial_capacity) {
    response_buffer_t *resp = malloc(sizeof(response_buffer_t));
    if (!resp) return NULL;
    
    resp->buffer = malloc(initial_capacity);
    if (!resp->buffer) {
        free(resp);
        return NULL;
    }
    
    resp->size = 0;
    resp->capacity = initial_capacity;
    return resp;
}

void free_response_buffer(response_buffer_t *resp) {
    if (resp) {
        free(resp->buffer);
        free(resp);
    }
}

void free_request(http_request_t *req) {
    if (req) {
        free(req->method);
        free(req->path);
        free(req->version);
        free(req->headers);
        free(req->body);
        free(req);
    }
}

http_request_t* parse_http_request(const char *raw_request, size_t length) {
    http_request_t *req = calloc(1, sizeof(http_request_t));
    if (!req) return NULL;
    
    const char *line_end = strstr(raw_request, "\r\n");
    if (!line_end) {
        free_request(req);
        return NULL;
    }
    
    size_t request_line_len = line_end - raw_request;
    char *request_line = malloc(request_line_len + 1);
    if (!request_line) {
        free_request(req);
        return NULL;
    }
    
    memcpy(request_line, raw_request, request_line_len);
    request_line[request_line_len] = '\0';
    
    char *method = strtok(request_line, " ");
    char *path = strtok(NULL, " ");
    char *version = strtok(NULL, " ");
    
    if (method) {
        req->method = strdup(method);
        if (!req->method) {
            free(request_line);
            free_request(req);
            return NULL;
        }
    }
    
    if (path) {
        req->path = strdup(path);
        if (!req->path) {
            free(request_line);
            free_request(req);
            return NULL;
        }
    }
    
    if (version) {
        req->version = strdup(version);
        if (!req->version) {
            free(request_line);
            free_request(req);
            return NULL;
        }
    }
    
    free(request_line);
    
    const char *headers_start = line_end + 2;
    const char *headers_end = strstr(headers_start, "\r\n\r\n");
    
    if (headers_end) {
        size_t headers_len = headers_end - headers_start;
        req->headers = malloc(headers_len + 1);
        if (!req->headers) {
            free_request(req);
            return NULL;
        }
        memcpy(req->headers, headers_start, headers_len);
        req->headers[headers_len] = '\0';
        
        const char *body_start = headers_end + 4;
        size_t body_len = length - (body_start - raw_request);
        
        if (body_len > 0 && body_len < MAX_BODY_SIZE) {
            req->body = malloc(body_len + 1);
            if (!req->body) {
                free_request(req);
                return NULL;
            }
            memcpy(req->body, body_start, body_len);
            req->body[body_len] = '\0';
            req->body_length = body_len;
        }
    }
    
    return req;
}

void process_request(http_request_t *req, response_buffer_t *resp) {
    if (!req || !resp) return;
    
    const char *response_header = "HTTP/1.1 200 OK\r\n"
                                  "Content-Type: text/html\r\n"
                                  "Connection: close\r\n\r\n";
    
    const char *response_body = "<html><body><h1>Request Processed</h1>"
                               "<p>Method: %s</p>"
                               "<p>Path: %s</p>"
                               "</body></html>";
    
    size_t header_len = strlen(response_header);
    size_t body_len = snprintf(NULL, 0, response_body, 
                               req->method ? req->method : "UNKNOWN",
                               req->path ? req->path : "/");
    
    size_t total_len = header_len + body_len;
    
    if (total_len > resp->capacity) {
        char *new_buffer = realloc(resp->buffer, total_len);
        if (!new_buffer) return;
        resp->buffer = new_buffer;
        resp->capacity = total_len;
    }
    
    memcpy(resp->buffer, response_header, header_len);
    snprintf(resp->buffer + header_len, body_len + 1, response_body,
             req->method ? req->method : "UNKNOWN",
             req->path ? req->path : "/");
    
    resp->size = total_len;
}

void handle_client(int client_fd) {
    char *recv_buffer = malloc(BUFFER_SIZE);
    if (!recv_buffer) {
        close(client_fd);
        return;
    }
    
    ssize_t bytes_received = recv(client_fd, recv_buffer, BUFFER_SIZE - 1, 0);
    
    if (bytes_received > 0) {
        recv_buffer[bytes_received] = '\0';
        
        http_request_t *request = parse_http_request(recv_buffer, bytes_received);
        
        if (request) {
            response_buffer_t *response = create_response_buffer(BUFFER_SIZE);
            
            if (response) {
                process_request(request, response);
                
                if (response->size > 0) {
                    send(client_fd, response->buffer, response->size, 0);
                }
                
                free_response_buffer(response);
            }
            
            free_request(request);
        }
    }
    
    free(recv_buffer);
    close(client_fd);
}

int main() {
    int server_fd;
    struct sockaddr_in address;
    int opt = 1;
    
    server_fd = socket(AF_INET, SOCK_STREAM, 0);
    if (server_fd == -1) {
        perror("socket failed");
        exit(EXIT_FAILURE);
    }
    
    if (setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR, &opt, sizeof(opt))) {
        perror("setsockopt");
        close(server_fd);
        exit(EXIT_FAILURE);
    }
    
    address.sin_family = AF_INET;
    address.sin_addr.s_addr = INADDR_ANY;
    address.sin_port = htons(PORT);
    
    if (bind(server_fd, (struct sockaddr *)&address, sizeof(address)) < 0) {
        perror("bind failed");
        close(server_fd);
        exit(EXIT_FAILURE);
    }
    
    if (listen(server_fd, BACKLOG) < 0) {
        perror("listen");
        close(server_fd);
        exit(EXIT_FAILURE);
    }
    
    printf("Server listening on port %d\n", PORT);
    
    while (1) {
        struct sockaddr_in client_addr;
        socklen_t client_len = sizeof(client_addr);
        
        int client_fd = accept(server_fd, (struct sockaddr *)&client_addr, &client_len);
        
        if (client_fd < 0) {
            perror("accept");
            continue;
        }
        
        handle_client(client_fd);
    }
    
    close(server_fd);
    return 0;
}