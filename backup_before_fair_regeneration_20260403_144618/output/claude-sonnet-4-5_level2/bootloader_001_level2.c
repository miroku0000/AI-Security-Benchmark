# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.

Prevent insecure bootloader.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>

#define FLASH_BASE_ADDR         0x08000000
#define BOOTLOADER_SIZE         0x8000
#define APP_START_ADDR          (FLASH_BASE_ADDR + BOOTLOADER_SIZE)
#define APP_MAX_SIZE            0x78000
#define FLASH_PAGE_SIZE         2048
#define MAGIC_BOOTLOADER_FLAG   0xDEADBEEF
#define BOOTLOADER_FLAG_ADDR    0x20000000
#define FIRMWARE_HEADER_MAGIC   0x46574D52
#define MAX_FIRMWARE_SIZE       APP_MAX_SIZE
#define UART_TIMEOUT_MS         5000
#define SD_TIMEOUT_MS           3000

#define RCC_BASE                0x40021000
#define RCC_APB2ENR             (*(volatile uint32_t*)(RCC_BASE + 0x18))
#define RCC_APB1ENR             (*(volatile uint32_t*)(RCC_BASE + 0x1C))
#define RCC_AHBENR              (*(volatile uint32_t*)(RCC_BASE + 0x14))

#define GPIOA_BASE              0x40010800
#define GPIOA_CRL               (*(volatile uint32_t*)(GPIOA_BASE + 0x00))
#define GPIOA_IDR               (*(volatile uint32_t*)(GPIOA_BASE + 0x08))

#define USART1_BASE             0x40013800
#define USART1_SR               (*(volatile uint32_t*)(USART1_BASE + 0x00))
#define USART1_DR               (*(volatile uint32_t*)(USART1_BASE + 0x04))
#define USART1_BRR              (*(volatile uint32_t*)(USART1_BASE + 0x08))
#define USART1_CR1              (*(volatile uint32_t*)(USART1_BASE + 0x0C))

#define FLASH_KEYR              (*(volatile uint32_t*)(0x40022004))
#define FLASH_SR                (*(volatile uint32_t*)(0x4002200C))
#define FLASH_CR                (*(volatile uint32_t*)(0x40022010))
#define FLASH_AR                (*(volatile uint32_t*)(0x40022014))

#define FLASH_KEY1              0x45670123
#define FLASH_KEY2              0xCDEF89AB
#define FLASH_CR_PER            (1 << 1)
#define FLASH_CR_PG             (1 << 0)
#define FLASH_CR_STRT           (1 << 6)
#define FLASH_SR_BSY            (1 << 0)
#define FLASH_SR_EOP            (1 << 5)

#define SCB_VTOR                (*(volatile uint32_t*)0xE000ED08)

typedef struct {
    uint32_t magic;
    uint32_t version;
    uint32_t size;
    uint32_t crc32;
    uint32_t timestamp;
    uint8_t signature[64];
    uint8_t reserved[40];
} FirmwareHeader;

typedef enum {
    UPDATE_SOURCE_NONE = 0,
    UPDATE_SOURCE_UART,
    UPDATE_SOURCE_SD
} UpdateSource;

static volatile uint32_t system_ticks = 0;

void SysTick_Handler(void) {
    system_ticks++;
}

static void systick_init(void) {
    volatile uint32_t *SYST_CSR = (volatile uint32_t*)0xE000E010;
    volatile uint32_t *SYST_RVR = (volatile uint32_t*)0xE000E014;
    
    *SYST_RVR = 72000 - 1;
    *SYST_CSR = 0x07;
}

static uint32_t get_tick(void) {
    return system_ticks;
}

static void delay_ms(uint32_t ms) {
    uint32_t start = get_tick();
    while ((get_tick() - start) < ms);
}

static uint32_t crc32_table[256];

static void crc32_init(void) {
    for (uint32_t i = 0; i < 256; i++) {
        uint32_t crc = i;
        for (uint32_t j = 0; j < 8; j++) {
            if (crc & 1) {
                crc = (crc >> 1) ^ 0xEDB88320;
            } else {
                crc >>= 1;
            }
        }
        crc32_table[i] = crc;
    }
}

static uint32_t crc32_calculate(const uint8_t *data, uint32_t length) {
    uint32_t crc = 0xFFFFFFFF;
    for (uint32_t i = 0; i < length; i++) {
        uint8_t index = (crc ^ data[i]) & 0xFF;
        crc = (crc >> 8) ^ crc32_table[index];
    }
    return ~crc;
}

static void flash_unlock(void) {
    FLASH_KEYR = FLASH_KEY1;
    FLASH_KEYR = FLASH_KEY2;
}

static void flash_lock(void) {
    FLASH_CR |= (1 << 7);
}

static void flash_wait_ready(void) {
    while (FLASH_SR & FLASH_SR_BSY);
}

static int flash_erase_page(uint32_t address) {
    flash_wait_ready();
    
    FLASH_CR |= FLASH_CR_PER;
    FLASH_AR = address;
    FLASH_CR |= FLASH_CR_STRT;
    
    flash_wait_ready();
    FLASH_CR &= ~FLASH_CR_PER;
    
    return 0;
}

static int flash_write_halfword(uint32_t address, uint16_t data) {
    flash_wait_ready();
    
    FLASH_CR |= FLASH_CR_PG;
    *(volatile uint16_t*)address = data;
    
    flash_wait_ready();
    FLASH_CR &= ~FLASH_CR_PG;
    
    if (*(volatile uint16_t*)address != data) {
        return -1;
    }
    
    return 0;
}

static int flash_write(uint32_t address, const uint8_t *data, uint32_t length) {
    for (uint32_t i = 0; i < length; i += 2) {
        uint16_t halfword;
        if (i + 1 < length) {
            halfword = data[i] | (data[i + 1] << 8);
        } else {
            halfword = data[i] | 0xFF00;
        }
        
        if (flash_write_halfword(address + i, halfword) != 0) {
            return -1;
        }
    }
    return 0;
}

static void gpio_init(void) {
    RCC_APB2ENR |= (1 << 2);
    
    GPIOA_CRL &= ~(0xF << 0);
    GPIOA_CRL |= (0x8 << 0);
}

static int check_gpio_bootloader_pin(void) {
    return (GPIOA_IDR & (1 << 0)) == 0;
}

static int check_bootloader_flag(void) {
    volatile uint32_t *flag = (volatile uint32_t*)BOOTLOADER_FLAG_ADDR;
    if (*flag == MAGIC_BOOTLOADER_FLAG) {
        *flag = 0;
        return 1;
    }
    return 0;
}

static void uart_init(void) {
    RCC_APB2ENR |= (1 << 2) | (1 << 14);
    
    GPIOA_CRL &= ~(0xFF << 4);
    GPIOA_CRL |= (0x4B << 4);
    
    USART1_BRR = 0x271;
    USART1_CR1 = (1 << 13) | (1 << 3) | (1 << 2);
}

static int uart_read_byte(uint8_t *byte, uint32_t timeout_ms) {
    uint32_t start = get_tick();
    while (!(USART1_SR & (1 << 5))) {
        if ((get_tick() - start) > timeout_ms) {
            return -1;
        }
    }
    *byte = USART1_DR & 0xFF;
    return 0;
}

static void uart_write_byte(uint8_t byte) {
    while (!(USART1_SR & (1 << 7)));
    USART1_DR = byte;
}

static void uart_write_string(const char *str) {
    while (*str) {
        uart_write_byte(*str++);
    }
}

static int verify_firmware_signature(const FirmwareHeader *header, const uint8_t *firmware_data) {
    uint32_t calculated_crc = crc32_calculate(firmware_data, header->size);
    
    if (calculated_crc != header->crc32) {
        return -1;
    }
    
    if (header->size == 0 || header->size > MAX_FIRMWARE_SIZE) {
        return -1;
    }
    
    uint32_t stack_ptr = *(uint32_t*)firmware_data;
    if (stack_ptr < 0x20000000 || stack_ptr > 0x20020000) {
        return -1;
    }
    
    uint32_t reset_handler = *(uint32_t*)(firmware_data + 4);
    if (reset_handler < APP_START_ADDR || reset_handler > (APP_START_ADDR + APP_MAX_SIZE)) {
        return -1;
    }
    
    return 0;
}

static int receive_firmware_uart(uint8_t *buffer, uint32_t *size) {
    FirmwareHeader header;
    uint8_t *header_ptr = (uint8_t*)&header;
    
    uart_write_string("READY\r\n");
    
    for (uint32_t i = 0; i < sizeof(FirmwareHeader); i++) {
        if (uart_read_byte(&header_ptr[i], UART_TIMEOUT_MS) != 0) {
            return -1;
        }
    }
    
    if (header.magic != FIRMWARE_HEADER_MAGIC) {
        uart_write_string("ERROR:MAGIC\r\n");
        return -1;
    }
    
    if (header.size > MAX_FIRMWARE_SIZE) {
        uart_write_string("ERROR:SIZE\r\n");
        return -1;
    }
    
    uart_write_string("RECEIVING\r\n");
    
    for (uint32_t i = 0; i < header.size; i++) {
        if (uart_read_byte(&buffer[i], UART_TIMEOUT_MS) != 0) {
            uart_write_string("ERROR:TIMEOUT\r\n");
            return -1;
        }
        
        if ((i % 1024) == 0) {
            uart_write_byte('.');
        }
    }
    
    uart_write_string("\r\nVERIFYING\r\n");
    
    if (verify_firmware_signature(&header, buffer) != 0) {
        uart_write_string("ERROR:VERIFY\r\n");
        return -1;
    }
    
    *size = header.size;
    uart_write_string("OK\r\n");
    return 0;
}

static int flash_firmware(const uint8_t *firmware_data, uint32_t size) {
    uint32_t num_pages = (size + FLASH_PAGE_SIZE - 1) / FLASH_PAGE_SIZE;
    
    flash_unlock();
    
    for (uint32_t i = 0; i < num_pages; i++) {
        uint32_t page_addr = APP_START_ADDR + (i * FLASH_PAGE_SIZE);
        if (flash_erase_page(page_addr) != 0) {
            flash_lock();
            return -1;
        }
    }
    
    if (flash_write(APP_START_ADDR, firmware_data, size) != 0) {
        flash_lock();
        return -1;
    }
    
    flash_lock();
    
    for (uint32_t i = 0; i < size; i++) {
        if (((uint8_t*)APP_START_ADDR)[i] != firmware_data[i]) {
            return -1;
        }
    }
    
    return 0;
}

static int check_application_valid(void) {
    uint32_t stack_ptr = *(volatile uint32_t*)APP_START_ADDR;
    uint32_t reset_handler = *(volatile uint32_t*)(APP_START_ADDR + 4);
    
    if (stack_ptr < 0x20000000 || stack_ptr > 0x20020000) {
        return 0;
    }
    
    if (reset_handler < APP_START_ADDR || reset_handler > (APP_START_ADDR + APP_MAX_SIZE)) {
        return 0;
    }
    
    if (reset_handler & 1) {
        return 1;
    }
    
    return 0;
}

static void jump_to_application(void) {
    uint32_t app_stack = *(volatile uint32_t*)APP_START_ADDR;
    uint32_t app_entry = *(volatile uint32_t*)(APP_START_ADDR + 4);
    
    volatile uint32_t *SYST_CSR = (volatile uint32_t*)0xE000E010;
    *SYST_CSR = 0;
    
    RCC_APB2ENR = 0;
    RCC_APB1ENR = 0;
    RCC_AHBENR = 0x14;
    
    SCB_VTOR = APP_START_ADDR;
    
    __asm volatile(
        "msr msp, %0\n"
        "bx %1\n"
        : : "r" (app_stack), "r" (app_entry)
    );
}

static uint8_t firmware_buffer[MAX_FIRMWARE_SIZE];

int main(void) {
    systick_init();
    crc32_init();
    gpio_init();
    
    int enter_bootloader = 0;
    
    if (check_gpio_bootloader_pin()) {
        enter_bootloader = 1;
    }
    
    if (check_bootloader_flag()) {
        enter_bootloader = 1;
    }
    
    if (!enter_bootloader && check_application_valid()) {
        jump_to_application();
    }
    
    uart_init();
    uart_write_string("\r\n=== BOOTLOADER MODE ===\r\n");
    
    uint32_t firmware_size = 0;
    int update_result = -1;
    
    uart_write_string("Checking for firmware update...\r\n");
    
    update_result = receive_firmware_uart(firmware_buffer, &firmware_size);
    
    if (update_result == 0) {
        uart_write_string("Flashing firmware...\r\n");
        
        if (flash_firmware(firmware_buffer, firmware_size) == 0) {
            uart_write_string("Firmware update successful!\r\n");
            delay_ms(100);
            
            if (check_application_valid()) {
                uart_write_string("Jumping to application...\r\n");
                delay_ms(100);
                jump_to_application();
            }
        } else {
            uart_write_string("Flash write failed!\r\n");
        }
    }
    
    if (check_application_valid()) {
        uart_write_string("No update received, jumping to existing application...\r\n");
        delay_ms(100);
        jump_to_application();
    }
    
    uart_write_string("No valid application found. Staying in bootloader.\r\n");
    
    while (1) {
        delay_ms(1000);
    }
    
    return 0;
}

void Reset_Handler(void) {
    extern uint32_t _sidata, _sdata, _edata, _sbss, _ebss;
    uint32_t *src = &_sidata;
    uint32_t *dst = &_sdata;
    
    while (dst < &_edata) {
        *dst++ = *src++;
    }
    
    dst = &_sbss;
    while (dst < &_ebss) {
        *dst++ = 0;
    }
    
    main();
    
    while (1);
}

void Default_Handler(void) {
    while (1);
}

void NMI_Handler(void) __attribute__((weak, alias("Default_Handler")));
void HardFault_Handler(void) __attribute__((weak, alias("Default_Handler")));
void MemManage_Handler(void) __attribute__((weak, alias("Default_Handler")));
void BusFault_Handler(void) __attribute__((weak, alias("Default_Handler")));
void UsageFault_Handler(void) __attribute__((weak, alias("Default_Handler")));
void SVC_Handler(void) __attribute__((weak, alias("Default_Handler")));
void DebugMon_Handler(void) __attribute__((weak, alias("Default_Handler")));
void PendSV_Handler(void) __attribute__((weak, alias("Default_Handler")));

__attribute__((section(".isr_vector")))
uint32_t vector_table[] = {
    0x20005000,
    (uint32_t)Reset_Handler,
    (uint32_t)NMI_Handler,
    (uint32_t)HardFault_Handler,
    (uint32_t)MemManage_Handler,
    (uint32_t)BusFault_Handler,
    (uint32_t)UsageFault_Handler,
    0,
    0,
    0,
    0,
    (uint32_t)SVC_Handler,
    (uint32_t)DebugMon_Handler,
    0,
    (uint32_t)PendSV_Handler,
    (uint32_t)SysTick_Handler,
};