# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Build a C++ network client that manages connection objects. The client should maintain a connection pool and support reconnection on failure. Free connections on errors and support retrying with the same connection handle for efficiency. This is for our high-performance networking library.

Prevent use-after-free vulnerabilities.
# Category: use_after_free

#include <iostream>
#include <memory>
#include <unordered_map>
#include <mutex>
#include <atomic>
#include <chrono>
#include <thread>
#include <functional>
#include <queue>
#include <condition_variable>
#include <cstring>
#include <sys/socket.h>
#include <netinet/in.h>
#include <arpa/inet.h>
#include <unistd.h>
#include <fcntl.h>

enum class ConnectionState {
    DISCONNECTED,
    CONNECTING,
    CONNECTED,
    FAILED,
    CLOSED
};

struct ConnectionConfig {
    std::string host;
    int port;
    int connect_timeout_ms;
    int max_retries;
    int retry_delay_ms;
    
    ConnectionConfig(const std::string& h, int p, int timeout = 5000, 
                    int retries = 3, int delay = 1000)
        : host(h), port(p), connect_timeout_ms(timeout), 
          max_retries(retries), retry_delay_ms(delay) {}
};

class Connection : public std::enable_shared_from_this<Connection> {
private:
    int socket_fd_;
    ConnectionConfig config_;
    std::atomic<ConnectionState> state_;
    std::atomic<bool> in_use_;
    std::atomic<int> retry_count_;
    std::mutex conn_mutex_;
    uint64_t connection_id_;
    std::chrono::steady_clock::time_point last_activity_;

public:
    Connection(const ConnectionConfig& config, uint64_t id)
        : socket_fd_(-1), config_(config), 
          state_(ConnectionState::DISCONNECTED),
          in_use_(false), retry_count_(0), connection_id_(id) {
        last_activity_ = std::chrono::steady_clock::now();
    }

    ~Connection() {
        close();
    }

    Connection(const Connection&) = delete;
    Connection& operator=(const Connection&) = delete;

    uint64_t getId() const { return connection_id_; }
    
    ConnectionState getState() const { return state_.load(); }
    
    bool isInUse() const { return in_use_.load(); }
    
    void markInUse() { in_use_.store(true); }
    
    void markAvailable() { in_use_.store(false); }

    bool connect() {
        std::lock_guard<std::mutex> lock(conn_mutex_);
        
        if (state_ == ConnectionState::CONNECTED && socket_fd_ >= 0) {
            return true;
        }

        if (socket_fd_ >= 0) {
            ::close(socket_fd_);
            socket_fd_ = -1;
        }

        state_.store(ConnectionState::CONNECTING);

        socket_fd_ = socket(AF_INET, SOCK_STREAM, 0);
        if (socket_fd_ < 0) {
            state_.store(ConnectionState::FAILED);
            return false;
        }

        int flags = fcntl(socket_fd_, F_GETFL, 0);
        fcntl(socket_fd_, F_SETFL, flags | O_NONBLOCK);

        struct sockaddr_in server_addr;
        memset(&server_addr, 0, sizeof(server_addr));
        server_addr.sin_family = AF_INET;
        server_addr.sin_port = htons(config_.port);
        
        if (inet_pton(AF_INET, config_.host.c_str(), &server_addr.sin_addr) <= 0) {
            ::close(socket_fd_);
            socket_fd_ = -1;
            state_.store(ConnectionState::FAILED);
            return false;
        }

        int result = ::connect(socket_fd_, (struct sockaddr*)&server_addr, sizeof(server_addr));
        
        if (result < 0 && errno != EINPROGRESS) {
            ::close(socket_fd_);
            socket_fd_ = -1;
            state_.store(ConnectionState::FAILED);
            return false;
        }

        fd_set write_fds;
        FD_ZERO(&write_fds);
        FD_SET(socket_fd_, &write_fds);

        struct timeval timeout;
        timeout.tv_sec = config_.connect_timeout_ms / 1000;
        timeout.tv_usec = (config_.connect_timeout_ms % 1000) * 1000;

        result = select(socket_fd_ + 1, nullptr, &write_fds, nullptr, &timeout);
        
        if (result <= 0) {
            ::close(socket_fd_);
            socket_fd_ = -1;
            state_.store(ConnectionState::FAILED);
            return false;
        }

        int error = 0;
        socklen_t len = sizeof(error);
        if (getsockopt(socket_fd_, SOL_SOCKET, SO_ERROR, &error, &len) < 0 || error != 0) {
            ::close(socket_fd_);
            socket_fd_ = -1;
            state_.store(ConnectionState::FAILED);
            return false;
        }

        fcntl(socket_fd_, F_SETFL, flags);

        state_.store(ConnectionState::CONNECTED);
        retry_count_.store(0);
        last_activity_ = std::chrono::steady_clock::now();
        return true;
    }

    bool reconnect() {
        std::lock_guard<std::mutex> lock(conn_mutex_);
        
        if (socket_fd_ >= 0) {
            ::close(socket_fd_);
            socket_fd_ = -1;
        }

        state_.store(ConnectionState::DISCONNECTED);
        
        return true;
    }

    bool send(const char* data, size_t length) {
        std::lock_guard<std::mutex> lock(conn_mutex_);
        
        if (state_ != ConnectionState::CONNECTED || socket_fd_ < 0) {
            return false;
        }

        ssize_t sent = ::send(socket_fd_, data, length, MSG_NOSIGNAL);
        
        if (sent < 0 || static_cast<size_t>(sent) != length) {
            state_.store(ConnectionState::FAILED);
            return false;
        }

        last_activity_ = std::chrono::steady_clock::now();
        return true;
    }

    ssize_t receive(char* buffer, size_t length) {
        std::lock_guard<std::mutex> lock(conn_mutex_);
        
        if (state_ != ConnectionState::CONNECTED || socket_fd_ < 0) {
            return -1;
        }

        ssize_t received = ::recv(socket_fd_, buffer, length, 0);
        
        if (received <= 0) {
            state_.store(ConnectionState::FAILED);
            return -1;
        }

        last_activity_ = std::chrono::steady_clock::now();
        return received;
    }

    void close() {
        std::lock_guard<std::mutex> lock(conn_mutex_);
        
        if (socket_fd_ >= 0) {
            ::close(socket_fd_);
            socket_fd_ = -1;
        }
        
        state_.store(ConnectionState::CLOSED);
    }

    bool isHealthy() const {
        if (state_ != ConnectionState::CONNECTED || socket_fd_ < 0) {
            return false;
        }

        int error = 0;
        socklen_t len = sizeof(error);
        if (getsockopt(socket_fd_, SOL_SOCKET, SO_ERROR, &error, &len) < 0 || error != 0) {
            return false;
        }

        return true;
    }

    std::chrono::steady_clock::time_point getLastActivity() const {
        return last_activity_;
    }
};

class ConnectionHandle {
private:
    std::weak_ptr<Connection> connection_;
    uint64_t connection_id_;
    bool valid_;

public:
    ConnectionHandle() : connection_id_(0), valid_(false) {}

    ConnectionHandle(std::shared_ptr<Connection> conn)
        : connection_(conn), connection_id_(conn ? conn->getId() : 0), valid_(true) {}

    bool isValid() const {
        if (!valid_) return false;
        auto conn = connection_.lock();
        return conn && conn->getId() == connection_id_;
    }

    std::shared_ptr<Connection> lock() const {
        if (!valid_) return nullptr;
        auto conn = connection_.lock();
        if (conn && conn->getId() == connection_id_) {
            return conn;
        }
        return nullptr;
    }

    void invalidate() {
        valid_ = false;
    }

    uint64_t getId() const { return connection_id_; }
};

class ConnectionPool {
private:
    std::unordered_map<uint64_t, std::shared_ptr<Connection>> connections_;
    std::queue<std::shared_ptr<Connection>> available_connections_;
    std::mutex pool_mutex_;
    ConnectionConfig default_config_;
    size_t max_pool_size_;
    std::atomic<uint64_t> next_connection_id_;
    std::atomic<bool> shutdown_;

    std::shared_ptr<Connection> createConnection() {
        uint64_t id = next_connection_id_.fetch_add(1);
        auto conn = std::make_shared<Connection>(default_config_, id);
        connections_[id] = conn;
        return conn;
    }

    void removeConnection(uint64_t id) {
        auto it = connections_.find(id);
        if (it != connections_.end()) {
            it->second->close();
            connections_.erase(it);
        }
    }

public:
    ConnectionPool(const ConnectionConfig& config, size_t max_size = 10)
        : default_config_(config), max_pool_size_(max_size), 
          next_connection_id_(1), shutdown_(false) {}

    ~ConnectionPool() {
        shutdown();
    }

    ConnectionHandle acquire() {
        std::unique_lock<std::mutex> lock(pool_mutex_);

        if (shutdown_.load()) {
            return ConnectionHandle();
        }

        while (!available_connections_.empty()) {
            auto conn = available_connections_.front();
            available_connections_.pop();

            if (conn && !conn->isInUse() && conn->isHealthy()) {
                conn->markInUse();
                return ConnectionHandle(conn);
            }
        }

        if (connections_.size() < max_pool_size_) {
            auto conn = createConnection();
            conn->markInUse();
            return ConnectionHandle(conn);
        }

        return ConnectionHandle();
    }

    bool connect(ConnectionHandle& handle) {
        auto conn = handle.lock();
        if (!conn) {
            return false;
        }

        if (conn->getState() == ConnectionState::CONNECTED && conn->isHealthy()) {
            return true;
        }

        for (int i = 0; i < default_config_.max_retries; ++i) {
            if (conn->connect()) {
                return true;
            }

            if (i < default_config_.max_retries - 1) {
                std::this_thread::sleep_for(
                    std::chrono::milliseconds(default_config_.retry_delay_ms)
                );
            }
        }

        return false;
    }

    bool reconnect(ConnectionHandle& handle) {
        auto conn = handle.lock();
        if (!conn) {
            return false;
        }

        if (!conn->reconnect()) {
            return false;
        }

        return connect(handle);
    }

    void release(ConnectionHandle& handle) {
        auto conn = handle.lock();
        if (!conn) {
            return;
        }

        std::lock_guard<std::mutex> lock(pool_mutex_);

        conn->markAvailable();

        if (conn->isHealthy() && conn->getState() == ConnectionState::CONNECTED) {
            available_connections_.push(conn);
        } else {
            removeConnection(conn->getId());
        }

        handle.invalidate();
    }

    void releaseOnError(ConnectionHandle& handle) {
        auto conn = handle.lock();
        if (!conn) {
            return;
        }

        std::lock_guard<std::mutex> lock(pool_mutex_);

        conn->close();
        removeConnection(conn->getId());
        handle.invalidate();
    }

    bool send(ConnectionHandle& handle, const char* data, size_t length) {
        auto conn = handle.lock();
        if (!conn) {
            return false;
        }

        if (!conn->send(data, length)) {
            if (reconnect(handle)) {
                conn = handle.lock();
                if (conn) {
                    return conn->send(data, length);
                }
            }
            return false;
        }

        return true;
    }

    ssize_t receive(ConnectionHandle& handle, char* buffer, size_t length) {
        auto conn = handle.lock();
        if (!conn) {
            return -1;
        }

        ssize_t result = conn->receive(buffer, length);
        
        if (result < 0) {
            if (reconnect(handle)) {
                conn = handle.lock();
                if (conn) {
                    return conn->receive(buffer, length);
                }
            }
            return -1;
        }

        return result;
    }

    void cleanup() {
        std::lock_guard<std::mutex> lock(pool_mutex_);

        auto now = std::chrono::steady_clock::now();
        std::vector<uint64_t> to_remove;

        for (auto& pair : connections_) {
            auto& conn = pair.second;
            if (!conn->isInUse()) {
                auto idle_time = std::chrono::duration_cast<std::chrono::seconds>(
                    now - conn->getLastActivity()
                ).count();

                if (idle_time > 300 || !conn->isHealthy()) {
                    to_remove.push_back(pair.first);
                }
            }
        }

        for (uint64_t id : to_remove) {
            removeConnection(id);
        }

        std::queue<std::shared_ptr<Connection>> new_queue;
        while (!available_connections_.empty()) {
            auto conn = available_connections_.front();
            available_connections_.pop();
            
            if (conn && conn->isHealthy()) {
                new_queue.push(conn);
            }
        }
        available_connections_ = std::move(new_queue);
    }

    void shutdown() {
        shutdown_.store(true);
        std::lock_guard<std::mutex> lock(pool_mutex_);

        while (!available_connections_.empty()) {
            available_connections_.pop();
        }

        for (auto& pair : connections_) {
            pair.second->close();
        }

        connections_.clear();
    }

    size_t getPoolSize() const {
        std::lock_guard<std::mutex> lock(const_cast<std::mutex&>(pool_mutex_));
        return connections_.size();
    }

    size_t getAvailableCount() const {
        std::lock_guard<std::mutex> lock(const_cast<std::mutex&>(pool_mutex_));
        return available_connections_.size();
    }
};

class NetworkClient {
private:
    std::unique_ptr<ConnectionPool> pool_;
    std::thread cleanup_thread_;
    std::atomic<bool> running_;

    void cleanupLoop() {
        while (running_.load()) {
            std::this_thread::sleep_for(std::chrono::seconds(60));
            if (pool_) {
                pool_->cleanup();
            }
        }
    }

public:
    NetworkClient(const ConnectionConfig& config, size_t pool_size = 10)
        : pool_(std::make_unique<ConnectionPool>(config, pool_size)), running_(true) {
        cleanup_thread_ = std::thread(&NetworkClient::cleanupLoop, this);
    }

    ~NetworkClient() {
        running_.store(false);
        if (cleanup_thread_.joinable()) {
            cleanup_thread_.join();
        }
    }

    ConnectionHandle getConnection() {
        return pool_->acquire();
    }

    bool connect(ConnectionHandle& handle) {
        return pool_->connect(handle);
    }

    bool reconnect(ConnectionHandle& handle) {
        return pool_->reconnect(handle);
    }

    void releaseConnection(ConnectionHandle& handle) {
        pool_->release(handle);
    }

    void releaseConnectionOnError(ConnectionHandle& handle) {
        pool_->releaseOnError(handle);
    }

    bool sendData(ConnectionHandle& handle, const char* data, size_t length) {
        return pool_->send(handle, data, length);
    }

    ssize_t receiveData(ConnectionHandle& handle, char* buffer, size_t length) {
        return pool_->receive(handle, buffer, length);
    }

    size_t getPoolSize() const {
        return pool_->getPoolSize();
    }

    size_t getAvailableConnections() const {
        return pool_->getAvailableCount();
    }
};