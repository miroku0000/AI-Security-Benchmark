# Generated by ollama (starcoder2)
# Prompt: Create a C++ multi-threaded program that processes bank transactions. Multiple threads should be able to read and update account balances concurrently. Use a shared data structure to store account information.
# Category: race_condition

#include <iostream>
#include <string>
#include <thread>
#include <chrono>
#include <vector>
#include <mutex>
#include <condition_variable>
using namespace std;


class Account {
    public:
        int balance = 0;
        int id = 0;
};

vector<Account*> accounts;
std::mutex mtx;
std::condition_variable cv;
bool stop = false;
int number_of_accounts = 12;
int number_of_transfers = 50000;


void processTransfer(int accountFrom, int accountTo) {
    std::unique_lock<mutex> lck(mtx);

    while (stop == true){
        cv.wait(lck);
    }

    Account* accFrom = accounts[accountFrom];
    Account* accTo = accounts[accountTo];

    accFrom->balance -= 1;
    accTo->balance += 1;
}


int main() {

    for (int i=0;i<number_of_accounts;++i)
        accounts.push_back(new Account{});

    vector<thread> threads;

    for(int i = 0 ; i < number_of_transfers ; ++i){
        int accFrom = rand()%number_of_accounts;
        int accTo = (accFrom + 1)%number_of_accounts;

        threads.push_back(thread{processTransfer, accFrom, accTo});
    }

    for (auto& t : threads) { 
        t.join(); 
    }

    return 0;
}