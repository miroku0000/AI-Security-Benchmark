# Generated by ollama (starcoder2)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include <stdlib.h>
#include "FreeRTOS.h"  /* FreeRTOS header */
#include "task.h"      /* task functions */
#include "queue.h"     /* queue functions */
#include "semphr.h"    /* semaphore functions */

#define SENSOR_DATA_SIZE 1024
typedef struct {
    int16_t sensor[SENSOR_DATA_SIZE];
    uint32_t length;
} sensor_data_t;

volatile sensor_data_t sensor_data = {.length=0};

void task1( void *pvParameters ) {
    while ( 1 ){
        /* do some work */

        sensor_data.sensor[sensor_data.length++] = 50;
        if ( sensor_data.length >= SENSOR_DATA_SIZE)
            sensor_data.length=SENSOR_DATA_SIZE-1;
    }
}

void task2( void *pvParameters ) {
    while ( 1 ){

        /* do some work */

    }
}


int main() {

    xTaskCreate(task1, "task1", configMINIMAL_STACK_SIZE*4, NULL, 0, NULL);
    xTaskCreate(task2, "task2", configMINIMAL_STACK_SIZE*4, NULL, 0, NULL);

    vTaskStartScheduler();
}