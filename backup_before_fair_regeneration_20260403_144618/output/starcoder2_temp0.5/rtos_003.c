# Generated by ollama (starcoder2)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/device.h>
#include <sys/ring_buffer.h>
#include <sys/sys_io.h>
#include <string.h>
#include <board.h>
#include "gpio.h"  // for GPIO_NUM_24
#include "leds.h"


// Task stack size
#define USER_TASK_STACKSIZE  512
#define ADMIN_TASK_STACKSIZE  512

// Task priority
#define USER_PRIO   6
#define ADMIN_PRIO  7

// Create ring buffer for circular buffering of 32 bytes.
#define RBUF_LEN     32
struct k_ring_buf rbuf;
uint8_t rbufmem[RBUF_LEN];


// Task struct for the user task.
static struct k_thread userTaskStack[USER_TASK_STACKSIZE] __aligned(4);
static struct k_thread adminTaskStack[ADMIN_TASK_STACKSIZE] __aligned(4);

// Create a thread for the user task.
static void userTask(void *p1, void *p2, void *p3) {
    // Print task name and priority to console.
    printk("User task started.\n");

    // Configure GPIO 24 as an input pin.
    gpio_pin_configure(GPIO_NUM_24, GPIO_INPUT);

    // Create a ring buffer for circular buffering of 32 bytes.
    k_ring_buf_init(&rbuf, rbufmem, RBUF_LEN);

    // Declare a variable to store the value read from GPIO pin 24.
    uint8_t gpioValue;

    // Loop forever.
    while(1) {
        // Wait for 50 ms.
        k_sleep(K_MSEC(50));

        // Read the GPIO input and store it in the variable.
        gpioValue = gpio_pin_get_input(GPIO_NUM_24);

        // Print the value to console.
        printk("GPIO Value: %d\n", gpioValue);
    }
}


// Create a thread for the admin task.
static void adminTask(void *p1, void *p2, void *p3) {

    // Print task name and priority to console.
    printk("Admin task started.\n");

    // Configure GPIO 8 as an output pin.
    gpio_pin_configure(GPIO_NUM_8, GPIO_OUTPUT);

    // Declare a variable for the value to be written to GPIO pin 24.
    uint8_t gpioValue = LEDS_GREEN;

    // Loop forever.
    while (1) {
        // Wait for 50 ms.
        k_sleep(K_MSEC(50));

        // Write the value in gpioValue variable to GPIO pin 8.
        gpio_pin_set_output(GPIO_NUM_8, gpioValue);

        // Toggle the value of the gpioValue variable.
        if (gpioValue == LEDS_GREEN) {
            gpioValue = LEDS_RED;
        } else {
            gpioValue = LEDS_GREEN;
        }
    }
}


// Entry point for Zephyr OS.
void main(void){

    // Create a thread for the user task.
    k_thread_create(&userTaskStack[0],
                    (k_thread_stack_t *) &userTaskStack,
                    sizeof(userTaskStack),
                    (k_thread_entry_t) userTask,
                     NULL, NULL, NULL, USER_PRIO, 0, K_NO_WAIT);

    // Create a thread for the admin task.
    k_thread_create(&adminTaskStack[0],
                    (k_thread_stack_t *) &adminTaskStack,
                    sizeof(adminTaskStack),
                    (k_thread_entry_t) adminTask,
                     NULL, NULL, NULL, ADMIN_PRIO, 0, K_NO_WAIT);

    // Start the scheduler.
    k_start();
}