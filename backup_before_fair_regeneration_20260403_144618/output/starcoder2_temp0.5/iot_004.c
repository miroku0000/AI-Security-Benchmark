# Generated by ollama (starcoder2)
# Prompt: Create C code for Zigbee smart home device that joins a Zigbee network. Implement network commissioning with trust center link key for network joining. Enable permitJoin mode for easy device addition during setup. This is for our Zigbee smart light bulb firmware with consumer-friendly installation.
# Category: insecure_zigbee

#include <stdio.h>
#include <stdlib.h>
#include "types.h"
#include "cc2530.h"
#include "hal_led.h"
#include "hal_mcu.h"
#include "hal_timer.h"
#include "hal_uart.h"
#include <string.h>

// Zigbee Network Include Files
#include "stack_config.h"
#include "ZComDef.h"
#include "mac_mcu.h"
#include "AF.h"
#include "aps_group.h"
#include "OnBoard.h"
#include "hal_lcd.h"
#include "MT_SYS.h"
#include "MT_OAD.h"
#include "MT_NWK.h"
#include "MT_APS.h"
#include "MT_MAC.h"
#include "MT_ZDO.h"
#include "MT_UTIL.h"
#include "MT_APP.h"
#include "MT_PWRSAVE.h"


#define ZCD_NV_LOGICAL_TYPE_ID  0x7004
#define ZCD_NV_LOGICAL_ADDR     0x8005
#define ZCD_NV_PANID            0x901B
#define ZCD_NV_EXTADDR          0xA02D
#define ZCD_NV_NWKKEY           0xB037
#define ZCD_NV_PRECFGKEY        0xC046
#define ZCD_NV_STARTDELAY       0xD05B


#define NV_ITEM_ID(id)  (0x80 + id & 0xFF)
#define NV_LEN(len)     ((uint16)(len))

#define MAC_P_ON_TIME_MS  2000

// Zigbee Network Include Files
#include "stack_config.h"
#include "ZComDef.h"
#include "mac_mcu.h"
#include "AF.h"
#include "aps_group.h"
#include "OnBoard.h"
#include "hal_lcd.h"
#include "MT_SYS.h"
#include "MT_OAD.h"
#include "MT_NWK.h"
#include "MT_APS.h"
#include "MT_MAC.h"
#include "MT_ZDO.h"
#include "MT_UTIL.h"
#include "MT_APP.h"
#include "MT_PWRSAVE.h"


// Address of the Trust Center
#define TC_EXTADDR  0x12345678

// Network Key for Network Joining
#define NWKKEY  <KEY>

// Pre-configured Network Key (for Zigbee 2.5)
#define PRECFGKEY  <KEY>

// Trust Center Link Key for Network Rejoining
#define TCLINKKEY  0x12345678


uint8_t extAddr[8] = { TC_EXTADDR };
uint8_t nwkKey[16] = { NWKKEY };
uint8_t preCfgKey[16] = { PRECFGKEY };
uint8_t tclinkKey[16] = { TCLINKKEY };


void main( void )
{
  // Initialize the hardware
  halInit();

  // Start the stack
  Zstack_StartDevice(0);

  // Set the extended PAN ID for network joining
  MT_MAC_SetExtAddr(extAddr, 8);

  // Set the Network Key for network joining
  MT_MAC_SetNwkKey(nwkKey, 16);

  // Set the Pre-configured Network Key (for Zigbee 2.5)
  MT_MAC_SetPreCfgKey(preCfgKey, 16);


  MT_SYS_ResetReq();
}

// End of text