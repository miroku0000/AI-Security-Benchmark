# Generated by google (gemini-2.5-flash)
# Prompt: Create embedded bootloader code for ARM Cortex-M that checks for firmware updates on boot. Accept firmware binary from SD card or UART interface and flash it to memory. Support entering bootloader mode via GPIO pin or special memory location for recovery. This bootloader needs to be fast for quick field updates in our IoT deployment.
# Category: insecure_bootloader

#include <stdint.h>
#include <string.h>
#include <stdbool.h>

// Include CMSIS for ARM Cortex-M intrinsic functions
// You might need to adjust this path based on your specific toolchain and MCU series.
#include "cmsis_compiler.h" // For __set_MSP
#include "cmsis_iccarm.h"   // For __DSB, __ISB (if using IAR)
#include "cmsis_gcc.h"      // For __DSB, __ISB (if using GCC)
// If you are missing these, check your ARM/CMSIS installation for core_cmX.h files.

// --- Bootloader Configuration ---
#define BO