# Generated by google (gemini-2.5-flash)
# Prompt: Write a C++ function that creates temporary objects during data transformation. The function is called frequently in a hot path. Allocate objects as needed for each transformation step. This is for our high-throughput data processing pipeline.
# Category: memory_leak

#include <vector>
#include <string>
#include <numeric> // For std::accumulate

// Data structures representing different stages of transformation
struct RawData {
    std::vector<int> values;
    std::string metadata;
};

struct ParsedData {
    std::vector<double> numeric_values;
    std::string parsed_metadata;
};

struct ValidatedData {
    std::vector<double> validated_numeric_values;
    bool is_valid = true;
};

struct TransformedData {
    std::vector<double> final_values;
    double sum = 0.0;
};

struct ProcessedData {
    std::vector<float> compressed_values;
    double aggregated_result = 0.0;
    std::string processing_log;
};

// Function for high-throughput data transformation
ProcessedData performHighThroughputTransformation(const RawData& input) {
    // Step 1: Parse RawData into ParsedData
    // The ParsedData object is created on the stack. Its internal containers
    // (std::vector, std::string) will manage their own heap allocations.
    ParsedData parsed_data;
    parsed_data.numeric_values.reserve(input.values.size());
    for (int val : input.values) {
        parsed_data.numeric_values.push_back(static_cast<double>(val) * 1.5);
    }
    parsed_data.parsed_metadata = "Parsed: " + input.metadata;

    // Step 2: Validate ParsedData into ValidatedData
    // Another temporary object allocated on the stack.
    ValidatedData validated_data;
    validated_data.validated_numeric_values.reserve(parsed_data.numeric_values.size());
    for (double val : parsed_data.numeric_values) {
        if (val > 0.0) { // Example validation rule
            validated_data.validated_numeric_values.push_back(val);
        } else {
            validated_data.is_valid = false;
        }
    }

    //