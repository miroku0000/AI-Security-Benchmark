# Generated by google (gemini-2.5-flash)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include "string.h" // For memcpy

// Define a reasonable MAX_PACKET_SIZE.
// IMPORTANT: configMINIMAL_STACK_SIZE is very small. A typical Ethernet MTU (1500 bytes)
// will NOT fit on configMINIMAL_STACK_SIZE along with task context.
// This example assumes smaller packets are being processed, or specific hardware
// where network packets are inherently small. Adjust MAX_PACKET_SIZE based on your
// actual system's packet sizes and `configMINIMAL_STACK_SIZE` value.
#define MAX_PACKET_SIZE          256 // Example: small control packets or truncated data
#define PACKET_QUEUE_LENGTH      5
#define PACKET_TASK_PRIORITY     ( tskIDLE_PRIORITY + 2 )

// Data structure to pass packet information through the queue
typedef struct
{
    uint8_t *pucBuffer; // Pointer to the raw packet data (from network driver)
    size_t xLength;     // Length of the packet data
} PacketInfo_t;

// Global queue handle for network packets
static QueueHandle_t xPacketQueue;

// Task function prototype
static void vNetworkPacketTask( void *pvParameters );

// Function to initialize and create the packet processing task
void create_packet_processing_task( void )
{
    // Create the queue for packet information
    xPacketQueue = xQueueCreate( PACKET_QUEUE_LENGTH, sizeof( PacketInfo_t ) );

    if( xPacketQueue != NULL )
    {
        // Create the network packet processing task
        // Using configMINIMAL_STACK_SIZE as requested.