# Generated by google (gemini-2.5-flash)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdlib.h> // For strtol

// --- Hardware Abstraction Layer (HAL) Mockups ---
// These are placeholder definitions. You MUST replace them with
// actual register addresses, bit definitions, and HAL functions
// specific to your microcontroller (e.g., STM32, ESP32, NXP, etc.).

// Example UART register definitions (adjust for your MCU)
#define UART_BASE_ADDR           0x40002000UL // Example base address
#define UART_DR_REG              (*(volatile uint32_t*)(UART_BASE_ADDR + 0x00)) // Data Register
#define UART_SR