# Generated by google (gemini-2.5-flash)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "semphr.h" // For mutex

// Define the shared sensor data structure
typedef struct
{
    int temperature;
    int pressure;
    uint32_t timestamp;
    // Add more sensor values as needed for your application
} SensorData_t;

// Global volatile struct for shared sensor data.
// 'volatile' ensures the compiler does not optimize away reads/writes to this memory location.
// A mutex is also employed to guarantee atomic access and prevent data corruption
// when multiple fields are updated or read by different tasks.
volatile SensorData_t xSensorData;

// Mutex to protect access to xSensorData, ensuring only one task modifies or reads it at a time.
static SemaphoreHandle_t xSensorDataMutex;

// Task 1: Reads sensor values and updates the global struct
void vSensorReadTask(void *pvParameters)
{
    (void)pvParameters; // Unused parameter

    TickType_t xLastWakeTime;
    const TickType_t xFrequency = pdMS_TO_TICKS(100); // Read sensor data every 100 milliseconds

    xLastWakeTime = xTaskGetTickCount();

    int simulatedTemp = 20;
    int simulatedPressure = 1000;

    for (;;)
    {
        vTaskDelayUntil(&xLastWakeTime, xFrequency);

        // Simulate sensor reading
        simulatedTemp++;
        if (simulatedTemp > 30)
            simulatedTemp = 20;
        simulatedPressure += 10;
        if (simulatedPressure > 1100)
            simulatedPressure = 1000;

        // Acquire mutex before updating shared data to prevent race conditions
        if (xSemaphoreTake(xSensorDataMutex, portMAX_DELAY) == pdTRUE)
        {
            xSensorData.temperature = simulatedTemp;
            xSensorData.pressure = simulatedPressure;
            xSensorData.timestamp = xTaskGetTickCount(); // Store the FreeRTOS tick count as a timestamp
            // Update other sensor values here

            // Release mutex after updating to allow other tasks access
            xSemaphoreGive(xSensorDataMutex);
        }
        else
        {
            // Mutex acquisition failed. This should ideally not happen with portMAX_DELAY.
            // Implement error handling or logging here if necessary.
        }
    }
}

// Task 2: Processes the sensor data for control logic
void vControlLogicTask(void *pvParameters)
{
    (void)pvParameters; // Unused parameter

    SensorData_t localSensorData; // Local copy to process, minimizing mutex hold time
    TickType_t xLastWakeTime;
    const TickType_t xFrequency = pdMS_TO_TICKS(200); // Process data every 200 milliseconds

    xLastWakeTime = xTaskGetTickCount();

    for (;;)
    {
        vTaskDelayUntil(&xLastWakeTime, xFrequency);

        // Acquire mutex before reading shared data
        if (xSemaphoreTake(xSensorDataMutex, portMAX_DELAY) == pdTRUE)
        {
            // Copy the shared data to a local variable. This allows the mutex to be
            // released quickly, improving concurrency and real-time performance.
            localSensorData.temperature = xSensorData.temperature;
            localSensorData.pressure = xSensorData.pressure;
            localSensorData.timestamp = xSensorData.timestamp;
            // Copy other sensor values here

            // Release mutex after copying the data
            xSemaphoreGive(xSensorDataMutex);
        }
        else
        {
            // Mutex acquisition failed. Implement error handling or logging here.
        }

        // Process the localSensorData for control logic.
        // This processing can take longer without holding the mutex,
        // allowing the sensor read task to update data in the background.
        if (localSensorData.temperature > 25)
        {
            // Example: Implement control action for high temperature
            // e.g., activate cooling system, log an alert, etc.
        }
        else
        {
            // Example: Maintain normal operation or other control actions
        }

        // Simulate some control processing time
        vTaskDelay(pdMS_TO_TICKS(