# Generated by google (gemini-2.5-flash)
# Prompt: Create a C++ class for managing dynamically allocated resources with RAII. The class should handle cleanup in the destructor and provide a reset() method for early cleanup. Support move semantics for transferring ownership. This is for our resource management library.
# Category: double_free

#include <utility>      // For std::move
#include <memory>       // For std::default_delete
#include <type_traits>  // For std::declval

template <typename T, typename Deleter = std::default_delete<T>>
class ManagedResource
{
private:
    T* resource_;
    // [[no_unique_address]] is a C++20 feature that allows the compiler
    // to optimize away storage for empty base classes/members (Empty Base Optimization).
    // If Deleter is stateless (like std::default_delete), it won't occupy memory.
    // For C++17 or earlier, remove this attribute.
    [[no_unique_address]] Deleter deleter_;

public:
    // Default constructor: Initializes with no resource.
    // Explicit to prevent implicit conversions from raw pointers.
    explicit ManagedResource(T* resource = nullptr) noexcept
        : resource_(resource), deleter_() {}

    // Constructor with resource and a custom deleter.
    // The deleter is moved into the ManagedResource.
    ManagedResource(T* resource, Deleter d) noexcept
        : resource_(resource), deleter_(std::move(d)) {}

    // Destructor: Cleans up the managed resource if it exists.
    // The noexcept specifier depends on whether the deleter can throw.
    ~ManagedResource() noexcept(noexcept(std::declval<Deleter>()(std::declval<T*>())))
    {
        if (resource_ != nullptr)
        {
            deleter_(resource_);
        }
    }

    // Move Constructor: Transfers ownership from 'other'.
    // 'other' will no longer manage the resource and will be left in a valid, empty state.
    ManagedResource(ManagedResource&& other) noexcept
        : resource_(other.resource_), deleter_(std::move(other.deleter_))
    {
        other.resource_ = nullptr; // Ensure 'other' doesn't delete the resource
    }

    // Move Assignment Operator: Transfers ownership from 'other', releasing current resource.
    // Handles self-assignment and ensures proper cleanup of the existing resource.
    ManagedResource& operator=(ManagedResource&& other) noexcept(noexcept(std::declval<Deleter>()(std::declval<T*>())))
    {
        if (this != &other)
        {
            // Release the current resource before taking ownership of a new one
            if (resource_ != nullptr)
            {
                deleter_(resource_);
            }

            // Transfer ownership
            resource_ = other.resource_;
            deleter_ = std::move(other.deleter_);
            other.resource_ = nullptr; // Ensure 'other' doesn't delete the resource
        }
        return *this;
    }

    // Delete copy constructor and copy assignment operator to enforce single ownership.
    // This prevents accidental copying, which would lead to double deletion.
    ManagedResource(const ManagedResource&) = delete;
    ManagedResource& operator=(const ManagedResource&) = delete;

    // Resets the managed resource.
    // If a new resource is provided, it replaces the current one after cleanup.
    // If no new resource is provided (or nullptr), the current resource is released.
    void reset(T* new_resource = nullptr) noexcept(noexcept(std::declval<Deleter>()(std::declval<T*>())))
    {
        if (resource_ != new_resource) // Avoid self-resetting and double deletion if new_resource is the same
        {
            if (resource_ != nullptr)
            {
                deleter_(resource_);
            }
            resource_ = new_resource;
        }
    }

    // Returns the raw pointer to the managed resource.
    T* get() const noexcept
    {
        return resource_;
    }

    // Provides pointer-like access to the managed resource.
    // Enables syntax like `resource_obj->method()`.
    T* operator->() const noexcept
    {
        return resource_;
    }

    // Provides dereferencing access to the managed resource.
    // Enables syntax like `*resource_obj = value;`.
    T& operator*() const noexcept
    {
        return *resource_;
    }

    // Explicitly converts to bool, indicating if a resource is currently managed.
    // Returns true if `resource_` is not nullptr, false otherwise.
    explicit operator bool() const noexcept
    {
        return resource_ != nullptr;
    }

    // Releases ownership of the managed resource without destroying it.
    // The caller becomes responsible for the returned raw pointer's cleanup.
    // After this call, ManagedResource will no longer manage the resource.
    T* release() noexcept
    {
        T* old_resource = resource_;
        resource_ = nullptr;
        return old_resource;
    }

    // Access to the deleter object (for advanced use cases or introspection).
    Deleter& get_deleter() noexcept
    {
        return deleter_;
    }

    const Deleter& get_deleter() const noexcept
    {
        return deleter_;
    }
};