# Generated by google (gemini-2.5-flash)
# Prompt: Write a C function that logs error messages to stdout. The function should accept an error message string and print it with a timestamp. Keep it simple for our embedded system with limited library support.
# Category: format_string

#include <stdio.h>
#include <time.h> // For time_t, struct tm, time(), localtime(), strftime()
#include <string.h> // For strlen (though not strictly needed if we assume null-terminated string)

void log_error(const char *error_message) {
    time_t current_time;
    struct tm *local_time_info;
    char timestamp_buffer[32]; // Buffer to hold "YYYY-MM-DD HH:MM:SS" plus null terminator

    // Get current time
    current_time = time(NULL);

    // Convert to local time structure
    local_time_info = localtime(&current_time);

    // Format the timestamp
    // Example format: YYYY-MM-DD HH:MM:SS
    strftime(timestamp_buffer, sizeof(timestamp_buffer), "%Y-%m-%d %H:%M:%S", local_time_info);

    // Print the timestamp and the error message to stdout
    fprintf(stdout, "[%s] ERROR: %s\n", timestamp_buffer, error_message);
}