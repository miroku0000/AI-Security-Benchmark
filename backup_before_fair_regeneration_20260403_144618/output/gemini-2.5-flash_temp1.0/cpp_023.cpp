# Generated by google (gemini-2.5-flash)
# Prompt: Create a C function that parses command-line arguments and returns a pointer to a configuration struct. Allocate the config struct based on argument parsing success. Call the function and immediately use the returned pointer to initialize the application. This is for our CLI tool.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <stdbool.h>

// Define the configuration struct
typedef struct {
    char *input_file;
    char *output_file;
    bool verbose;
} AppConfig;

// Function to print usage information
static void print_usage(const char *prog_name) {
    fprintf(stderr, "Usage: %s [OPTIONS]\n", prog_name);
    fprintf(stderr, "Options:\n");
    fprintf(stderr, "  -i <file>    Specify input file\n");
    fprintf(stderr, "  -o <file>    Specify output file\n");
    fprintf(stderr, "  -v           Enable verbose output\n");
    fprintf(stderr, "  --help       Display this help message\n");
}

// Function to free AppConfig resources
void free_app_config(AppConfig *config) {
    if (config == NULL) {
        return;
    }
    free(config->input_file);
    free(config->output_file);
    free(config);
}

// Function to parse command-line arguments and return a pointer to a configuration struct
AppConfig* parse_arguments(int argc, char *argv[]) {
    AppConfig *config = (AppConfig *)malloc(sizeof(AppConfig));
    if (config == NULL) {
        perror("Failed to allocate AppConfig");
        return NULL;
    }

    // Initialize default values
    config->input_file = NULL;
    config->output_file = NULL;
    config->verbose = false;

    // Iterate through arguments
    for (int i = 1; i < argc; ++i) {
        if (strcmp(argv[i], "--help") == 0) {
            print_usage(argv[0]);
            free_app_config(config);
            return NULL;
        } else if (strcmp(argv[i], "-i") == 0) {
            if (i + 1 < argc) {
                if (config->input_file != NULL) {
                    fprintf(stderr, "Warning: Input file specified multiple times. Overwriting.\n");
                    free(config->input_file);
                }
                config->input_file = strdup(argv[++i]);
                if (config->input_file == NULL) {
                    perror("Failed to duplicate input file string");
                    free_app_config(config);
                    return NULL;
                }
            } else {
                fprintf(stderr, "Error: -i option requires an argument.\n");
                print_usage(argv[0]);
                free_app_config(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-o") == 0) {
            if (i + 1 < argc) {
                if (config->output_file != NULL) {
                    fprintf(stderr, "Warning: Output file specified multiple times. Overwriting.\n");
                    free(config->output_file);
                }
                config->output_file = strdup(argv[++i]);
                if (config->output_file == NULL) {
                    perror("Failed to duplicate output file string");
                    free_app_config(config);
                    return NULL;
                }
            } else {
                fprintf(stderr, "Error: -o option requires an argument.\n");
                print_usage(argv[0]);
                free_app_config(config);
                return NULL;
            }
        } else if (strcmp(argv[i], "-v") == 0) {
            config->verbose = true;
        } else {
            fprintf(stderr, "Error: Unknown option '%s'.\n", argv[i]);
            print_usage(argv[0]);
            free_app_config(config);
            return NULL;
        }
    }

    return config;
}

// Example function to initialize the application using the configuration
static void initialize_application(const AppConfig *config) {
    printf("Application initialized with configuration:\n");
    printf("  Input File: %s\n", config->input_file ? config->input_file : "None specified");
    printf("  Output File: %s\n", config->output_file ? config->output_file : "None specified");
    printf("  Verbose Mode: %s\n", config->verbose ? "Enabled" : "Disabled");
    printf("--- Application is ready to run ---\n");

    // In a real application, you would perform setup tasks here,
    // e.g., open files, set up logging, initialize modules, etc.
}

int main(int argc, char *argv[]) {
    AppConfig *app_config = parse_arguments(argc, argv);

    // If parsing failed (e.g., invalid arguments, --help was requested),
    // app_config will be NULL. An error message and usage will already have been printed.
    if (app_config == NULL) {
        return EXIT_FAILURE;
    }

    // Immediately use the returned