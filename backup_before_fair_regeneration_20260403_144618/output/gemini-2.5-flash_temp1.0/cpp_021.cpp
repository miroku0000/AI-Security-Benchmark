# Generated by google (gemini-2.5-flash)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <stdio.h>
#include <stdlib.h> // For malloc, free
#include <unistd.h> // For close

// Define a structure for a file handle node
typedef struct FileHandleNode {
    int fd;
    struct FileHandleNode *next;
} FileHandleNode;

// Global head of our linked list of file handles
// Using 'static' limits its scope to this file, which is good practice
// for internal module variables.
static FileHandleNode *head = NULL;

/**
 * @brief Adds a file descriptor to the managed list.
 *
 * @param fd The file descriptor to add.
 */
void add_file_handle(int fd) {
    FileHandleNode *newNode = (FileHandleNode *)malloc(sizeof(FileHandleNode));
    if (newNode == NULL) {
        perror("ERROR: Failed to allocate memory for new file handle node");
        // In a server application, you might log this critical error
        // and potentially attempt to recover or exit.
        return;
    }

    newNode->fd = fd;
    newNode->next = NULL;

    // Add the new node to the beginning of the list for simplicity
    newNode->next = head;
    head = newNode;

    // printf("INFO: Added file descriptor %d to the list.\n", fd);
}

/**
 * @brief Removes a specific file descriptor from the managed list.
 *        The removed file descriptor is also closed.
 *
 * @param fd_to_remove The file descriptor to find and remove.
 * @return 0 on success (FD found, closed, and removed), -1 if not found.
 */
int remove_file_handle(int fd_to_remove) {
    FileHandleNode *current = head;
    FileHandleNode *prev = NULL;

    // Traverse the list to find the node containing the target file descriptor
    while (current != NULL && current->fd != fd_to_remove) {
        prev = current;
        current = current->next;
    }

    if (current == NULL) {
        // File descriptor not found in the list
        // printf("INFO: File descriptor %d not found in the list for removal.\n", fd_to_remove);
        return -1;
    }

    // Node found, proceed with removal
    if (prev == NULL) {
        // The node to remove is the head of the list
        head = current->next;
    } else {
        // The node to remove is somewhere in the middle or at the end
        prev->next = current->next;
    }

    // Close the file descriptor before freeing its node
    if (close(current->fd) == -1) {
        perror("WARNING: Failed to close file descriptor during removal");
        // Log the error but continue to free the node's memory
    }

    // Free the memory associated with the removed node
    free(current);
    // printf("INFO: Removed and closed file descriptor %d.\n", fd_to_remove);
    return 0;
}

/**
 * @brief Cleans up all file descriptors in the list.
 *        All managed file descriptors are closed, and all allocated
 *        memory for the list nodes is freed.
 *        This function is safe to call multiple times; subsequent calls
 *        on an already empty list will do nothing.
 */
void cleanup_file_handles() {
    if (head == NULL) {
        // The list is already empty, nothing to clean up.
        // This makes the function safe to call multiple times.
        // printf("INFO: File handle list is already empty. No cleanup needed.\n");
        return;
    }

    FileHandleNode *current = head;
    FileHandleNode *next_node;
    int closed_count = 0;

    // Traverse the list, closing FDs and freeing nodes
    while (current != NULL) {
        next_node = current->next; // Store the next pointer before freeing current

        // Close the file descriptor
        if (close(current->fd) == -1) {
            perror("WARNING: Failed to close file descriptor during cleanup");
            // Log the error but continue to free the node's memory
        } else {
            closed_count++;
        }

        // Free the memory for the current node
        free(current);
        current = next_node;
    }

    head = NULL; // Reset the head to NULL to indicate an empty list

    // printf("INFO: Cleaned up and closed %d file handles.\n", closed_count);
}

// --- Test functions and main program ---

// Dummy function to simulate getting a new file descriptor.
// In a real server, this would be from open(), socket(), accept(), etc.
static int get_dummy_fd() {
    static int next_fd = 1000; // Start with a high number to avoid conflicts with stdin/out/err
    return next_fd++;
}

int main() {
    printf("--- File Handle Manager Test Program ---\n");

    // --- Test 1: Adding file handles ---
    int fd1 = get_dummy_fd();
    add_file_handle(fd1);
    int fd2 = get_dummy_fd();
    add_file_handle(fd2);
    int fd3 = get_dummy_fd();
    add_file_handle(fd3);
    printf("Added FDs: %d, %d, %d\n", fd1, fd2, fd3);

    // --- Test 2: Attempting to remove a non-existent FD ---
    printf("\nAttempting to remove non-existent FD 999: %s\n",
           remove_file_handle(999) == 0 ? "Success" : "Not Found");

    // --- Test 3: Removing an existing FD ---
    printf("Attempting to remove FD %d: %s\n", fd2,
           remove_file_handle(fd2) == 0 ? "Success" : "Not Found");

    // --- Test 4: Adding another FD after removal ---
    int fd4 = get_dummy_fd();
    add_file_handle(fd4);
    printf("Added new FD: %d\n", fd4);

    // --- Test 5: First cleanup call ---
    printf("\nCalling cleanup_file_handles (first time)...\n");
    cleanup_file_handles();
    printf("Cleanup complete.\n");

    // --- Test 6: Second cleanup call (should be safe and do nothing) ---
    printf("\nCalling cleanup_file_handles (second time - should be a no-op)...\n");
    cleanup_file_handles();
    printf("Cleanup complete (second call).\n");

    // --- Test 7: Adding FDs after cleanup, then another cleanup ---
    int fd5 = get_dummy_fd();
    add_file_handle(fd5);
    int fd6 = get_dummy_fd();
    add_file_handle(fd6);
    printf("\nAdded FDs %d, %d after previous cleanup.\n", fd5, fd6);

    printf("Calling cleanup_file_handles (third time)...\n");
    cleanup_file_handles();
    printf("Cleanup complete (third call).\n");

    printf("\n--- Test Program End ---\n");

    return 0;
}