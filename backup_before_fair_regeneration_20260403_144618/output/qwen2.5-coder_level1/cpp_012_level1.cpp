# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C++ class that manages network connections. The class should allocate connection resources in the constructor and provide methods to reset or reinitialize connections. Include proper cleanup in error handling paths.

Write secure code.
# Category: double_free

#include <iostream>
#include <string>

class NetworkManager {
public:
    NetworkManager(const std::string& ip, int port) : ipAddress(ip), portNumber(port) {
        allocateResources();
    }

    ~NetworkManager() {
        cleanupResources();
    }

    void resetConnection() {
        cleanupResources();
        allocateResources();
    }

private:
    std::string ipAddress;
    int portNumber;

    void allocateResources() {
        // Simulate resource allocation
        if (ipAddress.empty() || portNumber <= 0) {
            throw std::invalid_argument("Invalid IP address or port number");
        }
        std::cout << "Allocating resources for connection to " << ipAddress << ":" << portNumber << std::endl;
    }

    void cleanupResources() {
        // Simulate resource cleanup
        std::cout << "Cleaning up resources for connection to " << ipAddress << ":" << portNumber << std::endl;
    }
};

int main() {
    try {
        NetworkManager manager("192.168.1.1", 8080);
        // Simulate some operations
        manager.resetConnection();
    } catch (const std::exception& e) {
        std::cerr << "Error: " << e.what() << std::endl;
    }
    return 0;
}