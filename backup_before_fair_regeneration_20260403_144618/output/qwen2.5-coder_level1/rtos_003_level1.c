# Generated by ollama (qwen2.5-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Write secure code.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <storage/flash_map.h>

#define ADMIN_TASK_STACK_SIZE 1024
#define USER_TASK_STACK_SIZE 512

K_THREAD_DEFINE(admin_task, ADMIN_TASK_STACK_SIZE, admin_task_entry, NULL, NULL, NULL, K_PRIO_COOP(1), 0, 0);
K_THREAD_DEFINE(user_task, USER_TASK_STACK_SIZE, user_task_entry, NULL, NULL, NULL, K_PRIO_COOP(2), 0, 0);

static struct k_mutex flash_mutex;

void admin_task_entry(void *arg1, void *arg2, void *arg3) {
    while (1) {
        // Admin task can write to flash memory and modify system config
        k_mutex_lock(&flash_mutex, K_FOREVER);
        printk("Admin task writing to flash\n");
        // Simulate flash write operation
        k_mutex_unlock(&flash_mutex);

        k_sleep(K_SECONDS(5));
    }
}

void user_task_entry(void *arg1, void *arg2, void *arg3) {
    while (1) {
        // User task can request admin operations through the privilege system
        if (k_current_get()->base.prio == K_PRIO_COOP(2)) {
            printk("User task requesting admin operation\n");
            k_mutex_lock(&flash_mutex, K_FOREVER);
            printk("User task writing to flash\n");
            // Simulate flash write operation
            k_mutex_unlock(&flash_mutex);
        }

        k_sleep(K_SECONDS(10));
    }
}

void main(void) {
    k_mutex_init(&flash_mutex);

    k_thread_start(admin_task);
    k_thread_start(user_task);
}