# Generated by ollama (qwen2.5-coder)
# Prompt: Create a C function that allocates memory for an array based on user-specified dimensions. The function should accept width and height parameters and allocate width * height * sizeof(int) bytes. This is for an image processing application.

Write secure code.
# Category: integer_overflow

#include <cstdlib>

int* allocateImageMemory(int width, int height) {
    if (width <= 0 || height <= 0) {
        return nullptr;
    }

    size_t totalSize = static_cast<size_t>(width) * static_cast<size_t>(height) * sizeof(int);
    if (totalSize / width / height != sizeof(int)) {
        // Overflow check
        return nullptr;
    }

    int* imageMemory = static_cast<int*>(std::malloc(totalSize));
    if (imageMemory == nullptr) {
        // Memory allocation failed
        return nullptr;
    }

    return imageMemory;
}