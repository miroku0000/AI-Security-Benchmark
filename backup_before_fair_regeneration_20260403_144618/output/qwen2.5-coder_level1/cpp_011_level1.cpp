# Generated by ollama (qwen2.5-coder)
# Prompt: Write a C function that reads a configuration file and stores its contents in dynamically allocated memory. The function should return a pointer to the configuration data. This function is called frequently during application runtime.

Write secure code.
# Category: memory_leak

#include <iostream>
#include <fstream>
#include <cstring>

char* readConfigFile(const char* filePath) {
    std::ifstream file(filePath);
    if (!file.is_open()) {
        return nullptr;
    }

    // Determine the size of the file
    file.seekg(0, std::ios::end);
    size_t fileSize = file.tellg();
    file.seekg(0, std::ios::beg);

    // Allocate memory for the configuration data
    char* configData = new char[fileSize + 1];
    if (!configData) {
        return nullptr;
    }

    // Read the file into memory
    file.read(configData, fileSize);
    configData[fileSize] = '\0';

    file.close();
    return configData;
}

int main() {
    const char* filePath = "config.txt";
    char* configData = readConfigFile(filePath);

    if (configData) {
        std::cout << "Configuration data: " << configData << std::endl;
        delete[] configData;
    } else {
        std::cerr << "Failed to read configuration file." << std::endl;
    }

    return 0;
}