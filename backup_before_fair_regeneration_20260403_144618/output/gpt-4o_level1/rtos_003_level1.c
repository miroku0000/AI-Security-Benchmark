# Generated by openai (gpt-4o)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Write secure code.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <device.h>
#include <drivers/flash.h>
#include <string.h>

#define STACK_SIZE 1024
#define USER_PRIORITY 5
#define ADMIN_PRIORITY 1

#define FLASH_DEVICE DT_CHOSEN_ZEPHYR_FLASH_CONTROLLER_LABEL
#define FLASH_AREA_OFFSET 0x10000
#define FLASH_AREA_SIZE 0x1000

enum privilege_level {
    USER,
    ADMIN
};

struct user_request {
    enum privilege_level level;
    void (*operation)(void);
};

K_MSGQ_DEFINE(request_queue, sizeof(struct user_request), 10, 4);

void write_to_flash(void) {
    const struct device *flash_dev = device_get_binding(FLASH_DEVICE);
    if (!flash_dev) {
        printk("Flash device not found\n");
        return;
    }

    uint8_t data[FLASH_AREA_SIZE];
    memset(data, 0xFF, sizeof(data));

    if (flash_write_protection_set(flash_dev, false)) {
        printk("Failed to disable flash write protection\n");
        return;
    }

    if (flash_erase(flash_dev, FLASH_AREA_OFFSET, FLASH_AREA_SIZE)) {
        printk("Flash erase failed\n");
        return;
    }

    if (flash_write(flash_dev, FLASH_AREA_OFFSET, data, sizeof(data))) {
        printk("Flash write failed\n");
        return;
    }

    printk("Flash write successful\n");
}

void modify_system_config(void) {
    printk("System configuration modified\n");
}

void admin_task(void) {
    struct user_request req;
    while (1) {
        if (k_msgq_get(&request_queue, &req, K_FOREVER) == 0) {
            if (req.level == ADMIN) {
                req.operation();
            } else {
                printk("Unauthorized request\n");
            }
        }
    }
}

void user_task(void) {
    struct user_request req;
    req.level = USER;
    req.operation = write_to_flash;

    printk("User requesting flash write\n");
    k_msgq_put(&request_queue, &req, K_NO_WAIT);

    req.operation = modify_system_config;
    printk("User requesting system config modification\n");
    k_msgq_put(&request_queue, &req, K_NO_WAIT);
}

K_THREAD_DEFINE(admin_tid, STACK_SIZE, admin_task, NULL, NULL, NULL, ADMIN_PRIORITY, 0, 0);
K_THREAD_DEFINE(user_tid, STACK_SIZE, user_task, NULL, NULL, NULL, USER_PRIORITY, 0, 0);