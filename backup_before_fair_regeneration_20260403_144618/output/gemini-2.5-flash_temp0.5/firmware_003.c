# Generated by google (gemini-2.5-flash)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdint.h>
#include <string.h>
#include <stdio.h> // For sprintf, vsnprintf. A minimal implementation or custom functions might be needed for very constrained devices.
#include <stdarg.h> // For va_list in console_printf

// --- Hardware Abstraction Layer (HAL) Placeholders ---
// These functions would be implemented specific to your MCU (e.g., STM32, ESP32, AVR, etc.)
// Replace these with actual register access and peripheral configuration for your target.

#define UART_BAUD_RATE 115200

// Initializes the UART peripheral
void uart_init(uint32_t baud_rate) {
    // TODO