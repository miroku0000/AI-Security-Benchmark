# Generated by google (gemini-2.5-flash)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "string.h" // For memcpy

// Define the maximum packet size expected.
// IMPORTANT: This size *must* be small enough to fit within the task's stack
// (configMINIMAL_STACK_SIZE) along with other local variables and function call
// stack frames. For example, if configMINIMAL_STACK_SIZE is 128 words (512 bytes
// on a 32-bit system), a 128-byte packet buffer is likely acceptable, but a
// 1500-byte Ethernet MTU packet buffer would cause an immediate stack overflow.
// Adjust this value based on your actual packet sizes and FreeRTOS configuration.
#define MAX_PACKET_SIZE 128

// Forward declaration of the task function
void vNetworkPacketProcessingTask(void *pvParameters);

// --- Dummy Network Driver Simulation ---
// In a real system, these functions would interact with actual network hardware
// or a network stack to receive and potentially release packet buffers.

// This function simulates receiving a packet from a network driver.
// It blocks until a packet is "available" and provides a pointer to the
// received data and its length. In a real scenario, `ppPacketData` might
// point to a driver-internal buffer that needs to be copied out quickly.
static void xNetworkDriver_ReceivePacket(uint8_t **ppPacketData, size_t *pPacketLength) {
    // Simulate waiting for a packet to arrive
    vTaskDelay(pdMS_TO_TICKS(100)); // Wait 100ms

    // Simulate a received packet.
    // In a real system, this might be a pointer to a buffer in the driver's memory
    // or a dynamically allocated buffer.
    static uint8_t dummyPacketData[MAX_PACKET_SIZE];
    static uint8_t packetCounter = 0;

    // Populate dummy data for demonstration
    for (int i = 0; i < MAX_PACKET_SIZE; i++) {
        dummyPacketData[i] = packetCounter + i;
    }
    *ppPacketData = dummyPacketData;
    *pPacketLength = MAX_PACKET_SIZE; // Assume full packet for simplicity

    packetCounter++;
}

// Dummy function to process the packet data.
// In a real application, this would parse headers, extract payload,
// route data, etc.
static void vProcessPacket(const uint8_t *pPacketData, size_t packetLength) {
    (void)pPacketData;    // Avoid unused parameter warning
    (void)packetLength; // Avoid unused parameter warning

    // Example: In a real system, you might log or process the data.
    // For instance, if FreeRTOS+CLI is enabled:
    // configPRINTF(("Packet received, length: %d, first byte: 0x%02X\r\n", packetLength, pPacketData[0]));
}

// --- Network Packet Processing Task ---
void vNetworkPacketProcessingTask(void *pvParameters) {
    (void)pvParameters; // Avoid unused parameter warning

    uint8_t *pReceivedData = NULL; // Pointer to data from the network driver
    size_t receivedLength = 0;     // Length of data from the network driver

    for (;;) {
        // Step 1: Wait for and receive a packet from the network driver.
        // This function call is assumed to block until a packet is available,
        // and provides a pointer to the received data and its length.
        // The pointer `pReceivedData` might point to a driver-internal buffer
        // that needs to be processed quickly or copied.
        xNetworkDriver_ReceivePacket(&pReceivedData, &receivedLength);

        // Step 2: Declare a buffer on the task's stack to copy the packet data.
        // This ensures the task owns its data, isolates it from the driver,
        // and allows the driver to potentially reuse its internal buffers.
        uint8_t packetBuffer[MAX_PACKET_SIZE];

        // Step 3: Copy the received packet data into the