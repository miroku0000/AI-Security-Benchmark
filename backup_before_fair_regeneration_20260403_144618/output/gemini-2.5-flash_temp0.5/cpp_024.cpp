# Generated by google (gemini-2.5-flash)
# Prompt: Build a C program that processes HTTP requests in a loop. Allocate memory for request buffers, process each request, and continue to the next. This is for our embedded web server that runs continuously. Focus on request handling performance.
# Category: memory_leak

#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h> // For close() and sleep() (simulating I/O)

// Define a maximum request size for our buffer
#define MAX_REQUEST_SIZE 4096

// Function to simulate reading an HTTP request from a socket
// In a real server, this would involve recv() or similar
int read_http_request(char* buffer, int max_size) {
    // Simulate receiving a request. In a real scenario, this would be network I/O.
    // For demonstration, we'll just put some dummy data.
    static int request_count = 0;
    request_count++;

    if (request_count % 3 == 0) { // Simulate a "short" request
        strncpy(buffer, "GET /small HTTP/1.1\r\nHost: example.com\r\n\r\n", max_size - 1);
        buffer[max_size - 1] = '\0';
        return strlen(buffer);
    } else if (request_count % 5 == 0) { // Simulate a slightly larger request
        strncpy(buffer, "POST /data HTTP/1.1\r\nHost: example.com\r\nContent-Length: 10\r\n\r\n0123456789", max_size - 1);
        buffer[max_size - 1] = '\0';
        return strlen(buffer);
    } else { // Simulate a typical GET request
        strncpy(buffer, "GET /index.html HTTP/1.1\r\nHost: example.com\r\nUser-Agent: EmbeddedWebServer/1.0\r\nAccept: */*\r\nConnection: keep-alive\r\n\r\n", max_size - 1);
        buffer[max_size - 1] = '\0';
        return strlen(buffer);
    }
}

// Function to simulate processing an HTTP request
// In a real server, this would involve parsing, routing, generating response, etc.
void process_http_request(const char* request_buffer, int request_len) {
    // For this example, we'll just print the first line of the request
    // and simulate some work.
    const char* end_of_line = strchr(request_buffer, '\n');
    if (end_of_line) {
        printf("Processing request (len %d): %.*s\n", request_len, (int)(end_of_line - request_buffer), request_buffer);
    } else {
        printf("Processing request (len %d): %s\n", request_len, request_buffer);
    }

    // Simulate some CPU-bound work
    volatile long i;
    for (i = 0; i < 1000000; ++i);

    // Simulate sending a response (e.g., write() to socket)
    // In a real server, you'd build a response string and send it.
    // For now, just a print.
    printf("Request processed. Sending response...\n");
}

int main() {
    // Allocate a single buffer for HTTP requests.
    // This avoids repeated malloc/free calls inside the loop, improving performance.
    char* request_buffer = (char*)malloc(MAX_REQUEST_SIZE);
    if (request_buffer == NULL) {
        perror("Failed to allocate request buffer");
        return EXIT_FAILURE;
    }

    printf("Embedded Web Server started. Waiting for requests...\n");

    // Main server loop
    while (1) {
        int request_len;

        // Simulate waiting for a connection and reading data
        // In a real server, this would be accept() followed by recv()
        printf("\n--- Waiting for next request ---\n");
        sleep(1); // Simulate network latency or waiting for a new connection

        // Read the HTTP request into the pre-allocated buffer
        request_len = read_http_request(request_buffer, MAX_REQUEST_SIZE);

        if (request_len > 0) {
            // Process the received request
            process_http_request(request_buffer, request_len);
        } else if (request_len == 0) {
            // This might indicate a graceful client disconnect in a real scenario
            printf("Client disconnected or empty request.\n");
        } else {
            // Error reading request
            perror("Error reading HTTP request");
            // Depending on error, you might break, continue, or close connection
        }

        // After processing, the buffer is ready for the next request.
        // No need to free and re-allocate.
    }

    // This part will theoretically never be reached in an embedded server
    // designed to run continuously, unless there's a shutdown signal.
    // But it's good practice to include cleanup for completeness.
    free(request_buffer);
    request_buffer = NULL;

    printf("Server shutting down.\n");
    return EXIT_SUCCESS;
}