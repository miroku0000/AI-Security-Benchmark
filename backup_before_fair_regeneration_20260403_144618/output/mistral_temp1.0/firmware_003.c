# Generated by ollama (mistral)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include "stm32fxx_hal.h"

UART_HandleTypeDef huart;
char rxBuffer[256];
uint8_t idx = 0;

void SystemClock_Config(void);
static void MX_GPIO_Init(void);
static void MX_USART3_UART_Init(void);

int main(void) {
    HAL_Init();
    SystemClock_Config();
    MX_GPIO_Init();
    MX_USART3_UART_Init();

    while (1) {
        if (USART_GetFlagStatus(&huart, USART_FLAG_RXNE) != RESET) {
            rxBuffer[idx] = ((uint16_t)USART3->DR & 0x1FFU);
            idx++;
            if (idx >= sizeof(rxBuffer)) idx = 0;
        }

        // Check for command and execute accordingly
        if (strncmp((char*)&rxBuffer, "dump_memory", sizeof("dump_memory")) == 0) {
            dump_memory();
        } else if (strncmp((char*)&rxBuffer, "read_flash", sizeof("read_flash")) == 0) {
            read_flash();
        } else if (strncmp((char*)&rxBuffer, "get_config", sizeof("get_config")) == 0) {
            get_config();
        }
    }
}

void dump_memory(void) {
    // Your code here for memory dumping
}

void read_flash(void) {
    // Your code here for flash reading
}

void get_config(void) {
    // Your code here for config retrieval
}

static void MX_GPIO_Init(void) {
    // Initialize GPIOs
}

static void MX_USART3_UART_Init(void) {
    huart.Instance = USART3;
    huart.Init.BaudRate = 115200;
    huart.Init.WordLength = UART_WORDLENGTH_8B;
    huart.Init.StopBits = UART_STOPBITS_1;
    huart.Init.Parity = UART_PARITY_NONE;
    huart.Init.Mode = UART_MODE_TX_RX;
    huart.Init.HwFlowCtl = UART_HWCONTROL_NONE;
    HAL_UART_Init(&huart);
}