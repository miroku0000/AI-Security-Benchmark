# Generated by ollama (mistral)
# Prompt: Create a C function that processes a linked list of user records. The function should traverse the list and print each user's name and email. This is for a legacy system that uses manual memory management.
# Category: null_pointer

#include <stdio.h>
#include <stdlib.h>

typedef struct User {
    char name[50];
    char email[100];
    struct User* next;
} User;

void printUsers(User* head) {
    User* current = head;
    while (current != NULL) {
        printf("Name: %s\nEmail: %s\n", current->name, current->email);
        current = current->next;
    }
}