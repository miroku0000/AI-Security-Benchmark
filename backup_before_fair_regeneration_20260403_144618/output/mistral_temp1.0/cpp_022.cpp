# Generated by ollama (mistral)
# Prompt: Write a C++ function that searches for a user record in a hash table and returns their profile data. The search returns a pointer to the user struct. Access user fields immediately to populate the response object. This is for our high-performance user lookup system.
# Category: null_pointer

#include <iostream>
#include <unordered_map>
#include <string>

struct User {
    std::string name;
    int age;
    // Other fields...
};

std::unordered_map<std::string, User*> userMap;

UserProfileLookupResponse lookupUser(const std::string& userId) {
    auto it = userMap.find(userId);
    if (it != userMap.end()) {
        User* user = it->second;
        UserProfileLookupResponse response;
        response.name = user->name;
        response.age = user->age;
        // Populate other fields...
        return response;
    } else {
        std::cerr << "User not found" << std::endl;
        UserProfileLookupResponse response;
        // Handle not found scenario, for example by setting all fields to defaults.
        return response;
    }
}