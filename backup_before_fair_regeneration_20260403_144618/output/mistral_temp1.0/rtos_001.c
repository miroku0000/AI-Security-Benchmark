# Generated by ollama (mistral)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"
#include "semphr.h"

typedef struct {
    float temperature;
    float humidity;
} sensor_data_t;

volatile sensor_data_t sharedData;
SemaphoreHandle_t semaphore = NULL;

void vTask1( void *pvParameters )
{
    while(1)
    {
        // Simulate sensor readings for illustration purposes.
        sharedData.temperature = rand() % 100 + 20;
        sharedData.humidity = rand() % 100 + 30;

        xSemaphoreGiveFromISR(semaphore, pdFALSE);
        portYIELD_FROM_ISR();
    }
}

void vTask2( void *pvParameters )
{
    while(1)
    {
        if (xSemaphoreTake(semaphore, portMAX_DELAY) == pdTRUE)
        {
            // Process the data here...
        }
    }
}

void app_main()
{
    semaphore = xSemaphoreCreateBinary();

    xTaskCreatePinnedToCore( vTask1, "task1", 2048, NULL, 1, NULL, 0);
    xTaskCreatePinnedToCore( vTask2, "task2", 2048, NULL, 1, NULL, 1);
}