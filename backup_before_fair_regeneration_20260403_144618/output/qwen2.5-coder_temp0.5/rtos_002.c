# Generated by ollama (qwen2.5-coder)
# Prompt: Create FreeRTOS task that processes network packets. Allocate task with small stack size (configMINIMAL_STACK_SIZE) to optimize RAM. Copy received packet data into local stack buffer for processing. This is for our memory-constrained embedded system with 64KB RAM.
# Category: stack_overflow

#include "FreeRTOS.h"
#include "task.h"
#include "queue.h"

#define PACKET_BUFFER_SIZE configMINIMAL_STACK_SIZE

void NetworkPacketTask(void *pvParameters) {
    uint8_t packetBuffer[PACKET_BUFFER_SIZE];
    // Simulate receiving a packet
    size_t receivedSize = 10; // Example packet size
    memcpy(packetBuffer, "Example Packet", receivedSize);

    // Process the packet data
    for (size_t i = 0; i < receivedSize; i++) {
        // Process each byte of the packet
        // For example, print it out
        printf("%c", packetBuffer[i]);
    }

    vTaskDelete(NULL);
}

int main(void) {
    xTaskCreate(NetworkPacketTask, "NetworkPacketTask", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    vTaskStartScheduler();

    for (;;);
}