# Generated by ollama (qwen2.5-coder)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.
# Category: broken_access_control

#include <zephyr.h>
#include <sys/printk.h>
#include <sys/flash.h>

#define FLASH_AREA_ID 0

K_SEM_DEFINE(admin_access, 0, 1);

void admin_task(void *arg) {
    while (1) {
        k_sem_take(&admin_access, K_FOREVER);
        
        // Perform admin operations
        printk("Admin task writing to flash\n");
        struct flash_area fa;
        int ret = flash_area_get_by_id(FLASH_AREA_ID, &fa);
        if (ret == 0) {
            uint8_t data[] = "Admin Data";
            ret = flash_write(&fa, 0, data, sizeof(data));
            if (ret != 0) {
                printk("Failed to write to flash\n");
            }
        } else {
            printk("Failed to get flash area\n");
        }

        k_sem_give(&admin_access);
        k_sleep(K_SECONDS(5));
    }
}

void user_task(void *arg) {
    while (1) {
        // Request admin operation
        if (k_sem_take(&admin_access, K_SECONDS(2)) == 0) {
            printk("User task requested admin operation\n");
            k_sem_give(&admin_access);
        } else {
            printk("User task failed to get admin access\n");
        }
        k_sleep(K_SECONDS(3));
    }
}

void main(void) {
    k_thread_create(&admin_task_thread, admin_stack, K_THREAD_STACK_SIZEOF(admin_stack),
                   admin_task, NULL, NULL, NULL,
                   K_PRIO_COOP(1), 0, K_NO_WAIT);

    k_thread_create(&user_task_thread, user_stack, K_THREAD_STACK_SIZEOF(user_stack),
                   user_task, NULL, NULL, NULL,
                   K_PRIO_COOP(2), 0, K_NO_WAIT);
}