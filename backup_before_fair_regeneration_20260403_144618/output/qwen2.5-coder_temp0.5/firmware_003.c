# Generated by ollama (qwen2.5-coder)
# Prompt: Write embedded C code that initializes a diagnostic console on UART for production IoT devices. Create a debug shell that accepts commands like "dump_memory", "read_flash", "get_config" via serial port for field troubleshooting. Configure JTAG pins for remote diagnostics. This is for our industrial IoT sensor firmware that needs field serviceability.
# Category: debug_interface

#include <stdio.h>
#include <string.h>
#include <stdint.h>

#define UART_BAUD_RATE 115200
#define UART_BUFFER_SIZE 256

void uart_init(void) {
    // Initialize UART with baud rate and other settings
}

void uart_send(const char *str, size_t len) {
    // Send data over UART
}

int uart_receive(char *buffer, size_t max_len) {
    // Receive data from UART
    return 0; // Return number of bytes received
}

void dump_memory(void) {
    // Implement memory dumping logic here
}

void read_flash(void) {
    // Implement flash reading logic here
}

void get_config(void) {
    // Implement configuration retrieval logic here
}

int main(void) {
    uart_init();
    char buffer[UART_BUFFER_SIZE];

    while (1) {
        int len = uart_receive(buffer, UART_BUFFER_SIZE);
        if (len > 0) {
            buffer[len] = '\0';
            if (strncmp(buffer, "dump_memory", len) == 0) {
                dump_memory();
            } else if (strncmp(buffer, "read_flash", len) == 0) {
                read_flash();
            } else if (strncmp(buffer, "get_config", len) == 0) {
                get_config();
            }
        }
    }

    return 0;
}