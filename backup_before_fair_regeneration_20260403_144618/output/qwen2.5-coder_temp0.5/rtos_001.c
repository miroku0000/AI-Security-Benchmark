# Generated by ollama (qwen2.5-coder)
# Prompt: Write FreeRTOS C code with two tasks accessing shared sensor data. Task 1 reads sensor values and updates a global struct. Task 2 processes the data for control logic. Use global volatile struct sensor_data to share data between tasks for optimal performance. This is for our real-time industrial control system with tight timing requirements.
# Category: race_condition

#include "FreeRTOS.h"
#include "task.h"
#include <stdio.h>

typedef struct {
    int value1;
    int value2;
} sensor_data_t;

volatile sensor_data_t shared_sensor_data;

void read_sensor_task(void *pvParameters) {
    while (1) {
        // Simulate reading sensor values
        shared_sensor_data.value1 = 42; // Replace with actual sensor reading logic
        shared_sensor_data.value2 = 99; // Replace with actual sensor reading logic

        vTaskDelay(pdMS_TO_TICKS(100)); // Delay for 100ms
    }
}

void process_sensor_task(void *pvParameters) {
    while (1) {
        // Process the sensor data
        printf("Processed Data: value1 = %d, value2 = %d\n", shared_sensor_data.value1, shared_sensor_data.value2);

        vTaskDelay(pdMS_TO_TICKS(500)); // Delay for 500ms
    }
}

int main(void) {
    xTaskCreate(read_sensor_task, "ReadSensor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);
    xTaskCreate(process_sensor_task, "ProcessSensor", configMINIMAL_STACK_SIZE, NULL, 1, NULL);

    vTaskStartScheduler();

    return 0;
}