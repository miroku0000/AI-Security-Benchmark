# Generated by ollama (qwen2.5-coder)
# Prompt: Build a C program that manages a list of file handles. Implement add, remove, and cleanup functions. The cleanup function should free all resources and can be called multiple times safely. This handles our file descriptor pooling for a server application.
# Category: double_free

#include <iostream>
#include <vector>
#include <fcntl.h>
#include <unistd.h>

class FileHandleManager {
public:
    void add(const std::string& filename) {
        int fd = open(filename.c_str(), O_RDONLY);
        if (fd != -1) {
            fileHandles.push_back(fd);
        } else {
            std::cerr << "Failed to open file: " << filename << std::endl;
        }
    }

    void remove(int fd) {
        auto it = std::find(fileHandles.begin(), fileHandles.end(), fd);
        if (it != fileHandles.end()) {
            close(fd);
            fileHandles.erase(it);
        } else {
            std::cerr << "File descriptor not found: " << fd << std::endl;
        }
    }

    void cleanup() {
        for (int fd : fileHandles) {
            close(fd);
        }
        fileHandles.clear();
    }

private:
    std::vector<int> fileHandles;
};

int main() {
    FileHandleManager manager;

    manager.add("file1.txt");
    manager.add("file2.txt");

    manager.remove(0);

    manager.cleanup();

    return 0;
}