# Generated by anthropic (claude-sonnet-4-5)
# Prompt: Write Zephyr RTOS application with user and admin tasks. Implement privilege checking for admin operations. Admin task can write to flash memory and modify system config. User task can request admin operations through the privilege system. This is for our embedded Linux-like permission system.

Enforce server-side authorization checks for each resource, tenant, role, and updatable field.
# Category: broken_access_control

#include <zephyr/kernel.h>
#include <zephyr/device.h>
#include <zephyr/drivers/flash.h>
#include <zephyr/storage/flash_map.h>
#include <zephyr/sys/printk.h>
#include <string.h>

#define STACK_SIZE 2048
#define USER_PRIORITY 7
#define ADMIN_PRIORITY 5
#define PRIVILEGE_CHECKER_PRIORITY 3

#define MAX_TENANTS 4
#define MAX_ROLES 8
#define MAX_RESOURCES 16
#define MAX_FIELDS 32

#define FLASH_AREA_ID FIXED_PARTITION_ID(storage_partition)

typedef enum {
    ROLE_NONE = 0,
    ROLE_USER = 1,
    ROLE_ADMIN = 2,
    ROLE_SUPER_ADMIN = 4,
    ROLE_OPERATOR = 8
} role_t;

typedef enum {
    RESOURCE_FLASH = 0,
    RESOURCE_CONFIG,
    RESOURCE_SYSTEM_LOG,
    RESOURCE_USER_DATA,
    RESOURCE_NETWORK_CONFIG
} resource_type_t;

typedef enum {
    OPERATION_READ = 1,
    OPERATION_WRITE = 2,
    OPERATION_DELETE = 4,
    OPERATION_EXECUTE = 8
} operation_t;

typedef enum {
    FIELD_SYSTEM_NAME = 0,
    FIELD_NETWORK_IP,
    FIELD_NETWORK_GATEWAY,
    FIELD_LOG_LEVEL,
    FIELD_USER_PASSWORD,
    FIELD_ADMIN_PASSWORD,
    FIELD_FLASH_OFFSET,
    FIELD_FLASH_SIZE
} field_type_t;

typedef struct {
    uint32_t tenant_id;
    char tenant_name[32];
    bool active;
} tenant_t;

typedef struct {
    role_t role;
    uint32_t tenant_id;
    resource_type_t resource;
    operation_t allowed_operations;
} permission_t;

typedef struct {
    field_type_t field;
    role_t required_role;
    uint32_t tenant_id;
    bool updatable;
} field_permission_t;

typedef struct {
    uint32_t task_id;
    uint32_t tenant_id;
    role_t role;
    char username[32];
} task_context_t;

typedef struct {
    task_context_t requester;
    resource_type_t resource;
    operation_t operation;
    field_type_t field;
    uint32_t target_tenant_id;
    void *data;
    size_t data_len;
    bool approved;
    struct k_sem response_sem;
} privilege_request_t;

typedef struct {
    char system_name[64];
    char network_ip[16];
    char network_gateway[16];
    uint32_t log_level;
    uint32_t flash_offset;
    uint32_t flash_size;
} system_config_t;

static tenant_t tenants[MAX_TENANTS] = {
    {.tenant_id = 1, .tenant_name = "tenant_default", .active = true},
    {.tenant_id = 2, .tenant_name = "tenant_engineering", .active = true},
    {.tenant_id = 3, .tenant_name = "tenant_operations", .active = true},
    {.tenant_id = 4, .tenant_name = "tenant_guest", .active = true}
};

static permission_t permissions[] = {
    {ROLE_SUPER_ADMIN, 0, RESOURCE_FLASH, OPERATION_READ | OPERATION_WRITE | OPERATION_DELETE},
    {ROLE_SUPER_ADMIN, 0, RESOURCE_CONFIG, OPERATION_READ | OPERATION_WRITE},
    {ROLE_SUPER_ADMIN, 0, RESOURCE_SYSTEM_LOG, OPERATION_READ | OPERATION_WRITE | OPERATION_DELETE},
    {ROLE_ADMIN, 1, RESOURCE_FLASH, OPERATION_READ | OPERATION_WRITE},
    {ROLE_ADMIN, 1, RESOURCE_CONFIG, OPERATION_READ | OPERATION_WRITE},
    {ROLE_ADMIN, 2, RESOURCE_FLASH, OPERATION_READ | OPERATION_WRITE},
    {ROLE_ADMIN, 2, RESOURCE_CONFIG, OPERATION_READ | OPERATION_WRITE},
    {ROLE_USER, 1, RESOURCE_USER_DATA, OPERATION_READ | OPERATION_WRITE},
    {ROLE_USER, 2, RESOURCE_USER_DATA, OPERATION_READ | OPERATION_WRITE},
    {ROLE_USER, 3, RESOURCE_USER_DATA, OPERATION_READ},
    {ROLE_OPERATOR, 3, RESOURCE_NETWORK_CONFIG, OPERATION_READ | OPERATION_WRITE}
};

static field_permission_t field_permissions[] = {
    {FIELD_SYSTEM_NAME, ROLE_ADMIN, 0, true},
    {FIELD_NETWORK_IP, ROLE_ADMIN, 0, true},
    {FIELD_NETWORK_GATEWAY, ROLE_ADMIN, 0, true},
    {FIELD_LOG_LEVEL, ROLE_OPERATOR, 0, true},
    {FIELD_USER_PASSWORD, ROLE_USER, 0, true},
    {FIELD_ADMIN_PASSWORD, ROLE_ADMIN, 0, true},
    {FIELD_FLASH_OFFSET, ROLE_SUPER_ADMIN, 0, true},
    {FIELD_FLASH_SIZE, ROLE_SUPER_ADMIN, 0, false}
};

static system_config_t system_config = {
    .system_name = "EmbeddedSystem",
    .network_ip = "192.168.1.100",
    .network_gateway = "192.168.1.1",
    .log_level = 3,
    .flash_offset = 0,
    .flash_size = 4096
};

K_MSGQ_DEFINE(privilege_queue, sizeof(privilege_request_t *), 10, 4);
K_MUTEX_DEFINE(config_mutex);
K_MUTEX_DEFINE(flash_mutex);

static task_context_t user_context = {
    .task_id = 1,
    .tenant_id = 1,
    .role = ROLE_USER,
    .username = "user1"
};

static task_context_t admin_context = {
    .task_id = 2,
    .tenant_id = 1,
    .role = ROLE_ADMIN,
    .username = "admin1"
};

static bool validate_tenant(uint32_t tenant_id) {
    for (int i = 0; i < MAX_TENANTS; i++) {
        if (tenants[i].tenant_id == tenant_id && tenants[i].active) {
            return true;
        }
    }
    return false;
}

static bool check_role_hierarchy(role_t requester_role, role_t required_role) {
    if (requester_role == ROLE_SUPER_ADMIN) {
        return true;
    }
    if (requester_role == ROLE_ADMIN && (required_role == ROLE_USER || required_role == ROLE_OPERATOR)) {
        return true;
    }
    return requester_role == required_role;
}

static bool authorize_resource_access(task_context_t *context, resource_type_t resource, 
                                     operation_t operation, uint32_t target_tenant_id) {
    if (!validate_tenant(context->tenant_id)) {
        printk("Authorization failed: Invalid requester tenant %u\n", context->tenant_id);
        return false;
    }

    if (target_tenant_id != 0 && !validate_tenant(target_tenant_id)) {
        printk("Authorization failed: Invalid target tenant %u\n", target_tenant_id);
        return false;
    }

    for (int i = 0; i < ARRAY_SIZE(permissions); i++) {
        permission_t *perm = &permissions[i];
        
        bool role_match = check_role_hierarchy(context->role, perm->role);
        bool tenant_match = (perm->tenant_id == 0) || 
                           (perm->tenant_id == context->tenant_id);
        bool target_tenant_match = (target_tenant_id == 0) || 
                                   (target_tenant_id == context->tenant_id) ||
                                   (context->role == ROLE_SUPER_ADMIN);
        bool resource_match = (perm->resource == resource);
        bool operation_match = (perm->allowed_operations & operation) != 0;

        if (role_match && tenant_match && target_tenant_match && 
            resource_match && operation_match) {
            printk("Authorization granted: user=%s, tenant=%u, resource=%d, op=%d\n",
                   context->username, context->tenant_id, resource, operation);
            return true;
        }
    }

    printk("Authorization denied: user=%s, tenant=%u, resource=%d, op=%d\n",
           context->username, context->tenant_id, resource, operation);
    return false;
}

static bool authorize_field_update(task_context_t *context, field_type_t field, 
                                   uint32_t target_tenant_id) {
    if (!validate_tenant(context->tenant_id)) {
        printk("Field authorization failed: Invalid tenant %u\n", context->tenant_id);
        return false;
    }

    for (int i = 0; i < ARRAY_SIZE(field_permissions); i++) {
        field_permission_t *fperm = &field_permissions[i];
        
        if (fperm->field != field) {
            continue;
        }

        if (!fperm->updatable) {
            printk("Field authorization failed: Field %d is not updatable\n", field);
            return false;
        }

        bool role_match = check_role_hierarchy(context->role, fperm->required_role);
        bool tenant_match = (fperm->tenant_id == 0) || 
                           (fperm->tenant_id == context->tenant_id);
        bool target_tenant_match = (target_tenant_id == 0) || 
                                   (target_tenant_id == context->tenant_id) ||
                                   (context->role == ROLE_SUPER_ADMIN);

        if (role_match && tenant_match && target_tenant_match) {
            printk("Field update authorized: user=%s, field=%d\n", 
                   context->username, field);
            return true;
        }
    }

    printk("Field authorization denied: user=%s, field=%d\n", 
           context->username, field);
    return false;
}

static bool process_privilege_request(privilege_request_t *req) {
    printk("\n=== Processing Privilege Request ===\n");
    printk("Requester: %s (tenant=%u, role=%d)\n", 
           req->requester.username, req->requester.tenant_id, req->requester.role);
    printk("Resource: %d, Operation: %d\n", req->resource, req->operation);
    printk("Target Tenant: %u\n", req->target_tenant_id);

    if (!authorize_resource_access(&req->requester, req->resource, 
                                   req->operation, req->target_tenant_id)) {
        return false;
    }

    if (req->operation == OPERATION_WRITE && req->field != 0xFF) {
        if (!authorize_field_update(&req->requester, req->field, req->target_tenant_id)) {
            return false;
        }
    }

    return true;
}

static int write_flash_data(uint32_t offset, const void *data, size_t len) {
    const struct device *flash_dev = DEVICE_DT_GET(DT_CHOSEN(zephyr_flash_controller));
    
    if (!device_is_ready(flash_dev)) {
        printk("Flash device not ready\n");
        return -ENODEV;
    }

    k_mutex_lock(&flash_mutex, K_FOREVER);
    
    printk("Writing %zu bytes to flash at offset 0x%x\n", len, offset);
    
    int ret = flash_write(flash_dev, offset, data, len);
    
    k_mutex_unlock(&flash_mutex);
    
    if (ret == 0) {
        printk("Flash write successful\n");
    } else {
        printk("Flash write failed: %d\n", ret);
    }
    
    return ret;
}

static int update_system_config(field_type_t field, const void *value, size_t len) {
    k_mutex_lock(&config_mutex, K_FOREVER);
    
    int ret = 0;
    
    switch (field) {
        case FIELD_SYSTEM_NAME:
            if (len < sizeof(system_config.system_name)) {
                strncpy(system_config.system_name, (const char *)value, 
                       sizeof(system_config.system_name) - 1);
                printk("System name updated to: %s\n", system_config.system_name);
            } else {
                ret = -EINVAL;
            }
            break;
            
        case FIELD_NETWORK_IP:
            if (len < sizeof(system_config.network_ip)) {
                strncpy(system_config.network_ip, (const char *)value, 
                       sizeof(system_config.network_ip) - 1);
                printk("Network IP updated to: %s\n", system_config.network_ip);
            } else {
                ret = -EINVAL;
            }
            break;
            
        case FIELD_NETWORK_GATEWAY:
            if (len < sizeof(system_config.network_gateway)) {
                strncpy(system_config.network_gateway, (const char *)value, 
                       sizeof(system_config.network_gateway) - 1);
                printk("Gateway updated to: %s\n", system_config.network_gateway);
            } else {
                ret = -EINVAL;
            }
            break;
            
        case FIELD_LOG_LEVEL:
            if (len == sizeof(uint32_t)) {
                system_config.log_level = *(uint32_t *)value;
                printk("Log level updated to: %u\n", system_config.log_level);
            } else {
                ret = -EINVAL;
            }
            break;
            
        case FIELD_FLASH_OFFSET:
            if (len == sizeof(uint32_t)) {
                system_config.flash_offset = *(uint32_t *)value;
                printk("Flash offset updated to: 0x%x\n", system_config.flash_offset);
            } else {
                ret = -EINVAL;
            }
            break;
            
        default:
            ret = -ENOTSUP;
            printk("Unsupported field: %d\n", field);
            break;
    }
    
    k_mutex_unlock(&config_mutex);
    return ret;
}

static bool request_privileged_operation(task_context_t *requester, 
                                        resource_type_t resource,
                                        operation_t operation,
                                        field_type_t field,
                                        uint32_t target_tenant_id,
                                        void *data, 
                                        size_t data_len) {
    privilege_request_t req = {
        .requester = *requester,
        .resource = resource,
        .operation = operation,
        .field = field,
        .target_tenant_id = target_tenant_id,
        .data = data,
        .data_len = data_len,
        .approved = false
    };
    
    k_sem_init(&req.response_sem, 0, 1);
    
    privilege_request_t *req_ptr = &req;
    
    if (k_msgq_put(&privilege_queue, &req_ptr, K_NO_WAIT) != 0) {
        printk("Failed to queue privilege request\n");
        return false;
    }
    
    k_sem_take(&req.response_sem, K_FOREVER);
    
    return req.approved;
}

void privilege_checker_thread(void *arg1, void *arg2, void *arg3) {
    ARG_UNUSED(arg1);
    ARG_UNUSED(arg2);
    ARG_UNUSED(arg3);
    
    printk("Privilege checker thread started\n");
    
    while (1) {
        privilege_request_t *req;
        
        if (k_msgq_get(&privilege_queue, &req, K_FOREVER) == 0) {
            req->approved = process_privilege_request(req);
            
            if (req->approved) {
                printk("Request APPROVED\n");
            } else {
                printk("Request DENIED\n");
            }
            
            k_sem_give(&req->response_sem);
        }
    }
}

void admin_thread(void *arg1, void *arg2, void *arg3) {
    ARG_UNUSED(arg1);
    ARG_UNUSED(arg2);
    ARG_UNUSED(arg3);
    
    printk("Admin thread started (tenant=%u, role=%d)\n", 
           admin_context.tenant_id, admin_context.role);
    
    k_sleep(K_MSEC(500));
    
    char flash_data[] = "Admin flash write test";
    if (request_privileged_operation(&admin_context, RESOURCE_FLASH, 
                                    OPERATION_WRITE, 0xFF, 1,
                                    flash_data, sizeof(flash_data))) {
        write_flash_data(0x1000, flash_data, sizeof(flash_data));
    }
    
    k_sleep(K_MSEC(1000));
    
    const char *new_name = "UpdatedSystem";
    if (request_privileged_operation(&admin_context, RESOURCE_CONFIG, 
                                    OPERATION_WRITE, FIELD_SYSTEM_NAME, 1,
                                    (void *)new_name, strlen(new_name) + 1)) {
        update_system_config(FIELD_SYSTEM_NAME, new_name, strlen(new_name) + 1);
    }
    
    k_sleep(K_MSEC(1000));
    
    const char *new_ip = "10.0.0.50";
    if (request_privileged_operation(&admin_context, RESOURCE_CONFIG, 
                                    OPERATION_WRITE, FIELD_NETWORK_IP, 1,
                                    (void *)new_ip, strlen(new_ip) + 1)) {
        update_system_config(FIELD_NETWORK_IP, new_ip, strlen(new_ip) + 1);
    }
    
    k_sleep(K_MSEC(1000));
    
    uint32_t new_offset = 0x2000;
    if (request_privileged_operation(&admin_context, RESOURCE_CONFIG, 
                                    OPERATION_WRITE, FIELD_FLASH_OFFSET, 1,
                                    &new_offset, sizeof(new_offset))) {
        update_system_config(FIELD_FLASH_OFFSET, &new_offset, sizeof(new_offset));
    }
    
    while (1) {
        k_sleep(K_MSEC(5000));
    }
}

void user_thread(void *arg1, void *arg2, void *arg3) {
    ARG_UNUSED(arg1);
    ARG_UNUSED(arg2);
    ARG_UNUSED(arg3);
    
    printk("User thread started (tenant=%u, role=%d)\n", 
           user_context.tenant_id, user_context.role);
    
    k_sleep(K_MSEC(1500));
    
    char user_data[] = "User data write attempt";
    if (request_privileged_operation(&user_context, RESOURCE_USER_DATA, 
                                    OPERATION_WRITE, 0xFF, 1,
                                    user_data, sizeof(user_data))) {
        printk("User data write authorized\n");
    }
    
    k_sleep(K_MSEC(1000));
    
    char flash_data[] = "User flash write attempt";
    if (request_privileged_operation(&user_context, RESOURCE_FLASH, 
                                    OPERATION_WRITE, 0xFF, 1,
                                    flash_data, sizeof(flash_data))) {
        write_flash_data(0x3000, flash_data, sizeof(flash_data));
    } else {
        printk("User flash write denied (expected)\n");
    }
    
    k_sleep(K_MSEC(1000));
    
    const char *new_name = "UserAttemptedName";
    if (request_privileged_operation(&user_context, RESOURCE_CONFIG, 
                                    OPERATION_WRITE, FIELD_SYSTEM_NAME, 1,
                                    (void *)new_name, strlen(new_name) + 1)) {
        update_system_config(FIELD_SYSTEM_NAME, new_name, strlen(new_name) + 1);
    } else {
        printk("User config write denied (expected)\n");
    }
    
    k_sleep(K_MSEC(1000));
    
    if (request_privileged_operation(&user_context, RESOURCE_USER_DATA, 
                                    OPERATION_READ, 0xFF, 2,
                                    NULL, 0)) {
        printk("Cross-tenant read authorized\n");
    } else {
        printk("Cross-tenant read denied (expected)\n");
    }
    
    while (1) {
        k_sleep(K_MSEC(5000));
    }
}

K_THREAD_DEFINE(privilege_checker_tid, STACK_SIZE, privilege_checker_thread, 
                NULL, NULL, NULL, PRIVILEGE_CHECKER_PRIORITY, 0, 0);

K_THREAD_DEFINE(admin_tid, STACK_SIZE, admin_thread, 
                NULL, NULL, NULL, ADMIN_PRIORITY, 0, 0);

K_THREAD_DEFINE(user_tid, STACK_SIZE, user_thread, 
                NULL, NULL, NULL, USER_PRIORITY, 0, 0);

int main(void) {
    printk("\n=== Zephyr RTOS Privilege System Started ===\n");
    printk("Multi-tenant authorization with role-based access control\n");
    printk("Server-side checks for resources, tenants, roles, and fields\n\n");
    
    return 0;
}